#ifndef _NOTOSANS_CONDENSED_BLACKITALIC40PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x07, 0xC0,
  0x00, 0x7F, 0x3F, 0x7F, 0x7F, 0x7E, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0xFC,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0xFC, 0xF8, 0xFC, 0xF8, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x07,
  0xC7, 0xC0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x0F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xB9,
  0xC1, 0xFB, 0x04, 0x1F, 0xB0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x0D, 0xF8, 0x80, 0xDF, 0x8C, 0x1D, 0xF8, 0xF9, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x0F, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x07, 0xE0, 0x3F, 0xC0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x03,
  0xE0, 0x3F, 0xF8, 0x1F, 0x01, 0xF9, 0xF0, 0xFC, 0x07, 0xC7, 0xC3, 0xE0,
  0x1F, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x7C, 0x03, 0xE3, 0xE3, 0xE0, 0x0F,
  0x8F, 0x9F, 0x80, 0x3E, 0x3E, 0x7C, 0x10, 0xF9, 0xF3, 0xE3, 0xFB, 0xFF,
  0xDF, 0xBF, 0xE7, 0xFE, 0x7C, 0xFF, 0xDF, 0xFB, 0xE7, 0xFF, 0x3F, 0xCF,
  0xBF, 0x7C, 0x7C, 0x7C, 0xF9, 0xF0, 0x03, 0xF3, 0xE7, 0xC0, 0x0F, 0x9F,
  0x9F, 0x00, 0x7C, 0x7C, 0x7C, 0x03, 0xF1, 0xF1, 0xF0, 0x0F, 0x87, 0xC7,
  0xC0, 0x7C, 0x1F, 0x3E, 0x01, 0xF0, 0x7C, 0xF8, 0x0F, 0x81, 0xFF, 0xC0,
  0x7E, 0x03, 0xFF, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0x80, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xCF,
  0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xF0, 0xFF, 0xE3, 0xF8,
  0x7F, 0xFC, 0xFE, 0x3F, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0xC7, 0xF7, 0xFF,
  0xE1, 0xFC, 0xFF, 0xF8, 0xFE, 0x1F, 0xFC, 0x3F, 0x87, 0xFE, 0x0F, 0xE0,
  0xFF, 0x83, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x06, 0x1F, 0x03, 0xCF, 0x81, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC1, 0xFF, 0xE1, 0xFE, 0x71, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x7C, 0xF8, 0x1C, 0x7E, 0x06, 0x3C, 0x02,
  0x08, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F,
  0xC7, 0xE3, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x00,
  0x3F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xEF, 0xFE, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFE, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC7, 0xFB, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xE7, 0xF1, 0xFC,
  0xFE, 0x3F, 0x9F, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB,
  0xF8, 0x7E, 0x7E, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x1F, 0xCF,
  0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x9F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x1F, 0xBF, 0x87, 0xBF, 0x81, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0x9F, 0xE0, 0x70, 0x7F, 0x01, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0x07, 0xF0, 0x20, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0xC0,
  0x3F, 0xCF, 0xDF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xEF, 0xC0, 0x3F, 0xFC, 0x07,
  0xDF, 0xC0, 0xF9, 0xFC, 0x0F, 0x9F, 0x81, 0xF3, 0xF8, 0x3E, 0x3F, 0x87,
  0xE3, 0xF8, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x08, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x80, 0x7F, 0x0F, 0xBF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x9E, 0x03, 0xF7,
  0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0x1F, 0xCF, 0xF1, 0xFC, 0xFF, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF,
  0xE3, 0xF8, 0xFE, 0x3F, 0x87, 0xF7, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xDF, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xE3, 0xF9,
  0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0xFE, 0x7F, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xE7, 0xF3, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xF3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFD, 0xFC, 0x3F,
  0xBF, 0x87, 0xF7, 0xF1, 0xFE, 0xFF, 0x7F, 0xDF, 0xFF, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0x7E, 0x01, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x86, 0x1F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x8F,
  0xF1, 0xFE, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x7E, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xF8,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0,
  0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC7,
  0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80,
  0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE,
  0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x38, 0x7F, 0x20, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x3C, 0x1F, 0x1F, 0x87, 0xFE,
  0xF8, 0xF8, 0xFF, 0xE3, 0xCF, 0x8F, 0xFF, 0x1E, 0x7C, 0x7C, 0xF8, 0xF7,
  0xC7, 0xC7, 0xC7, 0xBE, 0x7C, 0x3E, 0x3D, 0xE3, 0xE1, 0xE3, 0xEF, 0x1F,
  0x1F, 0x1F, 0xF9, 0xF0, 0xF8, 0xF7, 0xCF, 0x87, 0xC7, 0xBE, 0x7C, 0x7C,
  0x7D, 0xF3, 0xE3, 0xE3, 0xCF, 0x9F, 0xBF, 0x7E, 0x7C, 0xFF, 0xFF, 0xE3,
  0xE3, 0xFF, 0xFE, 0x1F, 0x0F, 0xCF, 0xE0, 0xF8, 0x18, 0x18, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x02, 0x00, 0x7F, 0x00, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F,
  0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x07, 0xF0,
  0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC,
  0xFF, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x83, 0xFB, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE,
  0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F,
  0xC7, 0xF0, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xC3, 0x87, 0xFC, 0x08, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x08, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFD, 0xFF, 0x83, 0xF8, 0xFF,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0,
  0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F,
  0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x7F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0x07, 0x07, 0xF8,
  0x04, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x1F, 0xFB, 0xFC, 0xFF, 0xEF, 0xE3, 0xFF, 0x3F, 0x8F, 0xFC, 0xFE,
  0x3F, 0xF3, 0xF8, 0xFF, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF8,
  0x1F, 0xC3, 0xFC, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x3F,
  0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC7, 0xFF,
  0xC0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xF1, 0xF7, 0xE0, 0x7E, 0xF9, 0xFF,
  0xF0, 0x3F, 0x7C, 0xFB, 0xF8, 0x1F, 0xBE, 0xFD, 0xF8, 0x1F, 0xDF, 0x7C,
  0xFC, 0x0F, 0xEF, 0xFE, 0xFE, 0x07, 0xF7, 0xFE, 0x7F, 0x03, 0xF3, 0xFF,
  0x3F, 0x81, 0xF9, 0xFF, 0x9F, 0x81, 0xFC, 0xFF, 0x8F, 0xC0, 0xFE, 0x7F,
  0xCF, 0xE0, 0x7E, 0x3F, 0xC7, 0xF0, 0x3F, 0x1F, 0xE3, 0xF8, 0x1F, 0x8F,
  0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x7F, 0xE0,
  0x7E, 0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0xE0, 0xFE, 0x07, 0xFE, 0x0F, 0xC0,
  0x7F, 0xE0, 0xFC, 0x0F, 0xFF, 0x1F, 0xC0, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF,
  0x1F, 0xC0, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0x9F, 0x81, 0xFF, 0xFB, 0xF8,
  0x1F, 0x9F, 0xBF, 0x81, 0xF9, 0xFB, 0xF0, 0x1F, 0x9F, 0xBF, 0x03, 0xF9,
  0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0x03, 0xF8, 0xFF, 0xF0, 0x3F, 0x0F, 0xFE,
  0x03, 0xF0, 0xFF, 0xE0, 0x7F, 0x0F, 0xFE, 0x07, 0xF0, 0x7F, 0xE0, 0x7E,
  0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xC0, 0x7E, 0x07, 0xFC, 0x0F, 0xE0, 0x7F,
  0xC0, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8,
  0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0xFF, 0x03, 0xFD, 0xFE, 0x07,
  0xFB, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F,
  0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x87, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x7F,
  0xC1, 0xFC, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83,
  0xF8, 0xFE, 0x0F, 0xC7, 0xF8, 0x7F, 0x3F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xE0, 0xFE,
  0x3F, 0xC1, 0xFC, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE,
  0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0,
  0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFE, 0x7F, 0x07, 0xF1, 0xFC,
  0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F,
  0x83, 0xFC, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xF3, 0xC1, 0xFE,
  0x04, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x84, 0x07, 0xF8,
  0xF0, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0x9F,
  0xC0, 0xFE, 0x7F, 0x07, 0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0,
  0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E,
  0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x03, 0xE0, 0x3F, 0xFF, 0x03, 0xF0, 0x3F, 0xBF, 0x81, 0xF8, 0x1F, 0xDF,
  0xC1, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x07, 0xF3,
  0xF8, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0xC3, 0xF8, 0xFE, 0x3F, 0xE1, 0xF8,
  0x7F, 0x1F, 0xF1, 0xFC, 0x3F, 0x9F, 0xF8, 0xFE, 0x1F, 0xCF, 0xFC, 0xFE,
  0x0F, 0xE7, 0xFE, 0x7F, 0x07, 0xF7, 0xFF, 0x3F, 0x03, 0xFB, 0xEF, 0xBF,
  0x81, 0xFF, 0xF7, 0xDF, 0xC0, 0xFD, 0xFF, 0xEF, 0xC0, 0x7E, 0xFB, 0xFF,
  0xE0, 0x3F, 0xFD, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0x7F,
  0xF8, 0x07, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x8F,
  0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x3F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07,
  0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE, 0xFE,
  0x1F, 0xCF, 0xE3, 0xF8, 0x7E, 0x3F, 0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x07,
  0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0,
  0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x3E,
  0x1F, 0x83, 0xE1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xE0, 0x1F, 0xFE, 0x01,
  0xF0, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFE, 0x7F,
  0x1F, 0xCF, 0xE3, 0xF0, 0xF8, 0x3E, 0x00, 0x80, 0x00, 0x3F, 0x3F, 0x07,
  0xFB, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xDF, 0xE3,
  0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xCF, 0xE1, 0xFC,
  0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE7, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFB,
  0xF0, 0x3F, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x10,
  0x0F, 0xEF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF1, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF3, 0xF8,
  0x7F, 0x3F, 0x87, 0xF3, 0xF0, 0x7F, 0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE7, 0xF1, 0xFC, 0x7F, 0xBF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFD, 0xFE, 0x0F, 0x8F, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0x81,
  0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0x18, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x08, 0x7F, 0x9C, 0x3F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x20, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x7F, 0x83, 0xF8,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFE, 0x7F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xBF, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xE3, 0xF3, 0xF0, 0xFD, 0xFC,
  0x3F, 0x7F, 0x7F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x04, 0xFE, 0x06, 0x3F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x10, 0x01, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x09, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x7F, 0x83, 0xF8, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F,
  0xE0, 0xFE, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x82, 0x00,
  0xFE, 0x0E, 0x07, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x10, 0x0F, 0xEF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFE, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x09, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE1, 0xFE, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xE0, 0x7E, 0x3F, 0x81, 0xFC,
  0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80,
  0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0x00, 0x40, 0x3F, 0x3F, 0x8F, 0xE0,
  0xFD, 0xFE, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xDF, 0xC7, 0xF1, 0xFE, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xF8, 0x7E, 0x1F, 0xCF, 0xE1, 0xF8,
  0x7F, 0x3F, 0x8F, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x3F,
  0x9F, 0xC3, 0xF0, 0xFE, 0x7F, 0x1F, 0xC3, 0xF9, 0xFC, 0x7F, 0x0F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x3F, 0x87, 0xF1, 0xFC, 0xFE, 0x1F, 0x87, 0xF3, 0xF8,
  0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x00, 0x00, 0x01, 0x00, 0xFC, 0xFC,
  0x0F, 0xDF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xEF,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8,
  0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x80, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xE7, 0xF9, 0xFC, 0x7F,
  0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xFF, 0x07, 0xEF, 0xE1, 0xFD,
  0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xCF, 0xF3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x80, 0x0F, 0xCF, 0xC0, 0x3F, 0x7F, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x9F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1,
  0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F,
  0xBF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0x3F,
  0x07, 0xFB, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xDF,
  0xE3, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xCF, 0xE1,
  0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xEF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x07, 0xE7, 0xC3, 0xF7,
  0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x20, 0x01, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0xFE, 0x18, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x80, 0xFE, 0x70, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xE3, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF9, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xC3, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFF, 0x7F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xBF,
  0x03, 0xF3, 0xF0, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xCF, 0xE1,
  0xFC, 0x7E, 0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x7E,
  0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x1F,
  0xC3, 0xFF, 0xF1, 0xFE, 0x1F, 0xBF, 0x8F, 0xF1, 0xFD, 0xFC, 0x7F, 0x8F,
  0xEF, 0xE7, 0xFC, 0x7E, 0x7F, 0x3F, 0xE7, 0xF3, 0xFB, 0xFF, 0x3F, 0x1F,
  0xDF, 0xFB, 0xF8, 0xFE, 0xFF, 0xDF, 0x87, 0xFF, 0xBE, 0xFC, 0x3F, 0x7D,
  0xFF, 0xE1, 0xFB, 0xEF, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF,
  0x03, 0xFF, 0x3F, 0xF8, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x07,
  0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x07, 0xF1, 0xFE,
  0x07, 0xF9, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0,
  0x3F, 0x9F, 0xC0, 0x3F, 0x9F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x07, 0xE1, 0xFC,
  0x07, 0xE3, 0xF8, 0x07, 0xE3, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xF0,
  0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x9F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x20, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xF8, 0x0F, 0xFA, 0x00, 0x38,
};

const GFXglyph NotoSans_Condensed_BlackItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 29, 11, 0, -29 },
  { 49, 16, 11, 18, 4, -29 },
  { 71, 24, 29, 23, 0, -29 },
  { 158, 20, 32, 20, 1, -30 },
  { 238, 30, 29, 33, 2, -29 },
  { 347, 26, 29, 26, 0, -29 },
  { 442, 8, 11, 10, 4, -29 },
  { 453, 15, 35, 12, 1, -29 },
  { 519, 15, 35, 12, -3, -29 },
  { 585, 17, 19, 19, 3, -31 },
  { 626, 18, 20, 21, 2, -24 },
  { 671, 10, 10, 11, -2, -5 },
  { 684, 12, 6, 13, 0, -14 },
  { 693, 8, 7, 11, 0, -7 },
  { 700, 22, 29, 17, -2, -29 },
  { 780, 19, 29, 20, 1, -29 },
  { 849, 17, 29, 20, 3, -29 },
  { 911, 21, 29, 20, -1, -29 },
  { 988, 20, 29, 20, 0, -29 },
  { 1061, 20, 29, 20, 0, -29 },
  { 1134, 20, 29, 20, 1, -29 },
  { 1207, 20, 29, 20, 1, -29 },
  { 1280, 21, 29, 20, 1, -29 },
  { 1357, 19, 29, 20, 1, -29 },
  { 1426, 19, 29, 20, 1, -29 },
  { 1495, 11, 22, 11, 0, -22 },
  { 1526, 13, 27, 11, -2, -22 },
  { 1570, 18, 21, 21, 2, -25 },
  { 1618, 18, 14, 21, 2, -21 },
  { 1650, 18, 21, 21, 2, -25 },
  { 1698, 16, 29, 16, 2, -29 },
  { 1756, 29, 32, 31, 1, -29 },
  { 1872, 23, 29, 23, -2, -29 },
  { 1956, 22, 29, 22, 0, -29 },
  { 2036, 21, 29, 21, 2, -29 },
  { 2113, 23, 29, 23, 0, -29 },
  { 2197, 20, 29, 18, 0, -29 },
  { 2270, 20, 29, 18, 0, -29 },
  { 2343, 22, 29, 24, 2, -29 },
  { 2423, 26, 29, 24, 0, -29 },
  { 2518, 19, 29, 16, -1, -29 },
  { 2587, 19, 38, 12, -6, -29 },
  { 2678, 26, 29, 22, 0, -29 },
  { 2773, 16, 29, 18, 0, -29 },
  { 2831, 33, 29, 32, 0, -29 },
  { 2951, 28, 29, 26, 0, -29 },
  { 3053, 23, 29, 25, 2, -29 },
  { 3137, 22, 29, 21, 0, -29 },
  { 3217, 23, 36, 25, 2, -29 },
  { 3321, 22, 29, 22, 0, -29 },
  { 3401, 20, 29, 19, 0, -29 },
  { 3474, 19, 29, 19, 3, -29 },
  { 3543, 23, 29, 24, 2, -29 },
  { 3627, 22, 29, 22, 3, -29 },
  { 3707, 33, 29, 32, 3, -29 },
  { 3827, 27, 29, 22, -2, -29 },
  { 3925, 20, 29, 21, 4, -29 },
  { 3998, 23, 29, 19, -2, -29 },
  { 4082, 17, 36, 12, -2, -29 },
  { 4159, 10, 29, 17, 4, -29 },
  { 4196, 17, 36, 12, -3, -29 },
  { 4273, 20, 19, 19, -1, -29 },
  { 4321, 18, 4, 16, -4, 3 },
  { 4330, 9, 7, 13, 6, -31 },
  { 4338, 20, 23, 21, 1, -23 },
  { 4396, 20, 30, 21, 0, -30 },
  { 4471, 17, 23, 17, 1, -23 },
  { 4520, 22, 30, 21, 1, -30 },
  { 4603, 18, 22, 20, 1, -22 },
  { 4653, 22, 41, 14, -4, -31 },
  { 4766, 22, 33, 21, -1, -23 },
  { 4857, 20, 30, 21, 0, -30 },
  { 4932, 13, 31, 11, 0, -31 },
  { 4983, 18, 41, 11, -5, -31 },
  { 5076, 23, 30, 21, 0, -30 },
  { 5163, 13, 30, 11, 0, -30 },
  { 5212, 30, 23, 31, 0, -23 },
  { 5299, 20, 23, 21, 0, -23 },
  { 5357, 19, 23, 21, 1, -23 },
  { 5412, 22, 33, 21, -2, -23 },
  { 5503, 20, 33, 21, 1, -23 },
  { 5586, 17, 23, 15, 0, -23 },
  { 5635, 17, 23, 17, 0, -23 },
  { 5684, 14, 27, 15, 2, -27 },
  { 5732, 20, 22, 21, 1, -22 },
  { 5787, 20, 22, 19, 2, -22 },
  { 5842, 29, 22, 29, 2, -22 },
  { 5922, 24, 22, 20, -2, -22 },
  { 5988, 24, 32, 19, -2, -22 },
  { 6084, 19, 22, 17, -1, -22 },
  { 6137, 17, 35, 14, 0, -29 },
  { 6212, 6, 40, 18, 6, -31 },
  { 6242, 16, 35, 14, -2, -29 },
  { 6312, 18, 8, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_BlackItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC40PT7B_H_
