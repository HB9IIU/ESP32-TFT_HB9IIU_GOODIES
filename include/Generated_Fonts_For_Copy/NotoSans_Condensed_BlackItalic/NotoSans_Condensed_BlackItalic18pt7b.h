#ifndef _NOTOSANS_CONDENSED_BLACKITALIC18PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x00, 0x0E, 0x38, 0xE0, 0xEF,
  0xDF, 0xB6, 0x6D, 0xC0, 0x0E, 0xC1, 0x98, 0x36, 0x0E, 0xC7, 0xFE, 0xFF,
  0x86, 0xC7, 0xFE, 0xFF, 0x9F, 0xF1, 0xD8, 0x37, 0x06, 0xC0, 0x02, 0x01,
  0x07, 0xE7, 0xF3, 0x51, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x93, 0xDF, 0xEF,
  0xE0, 0x80, 0x40, 0x38, 0x71, 0xF1, 0x86, 0xCC, 0x3B, 0x30, 0xCD, 0x83,
  0x7E, 0xEF, 0xB7, 0x9D, 0xBF, 0x0E, 0xDC, 0x33, 0x61, 0xCD, 0x86, 0x3E,
  0x30, 0xF0, 0x0F, 0x01, 0xF8, 0x1D, 0x83, 0xB8, 0x3F, 0x81, 0xF1, 0x3E,
  0xE7, 0xEE, 0xEF, 0xCE, 0x7C, 0xF7, 0x8F, 0xFC, 0x7F, 0xC0, 0xFF, 0xEC,
  0x0E, 0x38, 0x61, 0xC3, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x1C,
  0x18, 0x38, 0x1C, 0x70, 0xC3, 0x0C, 0x31, 0xC7, 0x1C, 0x73, 0x8E, 0x31,
  0xC6, 0x30, 0x1C, 0x1C, 0x7C, 0xFF, 0x3F, 0x3C, 0x7C, 0x2E, 0x08, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x7B, 0x99, 0xC0, 0x7F,
  0xFE, 0xFF, 0x80, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x3F, 0x7F, 0x77,
  0xE7, 0xE7, 0xE7, 0xE7, 0xEE, 0xEE, 0xFC, 0xFC, 0x78, 0x0E, 0x3D, 0xF7,
  0xEF, 0xD3, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x00, 0x07, 0x87, 0xF1,
  0xFC, 0x67, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0xF9, 0xFC,
  0xFF, 0x00, 0x1F, 0x1F, 0xCF, 0xE0, 0x70, 0x78, 0xF8, 0xF8, 0x7E, 0x07,
  0x03, 0xB7, 0xDF, 0xCF, 0xC0, 0x03, 0x83, 0xC1, 0xE1, 0xE1, 0xF1, 0xF8,
  0xDC, 0xCE, 0xFF, 0xFF, 0xBF, 0xC1, 0xC1, 0xE0, 0x1F, 0x8F, 0xCF, 0xE7,
  0x03, 0x81, 0xF9, 0xFC, 0x0E, 0x07, 0x03, 0xB3, 0xDF, 0xCF, 0xC0, 0x0F,
  0x9F, 0x8F, 0xCE, 0x07, 0x47, 0xF3, 0xF9, 0xDE, 0xEF, 0x77, 0x3F, 0x9F,
  0x87, 0x80, 0x3F, 0xCF, 0xF3, 0xF8, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x1C, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0xCE, 0xE7, 0x73,
  0xB9, 0xF8, 0x78, 0xFE, 0x77, 0x73, 0xB9, 0xCF, 0xC7, 0xC0, 0x0F, 0x1F,
  0x8F, 0xEF, 0x77, 0x3B, 0x9D, 0xFE, 0xFE, 0x37, 0x03, 0xA7, 0x9F, 0x8F,
  0x80, 0x39, 0xCE, 0x00, 0x00, 0x0C, 0xE7, 0x00, 0x1C, 0x71, 0xC0, 0x00,
  0x00, 0x02, 0x71, 0xC6, 0x38, 0x01, 0x07, 0x3F, 0xFC, 0xE0, 0xF8, 0x3F,
  0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0xF8,
  0x3E, 0x0F, 0x3F, 0xF8, 0xE0, 0x80, 0x3D, 0xFD, 0xFA, 0x71, 0xE7, 0x9E,
  0x38, 0x00, 0x03, 0x87, 0x0E, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC1, 0x8E,
  0x76, 0x37, 0xED, 0x9B, 0x36, 0xCD, 0x9B, 0x36, 0x6D, 0xDB, 0xBF, 0xC6,
  0xEE, 0x18, 0x00, 0x79, 0xC0, 0xFF, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x3F,
  0x0F, 0xC7, 0x71, 0xDC, 0xF7, 0x3F, 0xCF, 0xF7, 0xFD, 0xC7, 0xF1, 0xC0,
  0x1F, 0x0F, 0xF3, 0xFC, 0xE7, 0x3B, 0xCF, 0xE7, 0xF1, 0xFE, 0x73, 0x9C,
  0xE7, 0xFB, 0xFC, 0xFE, 0x00, 0x0F, 0x9F, 0xDF, 0xCF, 0x0F, 0x07, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x3F, 0x9F, 0xC7, 0xE0, 0x1F, 0x0F, 0xE3, 0xFC,
  0xE7, 0x39, 0xCE, 0x77, 0x9D, 0xC7, 0x73, 0xDC, 0xE7, 0xFB, 0xFC, 0xFC,
  0x00, 0x1F, 0x9F, 0xCF, 0xE7, 0x03, 0x81, 0xF9, 0xFC, 0xFC, 0x70, 0x38,
  0x1F, 0x9F, 0xCF, 0xC0, 0x1F, 0x9F, 0xCF, 0xE7, 0x03, 0x81, 0xF9, 0xF8,
  0xFC, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x00, 0x0F, 0x87, 0xF3, 0xF9, 0xE0,
  0x70, 0x39, 0xEE, 0x7B, 0xBE, 0xE3, 0xB9, 0xCF, 0xF3, 0xFC, 0x7F, 0x00,
  0x1C, 0xE7, 0x9C, 0xE3, 0x9C, 0x73, 0x9E, 0x7F, 0x9F, 0xF3, 0xFE, 0x71,
  0xCE, 0x79, 0xCE, 0x71, 0xCE, 0x38, 0x1F, 0x8F, 0xC3, 0x81, 0xC0, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x0F, 0xCF, 0xE0, 0x03, 0x81, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0,
  0xE3, 0xF1, 0xF0, 0xF0, 0x00, 0x1C, 0xF3, 0xDE, 0x39, 0xC3, 0xB8, 0x3F,
  0x83, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x70, 0x77, 0x0E, 0x78, 0xE3,
  0x80, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x1E, 0x38, 0x70, 0xE1, 0xFF, 0xFF,
  0xE0, 0x1E, 0x3E, 0x7C, 0x7C, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC6, 0xDF,
  0x9D, 0xBE, 0x3B, 0xFC, 0x77, 0xB8, 0xEF, 0x71, 0x9C, 0xE7, 0x3B, 0x8E,
  0x77, 0x00, 0x1C, 0x73, 0xE7, 0x3E, 0x73, 0xE7, 0x3E, 0x73, 0x6E, 0x77,
  0xE7, 0x7E, 0x77, 0xE7, 0x7C, 0x63, 0xCE, 0x3C, 0xE3, 0xC0, 0x0F, 0x0F,
  0xE3, 0xFD, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xB9, 0xEF, 0xF3,
  0xFC, 0x7C, 0x00, 0x1F, 0x0F, 0xE3, 0xFC, 0xE7, 0x3B, 0xCE, 0xE7, 0xF9,
  0xFC, 0x7C, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x0F, 0xE3, 0xFD,
  0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xB9, 0xEF, 0xF3, 0xFC, 0x7C,
  0x07, 0x80, 0xE0, 0x3C, 0x1F, 0x0F, 0xE3, 0xFC, 0xE7, 0x3B, 0xCE, 0xE7,
  0xF9, 0xFC, 0x77, 0x1D, 0xC7, 0x73, 0x9E, 0xE7, 0x80, 0x0F, 0x1F, 0xCF,
  0xC7, 0x23, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x47, 0xBF, 0x9F, 0xCF, 0xC0,
  0x7F, 0xBF, 0xBF, 0xC3, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C,
  0x0E, 0x07, 0x00, 0x39, 0xDE, 0x77, 0x1D, 0xCF, 0x73, 0x9C, 0xEE, 0x3B,
  0x8E, 0xE7, 0x39, 0xCF, 0xF3, 0xF8, 0x7C, 0x00, 0xE3, 0xF1, 0xF9, 0xDC,
  0xEE, 0xE7, 0x73, 0xF9, 0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x0F, 0x00, 0x73,
  0x8E, 0xE7, 0x3D, 0x8E, 0x73, 0x3C, 0xEE, 0x7B, 0x9D, 0xF7, 0x3B, 0xEE,
  0x7F, 0xF8, 0xFF, 0xF1, 0xF7, 0xC3, 0xEF, 0x87, 0x9F, 0x0F, 0x3C, 0x00,
  0x1C, 0x71, 0xCE, 0x1F, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x1F, 0x83, 0xF8, 0x3B, 0x87, 0x38, 0xF3, 0xC0, 0xE7, 0xF3, 0xBB, 0xDD,
  0xCF, 0xC3, 0xE1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x00, 0x1F,
  0xE3, 0xF8, 0x7F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07,
  0x01, 0xFE, 0x3F, 0x8F, 0xF0, 0x0F, 0x1F, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x78, 0xF8, 0xCE, 0xEE, 0xE6,
  0x66, 0x77, 0x77, 0x30, 0x1E, 0x3C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x1C,
  0x30, 0xE1, 0xC3, 0x86, 0x3C, 0x78, 0x06, 0x07, 0x03, 0x83, 0xE3, 0xF1,
  0x99, 0xCD, 0xC6, 0xC3, 0x80, 0x7F, 0xFF, 0xEE, 0x70, 0x1D, 0xCF, 0xE7,
  0xF9, 0xCE, 0x73, 0x9D, 0xCF, 0x73, 0xFC, 0x7F, 0x1D, 0xC0, 0x1C, 0x0E,
  0x0E, 0x07, 0x03, 0xF1, 0xFD, 0xEE, 0xE7, 0x73, 0xB9, 0xDD, 0xDE, 0xEF,
  0xF7, 0xF0, 0x1F, 0x3F, 0x7A, 0x70, 0x70, 0x70, 0xF0, 0x74, 0x7C, 0x3C,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x1F, 0x8F, 0xE7, 0xF9, 0xCE, 0x73, 0x9D,
  0xCF, 0x73, 0xFC, 0x7F, 0x1D, 0xC0, 0x1F, 0x1F, 0xDE, 0xEE, 0x77, 0xF3,
  0xF3, 0x80, 0xE4, 0x7E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x78, 0x3C, 0x0F,
  0x87, 0xE1, 0xF0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0xF8, 0x3C, 0x00, 0x1D, 0xCF, 0xE7, 0xF9, 0xCE, 0x73, 0x9D,
  0xCF, 0x73, 0xFC, 0x7F, 0x1D, 0xC0, 0xE2, 0x38, 0xFE, 0x3F, 0x00, 0x1C,
  0x0E, 0x0E, 0x07, 0x03, 0xF1, 0xFD, 0xFE, 0xE7, 0x73, 0xB9, 0xDD, 0xDC,
  0xEE, 0x77, 0x38, 0x1C, 0xF1, 0x80, 0x38, 0xE3, 0x9C, 0x71, 0xC7, 0x38,
  0xE3, 0x80, 0x07, 0x0F, 0x06, 0x00, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xF0, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x39, 0xCE, 0xE7, 0x71, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xBC, 0xE7,
  0x39, 0xE0, 0x1C, 0x73, 0x8E, 0x38, 0xE7, 0x9C, 0x71, 0xC7, 0x38, 0xE3,
  0x80, 0x37, 0xB8, 0xFF, 0xF7, 0xFF, 0xDC, 0xEF, 0x73, 0xB9, 0xDE, 0xE7,
  0x73, 0xB9, 0xCE, 0xE7, 0x7B, 0x9D, 0xC0, 0x37, 0x1F, 0xDF, 0xEE, 0x77,
  0x3B, 0x9D, 0xDD, 0xCE, 0xE7, 0x73, 0x80, 0x1F, 0x1F, 0x9E, 0xEE, 0x77,
  0x3B, 0x9F, 0xDC, 0xEE, 0x7E, 0x1E, 0x00, 0x1B, 0x87, 0xF3, 0xDC, 0xE7,
  0x39, 0xCE, 0x73, 0xB9, 0xEE, 0x7F, 0x9F, 0xC7, 0x01, 0xC0, 0xE0, 0x38,
  0x00, 0x1D, 0xCF, 0xE7, 0xF9, 0xCE, 0x73, 0x9D, 0xCF, 0x73, 0xFC, 0x7F,
  0x1D, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0x37, 0x3E, 0x7E, 0x78, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x3F, 0x7E, 0x72, 0x78, 0x7C, 0x3E, 0x1E,
  0x9E, 0xFC, 0xF8, 0x38, 0xC7, 0xFF, 0xFD, 0xCE, 0x38, 0xE3, 0xAF, 0xBE,
  0x39, 0xCE, 0xE7, 0x39, 0xCE, 0x73, 0x9D, 0xE7, 0x73, 0xFC, 0x7F, 0x1F,
  0xC0, 0xE7, 0xF3, 0xBB, 0xDD, 0xCE, 0xE7, 0xE3, 0xF0, 0xF0, 0x78, 0x38,
  0x00, 0xE7, 0x3F, 0x7B, 0xBB, 0xDD, 0xDE, 0xEF, 0xBE, 0x7D, 0xF3, 0xEF,
  0x1E, 0xF8, 0xF7, 0x87, 0xBC, 0x00, 0x3D, 0xE3, 0xB8, 0x7E, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x77, 0x1E, 0xF0, 0x39, 0xE7, 0x38, 0xEF,
  0x1D, 0xC3, 0xB8, 0x7E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1C,
  0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x9F, 0xCF, 0xC1, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF2, 0x7E, 0x7F, 0x00, 0x07, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x78, 0xF0,
  0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x18, 0x38, 0xF0, 0xE1, 0xC3, 0x87, 0x07, 0x1E, 0x78, 0xE1, 0xC7,
  0x1E, 0x3C, 0x70, 0xF1, 0xFF, 0x9F,
};

const GFXglyph NotoSans_Condensed_BlackItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 13, 5, 0, -13 },
  { 11, 7, 5, 8, 2, -13 },
  { 16, 11, 13, 10, 0, -13 },
  { 34, 9, 15, 9, 0, -14 },
  { 51, 14, 13, 15, 1, -13 },
  { 74, 12, 13, 11, 0, -13 },
  { 94, 3, 5, 4, 2, -13 },
  { 96, 7, 16, 6, 0, -13 },
  { 110, 6, 16, 6, -1, -13 },
  { 122, 8, 9, 9, 1, -14 },
  { 131, 8, 9, 9, 1, -11 },
  { 140, 5, 4, 5, -1, -2 },
  { 143, 5, 3, 6, 0, -6 },
  { 145, 3, 3, 5, 0, -3 },
  { 147, 10, 13, 8, -1, -13 },
  { 164, 8, 13, 9, 1, -13 },
  { 177, 7, 13, 9, 2, -13 },
  { 189, 10, 13, 9, -1, -13 },
  { 206, 9, 13, 9, 0, -13 },
  { 221, 9, 13, 9, 0, -13 },
  { 236, 9, 13, 9, 0, -13 },
  { 251, 9, 13, 9, 1, -13 },
  { 266, 10, 13, 9, 0, -13 },
  { 283, 9, 13, 9, 0, -13 },
  { 298, 9, 13, 9, 0, -13 },
  { 313, 5, 10, 5, 0, -10 },
  { 320, 6, 12, 5, -1, -10 },
  { 329, 8, 9, 9, 1, -11 },
  { 338, 8, 7, 9, 1, -10 },
  { 345, 8, 9, 9, 1, -11 },
  { 354, 7, 13, 7, 1, -13 },
  { 366, 14, 14, 14, 0, -13 },
  { 391, 10, 13, 10, -1, -13 },
  { 408, 10, 13, 10, 0, -13 },
  { 425, 9, 13, 9, 1, -13 },
  { 440, 10, 13, 11, 0, -13 },
  { 457, 9, 13, 8, 0, -13 },
  { 472, 9, 13, 8, 0, -13 },
  { 487, 10, 13, 11, 1, -13 },
  { 504, 11, 13, 11, 0, -13 },
  { 522, 9, 13, 7, -1, -13 },
  { 537, 9, 17, 5, -3, -13 },
  { 557, 12, 13, 10, 0, -13 },
  { 577, 7, 13, 8, 0, -13 },
  { 589, 15, 13, 14, 0, -13 },
  { 614, 12, 13, 12, 0, -13 },
  { 634, 10, 13, 11, 1, -13 },
  { 651, 10, 13, 9, 0, -13 },
  { 668, 10, 16, 11, 1, -13 },
  { 688, 10, 13, 10, 0, -13 },
  { 705, 9, 13, 8, 0, -13 },
  { 720, 9, 13, 8, 1, -13 },
  { 735, 10, 13, 11, 1, -13 },
  { 752, 9, 13, 10, 2, -13 },
  { 767, 15, 13, 14, 1, -13 },
  { 792, 12, 13, 10, -1, -13 },
  { 812, 9, 13, 9, 2, -13 },
  { 827, 11, 13, 8, -1, -13 },
  { 845, 8, 16, 6, -1, -13 },
  { 861, 4, 13, 8, 2, -13 },
  { 868, 7, 16, 6, -1, -13 },
  { 882, 9, 9, 9, 0, -13 },
  { 893, 8, 2, 7, -2, 1 },
  { 895, 4, 3, 6, 3, -14 },
  { 897, 10, 10, 9, 0, -10 },
  { 910, 9, 14, 9, 0, -14 },
  { 926, 8, 10, 8, 0, -10 },
  { 936, 10, 14, 9, 0, -14 },
  { 954, 9, 10, 9, 0, -10 },
  { 966, 10, 18, 6, -2, -14 },
  { 989, 10, 14, 9, 0, -10 },
  { 1007, 9, 14, 10, 0, -14 },
  { 1023, 6, 14, 5, 0, -14 },
  { 1034, 8, 18, 5, -2, -14 },
  { 1052, 10, 14, 9, 0, -14 },
  { 1070, 6, 14, 5, 0, -14 },
  { 1081, 14, 10, 14, 0, -10 },
  { 1099, 9, 10, 10, 0, -10 },
  { 1111, 9, 10, 9, 0, -10 },
  { 1123, 10, 14, 9, -1, -10 },
  { 1141, 10, 14, 9, 0, -10 },
  { 1159, 8, 10, 7, 0, -10 },
  { 1169, 8, 10, 8, 0, -10 },
  { 1179, 6, 12, 7, 1, -12 },
  { 1188, 10, 10, 10, 0, -10 },
  { 1201, 9, 10, 9, 1, -10 },
  { 1213, 13, 10, 13, 1, -10 },
  { 1230, 11, 10, 9, -1, -10 },
  { 1244, 11, 14, 9, -1, -10 },
  { 1264, 9, 10, 8, -1, -10 },
  { 1276, 8, 16, 6, 0, -13 },
  { 1292, 2, 18, 8, 3, -14 },
  { 1297, 7, 16, 6, -1, -13 },
  { 1311, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_BlackItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC18PT7B_H_
