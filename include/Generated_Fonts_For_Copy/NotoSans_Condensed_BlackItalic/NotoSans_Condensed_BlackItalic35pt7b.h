#ifndef _NOTOSANS_CONDENSED_BLACKITALIC35PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xF8, 0x00,
  0x7E, 0x7E, 0xFC, 0xF9, 0xFB, 0xF3, 0xE7, 0xE7, 0xCF, 0xCF, 0x9F, 0x1F,
  0x3E, 0x7C, 0x7C, 0xF8, 0xF0, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x00, 0x3C,
  0x78, 0x01, 0xE7, 0xC0, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x03,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x0F, 0x9E,
  0x00, 0x78, 0xF0, 0x03, 0xCF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x07, 0x8F, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0x80,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0x62, 0x1F, 0x30, 0x0F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x6F, 0x98, 0x77, 0xCF, 0x37, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1,
  0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x0F, 0xC0, 0x3E, 0x07, 0xF8, 0x0F, 0x03, 0xFE, 0x07, 0xC1, 0xFF,
  0xC3, 0xE0, 0x7D, 0xF0, 0xF0, 0x1E, 0x7C, 0x7C, 0x0F, 0x9F, 0x1E, 0x03,
  0xE7, 0x8F, 0x00, 0xF1, 0xE7, 0xC0, 0x3C, 0xF9, 0xE0, 0x0F, 0x3E, 0xF9,
  0xFB, 0xFF, 0x7C, 0xFF, 0xFF, 0xDE, 0x7F, 0xDF, 0xEF, 0xBF, 0xF3, 0xF3,
  0xCF, 0x3C, 0x01, 0xF7, 0xCF, 0x00, 0xF9, 0xF3, 0xC0, 0x3C, 0x78, 0xF0,
  0x1F, 0x1E, 0x3C, 0x07, 0x87, 0x9F, 0x03, 0xC1, 0xE7, 0x81, 0xF0, 0x7F,
  0xE0, 0x78, 0x1F, 0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xE7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0x0F, 0xF8, 0xFC, 0xFF,
  0xF7, 0xE3, 0xFF, 0xDF, 0x9F, 0xBF, 0xFC, 0x7E, 0x7F, 0xF3, 0xF1, 0xFF,
  0x8F, 0xC3, 0xFE, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xE7, 0xF0, 0x7E, 0xFD, 0xFB, 0xE7,
  0xCF, 0x9F, 0x7C, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0x01, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x21, 0xE0, 0x39, 0xE0, 0x7F, 0xE6,
  0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x1F, 0xE0, 0x3F, 0xF0,
  0x7E, 0xF8, 0x3E, 0xF8, 0x1C, 0xFC, 0x08, 0x70, 0x00, 0x40, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE1,
  0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x00, 0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0xEF,
  0xFC, 0x3C, 0xFB, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0xFC, 0xFC,
  0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0xBF, 0x0F, 0xDF, 0x8F, 0xCF, 0xC7, 0xE7,
  0xE3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F,
  0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF8, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x7F, 0xF1, 0xEF, 0xC3, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC1,
  0xE3, 0xF0, 0x30, 0xFC, 0x08, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x1F,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0x87, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC8, 0x07, 0xF3, 0x03, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xF0, 0x3C, 0xF8, 0x1F, 0x7E, 0x0F,
  0x9F, 0x83, 0xC7, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x20, 0x3F, 0x10, 0x3F, 0x8F, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x38, 0x0F, 0xBF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x7F, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x40, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E,
  0x0F, 0xDF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3,
  0xF3, 0xF0, 0xFC, 0x7E, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xF1, 0xF9, 0xF8, 0xFC, 0x7C, 0xFE, 0x3F, 0x7E, 0x3F, 0x3F, 0x1F,
  0x9F, 0x8F, 0xCF, 0xEF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F,
  0xFC, 0x0E, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x03, 0xE1,
  0xFC, 0x7F, 0x1F, 0x87, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC1, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xE0, 0x00, 0xC0,
  0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x0F, 0xF8, 0x7F, 0xE7,
  0xFF, 0x1F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0xF0, 0x01, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE3, 0x0F, 0xC8, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x0F, 0xE0, 0x7C,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x3F, 0x1E, 0x3C, 0x7F, 0xEF, 0x3C,
  0x7F, 0xE7, 0x9E, 0x7F, 0xF3, 0xDE, 0x3C, 0x79, 0xEF, 0x3E, 0x3C, 0xF7,
  0x9E, 0x3C, 0x7F, 0x8F, 0x1E, 0x3F, 0xCF, 0x8F, 0x1F, 0xE7, 0x8F, 0x9E,
  0xF3, 0xC7, 0xCF, 0x79, 0xF7, 0xEF, 0x3C, 0xFF, 0xFF, 0x1E, 0x3F, 0xFF,
  0x8F, 0x0F, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x03,
  0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xBE, 0x01, 0xFB,
  0xE0, 0x1F, 0xBE, 0x01, 0xF3, 0xE0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x7F, 0x03, 0xF7,
  0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC7, 0xE1, 0xF9, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0x3F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0xC3,
  0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xC3, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x86, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0xFF, 0x0F,
  0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1,
  0xF8, 0x3F, 0x1F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x3F, 0x0F, 0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE7, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x10, 0x7F, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE, 0x0C, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x3F, 0xE7, 0xE3, 0xFE, 0x7E,
  0x3F, 0xE7, 0xE7, 0xFC, 0xFE, 0x7F, 0xCF, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x01,
  0x3F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x01, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x07, 0xF8,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC7, 0xFF, 0x07, 0xFE,
  0x3F, 0xF8, 0x3E, 0xF3, 0xEF, 0x81, 0xF7, 0xDF, 0xFC, 0x1F, 0xBF, 0xF7,
  0xE0, 0xFD, 0xFF, 0xBF, 0x07, 0xEF, 0xF9, 0xF0, 0x3E, 0x7F, 0xDF, 0x81,
  0xF3, 0xFE, 0xFC, 0x1F, 0x9F, 0xE7, 0xE0, 0xFC, 0xFF, 0x3F, 0x07, 0xE7,
  0xF1, 0xF0, 0x3E, 0x3F, 0x9F, 0x81, 0xF1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC7,
  0xE0, 0xFC, 0x7C, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x07, 0xF8, 0x3F, 0x07,
  0xF8, 0x3F, 0x07, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x7E, 0x0F,
  0xFC, 0x7E, 0x0F, 0xFC, 0x7E, 0x0F, 0xFC, 0x7C, 0x1F, 0xFC, 0x7C, 0x1F,
  0x7C, 0xFC, 0x1F, 0x7E, 0xFC, 0x1F, 0x7E, 0xFC, 0x3F, 0x3E, 0xF8, 0x3F,
  0x3E, 0xF8, 0x3F, 0x3F, 0xF8, 0x3E, 0x3F, 0xF8, 0x3E, 0x3F, 0xF8, 0x7E,
  0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C,
  0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC3, 0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7F, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0x7E, 0x1F, 0xC7, 0xE3, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0x9F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF1, 0xFC, 0x7E,
  0x3F, 0x0F, 0xDF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFE, 0x7F, 0x1F, 0xC3, 0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F,
  0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x1F, 0xC7, 0xE3,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x9F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE3, 0xF1, 0xFC, 0x7E, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC1,
  0xF9, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F, 0x8F, 0xE7,
  0xE0, 0xFC, 0xFC, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xF1, 0xC1, 0xF8, 0x10, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x84, 0x0F, 0xE3,
  0xC7, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xF0,
  0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83,
  0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F,
  0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x7F,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x1F,
  0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x87, 0xEF, 0xC3, 0xF8, 0x7E,
  0xFC, 0x3F, 0x8F, 0xCF, 0xC7, 0xF8, 0xFC, 0xFC, 0x7F, 0x8F, 0xCF, 0xCF,
  0xF1, 0xF8, 0xFC, 0xFF, 0x1F, 0x8F, 0xCF, 0xF1, 0xF0, 0xFD, 0xFF, 0x3F,
  0x0F, 0x9F, 0xF3, 0xF0, 0xFB, 0xEF, 0x7E, 0x0F, 0xBF, 0xF7, 0xE0, 0xFB,
  0xFF, 0x7C, 0x0F, 0xFD, 0xFF, 0xC0, 0xFF, 0xDF, 0xFC, 0x0F, 0xF9, 0xFF,
  0x80, 0xFF, 0x9F, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF1, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03,
  0xF9, 0xFC, 0x01, 0xFB, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F,
  0xDF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x8F, 0xC0, 0x3F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0x87, 0xF7, 0xE3, 0xF9,
  0xF8, 0xFC, 0x7E, 0x7F, 0x1F, 0x9F, 0x87, 0xEF, 0xE1, 0xFB, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xF3, 0xC0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0x7D, 0xF0, 0x1F, 0xFC, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0xFC, 0x7E, 0x7E,
  0x3E, 0x1F, 0x1F, 0x03, 0x80, 0x43, 0xFB, 0xE1, 0xFE, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFF, 0x8F, 0xCF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xF7, 0xC0, 0xF9, 0xF0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x30, 0x0F, 0xBF, 0x03, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xDF, 0xC7, 0xE7, 0xF3, 0xF1, 0xFC, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0x87, 0xE3, 0xE1, 0xF9, 0xF8, 0xFE, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3E, 0xFF, 0x0F, 0x9F,
  0x00, 0x00, 0xE0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xF3,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x0C, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC0, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x1C, 0x7E, 0x0F, 0xEF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xF3, 0xF8, 0xFE, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xF1, 0xF8,
  0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xEF, 0x80, 0xF9, 0xF0, 0x00, 0x00, 0x60, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x08, 0xFE, 0x38, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xE4, 0x00, 0x7E, 0x00, 0x07, 0xE4, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x04, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x10, 0x1F, 0xBE, 0x03, 0xFB, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFD, 0xFE, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F,
  0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x80,
  0x7E, 0x0F, 0x9F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x38, 0x0F, 0xBF, 0x03, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xDF, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE0, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC7, 0xF1, 0xF8, 0xFE,
  0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0xFC,
  0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x0E, 0x07,
  0x01, 0xF7, 0xF3, 0xF0, 0x3F, 0xFE, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xBF, 0xDF, 0xC7, 0xE7, 0xF3, 0xF1, 0xFC, 0xFE, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x80, 0x00, 0x0E, 0x03, 0xEF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF7, 0xF1, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF,
  0x3F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0x00, 0x3E, 0xFC, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xE7, 0xF0,
  0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF7, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0x41, 0xFB, 0xE0, 0xFE, 0xF8, 0x7F,
  0xFE, 0x3F, 0xFF, 0x8F, 0xDF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xCF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFB,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x1F, 0x7C, 0x3D,
  0xF0, 0xFB, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFA, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x0F,
  0xF8, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xE1, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x20,
  0x7E, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFE,
  0xBF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF,
  0x00, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0x87, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF,
  0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xDF, 0x03, 0xE7, 0xC0, 0xFC, 0x3F, 0xFE, 0x1F,
  0xBF, 0x1F, 0xDF, 0x8F, 0xCF, 0xC7, 0xE7, 0xE7, 0xE3, 0xF3, 0xF0, 0xFB,
  0xF0, 0x7D, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x00, 0xFC, 0x7F, 0x1F, 0xFE, 0x3F, 0x8F, 0xBF, 0x3F, 0xCF, 0xDF, 0x9F,
  0xE7, 0xEF, 0xDF, 0xF7, 0xE7, 0xEF, 0xF3, 0xF3, 0xF7, 0xF9, 0xF1, 0xF7,
  0xFD, 0xF8, 0xFB, 0xDE, 0xF8, 0x7D, 0xEF, 0x7C, 0x3F, 0xF7, 0xFE, 0x1F,
  0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0x81,
  0xFE, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x00, 0x0F, 0xE3, 0xF8, 0x3F, 0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x03, 0xF9, 0xFC,
  0x3F, 0x87, 0xE0, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xFB, 0xF0,
  0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0xF8,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0xE0,
  0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x08, 0x00, 0x00, 0x0C,
  0x01, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80,
  0x3E,
};

const GFXglyph NotoSans_Condensed_BlackItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 25, 10, 0, -25 },
  { 36, 15, 9, 16, 3, -25 },
  { 53, 21, 25, 20, 0, -25 },
  { 119, 17, 29, 18, 1, -27 },
  { 181, 26, 25, 29, 2, -25 },
  { 263, 22, 25, 22, 0, -25 },
  { 332, 7, 9, 8, 3, -25 },
  { 340, 13, 32, 11, 1, -26 },
  { 392, 13, 32, 11, -3, -26 },
  { 444, 16, 17, 17, 2, -27 },
  { 478, 15, 17, 18, 2, -21 },
  { 510, 9, 10, 10, -2, -5 },
  { 522, 11, 5, 11, 0, -12 },
  { 529, 7, 6, 10, 0, -6 },
  { 535, 20, 25, 15, -2, -25 },
  { 598, 17, 25, 18, 1, -25 },
  { 652, 14, 25, 18, 3, -25 },
  { 696, 18, 25, 18, -1, -25 },
  { 753, 18, 25, 18, 0, -25 },
  { 810, 18, 25, 18, 0, -25 },
  { 867, 17, 25, 18, 1, -25 },
  { 921, 18, 25, 18, 1, -25 },
  { 978, 19, 25, 18, 1, -25 },
  { 1038, 18, 25, 18, 0, -25 },
  { 1095, 17, 25, 18, 1, -25 },
  { 1149, 10, 20, 10, 0, -20 },
  { 1174, 12, 25, 10, -2, -20 },
  { 1212, 16, 18, 18, 1, -22 },
  { 1248, 15, 13, 18, 2, -19 },
  { 1273, 15, 18, 18, 2, -22 },
  { 1307, 15, 25, 14, 1, -25 },
  { 1354, 25, 28, 27, 1, -25 },
  { 1442, 20, 25, 20, -2, -25 },
  { 1505, 20, 25, 19, 0, -25 },
  { 1568, 19, 25, 18, 1, -25 },
  { 1628, 20, 25, 20, 0, -25 },
  { 1691, 18, 25, 16, 0, -25 },
  { 1748, 18, 25, 16, 0, -25 },
  { 1805, 20, 25, 21, 1, -25 },
  { 1868, 22, 25, 21, 0, -25 },
  { 1937, 17, 25, 14, -1, -25 },
  { 1991, 18, 33, 11, -6, -25 },
  { 2066, 23, 25, 20, 0, -25 },
  { 2138, 14, 25, 15, 0, -25 },
  { 2182, 29, 25, 28, 0, -25 },
  { 2273, 24, 25, 23, 0, -25 },
  { 2348, 20, 25, 22, 1, -25 },
  { 2411, 19, 25, 18, 0, -25 },
  { 2471, 20, 31, 22, 1, -25 },
  { 2549, 19, 25, 19, 0, -25 },
  { 2609, 18, 25, 16, 0, -25 },
  { 2666, 16, 25, 16, 3, -25 },
  { 2716, 21, 25, 21, 1, -25 },
  { 2782, 19, 25, 19, 3, -25 },
  { 2842, 28, 25, 28, 3, -25 },
  { 2930, 24, 25, 19, -2, -25 },
  { 3005, 18, 25, 18, 3, -25 },
  { 3062, 20, 25, 16, -1, -25 },
  { 3125, 16, 32, 11, -2, -26 },
  { 3189, 8, 25, 15, 4, -25 },
  { 3214, 15, 32, 11, -3, -26 },
  { 3274, 18, 17, 17, -1, -25 },
  { 3313, 15, 4, 14, -3, 2 },
  { 3321, 8, 6, 12, 5, -27 },
  { 3327, 18, 20, 18, 1, -20 },
  { 3372, 18, 27, 18, 0, -27 },
  { 3433, 15, 20, 15, 1, -20 },
  { 3471, 19, 27, 18, 1, -27 },
  { 3536, 16, 20, 17, 1, -20 },
  { 3576, 20, 35, 12, -4, -27 },
  { 3664, 20, 28, 18, -1, -20 },
  { 3734, 18, 27, 19, 0, -27 },
  { 3795, 11, 27, 10, 0, -27 },
  { 3833, 15, 35, 10, -4, -27 },
  { 3899, 20, 27, 18, 0, -27 },
  { 3967, 11, 27, 10, 0, -27 },
  { 4005, 27, 20, 27, 0, -20 },
  { 4073, 18, 20, 19, 0, -20 },
  { 4118, 16, 20, 18, 1, -20 },
  { 4158, 20, 28, 18, -2, -20 },
  { 4228, 18, 28, 18, 1, -20 },
  { 4291, 15, 20, 13, 0, -20 },
  { 4329, 15, 20, 15, 0, -20 },
  { 4367, 13, 23, 13, 1, -23 },
  { 4405, 18, 19, 19, 1, -19 },
  { 4448, 17, 19, 17, 2, -19 },
  { 4489, 25, 19, 25, 2, -19 },
  { 4549, 21, 19, 17, -2, -19 },
  { 4599, 21, 27, 17, -2, -19 },
  { 4670, 17, 19, 15, -1, -19 },
  { 4711, 15, 31, 12, 0, -25 },
  { 4770, 5, 35, 16, 5, -27 },
  { 4792, 14, 31, 12, -2, -25 },
  { 4847, 16, 7, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_BlackItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC35PT7B_H_
