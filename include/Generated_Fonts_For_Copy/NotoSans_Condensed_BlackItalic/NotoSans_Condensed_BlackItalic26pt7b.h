#ifndef _NOTOSANS_CONDENSED_BLACKITALIC26PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x40, 0x00, 0x30, 0x78, 0xF8, 0xF8, 0xF0, 0x7D, 0xEF, 0x3D, 0xE7,
  0xBD, 0xE7, 0xBC, 0xE7, 0xBC, 0xE0, 0x03, 0xDE, 0x07, 0x38, 0x0E, 0x70,
  0x1D, 0xE0, 0x73, 0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1C,
  0xE0, 0x7B, 0xC3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x0E, 0x70, 0x1C, 0xE0,
  0x39, 0xC0, 0xE7, 0x01, 0xCE, 0x00, 0x00, 0xC0, 0x06, 0x00, 0xFC, 0x1F,
  0xF1, 0xFF, 0x8F, 0xF8, 0xF6, 0x47, 0xB0, 0x1F, 0x00, 0xFC, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0x79, 0x1B, 0xCF, 0xFC, 0x7F, 0xE7, 0xFE, 0x0F,
  0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x03, 0xC1, 0xF8, 0x38, 0x3F,
  0x87, 0x07, 0xB8, 0xF0, 0x73, 0x8E, 0x07, 0x39, 0xE0, 0x73, 0x9C, 0x0F,
  0x7B, 0x80, 0xF7, 0x7B, 0xE7, 0xF7, 0x7F, 0x7E, 0xEF, 0xF3, 0x9E, 0xE7,
  0x01, 0xCE, 0x70, 0x3C, 0xE7, 0x03, 0x9E, 0xF0, 0x71, 0xEE, 0x0F, 0x0F,
  0xE0, 0xE0, 0xFC, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x8F, 0xE7, 0x8F, 0xF7, 0xCF, 0xFF, 0xCF, 0xBF, 0xE7, 0xCF, 0xE3,
  0xE7, 0xF1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xEF, 0x80, 0x7D,
  0xE7, 0x9E, 0x79, 0xCF, 0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x1E, 0x0F, 0x00, 0x0F, 0x01, 0xE1, 0x3C, 0x37, 0x0F, 0xFF, 0xFF, 0xC7,
  0xF9, 0xF8, 0x7F, 0x1F, 0xF0, 0xCF, 0x09, 0x80, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x3C, 0xF7, 0x9E, 0x7B, 0xCF, 0x38, 0x7F, 0x7F,
  0x7E, 0xFE, 0x23, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0xFE, 0x1F, 0xE3, 0xFF, 0x3C, 0xF7,
  0xCF, 0x7C, 0xF7, 0x8F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x1E, 0xF1, 0xEF,
  0x3E, 0xF3, 0xCF, 0xFC, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x7C,
  0x3F, 0x0F, 0xE3, 0xFC, 0xFF, 0xBF, 0xE3, 0xBC, 0x27, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x00,
  0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0x0E, 0x7C, 0x11, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xC0,
  0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0x8F, 0x80, 0x7C, 0x03, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7C, 0x07, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFA, 0x07, 0xDF, 0xFC,
  0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x1D, 0xF1, 0xEF, 0x0E, 0x78, 0xE3,
  0xDF, 0xFF, 0x7F, 0xFB, 0xFF, 0xC0, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFA, 0x0F,
  0x9F, 0xFC, 0xFF, 0xC7, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3F, 0xE3, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x78, 0x7F, 0xE7, 0xFF, 0x3F,
  0xF9, 0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0xCF, 0x9F, 0xF8, 0xFF, 0xC3, 0xFC,
  0x0F, 0xC0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x3F,
  0x83, 0xFE, 0x3F, 0xF1, 0xE7, 0x8F, 0x3C, 0x7B, 0xE3, 0xFE, 0x0F, 0xE0,
  0x7E, 0x07, 0xF8, 0x7B, 0xC7, 0x9F, 0x7C, 0x7B, 0xE7, 0xDF, 0x3C, 0x7F,
  0xE3, 0xFE, 0x0F, 0xE0, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0xFF, 0x7D, 0xF7,
  0x8F, 0x79, 0xF7, 0x9F, 0x79, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x3B, 0xE0,
  0x3C, 0x07, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x0C, 0x3C, 0xF9,
  0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC3, 0xCF, 0x9F, 0x3C, 0x00, 0x03,
  0x03, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x00, 0x00, 0x10, 0x07,
  0x01, 0xF0, 0xFF, 0x3F, 0xCF, 0xF0, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xF0, 0x7F, 0x1F, 0xCF, 0xF0, 0xFC, 0x0F,
  0x00, 0xC0, 0x00, 0x0F, 0x07, 0xF9, 0xFF, 0x3F, 0xF2, 0x3E, 0x07, 0xC0,
  0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x04, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0x81, 0xE1, 0xC0, 0x1C, 0x71, 0xFB, 0x9E, 0x7F, 0x3B, 0x9F,
  0xE7, 0x77, 0x9C, 0xFC, 0xE7, 0xBB, 0x9C, 0xE7, 0x77, 0x9C, 0xEE, 0xF7,
  0x99, 0xDE, 0xFF, 0x39, 0xFF, 0xC7, 0x3C, 0xF0, 0xE0, 0x00, 0x1E, 0x01,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x07,
  0xDE, 0x0F, 0x3C, 0x3E, 0x78, 0x78, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x9F, 0x0F, 0x3C, 0x1E, 0xF8, 0x3F, 0xF0, 0x78, 0x0F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC7, 0xFF, 0x1F, 0x7C, 0x78, 0xF1, 0xE7, 0xCF, 0xBF, 0x3F, 0xF8,
  0xFF, 0x83, 0xFF, 0x0F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0xFC,
  0x7F, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0x87,
  0xFE, 0x3F, 0x10, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x82, 0x3F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1,
  0xF7, 0xE3, 0xC7, 0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0,
  0xF9, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x9F, 0x3E, 0x3F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0xE0, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xE3, 0xF0, 0x87, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x79, 0xFD, 0xF3,
  0xFB, 0xE7, 0xE7, 0xDF, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC3,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x7F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0x87, 0x87, 0xC7, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x00, 0x0F,
  0xF8, 0x7F, 0xC7, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0x80, 0xF0, 0x00, 0x0F,
  0x0F, 0x87, 0x8F, 0x83, 0xCF, 0xC3, 0xE7, 0xC1, 0xF7, 0xC0, 0xF7, 0xC0,
  0x7B, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xF3, 0xE0, 0x78, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x81,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE,
  0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0xC7, 0xF9,
  0xFE, 0x3D, 0xCF, 0xF1, 0xEE, 0xFF, 0x0F, 0x77, 0x78, 0x7B, 0xFB, 0xC7,
  0xDF, 0xBE, 0x3C, 0xFD, 0xF1, 0xE7, 0xEF, 0x0F, 0x3E, 0x78, 0x79, 0xF3,
  0xC7, 0xCF, 0x3E, 0x3C, 0x79, 0xF0, 0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0xF8,
  0x7C, 0x7F, 0x1E, 0x1F, 0xC7, 0x87, 0xF1, 0xE1, 0xFC, 0xF8, 0xFF, 0xBC,
  0x3D, 0xEF, 0x0F, 0x7B, 0xC3, 0xDE, 0xF0, 0xF7, 0xBC, 0x7C, 0xFE, 0x1E,
  0x3F, 0x87, 0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0xFE, 0x3E, 0x1F, 0x0F, 0x07,
  0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xF3, 0xE7, 0xC7,
  0xDF, 0x0F, 0xBE, 0x1F, 0x78, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xEF,
  0x87, 0xDF, 0x0F, 0xBE, 0x3E, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x7E,
  0x00, 0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0x7C, 0x79, 0xF1,
  0xE7, 0xCF, 0x9F, 0x3E, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x7F, 0x81,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xF3, 0xE7, 0xC7, 0xDF, 0x0F,
  0xBE, 0x1F, 0x78, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xEF, 0x87, 0xDF,
  0x0F, 0xBE, 0x3E, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x1F, 0x7C, 0x79, 0xF1, 0xE7, 0xCF, 0x9F, 0x3E, 0xF8, 0xFF,
  0xE3, 0xFF, 0x0F, 0xF8, 0x7D, 0xE1, 0xF7, 0x87, 0xDF, 0x1E, 0x7C, 0x79,
  0xF3, 0xE3, 0xEF, 0x8F, 0x80, 0x01, 0xE0, 0x7F, 0xC7, 0xFE, 0x3F, 0xE3,
  0xE3, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF3, 0x0F, 0x9F, 0xFC, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0,
  0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0xF8, 0x00, 0x1E, 0x1E, 0x3C, 0x7C, 0xF8, 0xF9, 0xF1,
  0xF3, 0xE3, 0xC7, 0x87, 0x8F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF1,
  0xE1, 0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1E, 0x3E, 0x7C, 0x7F, 0xF8, 0xFF,
  0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7,
  0xCF, 0x8F, 0x9F, 0x1E, 0x3E, 0x7C, 0x3C, 0xF0, 0x7B, 0xE0, 0xF7, 0x81,
  0xEF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x78, 0x7F, 0xC7, 0xC7, 0xFE, 0x3E,
  0x3D, 0xF1, 0xF3, 0xEF, 0x1F, 0x9F, 0x78, 0xFC, 0xF3, 0xCF, 0xCF, 0x9E,
  0x7E, 0x78, 0xF7, 0xF3, 0xC7, 0xBF, 0xBE, 0x3D, 0xDD, 0xE1, 0xFE, 0xEF,
  0x0F, 0xF7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC,
  0x7E, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0xC1, 0xF1, 0xF0,
  0x7C, 0xF8, 0x1F, 0x7C, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3E, 0x7C, 0x1F, 0x0F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x7D, 0xE3, 0xE7, 0x8F, 0x9E, 0x7C, 0x79, 0xE1, 0xFF,
  0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x80,
  0x07, 0xE0, 0xFC, 0x3F, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0xE1, 0xF8, 0x3F, 0x00, 0xE3, 0xCF, 0x3C, 0xF3,
  0xC7, 0x1C, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x8F, 0x3C, 0xF3, 0xC0, 0x07,
  0xE0, 0xFC, 0x3F, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x78, 0x0F, 0x07, 0xE1, 0xFC, 0x3F, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x7E, 0x07, 0xF0, 0x3B, 0x83, 0xDC, 0x3C, 0xF1, 0xC7, 0x9E,
  0x1D, 0xE0, 0xEF, 0x07, 0x80, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0xFB, 0xE7,
  0x8F, 0x0C, 0x00, 0xFB, 0xCF, 0xFC, 0xFF, 0xE7, 0xDF, 0x7C, 0xFB, 0xE7,
  0xDE, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE1,
  0xEF, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x30,
  0x7F, 0xC7, 0xFF, 0x3F, 0xF9, 0xF7, 0xCF, 0x1E, 0x79, 0xF7, 0xCF, 0xBC,
  0x7D, 0xE3, 0xCF, 0x3E, 0x7F, 0xF7, 0xFF, 0x3F, 0xF1, 0xEF, 0x00, 0x03,
  0x03, 0xFC, 0xFF, 0x3F, 0xE7, 0xC9, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC2, 0x7D, 0x8F, 0xF0, 0xFE, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x33, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xF1,
  0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF8,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1E, 0xF0, 0x03, 0x01, 0xFC, 0x3F, 0xE7,
  0xFF, 0x78, 0xFF, 0x9E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0x00, 0xF0, 0x0F,
  0x88, 0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1E, 0x00, 0x7C, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x02, 0x00, 0x3E, 0xF1, 0xFF,
  0x8F, 0xFE, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x9F, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xDE, 0x00, 0xF8, 0x03,
  0xC3, 0x1F, 0x0F, 0xF8, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x20, 0x7F, 0xC7, 0xFF, 0x3F, 0xF9, 0xF7,
  0xCF, 0x3E, 0x79, 0xF7, 0xCF, 0xBE, 0x79, 0xE3, 0xCF, 0x1E, 0x79, 0xF7,
  0xCF, 0xBE, 0x79, 0xE3, 0xC0, 0x0F, 0x0F, 0x1F, 0x0E, 0x00, 0x00, 0x1E,
  0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF8,
  0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x3F, 0x87, 0xE0, 0xFC, 0x1F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x47, 0x8F, 0x1F, 0x3C, 0x3E, 0xF8, 0x7B, 0xE0, 0xFF, 0x81, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x79, 0xE1, 0xF3, 0xE3, 0xE7,
  0xC7, 0x8F, 0x80, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0x00,
  0x60, 0x81, 0xDF, 0x3E, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3E, 0xFD, 0xF3,
  0xCF, 0x9F, 0x3C, 0xF9, 0xE7, 0xCF, 0x9E, 0x7C, 0xF1, 0xE7, 0x8F, 0x3E,
  0x79, 0xF3, 0xE7, 0x9F, 0x3C, 0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0xF1, 0xE7,
  0xC0, 0x00, 0x40, 0xEF, 0x8F, 0xFE, 0x7F, 0xF3, 0xEF, 0x9E, 0x3C, 0xF3,
  0xEF, 0x9F, 0x7C, 0xF3, 0xC7, 0x9E, 0x3C, 0xF3, 0xEF, 0x9F, 0x7C, 0xF3,
  0xC7, 0x80, 0x03, 0x01, 0xFC, 0x3F, 0xE7, 0xFF, 0x7D, 0xFF, 0x9F, 0xF9,
  0xFF, 0x1F, 0xF1, 0xEF, 0x1E, 0xF3, 0xEF, 0xFC, 0xFF, 0xC7, 0xF8, 0x3E,
  0x00, 0x00, 0x30, 0x3B, 0xE1, 0xFF, 0xC7, 0xFF, 0x1F, 0x7C, 0x78, 0xF1,
  0xE7, 0xCF, 0x9F, 0x3C, 0x7C, 0xF1, 0xE3, 0xCF, 0x8F, 0xFE, 0x7F, 0xF1,
  0xFF, 0x87, 0xBC, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x00, 0x04, 0x00, 0xFB, 0xCF, 0xFC, 0xFF, 0xE7, 0xDF, 0x7C, 0xFB,
  0xE7, 0xDE, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE1, 0xEF, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x63, 0xBC, 0xF7, 0x9F, 0xE3, 0xFC, 0x7C, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x07, 0x03,
  0xFC, 0xFF, 0x9F, 0xE3, 0xC4, 0x7C, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x77, 0xCF, 0xF9, 0xFE, 0x3F, 0x80, 0x0E, 0x07, 0x81, 0xE5, 0xFE,
  0xFF, 0xBF, 0xE7, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3F,
  0x8F, 0xE3, 0xF8, 0x7E, 0x00, 0x3C, 0xFB, 0xE7, 0xDF, 0x3C, 0xF1, 0xE7,
  0x8F, 0x3C, 0xFB, 0xE7, 0xDF, 0x3C, 0xF1, 0xE7, 0x9F, 0x3F, 0xF9, 0xFF,
  0x8F, 0xFC, 0x3D, 0xE0, 0xF8, 0xFB, 0xC7, 0x9E, 0x7C, 0xF3, 0xC7, 0xBE,
  0x3D, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3E, 0x00, 0xF3, 0xE7, 0xFC, 0xF9, 0xEF, 0x7E, 0x7B, 0xDF, 0xBE,
  0xF7, 0xEF, 0x3F, 0xBB, 0xCE, 0xEF, 0xE3, 0xBF, 0xF8, 0xFD, 0xFC, 0x3F,
  0x7F, 0x0F, 0xDF, 0xC3, 0xE7, 0xE0, 0xF9, 0xF8, 0x3C, 0x7C, 0x00, 0x1F,
  0x3E, 0x3E, 0xF8, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xEF, 0x87, 0x9F, 0x1F,
  0x3E, 0x00, 0x1F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0xF8,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0x00, 0x20, 0x7C, 0x1F, 0x83, 0xE0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xC1, 0xF8, 0x7C, 0x0F, 0x81, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3F, 0x07, 0xE0, 0x7C, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x04, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x80, 0xF0, 0x7E, 0x1F, 0x87, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x3F, 0x0F, 0xC1, 0xF8, 0x3C, 0x00, 0x10, 0x1F,
  0xE3, 0xFF, 0xFF, 0xFF, 0x83, 0xE0,
};

const GFXglyph NotoSans_Condensed_BlackItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 11, 7, 12, 2, -19 },
  { 30, 15, 19, 15, 0, -19 },
  { 66, 13, 22, 13, 0, -20 },
  { 102, 20, 19, 22, 1, -19 },
  { 150, 17, 19, 17, 0, -19 },
  { 191, 6, 7, 6, 2, -19 },
  { 197, 10, 23, 8, 0, -19 },
  { 226, 10, 23, 8, -2, -19 },
  { 255, 11, 12, 12, 2, -20 },
  { 272, 12, 13, 14, 1, -16 },
  { 292, 6, 8, 7, -1, -4 },
  { 298, 8, 4, 8, 0, -9 },
  { 302, 5, 5, 7, 0, -5 },
  { 306, 14, 19, 11, -1, -19 },
  { 340, 12, 19, 13, 1, -19 },
  { 369, 11, 19, 13, 2, -19 },
  { 396, 14, 19, 13, -1, -19 },
  { 430, 13, 19, 13, 0, -19 },
  { 461, 13, 19, 13, 0, -19 },
  { 492, 13, 19, 13, 0, -19 },
  { 523, 13, 19, 13, 1, -19 },
  { 554, 13, 19, 13, 1, -19 },
  { 585, 13, 19, 13, 0, -19 },
  { 616, 12, 19, 13, 1, -19 },
  { 645, 7, 15, 7, 0, -15 },
  { 659, 9, 19, 7, -2, -15 },
  { 681, 12, 13, 14, 1, -16 },
  { 701, 12, 9, 14, 1, -14 },
  { 715, 12, 13, 14, 1, -16 },
  { 735, 11, 19, 11, 1, -19 },
  { 762, 19, 21, 20, 1, -19 },
  { 812, 15, 19, 15, -2, -19 },
  { 848, 14, 19, 14, 0, -19 },
  { 882, 14, 19, 14, 1, -19 },
  { 916, 15, 19, 15, 0, -19 },
  { 952, 13, 19, 12, 0, -19 },
  { 983, 13, 19, 12, 0, -19 },
  { 1014, 15, 19, 15, 1, -19 },
  { 1050, 17, 19, 16, 0, -19 },
  { 1091, 13, 19, 10, -1, -19 },
  { 1122, 13, 25, 8, -4, -19 },
  { 1163, 17, 19, 15, 0, -19 },
  { 1204, 10, 19, 11, 0, -19 },
  { 1228, 21, 19, 21, 0, -19 },
  { 1278, 18, 19, 17, 0, -19 },
  { 1321, 15, 19, 16, 1, -19 },
  { 1357, 14, 19, 14, 0, -19 },
  { 1391, 15, 23, 16, 1, -19 },
  { 1435, 14, 19, 14, 0, -19 },
  { 1469, 13, 19, 12, 0, -19 },
  { 1500, 12, 19, 12, 2, -19 },
  { 1529, 15, 19, 15, 1, -19 },
  { 1565, 15, 19, 14, 2, -19 },
  { 1601, 21, 19, 21, 2, -19 },
  { 1651, 18, 19, 14, -2, -19 },
  { 1694, 14, 19, 14, 2, -19 },
  { 1728, 15, 19, 12, -1, -19 },
  { 1764, 11, 23, 8, -1, -19 },
  { 1796, 6, 19, 11, 3, -19 },
  { 1811, 11, 23, 8, -2, -19 },
  { 1843, 13, 13, 13, 0, -19 },
  { 1865, 12, 3, 11, -3, 2 },
  { 1870, 6, 4, 9, 4, -20 },
  { 1873, 13, 15, 14, 1, -15 },
  { 1898, 13, 20, 14, 0, -20 },
  { 1931, 11, 15, 11, 1, -15 },
  { 1952, 14, 20, 14, 1, -20 },
  { 1987, 12, 15, 13, 1, -15 },
  { 2010, 15, 26, 9, -3, -20 },
  { 2059, 14, 21, 14, 0, -15 },
  { 2096, 13, 20, 14, 0, -20 },
  { 2129, 8, 20, 7, 0, -20 },
  { 2149, 11, 26, 7, -3, -20 },
  { 2185, 15, 20, 14, 0, -20 },
  { 2223, 8, 20, 7, 0, -20 },
  { 2243, 20, 15, 20, 0, -15 },
  { 2281, 13, 15, 14, 0, -15 },
  { 2306, 12, 15, 13, 1, -15 },
  { 2329, 14, 21, 14, -1, -15 },
  { 2366, 13, 21, 14, 1, -15 },
  { 2401, 11, 15, 10, 0, -15 },
  { 2422, 11, 15, 11, 0, -15 },
  { 2443, 10, 17, 10, 1, -17 },
  { 2465, 13, 14, 14, 1, -14 },
  { 2488, 13, 14, 13, 1, -14 },
  { 2511, 18, 14, 19, 2, -14 },
  { 2543, 15, 14, 13, -1, -14 },
  { 2570, 16, 20, 13, -2, -14 },
  { 2610, 13, 14, 11, -1, -14 },
  { 2633, 11, 23, 9, 0, -19 },
  { 2665, 4, 26, 12, 4, -20 },
  { 2678, 11, 23, 9, -2, -19 },
  { 2710, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_BlackItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC26PT7B_H_
