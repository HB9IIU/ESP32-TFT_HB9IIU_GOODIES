#ifndef _NOTOSANS_CONDENSED_BLACKITALIC25PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x78, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0, 0x7B, 0xEF, 0x79, 0xEF, 0x39,
  0xE7, 0x39, 0xE7, 0x3C, 0xE0, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xE0, 0x39,
  0xC0, 0x73, 0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x0E, 0xF0, 0x39, 0xC1,
  0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x87, 0x38, 0x0E, 0x70, 0x1D, 0xC0, 0x73,
  0x80, 0xE7, 0x00, 0x00, 0xC0, 0x04, 0x01, 0xFC, 0x1F, 0xF1, 0xFF, 0x1E,
  0xD8, 0xF4, 0x07, 0xE0, 0x1F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x3E,
  0x23, 0x71, 0xDF, 0x8F, 0xFC, 0xFF, 0xC3, 0xF8, 0x03, 0x00, 0x18, 0x00,
  0x1E, 0x07, 0x87, 0xE0, 0xE0, 0xFE, 0x38, 0x39, 0xC7, 0x07, 0x39, 0xC0,
  0xEF, 0x78, 0x3D, 0xCE, 0x07, 0xBB, 0x9E, 0xFF, 0x77, 0xEF, 0xDD, 0xFC,
  0xF7, 0xBB, 0x80, 0xEF, 0x70, 0x39, 0xCE, 0x0F, 0x39, 0xC1, 0xC7, 0x78,
  0x70, 0xFE, 0x0E, 0x1F, 0xC3, 0x81, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xDF, 0x3F, 0xDE, 0x7F, 0xDE, 0x7B, 0xFC, 0xFB, 0xFC, 0xF1, 0xF8, 0xFB,
  0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0x7E, 0x7B, 0xDE, 0xE7, 0x7B, 0xC0,
  0x07, 0xC1, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x0F, 0x07, 0x87, 0x87, 0x80, 0x0F, 0x01, 0xE1, 0x38, 0x7F, 0x2F, 0xFE,
  0xFF, 0xC7, 0xF9, 0xF8, 0xFF, 0x0E, 0xF0, 0x8C, 0x01, 0x00, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x3D, 0xE7, 0x9C, 0xF3, 0x80, 0x7F, 0x7E, 0x7E, 0xFE,
  0x7F, 0xFF, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0xFE, 0x1F, 0xE3, 0xFE, 0x3D, 0xF7, 0x9F, 0x79, 0xF7, 0x9E, 0xF9,
  0xEF, 0x1E, 0xF1, 0xEF, 0x3E, 0xF3, 0xCF, 0x3C, 0xFF, 0x8F, 0xF8, 0x7F,
  0x07, 0xE0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x7F, 0xBF, 0xE7, 0x79, 0xBE,
  0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x80, 0x03, 0xE0, 0x3F, 0xC7, 0xFE, 0x1F, 0xF0, 0xC7, 0x84, 0x3C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xE0, 0xFF, 0x87, 0xFC,
  0x3F, 0xF1, 0x0F, 0x00, 0x78, 0x07, 0xC1, 0xFC, 0x0F, 0x80, 0xFE, 0x07,
  0xF8, 0x03, 0xC0, 0x1E, 0x41, 0xF3, 0x9F, 0x9F, 0xF8, 0xFF, 0x87, 0xF8,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0x83, 0xBC, 0x1D, 0xE1, 0xCF, 0x1C, 0xF9, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC,
  0x3F, 0xE1, 0xE0, 0x0F, 0x00, 0x7E, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x41, 0xF3, 0xDF, 0x9F, 0xF8, 0xFF, 0x83, 0xF8,
  0x00, 0x03, 0xF0, 0xFF, 0x1F, 0xF1, 0xFB, 0x3E, 0x07, 0xC0, 0x7B, 0x87,
  0xFC, 0xFF, 0xEF, 0xFE, 0xFB, 0xEF, 0x3E, 0xF3, 0xEF, 0x3C, 0xFF, 0xCF,
  0xFC, 0x7F, 0x83, 0xF0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0xFF, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xE0,
  0x7F, 0x87, 0xFE, 0x3D, 0xF1, 0xE7, 0x8F, 0x78, 0x7F, 0xC3, 0xFC, 0x0F,
  0xC0, 0xFE, 0x0F, 0xF8, 0xF3, 0xC7, 0x9E, 0x78, 0xF3, 0xE7, 0x8F, 0xFC,
  0x7F, 0xC1, 0xF8, 0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0xFE, 0x79, 0xE7,
  0x9F, 0x79, 0xEF, 0x9E, 0xFF, 0xE7, 0xFE, 0x7F, 0xE3, 0xBC, 0x03, 0xC0,
  0x78, 0x9F, 0x8F, 0xF0, 0xFE, 0x0F, 0x80, 0x1C, 0x7C, 0xF9, 0xE0, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xE7, 0xCF, 0x9E, 0x00, 0x0E, 0x1F, 0x1F, 0x1E,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78, 0x70, 0xF0,
  0xE0, 0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xF7, 0xF1, 0xF8, 0x3F, 0x03, 0xF8,
  0x1F, 0xE0, 0xFC, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x1E, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0xF8, 0xFF, 0x7F, 0x1F, 0x83, 0xC0, 0x60, 0x00,
  0x1F, 0x9F, 0xF7, 0xFD, 0xFF, 0x23, 0xC0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0xFD, 0xF8, 0x78, 0x0E, 0x3C, 0x21, 0xCE, 0x7F,
  0x77, 0x3F, 0xDD, 0xDE, 0xE7, 0xE7, 0x39, 0xFB, 0xCE, 0x7E, 0xE3, 0xBB,
  0xB9, 0xCE, 0xEE, 0x77, 0x3B, 0xFF, 0xCE, 0x7B, 0xE3, 0x80, 0x00, 0xF0,
  0x08, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xB8, 0x1E, 0xE0, 0x7B, 0x83, 0xCE, 0x0F, 0x3C,
  0x7C, 0xF1, 0xE7, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0xDE, 0x1F,
  0xF8, 0x7F, 0xC1, 0xF0, 0x0F, 0xE0, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x1E,
  0x7C, 0x79, 0xF3, 0xE7, 0x8F, 0xFE, 0x3F, 0xE0, 0xFF, 0xC3, 0xDF, 0x1F,
  0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0xFF, 0x1F, 0xF8, 0xFF, 0xE3, 0xFE, 0x00,
  0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x7F, 0xE3, 0xE1, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x23, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xE1, 0xFF, 0x87,
  0xFF, 0x1E, 0x7C, 0x78, 0xF3, 0xE3, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC7, 0xDF, 0x1F, 0x7C, 0xF9, 0xE7, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3,
  0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x87,
  0xFC, 0x3F, 0xE1, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0xC7, 0xFE, 0x3E, 0x09, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF9, 0xFB, 0xE7, 0xEF, 0xBF, 0xBE, 0x3C, 0xF8,
  0xF3, 0xE3, 0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0x00, 0x0F, 0x0F,
  0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x7C, 0x7C, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0x0F, 0xF0,
  0xFF, 0x1F, 0xF0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x07, 0xF8, 0xFF, 0x8F,
  0xF8, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x06,
  0x00, 0x0F, 0x1F, 0x0F, 0x3E, 0x1F, 0x3E, 0x1E, 0x7C, 0x1E, 0xF8, 0x1E,
  0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7D,
  0xE0, 0x7D, 0xE0, 0x79, 0xF0, 0x79, 0xF0, 0x79, 0xF0, 0xF8, 0xF0, 0xF0,
  0xF8, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C,
  0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0xFD, 0xFF, 0xFF, 0xBF, 0xE0,
  0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7F, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xFB, 0xFC, 0x3F, 0xDD, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFE, 0xF0, 0xF7, 0xF7, 0x87, 0xBF, 0xBC, 0x3D, 0xF9,
  0xE1, 0xEF, 0xDE, 0x0F, 0x7C, 0xF0, 0xF3, 0xE7, 0x87, 0x9E, 0x3C, 0x00,
  0x0F, 0x87, 0x87, 0xC3, 0xC7, 0xE1, 0xE3, 0xF0, 0xF1, 0xFC, 0xF0, 0xFE,
  0x78, 0xFF, 0x3C, 0x7F, 0x9E, 0x3D, 0xFF, 0x1E, 0xFF, 0x0F, 0x7F, 0x8F,
  0x3F, 0xC7, 0x9F, 0xE3, 0xC7, 0xE1, 0xE3, 0xF0, 0xF1, 0xF8, 0xF0, 0xFC,
  0x78, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x3E, 0x3D,
  0xF0, 0xF7, 0xC3, 0xDE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x1E,
  0xF8, 0xFB, 0xE3, 0xEF, 0xFF, 0x1F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0xFE, 0x1E, 0x7C, 0x79, 0xF3, 0xE7, 0x8F,
  0xBE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF,
  0xCF, 0xFF, 0x3E, 0x3D, 0xF0, 0xF7, 0xC3, 0xDE, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0xFB, 0xE3, 0xEF, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC0, 0xFE, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x1E, 0x7C, 0x79, 0xF3, 0xE7, 0x8F, 0xBE,
  0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xE7, 0x87, 0x9F,
  0x1E, 0x7C, 0xF9, 0xF3, 0xC3, 0xE0, 0x07, 0xE0, 0x7F, 0xC7, 0xFC, 0x7F,
  0xE3, 0xE2, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x61, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x00, 0x1E, 0x3E, 0x7C, 0x78, 0xF8, 0xF1, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F,
  0x1F, 0x1E, 0x3E, 0x3C, 0x78, 0xF8, 0xF1, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F,
  0x8F, 0x1F, 0x3E, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0xF8,
  0x7F, 0xE1, 0xEF, 0x8F, 0xBE, 0x3C, 0xF9, 0xF3, 0xE7, 0x8F, 0x9E, 0x3E,
  0xF8, 0xFB, 0xC1, 0xFF, 0x07, 0x78, 0x1D, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x1F,
  0xF1, 0xF1, 0xEF, 0x1F, 0x1E, 0xF1, 0xF3, 0xEF, 0x3F, 0x3C, 0xF3, 0xF3,
  0xCF, 0x7F, 0x78, 0xF7, 0xF7, 0x8F, 0x7F, 0xF8, 0xFF, 0xFF, 0x0F, 0xEF,
  0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xF8,
  0xFC, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC1, 0xE3, 0xE0, 0x7D, 0xF0, 0x1F,
  0x78, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xDE, 0x01,
  0xF7, 0x80, 0xF9, 0xF0, 0x7C, 0x7C, 0x3F, 0x1F, 0x00, 0xF8, 0xFF, 0xC7,
  0xDE, 0x7C, 0xF3, 0xC7, 0xBE, 0x3D, 0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0xFE, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x07,
  0xE1, 0xF8, 0x3F, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x7F, 0x0F, 0xC1, 0xF8, 0x00, 0xE3, 0x8E, 0x3C, 0xF3, 0xCF, 0x1C,
  0x71, 0xC7, 0x9E, 0x79, 0xE3, 0x8E, 0x38, 0xF0, 0x07, 0xE0, 0xF8, 0x3F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x3F, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0xFE,
  0x1F, 0xE3, 0xCE, 0x38, 0xE7, 0x8F, 0x70, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF7, 0xDE, 0x70, 0x1E, 0x73, 0xFF, 0x7F, 0xF7, 0xFF, 0xF9, 0xEF,
  0x9E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0x3C, 0xF7, 0xCF, 0xFC, 0xFF, 0xC7,
  0xB8, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x70, 0x7F,
  0xC7, 0xFE, 0x3F, 0xF1, 0xE7, 0xCF, 0x3E, 0xF9, 0xE7, 0x8F, 0x3C, 0x79,
  0xE7, 0xCF, 0xFC, 0xFF, 0xE7, 0xFE, 0x39, 0xE0, 0x0F, 0x87, 0xF3, 0xFD,
  0xFE, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x33, 0xFC, 0xFF,
  0x1F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x0F, 0x78,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xCF, 0x3E, 0x79, 0xE3, 0xCF, 0x1E, 0x79,
  0xE3, 0xCF, 0x1E, 0xF8, 0xFF, 0xC7, 0xFE, 0x1E, 0xE0, 0x0F, 0x83, 0xFC,
  0xFF, 0xBC, 0xF7, 0x9F, 0xEF, 0xFF, 0xF7, 0xFC, 0xF8, 0x1E, 0x03, 0xC2,
  0x7F, 0xCF, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7A,
  0x03, 0xE0, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8,
  0x00, 0x0F, 0x38, 0xFF, 0xC7, 0xFE, 0x7F, 0xF3, 0xCF, 0x3E, 0x79, 0xE3,
  0xCF, 0x1E, 0x79, 0xE3, 0xCF, 0x1E, 0xF8, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0,
  0x0F, 0x00, 0x78, 0xEF, 0xC7, 0xFC, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x70, 0x7F, 0xC7, 0xFF, 0x3F,
  0xF9, 0xE7, 0xCF, 0x3C, 0xF9, 0xE7, 0x8F, 0x3C, 0xF9, 0xE7, 0xCF, 0x3C,
  0xF9, 0xE7, 0x8F, 0x3C, 0xF8, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x1E, 0x1E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0,
  0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE1, 0xFC, 0x3F, 0x07, 0xC0, 0xF0, 0x00, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0xF3, 0xE7, 0x8F,
  0x3E, 0x3D, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1E, 0xF8, 0xFB, 0xE3, 0xC7, 0x8F, 0x1F, 0x00, 0x0F, 0x0F, 0x1F,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78,
  0x78, 0xF8, 0xF0, 0xF0, 0x1C, 0xE3, 0xC3, 0xFE, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF3, 0xCF, 0x9E, 0x79, 0xE7, 0xDF, 0x3C, 0xFB, 0xC7, 0x9E, 0x79,
  0xF3, 0xCF, 0x3C, 0x79, 0xE7, 0x9F, 0x7C, 0xF3, 0xCF, 0x1E, 0x79, 0xE7,
  0xCF, 0x00, 0x1D, 0xE0, 0xFF, 0x8F, 0xFE, 0x7F, 0xF3, 0xCF, 0x9E, 0x79,
  0xF3, 0xCF, 0x1E, 0x79, 0xF3, 0xCF, 0x9E, 0x79, 0xF3, 0xCF, 0x1E, 0x79,
  0xF0, 0x0F, 0x83, 0xF8, 0xFF, 0xBE, 0xF7, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xF3, 0xFE, 0x7B, 0xDF, 0x7F, 0xCF, 0xF8, 0xFC, 0x00, 0x0E, 0xF0, 0x3F,
  0xE1, 0xFF, 0x87, 0xDE, 0x1E, 0x7C, 0x79, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF3, 0xE3, 0xFF, 0x1F, 0xFC, 0x7F, 0xE1, 0xEF, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x73, 0xFF, 0x3F,
  0xF7, 0xFF, 0x79, 0xEF, 0x9E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0x3C, 0xF7,
  0xCF, 0xFC, 0xFF, 0xC7, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x1C, 0xE3, 0xB8, 0xFF, 0x1F, 0xE3, 0xE4, 0x78, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x87,
  0xFC, 0xFF, 0x1E, 0x67, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF3,
  0x3E, 0x7F, 0xCF, 0xF1, 0xFC, 0x00, 0x0E, 0x0F, 0x07, 0x87, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0xD3, 0xF9, 0xFC,
  0x7E, 0x00, 0x3C, 0xF7, 0xCF, 0x78, 0xF7, 0x9F, 0x79, 0xF7, 0x9E, 0xF9,
  0xEF, 0x1E, 0xF3, 0xEF, 0x3C, 0xFF, 0xCF, 0xFC, 0xFF, 0xC7, 0xBC, 0xF8,
  0xFF, 0xCF, 0x9E, 0x78, 0xF3, 0xC7, 0xBC, 0x3D, 0xE1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0xF9, 0xF3,
  0xFE, 0x7C, 0xFF, 0x3F, 0x7B, 0xCF, 0xDE, 0xF7, 0xE7, 0xBD, 0xFB, 0xCF,
  0x7E, 0xF3, 0xFB, 0xF8, 0xFE, 0xFE, 0x3F, 0xBF, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xFC, 0xF8, 0x3E, 0x3E, 0x00, 0x1E, 0x3E, 0x3E, 0xF8, 0x7D, 0xE0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0xF7, 0x83, 0xEF, 0x07, 0x9E, 0x1F, 0x3E, 0x00, 0x1F, 0x1E, 0x3E,
  0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFE, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x07, 0xFC, 0xFF, 0xCF, 0xFC, 0x01, 0xE0, 0xF8, 0x1F,
  0x07, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0xC3, 0xE0, 0x7C,
  0x0F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0C, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xF0, 0x78, 0x3E, 0x1F, 0x8F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F,
  0x83, 0xE0, 0xF0, 0x38, 0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xC3, 0xF8, 0x08,
};

const GFXglyph NotoSans_Condensed_BlackItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 18, 7, 0, -18 },
  { 19, 11, 7, 11, 2, -18 },
  { 29, 15, 18, 14, 0, -18 },
  { 63, 13, 20, 13, 0, -19 },
  { 96, 19, 18, 21, 1, -18 },
  { 139, 16, 18, 16, 0, -18 },
  { 175, 5, 7, 6, 2, -18 },
  { 180, 10, 22, 8, 0, -18 },
  { 208, 9, 22, 8, -2, -18 },
  { 233, 11, 12, 12, 2, -19 },
  { 250, 11, 12, 13, 1, -15 },
  { 267, 6, 6, 7, -1, -3 },
  { 272, 8, 4, 8, 0, -9 },
  { 276, 5, 4, 7, 0, -4 },
  { 279, 14, 18, 10, -1, -18 },
  { 311, 12, 18, 13, 1, -18 },
  { 338, 10, 18, 13, 2, -18 },
  { 361, 13, 18, 13, -1, -18 },
  { 391, 13, 18, 13, 0, -18 },
  { 421, 13, 18, 13, 0, -18 },
  { 451, 13, 18, 13, 0, -18 },
  { 481, 12, 18, 13, 1, -18 },
  { 508, 13, 18, 13, 1, -18 },
  { 538, 13, 18, 13, 0, -18 },
  { 568, 12, 18, 13, 1, -18 },
  { 595, 7, 14, 7, 0, -14 },
  { 608, 8, 17, 7, -1, -14 },
  { 625, 11, 12, 13, 1, -15 },
  { 642, 11, 9, 13, 1, -13 },
  { 655, 11, 12, 13, 1, -15 },
  { 672, 10, 18, 10, 1, -18 },
  { 695, 18, 20, 19, 1, -18 },
  { 740, 14, 18, 14, -1, -18 },
  { 772, 14, 18, 14, 0, -18 },
  { 804, 13, 18, 13, 1, -18 },
  { 834, 14, 18, 15, 0, -18 },
  { 866, 13, 18, 12, 0, -18 },
  { 896, 13, 18, 11, 0, -18 },
  { 926, 14, 18, 15, 1, -18 },
  { 958, 16, 18, 15, 0, -18 },
  { 994, 12, 18, 10, -1, -18 },
  { 1021, 12, 24, 8, -4, -18 },
  { 1057, 16, 18, 14, 0, -18 },
  { 1093, 10, 18, 11, 0, -18 },
  { 1116, 21, 18, 20, 0, -18 },
  { 1164, 17, 18, 17, 0, -18 },
  { 1203, 14, 18, 16, 1, -18 },
  { 1235, 14, 18, 13, 0, -18 },
  { 1267, 14, 22, 16, 1, -18 },
  { 1306, 14, 18, 14, 0, -18 },
  { 1338, 13, 18, 12, 0, -18 },
  { 1368, 11, 18, 12, 2, -18 },
  { 1393, 15, 18, 15, 1, -18 },
  { 1427, 14, 18, 14, 2, -18 },
  { 1459, 20, 18, 20, 2, -18 },
  { 1504, 18, 18, 14, -2, -18 },
  { 1545, 13, 18, 13, 2, -18 },
  { 1575, 14, 18, 12, -1, -18 },
  { 1607, 11, 22, 8, -1, -18 },
  { 1638, 6, 18, 10, 3, -18 },
  { 1652, 11, 22, 8, -2, -18 },
  { 1683, 12, 12, 12, 0, -18 },
  { 1701, 10, 3, 10, -2, 2 },
  { 1705, 5, 4, 8, 4, -19 },
  { 1708, 12, 14, 13, 1, -14 },
  { 1729, 13, 19, 13, 0, -19 },
  { 1760, 10, 14, 11, 1, -14 },
  { 1778, 13, 19, 13, 1, -19 },
  { 1809, 11, 14, 12, 1, -14 },
  { 1829, 14, 25, 8, -3, -19 },
  { 1873, 13, 20, 13, 0, -14 },
  { 1906, 13, 19, 13, 0, -19 },
  { 1937, 8, 19, 7, 0, -19 },
  { 1956, 11, 25, 7, -3, -19 },
  { 1991, 14, 19, 13, 0, -19 },
  { 2025, 8, 19, 7, 0, -19 },
  { 2044, 19, 14, 20, 0, -14 },
  { 2078, 13, 14, 13, 0, -14 },
  { 2101, 11, 14, 13, 1, -14 },
  { 2121, 14, 20, 13, -1, -14 },
  { 2156, 12, 20, 13, 1, -14 },
  { 2186, 11, 14, 9, 0, -14 },
  { 2206, 11, 14, 11, 0, -14 },
  { 2226, 9, 17, 9, 1, -17 },
  { 2246, 12, 14, 13, 1, -14 },
  { 2267, 13, 14, 12, 1, -14 },
  { 2290, 18, 14, 18, 1, -14 },
  { 2322, 15, 14, 12, -1, -14 },
  { 2349, 15, 20, 12, -2, -14 },
  { 2387, 12, 14, 10, -1, -14 },
  { 2408, 11, 22, 9, 0, -18 },
  { 2439, 3, 25, 11, 4, -19 },
  { 2449, 10, 22, 9, -1, -18 },
  { 2477, 11, 5, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_BlackItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC25PT7B_H_
