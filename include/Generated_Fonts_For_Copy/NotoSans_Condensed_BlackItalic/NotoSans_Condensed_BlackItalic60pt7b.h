#ifndef _NOTOSANS_CONDENSED_BLACKITALIC60PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF9,
  0xFF, 0x9F, 0xF8, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xFE, 0x3F, 0xF3, 0xFF,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F,
  0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC1, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF3, 0x87, 0x80, 0x7F, 0xCE, 0x06, 0x01, 0xFE,
  0x78, 0x00, 0x07, 0xF9, 0xE0, 0x00, 0x1F, 0xF7, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF7, 0xFC, 0x00, 0x03,
  0xDF, 0xF0, 0x60, 0x0E, 0x7F, 0xC1, 0xE0, 0x39, 0xFF, 0x07, 0xE1, 0xEF,
  0xFC, 0x1F, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x03, 0xFC,
  0x00, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0xC3, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE3, 0xFC, 0x00, 0x03,
  0xFC, 0x7F, 0x8F, 0xE0, 0xFF, 0x0F, 0xF1, 0xFC, 0x7F, 0x8F, 0xFE, 0x3F,
  0xCF, 0xF3, 0xFC, 0x7F, 0xFC, 0x7F, 0xFF, 0xCF, 0xE3, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0x8F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC, 0x3F, 0xE1,
  0xFC, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x3F, 0xC0, 0x00, 0x7F,
  0x8F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x0F,
  0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xE3,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0x00, 0xFF,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF,
  0x83, 0xFF, 0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0xFF, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xF8,
  0x7F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x04, 0x07, 0xF8,
  0x03, 0xC1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0xDF, 0xFF,
  0xE3, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xF7,
  0xF8, 0x1F, 0xFD, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0x0F, 0xF0, 0x07,
  0xC3, 0xFE, 0x00, 0xE0, 0xFE, 0x00, 0x10, 0x1E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFE, 0x00, 0x02, 0x03, 0xF8, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF9, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xE3, 0xFF, 0x0F, 0xFE,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x3F, 0xF1, 0xFF, 0x83, 0xFF,
  0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF,
  0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xF7, 0xFF, 0x07, 0xFF, 0x7F, 0xE0, 0x7F,
  0xF7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF,
  0xC0, 0xFF, 0xEF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F,
  0xFC, 0xFF, 0xC1, 0xFF, 0xCF, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xEF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xDF, 0xF8, 0x3F, 0x1F, 0xF8,
  0x1E, 0x3F, 0xF8, 0x0C, 0x3F, 0xF8, 0x08, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0x3E,
  0x07, 0xFE, 0x00, 0x3C, 0x07, 0xFE, 0x00, 0x10, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0xFC, 0x01, 0xC0, 0x7F, 0xF0,
  0x04, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x01,
  0xFF, 0xE3, 0x80, 0x0F, 0xFF, 0x0F, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x7F, 0x7F,
  0xE0, 0x01, 0xFE, 0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0x80, 0x0F, 0xE7, 0xFE,
  0x00, 0x3F, 0xCF, 0xFC, 0x00, 0xFF, 0x1F, 0xF8, 0x03, 0xFC, 0x3F, 0xF0,
  0x07, 0xF8, 0x7F, 0xE0, 0x1F, 0xE1, 0xFF, 0x80, 0x7F, 0x83, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x02, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x80, 0x03, 0xFF, 0x83, 0x80, 0x1F,
  0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x30, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x83, 0x00, 0x07,
  0xFE, 0x7F, 0x80, 0x3F, 0xF7, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF,
  0xE3, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x0F, 0xFE,
  0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x1F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x83,
  0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF3, 0xFF,
  0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC,
  0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xF8, 0x7F, 0xF1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF,
  0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x07, 0xFF, 0x1F,
  0xF8, 0x3F, 0xF9, 0xFF, 0xC1, 0xFF, 0xCF, 0xFE, 0x1F, 0xFE, 0x7F, 0xF1,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xDF, 0xF0, 0x07, 0xF9, 0xFF, 0x80, 0x0F, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x30, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xC7, 0xFF, 0x1E, 0x03, 0xFF,
  0x18, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x07, 0xFF, 0x07, 0xF0, 0xFF,
  0x03, 0xFF, 0xFC, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x1F, 0xC7, 0xF8, 0x3F,
  0xFF, 0xE3, 0xF8, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x3F, 0xC3, 0xFF, 0xFF,
  0x87, 0xE7, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F,
  0xBF, 0x87, 0xF8, 0x3F, 0x87, 0xF7, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0xFE,
  0x3F, 0xC1, 0xFC, 0x1F, 0xDF, 0x87, 0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0xFE,
  0x07, 0xF0, 0x7E, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xDF, 0xC7, 0xF8, 0x3F,
  0x83, 0xFB, 0xF8, 0xFF, 0x07, 0xF0, 0x7E, 0x7F, 0x1F, 0xE1, 0xFE, 0x1F,
  0xCF, 0xE3, 0xFC, 0x3F, 0xC3, 0xF1, 0xF8, 0x7F, 0x8F, 0xF8, 0xFE, 0x3F,
  0x0F, 0xFF, 0xFF, 0x7F, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xC3, 0xFF, 0xDF, 0xFF, 0x03, 0xF8, 0x3F, 0xF1,
  0xFF, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE,
  0x1F, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xC0,
  0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE,
  0x1F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x78, 0x07, 0xFF, 0x80, 0x10, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x01,
  0x00, 0x7F, 0xF8, 0x07, 0x00, 0x7F, 0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF8, 0xFF, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x08, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0x87, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x0E, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF8,
  0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF,
  0x8F, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF0,
  0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x03,
  0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x87, 0xFB,
  0xFE, 0x00, 0xFF, 0xBF, 0xC7, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xE3, 0xFD,
  0xFF, 0x80, 0x3F, 0xEF, 0xF1, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xF9, 0xFE,
  0x7F, 0xE0, 0x1F, 0xFB, 0xFC, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFE, 0xFF,
  0xBF, 0xF0, 0x07, 0xFC, 0xFF, 0x7F, 0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xFF,
  0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F,
  0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xE0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x07, 0xFF,
  0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC7,
  0xFE, 0x01, 0xFF, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0x9F, 0xF1, 0xFF, 0x00,
  0x7F, 0xCF, 0xF8, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0xFF, 0xC0, 0x3F, 0xF3,
  0xFF, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0xBF, 0xF0, 0x0F, 0xFC, 0x7F, 0xDF,
  0xF0, 0x07, 0xFC, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC7,
  0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xCF,
  0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF,
  0xCF, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC7,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF,
  0x9F, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x0F, 0xFE, 0x7F,
  0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE,
  0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87, 0xFF,
  0x81, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xCF,
  0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8,
  0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x1F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xC0, 0x1F,
  0xFC, 0x03, 0x80, 0x3F, 0xF8, 0x01, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x30, 0x01, 0xFF, 0xC0,
  0x70, 0x03, 0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x7F,
  0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8,
  0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0xDF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xE7, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xF1, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0xF0,
  0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0xFC,
  0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF,
  0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0xBF,
  0xCF, 0xFC, 0x01, 0xFF, 0x7F, 0xDF, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xCF,
  0xF7, 0xFE, 0x00, 0x7F, 0xDF, 0xE7, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xDF,
  0xF8, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0, 0x1F, 0xFC, 0x7F,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF1, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x80, 0x1F,
  0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x83, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE7,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07,
  0xF8, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x03,
  0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFC, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x87, 0x80, 0x07, 0xFE, 0xFF, 0x80,
  0x3F, 0xF7, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x83,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFE, 0x07, 0xFF, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE1,
  0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x1F, 0xF0, 0x3F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xEF, 0xFF, 0x80, 0xFF, 0x9F, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0x81,
  0x81, 0xFF, 0xC0, 0x20, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x20, 0x7F, 0xE0,
  0x18, 0x1F, 0xFC, 0x3E, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x9F, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xE0, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x1F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF, 0x0F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x02, 0x07, 0xFE, 0x00, 0xE0, 0x7F, 0xF8, 0x7E, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xCC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x11, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xFE, 0x3F, 0xC0,
  0x0F, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0xC0, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x10, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x03,
  0x00, 0x0F, 0xFE, 0x01, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x8F, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF7,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFE, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x83,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x0C, 0x7F, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x02, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x1F,
  0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x0F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xEF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x07, 0xF8, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE7, 0xFF,
  0x8F, 0xFF, 0x00, 0xFF, 0xBF, 0xFE, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE1, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xE7, 0xFF,
  0x00, 0xFF, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFE, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x07,
  0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3,
  0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xF3, 0xFF, 0x83, 0xFF, 0x9F, 0xF8, 0x1F, 0xFC,
  0xFF, 0xC0, 0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0x7F, 0xF0, 0x3F, 0xF3, 0xFF,
  0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x07,
  0xFE, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF, 0x83, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07,
  0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xF7, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0x80,
  0x07, 0xFE, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x03, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF,
  0xBF, 0xE0, 0x3F, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0xFF,
  0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0xC7, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE,
  0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x04, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F,
  0xE7, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFC, 0x3E,
  0x03, 0xFF, 0x01, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0xC0, 0x0F, 0xFC, 0x3C, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x60, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x0F, 0xFE,
  0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x83,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xDF, 0xF0, 0x0F, 0xFE, 0x7F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x1F,
  0xFC, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xF1,
  0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x7F,
  0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFB, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x7F, 0xC1, 0xFF, 0xE0, 0xFF, 0xCF,
  0xF8, 0x3F, 0xFC, 0x1F, 0xF9, 0xFF, 0x0F, 0xFF, 0x87, 0xFE, 0x3F, 0xE1,
  0xFF, 0xF0, 0xFF, 0xC7, 0xFC, 0x7F, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF1, 0xFF, 0xF8, 0xFF, 0xC3, 0xFE, 0x7F, 0xFF, 0x3F,
  0xF0, 0x7F, 0xCF, 0xFF, 0xE7, 0xFE, 0x0F, 0xF9, 0xFF, 0xFC, 0xFF, 0x81,
  0xFF, 0x7F, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xEF, 0xF7, 0xFC, 0x07, 0xFD,
  0xFD, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x1F, 0xEF, 0xE7,
  0xF7, 0xFC, 0x03, 0xFD, 0xFC, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE1,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x07,
  0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0x7F,
  0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x67, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x11, 0xFF, 0xC0, 0x03, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0xC0, 0x01, 0xFF, 0x88, 0x00, 0x00, 0xC0,
};

const GFXglyph NotoSans_Condensed_BlackItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 19, 44, 16, 0, -43 },
  { 106, 25, 16, 27, 5, -43 },
  { 156, 36, 43, 34, 0, -43 },
  { 350, 30, 50, 30, 1, -46 },
  { 538, 46, 44, 50, 3, -43 },
  { 791, 38, 44, 38, 0, -43 },
  { 1000, 13, 16, 14, 5, -43 },
  { 1026, 22, 53, 19, 1, -44 },
  { 1172, 23, 53, 19, -5, -44 },
  { 1325, 26, 28, 28, 4, -46 },
  { 1416, 27, 29, 32, 3, -36 },
  { 1514, 15, 16, 16, -3, -8 },
  { 1544, 17, 9, 19, 1, -21 },
  { 1564, 11, 12, 16, 0, -11 },
  { 1581, 33, 44, 25, -3, -43 },
  { 1763, 28, 44, 30, 2, -43 },
  { 1917, 24, 43, 30, 5, -43 },
  { 2046, 32, 43, 30, -2, -43 },
  { 2218, 30, 44, 30, 0, -43 },
  { 2383, 31, 43, 30, 0, -43 },
  { 2550, 30, 44, 30, 1, -43 },
  { 2715, 30, 44, 30, 2, -43 },
  { 2880, 32, 43, 30, 1, -43 },
  { 3052, 30, 44, 30, 1, -43 },
  { 3217, 29, 44, 30, 1, -43 },
  { 3377, 17, 35, 17, 0, -34 },
  { 3452, 20, 42, 17, -3, -34 },
  { 3557, 28, 31, 32, 2, -37 },
  { 3666, 27, 22, 32, 3, -32 },
  { 3741, 27, 31, 32, 3, -37 },
  { 3846, 24, 44, 25, 3, -43 },
  { 3978, 43, 48, 46, 2, -43 },
  { 4236, 34, 43, 35, -3, -43 },
  { 4419, 33, 43, 33, 0, -43 },
  { 4597, 32, 44, 31, 2, -43 },
  { 4773, 35, 43, 35, 0, -43 },
  { 4962, 30, 43, 28, 0, -43 },
  { 5124, 30, 43, 27, 0, -43 },
  { 5286, 35, 44, 36, 2, -43 },
  { 5479, 38, 43, 36, 0, -43 },
  { 5684, 29, 43, 23, -2, -43 },
  { 5840, 30, 56, 18, -10, -43 },
  { 6050, 39, 43, 34, 0, -43 },
  { 6260, 24, 43, 26, 0, -43 },
  { 6389, 49, 43, 48, 0, -43 },
  { 6653, 41, 43, 40, 0, -43 },
  { 6874, 35, 45, 37, 2, -44 },
  { 7071, 33, 43, 31, 0, -43 },
  { 7249, 35, 54, 37, 2, -44 },
  { 7486, 33, 43, 33, 0, -43 },
  { 7664, 31, 44, 28, 0, -43 },
  { 7835, 27, 43, 28, 5, -43 },
  { 7981, 34, 44, 35, 3, -43 },
  { 8168, 33, 43, 33, 5, -43 },
  { 8346, 49, 43, 48, 5, -43 },
  { 8610, 41, 43, 33, -4, -43 },
  { 8831, 32, 43, 31, 5, -43 },
  { 9003, 34, 43, 28, -2, -43 },
  { 9186, 26, 54, 19, -3, -44 },
  { 9362, 15, 44, 25, 6, -43 },
  { 9445, 25, 54, 19, -4, -44 },
  { 9614, 30, 28, 29, -1, -43 },
  { 9719, 26, 7, 24, -6, 4 },
  { 9742, 13, 10, 20, 9, -46 },
  { 9759, 31, 35, 31, 1, -34 },
  { 9895, 30, 47, 31, 0, -46 },
  { 10072, 26, 35, 26, 1, -34 },
  { 10186, 33, 47, 31, 1, -46 },
  { 10380, 28, 35, 30, 1, -34 },
  { 10503, 33, 60, 20, -6, -46 },
  { 10751, 33, 48, 31, -1, -34 },
  { 10949, 30, 46, 32, 0, -46 },
  { 11122, 19, 47, 16, 0, -47 },
  { 11234, 27, 61, 16, -8, -47 },
  { 11440, 35, 46, 31, 0, -46 },
  { 11642, 20, 46, 16, 0, -46 },
  { 11757, 46, 34, 47, 0, -34 },
  { 11953, 30, 34, 32, 0, -34 },
  { 12081, 29, 35, 31, 1, -34 },
  { 12208, 33, 48, 31, -3, -34 },
  { 12406, 31, 48, 31, 1, -34 },
  { 12592, 26, 34, 23, 0, -34 },
  { 12703, 26, 35, 25, 0, -34 },
  { 12817, 22, 41, 23, 2, -40 },
  { 12930, 30, 34, 32, 2, -33 },
  { 13058, 29, 33, 29, 3, -33 },
  { 13178, 43, 33, 43, 4, -33 },
  { 13356, 36, 33, 30, -3, -33 },
  { 13505, 36, 47, 29, -4, -33 },
  { 13717, 29, 33, 25, -2, -33 },
  { 13837, 25, 52, 21, 0, -43 },
  { 14000, 8, 60, 27, 9, -46 },
  { 14060, 25, 52, 21, -4, -43 },
  { 14223, 28, 12, 32, 2, -27 },
};

const GFXfont NotoSans_Condensed_BlackItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC60PT7B_H_
