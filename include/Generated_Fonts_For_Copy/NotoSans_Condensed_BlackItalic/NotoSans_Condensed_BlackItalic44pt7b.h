#ifndef _NOTOSANS_CONDENSED_BLACKITALIC44PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x04, 0x00, 0x7F, 0x9F, 0xDF,
  0xC7, 0xF7, 0xF3, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x8F, 0xE7, 0xE3,
  0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0xCF, 0xC7, 0xE0, 0x00, 0x1F,
  0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0x7C, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xF8, 0x07, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE0, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1,
  0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x07,
  0xE3, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x71, 0x81, 0xFD, 0xC2, 0x07, 0xF7, 0x00,
  0x1F, 0xD8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xBF, 0x88, 0x06, 0xFE, 0x18, 0x3B, 0xF8, 0xF8, 0xEF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x04, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xF8, 0x0F, 0xC0, 0x1F,
  0xFE, 0x07, 0xE0, 0x0F, 0xDF, 0x81, 0xF8, 0x03, 0xE3, 0xE0, 0xFC, 0x01,
  0xF8, 0xF8, 0x3E, 0x00, 0x7E, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x8F, 0xC0,
  0x07, 0xC7, 0xE3, 0xE0, 0x03, 0xF1, 0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x7C,
  0x00, 0x3F, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xDF, 0x9F, 0xF1, 0xFF, 0xE7,
  0xCF, 0xFE, 0x7F, 0xF3, 0xF7, 0xFF, 0x9F, 0xFD, 0xF9, 0xFF, 0xF3, 0xFC,
  0x7E, 0xFC, 0xFC, 0x3E, 0x3F, 0x3F, 0x3F, 0x00, 0x0F, 0x8F, 0x8F, 0xC0,
  0x07, 0xE7, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x3E,
  0x00, 0x7E, 0x1F, 0x9F, 0x80, 0x3F, 0x07, 0xC7, 0xE0, 0x0F, 0xC1, 0xF9,
  0xF0, 0x07, 0xE0, 0x7F, 0xFC, 0x01, 0xF0, 0x1F, 0xFE, 0x00, 0xFC, 0x03,
  0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFB, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xCF, 0xF0, 0x3F, 0xF8, 0xFF, 0x0F, 0xFF, 0x8F, 0xE1, 0xFF, 0xF9,
  0xFE, 0x3F, 0xFF, 0xDF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF, 0x87,
  0xF1, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0x07,
  0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xCF, 0xFC, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF9, 0xFC, 0xFC,
  0x7E, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0x0F, 0x80, 0x71, 0xF0, 0x1F, 0xBE, 0x1B, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x9E, 0x1F, 0xF8,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0x3F, 0x03, 0xE7, 0xF0, 0x38, 0xFC,
  0x02, 0x0E, 0x00, 0x01, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07,
  0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xE7, 0xFF,
  0x3F, 0xFB, 0xFF, 0xC0, 0x0C, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E,
  0x10, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFE, 0x7F, 0x1F, 0xE3,
  0xF8, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xFC, 0x3F, 0x9F,
  0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x87, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC3, 0xFC, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x87, 0xF3, 0xFC,
  0x7F, 0x9F, 0xE3, 0xF8, 0xFF, 0x3F, 0xC3, 0xF9, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7,
  0xEF, 0xE1, 0xF3, 0xF8, 0x39, 0xFE, 0x04, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF0, 0xFF, 0x01, 0xC1,
  0xFE, 0x03, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xE0, 0xFF, 0x02, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x80, 0x1F, 0xE3, 0xC0, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7D, 0xFC, 0x03, 0xEF, 0xF0, 0x1F,
  0xBF, 0x80, 0xFC, 0xFE, 0x03, 0xE3, 0xF8, 0x1F, 0x9F, 0xE0, 0xFC, 0x7F,
  0x87, 0xE1, 0xFC, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x20, 0x0F, 0xF0, 0xE0, 0x7F, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFB, 0x81, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF3, 0xE0,
  0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF1, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F,
  0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1,
  0xFC, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xCF, 0xE1, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xDF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xF1, 0xFE, 0x7F,
  0x87, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC,
  0xFF, 0x3F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xF1, 0xFE, 0x7F, 0x0F, 0xF3,
  0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0xFE, 0x3F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFE, 0xFE, 0x00,
  0x8F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x84, 0x07, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFE, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x00, 0x00, 0x38, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x60, 0xFF, 0x10, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xFF, 0x9F, 0x1F, 0x87, 0xFF, 0x9F, 0x1F, 0x0F, 0xFF,
  0x9F, 0x3F, 0x1F, 0xFF, 0x1F, 0x3E, 0x3F, 0x1F, 0x1F, 0x3E, 0x3E, 0x1F,
  0x1F, 0x7C, 0x7E, 0x3F, 0x1F, 0x7C, 0x7C, 0x3E, 0x1F, 0x7C, 0xFC, 0x3E,
  0x1F, 0x7C, 0xFC, 0x3E, 0x3E, 0xF8, 0xF8, 0x7E, 0x3E, 0xF8, 0xF8, 0x7C,
  0x3E, 0xF8, 0xF8, 0xFC, 0x7C, 0xF8, 0xFC, 0xFC, 0xF8, 0xF8, 0xFF, 0xFF,
  0xF8, 0xF8, 0x7F, 0xFF, 0xF0, 0xFC, 0x7F, 0x9F, 0xE0, 0x7C, 0x3F, 0x1F,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06,
  0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F,
  0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0x80, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x7F, 0xC0, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83,
  0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xF8,
  0x7F, 0x8F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFC, 0x18, 0x1F, 0xF0, 0x10,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x81, 0xFF, 0x0F,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xE7, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F,
  0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF0, 0x18,
  0x1F, 0xF0, 0x04, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xF9, 0xFE, 0x1F,
  0xFC, 0xFF, 0x1F, 0xFE, 0x7F, 0x8F, 0xFE, 0x3F, 0xC7, 0xFF, 0x1F, 0xE3,
  0xFF, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0xE3, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8,
  0xFF, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xBF, 0xE0, 0x03,
  0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE,
  0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0F, 0xDF, 0x9F, 0xBF, 0x81, 0xFD, 0xF9, 0xFB, 0xF8, 0x1F, 0xDF,
  0xBF, 0x7F, 0x81, 0xFD, 0xFB, 0xF7, 0xF0, 0x1F, 0xDF, 0xFE, 0x7F, 0x03,
  0xFD, 0xFF, 0xE7, 0xF0, 0x3F, 0x9F, 0xFE, 0xFF, 0x03, 0xF9, 0xFF, 0xCF,
  0xE0, 0x3F, 0x9F, 0xFC, 0xFE, 0x03, 0xF9, 0xFF, 0x8F, 0xE0, 0x7F, 0x9F,
  0xF8, 0xFE, 0x07, 0xF1, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xF1, 0xFC, 0x07,
  0xF1, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE1, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xFF, 0x01, 0xFC, 0x0F, 0xFC,
  0x07, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0x03,
  0xF8, 0x1F, 0xFE, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0x81, 0xFF, 0xE0, 0xFE,
  0x07, 0xFF, 0x87, 0xF8, 0x1F, 0xFE, 0x1F, 0xC0, 0xFF, 0xFC, 0x7F, 0x03,
  0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0x3F, 0x80, 0xFC,
  0xFE, 0xFE, 0x07, 0xF3, 0xFB, 0xF8, 0x1F, 0xCF, 0xEF, 0xE0, 0x7F, 0x3F,
  0xBF, 0x81, 0xFC, 0xFF, 0xFC, 0x0F, 0xF1, 0xFF, 0xF0, 0x3F, 0x87, 0xFF,
  0xC0, 0xFE, 0x1F, 0xFF, 0x03, 0xF8, 0x7F, 0xFC, 0x0F, 0xE0, 0xFF, 0xE0,
  0x7F, 0x03, 0xFF, 0x81, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x3F, 0xF8, 0x1F,
  0xC0, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xE0,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF0,
  0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF,
  0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3,
  0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0xC7, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x07, 0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xE3,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F,
  0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F,
  0xF3, 0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0xEF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xF3, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xDF, 0xE0,
  0x3F, 0x8F, 0xF0, 0x3F, 0x8F, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x8F, 0xF0,
  0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xFC,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFC,
  0x1C, 0x0F, 0xF0, 0x30, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x10, 0x07, 0xF8, 0x70, 0x3F, 0xC3,
  0xFB, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F,
  0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00,
  0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xC0, 0xFF,
  0x7F, 0x03, 0xFC, 0x1F, 0xE7, 0xF0, 0x3F, 0xC1, 0xFE, 0x7F, 0x07, 0xFC,
  0x1F, 0xC7, 0xF0, 0x7F, 0xC3, 0xFC, 0x7F, 0x0F, 0xFC, 0x3F, 0xC7, 0xF0,
  0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xFC, 0x7F, 0x87, 0xF1, 0xFF, 0xC7, 0xF0,
  0x7F, 0x1F, 0xF8, 0xFF, 0x07, 0xF3, 0xFF, 0x8F, 0xF0, 0x7F, 0x3F, 0xF8,
  0xFE, 0x07, 0xF3, 0xFF, 0x9F, 0xE0, 0x7F, 0x7F, 0xF9, 0xFC, 0x07, 0xF7,
  0xFF, 0x9F, 0xC0, 0x7E, 0xFF, 0xFB, 0xFC, 0x07, 0xEF, 0xDF, 0xBF, 0x80,
  0x7E, 0xFD, 0xFB, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0xF9, 0xFF,
  0xF0, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF,
  0x1F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xDF,
  0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xC7, 0xF8,
  0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFB, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0x0F, 0xF3,
  0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0,
  0xFE, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xFC, 0xFE, 0x03, 0xF7, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0x1F, 0xE7, 0xF8, 0xFE, 0x1F, 0x87, 0xF0,
  0xFC, 0x00, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x7F, 0xDF, 0xC3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F,
  0x87, 0xF9, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0xFF, 0x07,
  0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF3, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF1, 0xC0, 0x1F,
  0xDF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF1,
  0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0x3F, 0xE0, 0xFC, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFD, 0xE1, 0xFE, 0x04,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x43,
  0xFC, 0x38, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xF1, 0xFC, 0x03, 0xF9, 0xFC, 0x07,
  0xFD, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F,
  0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x3F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xDF, 0x80, 0x1F, 0x9F, 0x80, 0x00, 0x1C, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xC7, 0xF3, 0xFC, 0x7F, 0x3F, 0x87, 0xF7, 0xF8, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0x8F, 0xF8, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xD8, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0x3F, 0x01, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F,
  0xE1, 0xFC, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F,
  0xC7, 0xF8, 0x3F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xC0, 0x3F, 0xC0, 0xFE,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF1, 0xE0, 0x1F, 0xDF, 0xC0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F,
  0xC7, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F,
  0xE1, 0xFE, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC3,
  0xFC, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFE, 0x1F, 0xE0, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xDF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC, 0x07,
  0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0,
  0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x03, 0xF3, 0xFC, 0x7F, 0x81, 0xFB,
  0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0x1F,
  0xE3, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xE1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFF,
  0x3F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE1, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0x87,
  0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x01,
  0xC0, 0x1F, 0x9F, 0xC0, 0x7E, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x0F,
  0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7,
  0xF8, 0x7F, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF0,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xBF, 0xC7, 0xF8, 0xFF, 0x3F, 0x87, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x7F, 0x83, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1,
  0xFE, 0xFF, 0x0F, 0xE7, 0xF8, 0xFF, 0x3F, 0xC7, 0xF9, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xF9, 0xFC, 0x01, 0xFB, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFC,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xBF, 0xF0, 0x3F, 0xBF,
  0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF3, 0xF0, 0x7F, 0xDF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F,
  0x87, 0xF9, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07,
  0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF3, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xF0, 0xE0, 0xFE, 0x04, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x10, 0x0F, 0xE3, 0x03,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFF, 0x10, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE,
  0x1F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xE3,
  0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F,
  0x87, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFD, 0xF8, 0x1F, 0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0xFF,
  0x03, 0xFD, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0x81,
  0xFC, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE1, 0xFF, 0xFC, 0x7F, 0xC3,
  0xFB, 0xF8, 0xFF, 0x87, 0xF7, 0xF1, 0xFF, 0x1F, 0xEF, 0xE7, 0xFE, 0x3F,
  0x9F, 0xCF, 0xFC, 0x7F, 0x3F, 0x9F, 0xF9, 0xFC, 0x7F, 0x7F, 0xF3, 0xF8,
  0xFC, 0xFF, 0xEF, 0xE1, 0xFB, 0xFF, 0xDF, 0xC3, 0xF7, 0xFF, 0xBF, 0x87,
  0xEF, 0xBF, 0xFE, 0x0F, 0xDF, 0x7F, 0xFC, 0x1F, 0xFE, 0xFB, 0xF0, 0x3F,
  0xF9, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x01, 0xFF,
  0x8F, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0,
  0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87,
  0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x17, 0xFC, 0x01,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xF8, 0x03, 0xFE, 0x80, 0x03, 0x00,
};

const GFXglyph NotoSans_Condensed_BlackItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 32, 12, 0, -31 },
  { 57, 18, 11, 20, 4, -31 },
  { 82, 26, 31, 25, 0, -31 },
  { 183, 22, 36, 22, 1, -33 },
  { 282, 34, 32, 37, 2, -32 },
  { 418, 28, 32, 28, 0, -32 },
  { 530, 9, 11, 11, 4, -31 },
  { 543, 16, 39, 14, 1, -32 },
  { 621, 16, 39, 14, -3, -32 },
  { 699, 19, 21, 21, 3, -34 },
  { 749, 20, 21, 23, 2, -26 },
  { 802, 12, 12, 12, -3, -6 },
  { 820, 13, 7, 14, 0, -15 },
  { 832, 8, 9, 12, 0, -8 },
  { 841, 24, 32, 18, -2, -32 },
  { 937, 21, 32, 22, 1, -32 },
  { 1021, 18, 31, 22, 4, -31 },
  { 1091, 23, 32, 22, -1, -32 },
  { 1183, 22, 32, 22, 0, -32 },
  { 1271, 22, 31, 22, 0, -31 },
  { 1357, 22, 31, 22, 1, -31 },
  { 1443, 22, 32, 22, 1, -32 },
  { 1531, 24, 31, 22, 1, -31 },
  { 1624, 21, 32, 22, 1, -32 },
  { 1708, 21, 32, 22, 1, -32 },
  { 1792, 12, 26, 12, 0, -25 },
  { 1831, 15, 31, 12, -3, -25 },
  { 1890, 20, 22, 23, 2, -27 },
  { 1945, 20, 15, 23, 2, -23 },
  { 1983, 20, 22, 23, 2, -27 },
  { 2038, 18, 33, 18, 2, -32 },
  { 2113, 32, 36, 34, 1, -32 },
  { 2257, 26, 32, 25, -3, -32 },
  { 2361, 25, 31, 24, 0, -31 },
  { 2458, 23, 32, 23, 2, -32 },
  { 2550, 25, 31, 26, 0, -31 },
  { 2647, 22, 31, 20, 0, -31 },
  { 2733, 22, 31, 20, 0, -31 },
  { 2819, 25, 32, 26, 2, -32 },
  { 2919, 28, 31, 27, 0, -31 },
  { 3028, 22, 31, 17, -2, -31 },
  { 3114, 22, 41, 13, -7, -31 },
  { 3227, 29, 31, 25, 0, -31 },
  { 3340, 17, 31, 19, 0, -31 },
  { 3406, 36, 31, 35, 0, -31 },
  { 3546, 30, 31, 29, 0, -31 },
  { 3663, 25, 32, 27, 2, -32 },
  { 3763, 24, 31, 23, 0, -31 },
  { 3856, 25, 39, 27, 2, -32 },
  { 3978, 24, 31, 24, 0, -31 },
  { 4071, 22, 32, 21, 0, -32 },
  { 4159, 21, 31, 21, 3, -31 },
  { 4241, 25, 31, 26, 2, -31 },
  { 4338, 24, 31, 24, 4, -31 },
  { 4431, 36, 31, 35, 3, -31 },
  { 4571, 30, 31, 24, -3, -31 },
  { 4688, 23, 31, 23, 4, -31 },
  { 4778, 26, 31, 21, -2, -31 },
  { 4879, 19, 39, 14, -2, -32 },
  { 4972, 11, 32, 18, 4, -32 },
  { 5016, 19, 39, 14, -3, -32 },
  { 5109, 22, 20, 21, -1, -31 },
  { 5164, 19, 5, 18, -4, 3 },
  { 5176, 10, 7, 15, 6, -34 },
  { 5185, 22, 25, 23, 1, -25 },
  { 5254, 22, 33, 23, 0, -33 },
  { 5345, 19, 25, 19, 1, -25 },
  { 5405, 24, 33, 23, 1, -33 },
  { 5504, 20, 25, 22, 1, -25 },
  { 5567, 25, 45, 15, -5, -34 },
  { 5708, 24, 36, 23, -1, -25 },
  { 5816, 22, 33, 23, 0, -33 },
  { 5907, 14, 34, 12, 0, -34 },
  { 5967, 20, 45, 12, -6, -34 },
  { 6080, 25, 33, 23, 0, -33 },
  { 6184, 14, 33, 12, 0, -33 },
  { 6242, 33, 25, 35, 0, -25 },
  { 6346, 22, 25, 23, 0, -25 },
  { 6415, 21, 25, 23, 1, -25 },
  { 6481, 24, 36, 23, -2, -25 },
  { 6589, 22, 36, 23, 1, -25 },
  { 6688, 19, 25, 17, 0, -25 },
  { 6748, 19, 25, 19, 0, -25 },
  { 6808, 16, 29, 17, 2, -29 },
  { 6866, 23, 24, 23, 1, -24 },
  { 6935, 22, 24, 21, 2, -24 },
  { 7001, 31, 24, 32, 3, -24 },
  { 7094, 26, 24, 22, -2, -24 },
  { 7172, 27, 35, 21, -3, -24 },
  { 7291, 22, 24, 18, -2, -24 },
  { 7357, 19, 38, 15, 0, -31 },
  { 7448, 6, 44, 20, 7, -34 },
  { 7481, 18, 38, 15, -3, -31 },
  { 7567, 20, 9, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_BlackItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC44PT7B_H_
