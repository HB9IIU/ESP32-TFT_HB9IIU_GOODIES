#ifndef _NOTOSANS_CONDENSED_BLACKITALIC54PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00,
  0x30, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0xDF, 0xF1,
  0xFF, 0x7F, 0xC7, 0xF9, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0x9F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xF8, 0xFF,
  0x0F, 0xE3, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x87,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFD, 0xC7, 0x80, 0xFF, 0x38,
  0x30, 0x1F, 0xE7, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x77, 0xF8,
  0x00, 0x0E, 0xFF, 0x04, 0x01, 0xCF, 0xE0, 0xE0, 0x7B, 0xFC, 0x1F, 0x0E,
  0x7F, 0x83, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x00,
  0xFF, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x3F,
  0x81, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFE,
  0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x3F, 0x81, 0xE0, 0xFE, 0x7F, 0x9F, 0xC7,
  0xFC, 0x7F, 0x3F, 0x9F, 0xC7, 0xFF, 0x3F, 0xFF, 0xCF, 0xE7, 0xFF, 0xDF,
  0xFF, 0xCF, 0xE7, 0xFF, 0xE7, 0xFF, 0xCF, 0xE7, 0xFF, 0xF3, 0xFF, 0xC7,
  0xF3, 0xFF, 0xFC, 0xFF, 0xC7, 0xF3, 0xFC, 0xFE, 0x1F, 0x87, 0xF9, 0xFC,
  0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x1F, 0xC0,
  0x01, 0xFC, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x87, 0xE0, 0x01, 0xFC,
  0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x8F,
  0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF,
  0x8F, 0xF8, 0x1F, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xE7, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xC1,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x9F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x01, 0x00, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x04, 0x0F, 0xE0, 0x0E, 0x1F, 0xC0, 0x3F,
  0x3F, 0x80, 0x7F, 0xFE, 0x0E, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFE, 0xFE,
  0x03, 0xFD, 0xFE, 0x03, 0xF1, 0xFE, 0x03, 0xC3, 0xFC, 0x03, 0x87, 0xF0,
  0x02, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x1F, 0x9F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x06, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0x87, 0xFC, 0x7F,
  0xC7, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xF3, 0xFF, 0x0F, 0xF9, 0xFF, 0x07,
  0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0xC1, 0xFF, 0x7F, 0xE0, 0xFF, 0xBF, 0xE0,
  0x7F, 0xDF, 0xF0, 0x7F, 0xEF, 0xF8, 0x3F, 0xEF, 0xFC, 0x1F, 0xF7, 0xFC,
  0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0x83, 0xFE, 0x7F,
  0xC1, 0xFF, 0x3F, 0xE1, 0xFF, 0x9F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7,
  0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFE, 0xFF,
  0x87, 0xF7, 0xFE, 0x0F, 0x9F, 0xF0, 0x18, 0x7F, 0xC0, 0x41, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFE, 0x3F, 0xF8, 0x03, 0xE0, 0xFF, 0xC0, 0x1E,
  0x07, 0xFC, 0x00, 0x40, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xF0, 0x7F, 0xE0, 0x18, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0x00, 0x07,
  0xFE, 0x38, 0x01, 0xFF, 0xC7, 0xF1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFD, 0xFF, 0x00, 0x3F,
  0x9F, 0xF0, 0x07, 0xF1, 0xFF, 0x00, 0x7F, 0x3F, 0xE0, 0x0F, 0xE3, 0xFE,
  0x01, 0xFC, 0x3F, 0xE0, 0x1F, 0xC3, 0xFE, 0x03, 0xF8, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0x00, 0x0F, 0xFC, 0x38, 0x03, 0xFF,
  0x07, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE1, 0xC0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x7F,
  0xE0, 0x7F, 0xDF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xC7, 0xFE, 0x3F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC,
  0x3F, 0xE3, 0xFF, 0x07, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x7F, 0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xE1, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFC, 0xFF, 0xC7, 0xFE, 0x1F, 0xF1, 0xFF, 0x87, 0xFC, 0x7F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xFC, 0x1F, 0xF3, 0xFF, 0x0F, 0xFC,
  0xFF, 0xC3, 0xFF, 0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0x7F, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0x00, 0xFC, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x83, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE,
  0x07, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0x07, 0xFC, 0x30, 0x1F, 0xF0, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7E, 0x07, 0xF0,
  0x7F, 0xFE, 0x7E, 0x0F, 0xE0, 0xFF, 0xFE, 0x7F, 0x0F, 0xC1, 0xFF, 0xFE,
  0x3F, 0x1F, 0xC3, 0xFF, 0xFC, 0x3F, 0x1F, 0x87, 0xF8, 0xFC, 0x3F, 0x3F,
  0x87, 0xF1, 0xFC, 0x3F, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x3F, 0x1F, 0xC1, 0xF8, 0x7E, 0x7E, 0x1F, 0x83, 0xF8, 0x7E,
  0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x7E, 0x3F, 0x83, 0xF0, 0x7E, 0x7E, 0x3F,
  0x83, 0xF0, 0xFC, 0x7E, 0x3F, 0x87, 0xF0, 0xFC, 0x7E, 0x3F, 0x87, 0xF1,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE1, 0xF8, 0xFE, 0x3F, 0x9F, 0xF7, 0xF0, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x7E, 0x1F, 0xFD,
  0xFF, 0xC0, 0x7E, 0x0F, 0xF9, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x7E, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x10, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFC, 0xFF,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0x8F, 0xF8,
  0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x81,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x83, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xC0, 0x7F, 0xF0,
  0x04, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x02, 0x03, 0xFF, 0x80, 0x60, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xE1, 0xFF,
  0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xF0, 0x1F, 0xFE, 0x00,
  0x60, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF1, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0x1F, 0xF8, 0x7F, 0xFE, 0x3F,
  0xF0, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF,
  0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC,
  0x07, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x01, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF,
  0x0F, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x03,
  0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xEF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0x07, 0xFB, 0xF8, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0x8F, 0xEF,
  0xF8, 0x0F, 0xFB, 0xF8, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0x9F, 0xFF, 0xF0,
  0x0F, 0xFB, 0xF9, 0xFD, 0xFF, 0x00, 0xFF, 0x3F, 0xBF, 0xDF, 0xF0, 0x0F,
  0xF3, 0xFB, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xFF, 0x9F, 0xE0, 0x1F, 0xF3,
  0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0x3F, 0xE0, 0x1F, 0xE3, 0xFF,
  0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0xE7,
  0xFC, 0x03, 0xFE, 0x3F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0xC7, 0xFC,
  0x03, 0xFC, 0x3F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFE, 0x03, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xF8,
  0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xFE,
  0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0x7F, 0x8F, 0xF8, 0x07,
  0xFB, 0xFC, 0x7F, 0xC0, 0x3F, 0xDF, 0xF3, 0xFE, 0x03, 0xFE, 0xFF, 0x9F,
  0xF0, 0x1F, 0xF7, 0xFC, 0xFF, 0x00, 0xFF, 0x9F, 0xEF, 0xF8, 0x07, 0xF8,
  0xFF, 0x7F, 0xC0, 0x3F, 0xC7, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xFF, 0xE0,
  0x1F, 0xF1, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0xF8, 0x07, 0xF8, 0x3F,
  0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F,
  0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xC0, 0x7F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F,
  0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF,
  0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB,
  0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF,
  0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF,
  0x80, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC,
  0x07, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC3,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x3F,
  0xE3, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0x00,
  0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x07,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3,
  0xFF, 0x00, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFF, 0x07,
  0xFC, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xFC, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x87,
  0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0x1F, 0x80, 0x7F, 0xE0, 0x30, 0x07, 0xFC,
  0x01, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x40, 0x07, 0xFE, 0x07, 0x00, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD,
  0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xF3, 0xFE,
  0x01, 0xFF, 0x9F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x07,
  0xFC, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF,
  0x87, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x3F,
  0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xE7, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC7, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0xC0, 0xFF,
  0x87, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0x83, 0xFF, 0xC1, 0xFF, 0x07,
  0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8,
  0x7F, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0xFF,
  0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xFF, 0xC7, 0xFC, 0x0F, 0xF9, 0xFF, 0xFC,
  0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0xFC, 0xFF,
  0x80, 0xFF, 0xBF, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFB, 0xFD, 0xFF, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x0F,
  0xFC, 0x7F, 0xC0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xE7,
  0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFE, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xF9, 0xFE, 0x03, 0xFF, 0xDF,
  0xE0, 0x7F, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xFC, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87,
  0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0,
  0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xBF, 0xC0, 0x3F, 0xF3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0xF8, 0x07,
  0xFB, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF9, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF,
  0x1F, 0xF0, 0x7F, 0xE3, 0xFE, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE3, 0xFE, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xFE, 0x7F, 0xE1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xDF, 0xFE, 0x07, 0xF9, 0xFF, 0x80, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFC,
  0x78, 0x1F, 0xF8, 0x10, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x20, 0xFF, 0xC0, 0x40, 0x7F, 0xE3, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xCF, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFE, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF,
  0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC7,
  0xFE, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xC0,
  0x0F, 0xFC, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xF0,
  0xFF, 0x1F, 0xF0, 0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFC,
  0x7F, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x43, 0xFF, 0x00, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xC4, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0x7F, 0x80,
  0x3F, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F,
  0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFF,
  0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x02, 0x00, 0x1F, 0xF0, 0x0E, 0x00, 0xFF, 0xC0, 0x3F,
  0xCF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x3F,
  0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFE,
  0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8,
  0xFF, 0xC3, 0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF,
  0x87, 0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x01, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xF9,
  0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0xFF,
  0xE3, 0xFF, 0x00, 0xFE, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F,
  0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0,
  0xFF, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x3F, 0xF0, 0x0F, 0xEF, 0xFF,
  0x03, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFC,
  0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0xE0,
  0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7,
  0xFE, 0x1F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFF, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0,
  0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFE, 0x0F, 0xFC, 0xFF, 0x83, 0xFF, 0x7F,
  0xE0, 0xFF, 0xDF, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE,
  0x7F, 0xC0, 0xFF, 0xBF, 0xF0, 0x7F, 0xEF, 0xFC, 0x1F, 0xF3, 0xFF, 0x07,
  0xFC, 0xFF, 0xC3, 0xFF, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0xE1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0xFF, 0xC0, 0x07, 0xF7, 0xFF,
  0x80, 0x3F, 0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x07,
  0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xE7, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0xC0, 0x1F, 0xF7,
  0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0x04, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x0F,
  0xF9, 0xFE, 0x03, 0xFF, 0xDF, 0xE0, 0x3F, 0xFD, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xFC, 0x1F,
  0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0,
  0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC,
  0x01, 0xFE, 0xFF, 0x80, 0x02, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xF8, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F,
  0xDF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFE, 0x10, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFC, 0x18, 0x1F, 0xF0, 0x10, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x18, 0x07, 0xFE, 0x3C, 0x0F, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC6, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x7F,
  0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFB,
  0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFB, 0xFE, 0x07, 0xFE, 0xFF, 0x81,
  0xFF, 0x3F, 0xE0, 0xFF, 0xCF, 0xF8, 0x3F, 0xE1, 0xFE, 0x1F, 0xF8, 0x7F,
  0x87, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xE0,
  0x7F, 0x9F, 0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xFB, 0xFE, 0x01, 0xFE, 0xFF,
  0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFB, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF7, 0xFC, 0x3F, 0xF8, 0x3F, 0xEF, 0xF8, 0x7F, 0xF0, 0xFF, 0x9F,
  0xF1, 0xFF, 0xE1, 0xFF, 0x3F, 0xE3, 0xFF, 0xC7, 0xFC, 0x7F, 0xC7, 0xFF,
  0x8F, 0xF8, 0xFF, 0x9F, 0xFF, 0x1F, 0xE1, 0xFF, 0x3F, 0xFE, 0x7F, 0xC3,
  0xFE, 0xFF, 0xFC, 0xFF, 0x87, 0xFD, 0xFF, 0xFB, 0xFE, 0x0F, 0xFB, 0xF7,
  0xF7, 0xFC, 0x1F, 0xEF, 0xEF, 0xEF, 0xF0, 0x3F, 0xDF, 0xDF, 0xFF, 0xE0,
  0x7F, 0xBF, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x7E, 0xFF, 0x01, 0xFF, 0xFC,
  0xFD, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xF0,
  0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF8,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFD,
  0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE,
  0x0F, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF8, 0x01, 0xFE,
  0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFF,
  0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xBF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x40,
  0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_BlackItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 17, 40, 15, 0, -39 },
  { 86, 22, 14, 24, 5, -39 },
  { 125, 32, 39, 30, 0, -39 },
  { 281, 27, 44, 27, 1, -41 },
  { 430, 41, 39, 45, 3, -39 },
  { 630, 35, 40, 34, 0, -39 },
  { 805, 11, 14, 13, 5, -39 },
  { 825, 20, 49, 17, 1, -40 },
  { 948, 20, 49, 17, -4, -40 },
  { 1071, 23, 26, 25, 4, -42 },
  { 1146, 25, 26, 28, 2, -32 },
  { 1228, 14, 14, 15, -3, -7 },
  { 1253, 15, 9, 17, 1, -19 },
  { 1270, 10, 10, 15, 0, -9 },
  { 1283, 30, 40, 23, -3, -39 },
  { 1433, 25, 40, 27, 2, -39 },
  { 1558, 22, 39, 27, 5, -39 },
  { 1666, 29, 39, 27, -2, -39 },
  { 1808, 27, 40, 27, 0, -39 },
  { 1943, 28, 39, 27, 0, -39 },
  { 2080, 27, 40, 27, 1, -39 },
  { 2215, 27, 40, 27, 2, -39 },
  { 2350, 29, 39, 27, 1, -39 },
  { 2492, 27, 40, 27, 1, -39 },
  { 2627, 26, 40, 27, 1, -39 },
  { 2757, 15, 31, 15, 0, -30 },
  { 2816, 18, 37, 15, -3, -30 },
  { 2900, 25, 27, 28, 2, -33 },
  { 2985, 25, 20, 28, 2, -29 },
  { 3048, 25, 27, 28, 2, -33 },
  { 3133, 22, 40, 22, 2, -39 },
  { 3243, 40, 43, 41, 1, -39 },
  { 3458, 31, 39, 31, -3, -39 },
  { 3610, 30, 39, 30, 0, -39 },
  { 3757, 29, 40, 28, 2, -39 },
  { 3902, 31, 39, 32, 0, -39 },
  { 4054, 27, 39, 25, 0, -39 },
  { 4186, 27, 39, 25, 0, -39 },
  { 4318, 31, 40, 32, 2, -39 },
  { 4473, 34, 39, 33, 0, -39 },
  { 4639, 27, 39, 21, -2, -39 },
  { 4771, 27, 51, 16, -9, -39 },
  { 4944, 35, 39, 30, 0, -39 },
  { 5115, 21, 39, 24, 0, -39 },
  { 5218, 44, 39, 43, 0, -39 },
  { 5433, 37, 39, 36, 0, -39 },
  { 5614, 31, 40, 34, 2, -39 },
  { 5769, 29, 39, 28, 0, -39 },
  { 5911, 31, 48, 34, 2, -39 },
  { 6097, 29, 39, 30, 0, -39 },
  { 6239, 28, 40, 25, 0, -39 },
  { 6379, 25, 39, 25, 4, -39 },
  { 6501, 32, 40, 32, 2, -39 },
  { 6661, 29, 39, 30, 5, -39 },
  { 6803, 44, 39, 43, 4, -39 },
  { 7018, 37, 39, 30, -3, -39 },
  { 7199, 28, 39, 28, 5, -39 },
  { 7336, 31, 39, 25, -2, -39 },
  { 7488, 23, 49, 17, -2, -40 },
  { 7629, 14, 40, 23, 5, -39 },
  { 7699, 23, 49, 17, -4, -40 },
  { 7840, 27, 26, 26, -1, -39 },
  { 7928, 23, 6, 22, -5, 4 },
  { 7946, 12, 8, 18, 8, -41 },
  { 7958, 28, 31, 28, 1, -30 },
  { 8067, 27, 42, 28, 0, -41 },
  { 8209, 24, 31, 23, 1, -30 },
  { 8302, 30, 42, 28, 1, -41 },
  { 8460, 25, 31, 27, 1, -30 },
  { 8557, 30, 54, 18, -6, -41 },
  { 8760, 30, 43, 28, -1, -30 },
  { 8922, 27, 41, 29, 0, -41 },
  { 9061, 17, 42, 15, 0, -42 },
  { 9151, 24, 55, 15, -7, -42 },
  { 9316, 31, 41, 28, 0, -41 },
  { 9475, 18, 41, 15, 0, -41 },
  { 9568, 41, 30, 42, 0, -30 },
  { 9722, 27, 30, 29, 0, -30 },
  { 9824, 26, 31, 28, 1, -30 },
  { 9925, 30, 43, 28, -3, -30 },
  { 10087, 28, 43, 28, 1, -30 },
  { 10238, 23, 30, 20, 0, -30 },
  { 10325, 23, 31, 23, 0, -30 },
  { 10415, 20, 37, 20, 2, -36 },
  { 10508, 28, 31, 29, 1, -30 },
  { 10617, 26, 30, 26, 3, -30 },
  { 10715, 39, 30, 39, 3, -30 },
  { 10862, 32, 30, 27, -3, -30 },
  { 10982, 32, 43, 26, -3, -30 },
  { 11154, 26, 30, 23, -2, -30 },
  { 11252, 23, 48, 19, 0, -39 },
  { 11390, 8, 53, 24, 8, -41 },
  { 11443, 22, 48, 19, -3, -39 },
  { 11575, 25, 10, 28, 2, -24 },
};

const GFXfont NotoSans_Condensed_BlackItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC54PT7B_H_
