#ifndef _NOTOSANS_CONDENSED_BLACKITALIC6PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x62, 0xC0, 0x6F, 0xEC, 0x2D, 0x3C, 0xD7, 0x4E, 0xB0, 0x67, 0xEE,
  0x80, 0x6A, 0x80, 0x56, 0x80, 0x5D, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x2A, 0x40, 0x76, 0xE0, 0x75, 0x20, 0x65, 0x70, 0x6C, 0xE0, 0x2F, 0xA0,
  0x7C, 0xE0, 0x7E, 0xE0, 0x65, 0x60, 0x6E, 0xE0, 0x75, 0xE0, 0x48, 0x4A,
  0x39, 0x80, 0xFC, 0x8F, 0x00, 0xE8, 0x40, 0x77, 0xFD, 0xC0, 0x6F, 0xD0,
  0x6E, 0xF0, 0x7A, 0x70, 0x6E, 0xF0, 0x6E, 0x60, 0x6E, 0x40, 0x7A, 0xAE,
  0x56, 0xAA, 0x69, 0x60, 0x25, 0x2C, 0x76, 0xAA, 0x5B, 0x5E, 0xED, 0x60,
  0x5B, 0xBA, 0x79, 0xAE, 0x6F, 0x40, 0x79, 0xAE, 0x20, 0x6E, 0xD0, 0x79,
  0xE0, 0xE9, 0x20, 0x56, 0xAE, 0xFB, 0x40, 0xED, 0x7D, 0xE0, 0x76, 0x6A,
  0xFA, 0x40, 0x6B, 0x70, 0x6A, 0x80, 0xF0, 0x56, 0x80, 0x4E, 0x80, 0xE0,
  0x80, 0xF7, 0x80, 0x4B, 0xDE, 0xF3, 0x00, 0x27, 0xDE, 0xFB, 0x00, 0x32,
  0x64, 0x4C, 0xF7, 0xE0, 0x4B, 0xDA, 0x4E, 0x80, 0x20, 0xA5, 0x80, 0x4A,
  0xEA, 0x5E, 0x80, 0xFD, 0xAC, 0xF6, 0x80, 0xF7, 0x00, 0xF7, 0xC0, 0xF7,
  0xA0, 0xF2, 0x00, 0xEB, 0x00, 0x7B, 0xF7, 0x80, 0xB9, 0x00, 0xBF, 0xB8,
  0xEB, 0x80, 0xB9, 0x40, 0xEB, 0x00, 0x6A, 0x4C, 0xFC, 0xD6, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_BlackItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 1, -4 },
  { 3, 4, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 1, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 3, 4, 3, 0, -4 },
  { 46, 2, 3, 2, 0, -3 },
  { 47, 2, 4, 2, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 3, 2, 3, 0, -3 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 3, 4, 2, 0, -4 },
  { 55, 5, 4, 5, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 3, 4, 2, 0, -4 },
  { 76, 3, 5, 2, -1, -4 },
  { 78, 4, 4, 3, 0, -4 },
  { 80, 2, 4, 3, 0, -4 },
  { 81, 5, 4, 5, 0, -4 },
  { 84, 4, 4, 4, 0, -4 },
  { 86, 4, 4, 4, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 4, 5, 4, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 3, 4, 3, 1, -4 },
  { 103, 5, 4, 5, 0, -4 },
  { 106, 4, 4, 3, 0, -4 },
  { 108, 3, 4, 3, 1, -4 },
  { 110, 3, 4, 3, 0, -4 },
  { 112, 2, 5, 2, 0, -4 },
  { 114, 1, 4, 3, 1, -4 },
  { 115, 2, 5, 2, 0, -4 },
  { 117, 3, 3, 3, 0, -4 },
  { 119, 3, 1, 2, -1, 0 },
  { 120, 1, 1, 2, 1, -5 },
  { 121, 3, 3, 3, 0, -3 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 3, 3, 3, 0, -3 },
  { 127, 3, 5, 3, 0, -5 },
  { 129, 3, 3, 3, 0, -3 },
  { 131, 4, 6, 2, -1, -5 },
  { 134, 3, 4, 3, 0, -3 },
  { 136, 3, 5, 3, 0, -5 },
  { 138, 2, 5, 2, 0, -5 },
  { 140, 3, 6, 2, -1, -5 },
  { 143, 3, 5, 3, 0, -5 },
  { 145, 2, 5, 2, 0, -5 },
  { 147, 5, 3, 5, 0, -3 },
  { 149, 3, 3, 3, 0, -3 },
  { 151, 3, 3, 3, 0, -3 },
  { 153, 3, 4, 3, 0, -3 },
  { 155, 3, 4, 3, 0, -3 },
  { 157, 3, 3, 2, 0, -3 },
  { 159, 3, 3, 3, 0, -3 },
  { 161, 2, 4, 2, 0, -4 },
  { 162, 3, 3, 3, 0, -3 },
  { 164, 3, 3, 3, 0, -3 },
  { 166, 5, 3, 4, 0, -3 },
  { 168, 3, 3, 3, 0, -3 },
  { 170, 3, 4, 3, 0, -3 },
  { 172, 3, 3, 3, 0, -3 },
  { 174, 3, 5, 2, 0, -4 },
  { 176, 1, 6, 3, 1, -5 },
  { 177, 2, 5, 2, 0, -4 },
  { 179, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_BlackItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC6PT7B_H_
