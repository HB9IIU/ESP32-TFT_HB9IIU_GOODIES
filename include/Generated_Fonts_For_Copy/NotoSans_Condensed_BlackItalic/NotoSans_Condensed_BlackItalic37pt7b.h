#ifndef _NOTOSANS_CONDENSED_BLACKITALIC37PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0x00, 0x7C,
  0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF1, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0x78, 0xF0, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x07, 0xCF, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x71, 0x0F, 0xD8, 0x03, 0xF6, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x1B, 0xF2, 0x06, 0xFC, 0xE1, 0xBE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x80, 0xFE, 0x01,
  0xF0, 0x1F, 0xF0, 0x1E, 0x03, 0xFF, 0x03, 0xE0, 0x3F, 0xF0, 0x7C, 0x07,
  0xCF, 0x07, 0xC0, 0x7C, 0xF0, 0xF8, 0x0F, 0x8F, 0x1F, 0x00, 0xF8, 0xF1,
  0xF0, 0x0F, 0x9F, 0x3E, 0x00, 0xF9, 0xF3, 0xC0, 0x0F, 0x9E, 0x7C, 0xFC,
  0xFB, 0xEF, 0x9F, 0xEF, 0xFC, 0xFB, 0xFF, 0x7F, 0xDF, 0x7F, 0xF7, 0xF9,
  0xE7, 0xDF, 0x1E, 0x3E, 0xF9, 0xF0, 0x07, 0xCF, 0x9F, 0x00, 0x7C, 0xF9,
  0xF0, 0x0F, 0x8F, 0x9F, 0x01, 0xF0, 0xF1, 0xE0, 0x1F, 0x0F, 0x3E, 0x03,
  0xE0, 0xF3, 0xE0, 0x3C, 0x0F, 0xFC, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x07,
  0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x0F, 0xFC, 0x7E, 0x1F,
  0xFC, 0xFE, 0x3F, 0xFE, 0xFC, 0x7F, 0xFF, 0xFC, 0x7E, 0x7F, 0xF8, 0xFE,
  0x7F, 0xF8, 0xFE, 0x3F, 0xF0, 0xFE, 0x3F, 0xE0, 0xFE, 0x3F, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xF3, 0xFC, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x63, 0xE0, 0x7B,
  0xE0, 0xFF, 0xDE, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x1F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF0, 0x7C, 0xF8, 0x3C, 0xFC, 0x18, 0xF0, 0x08,
  0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x1F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C,
  0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xE7, 0xFD, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xF9, 0xFC, 0x7E, 0x7F, 0x3F, 0x9F, 0xCF,
  0xC7, 0xF7, 0xF1, 0xFD, 0xFC, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1,
  0xFB, 0xF8, 0xFE, 0xFE, 0x3F, 0xBF, 0x0F, 0xCF, 0xC7, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0xBF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x9F, 0xFF, 0x7F, 0xFC, 0x7F, 0xF8, 0xF3, 0xF0, 0xCF,
  0xE1, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xF1, 0xF8, 0x18, 0x3F,
  0x02, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC1, 0x83, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC8, 0x07, 0xF1,
  0xC1, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7B, 0xF0, 0x1F, 0xFE, 0x07, 0xDF, 0x81, 0xF3, 0xF0, 0x3C, 0x7E,
  0x0F, 0x9F, 0xC3, 0xE3, 0xF0, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC1, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF2,
  0x03, 0xF8, 0xC1, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xE2, 0x00, 0xFD, 0xF8, 0x3F, 0x7F, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE7, 0xF9, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8,
  0xFC, 0x7F, 0x1F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xDF, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xC1,
  0xF9, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xBF, 0x0F, 0xE7, 0xF1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xCF, 0xE1, 0xF9, 0xFC, 0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0xDF, 0xC7, 0xE7, 0xF1, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xCF, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x20, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0x83, 0xF0, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x00, 0x00,
  0xE0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0x80, 0x00, 0x01, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF,
  0x07, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0xE0,
  0x3F, 0xF1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xCC, 0x3F, 0x90,
  0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x00,
  0xF0, 0xF8, 0x3F, 0x1F, 0x1F, 0x1F, 0xF9, 0xE7, 0xC7, 0xFF, 0x3C, 0xF1,
  0xFF, 0xC7, 0xBE, 0x7C, 0x78, 0xF7, 0x8F, 0x1F, 0x1E, 0xF3, 0xE3, 0xE7,
  0xDE, 0x7C, 0x78, 0xF7, 0xCF, 0x0F, 0x1E, 0xF1, 0xE3, 0xE3, 0xDE, 0x3C,
  0x7C, 0xF3, 0xC7, 0x9F, 0x9E, 0x78, 0xFF, 0xFF, 0x8F, 0x1F, 0xFF, 0xF1,
  0xE1, 0xFB, 0xF8, 0x3E, 0x1E, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x20, 0x0F, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C,
  0x07, 0xF3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xC1, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7E, 0x03,
  0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8,
  0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0x8F,
  0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xF3, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xE0, 0xC1, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x02, 0x07, 0xF8, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF3,
  0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC7,
  0xF0, 0x7E, 0x3F, 0x87, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0xFE, 0x0F,
  0xE7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x7F, 0x8F, 0xC3, 0xF8, 0xFE,
  0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0x02, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xF1, 0xFC, 0xFF,
  0xC7, 0xE3, 0xFF, 0x1F, 0x8F, 0xF8, 0x7E, 0x3F, 0xE3, 0xF8, 0x1F, 0x8F,
  0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xC1, 0xFE, 0x3F, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1,
  0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0x83,
  0xF0, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x4F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x07, 0xE3, 0xF8, 0x07,
  0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xDF, 0xE0, 0x0F,
  0xDF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xBF, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF,
  0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x07,
  0xFF, 0x3E, 0xFC, 0x1F, 0xFC, 0xFB, 0xF0, 0x7F, 0xF7, 0xFF, 0x83, 0xF7,
  0xDF, 0x7E, 0x0F, 0xDF, 0x7D, 0xF8, 0x3F, 0x7F, 0xE7, 0xE0, 0xFD, 0xFF,
  0xBF, 0x83, 0xF7, 0xFC, 0xFC, 0x1F, 0x9F, 0xF3, 0xF0, 0x7E, 0x7F, 0x8F,
  0xC1, 0xF9, 0xFE, 0x3F, 0x07, 0xE7, 0xF9, 0xFC, 0x1F, 0x9F, 0xC7, 0xE0,
  0xFC, 0x7F, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x00, 0x07, 0xF8, 0x1F, 0xC1,
  0xFE, 0x07, 0xE0, 0x7F, 0xC1, 0xF8, 0x1F, 0xF0, 0x7E, 0x07, 0xFC, 0x1F,
  0x83, 0xFF, 0x0F, 0xC0, 0xFF, 0xC3, 0xF0, 0x3F, 0xF8, 0xFC, 0x0F, 0xFE,
  0x3F, 0x03, 0xFF, 0x9F, 0x81, 0xFF, 0xE7, 0xE0, 0x7E, 0xF9, 0xF8, 0x1F,
  0xBF, 0x7E, 0x07, 0xEF, 0xDF, 0x83, 0xF3, 0xF7, 0xC0, 0xFC, 0xFF, 0xF0,
  0x3F, 0x1F, 0xFC, 0x0F, 0xC7, 0xFF, 0x03, 0xF1, 0xFF, 0xC1, 0xF8, 0x7F,
  0xE0, 0x7E, 0x0F, 0xF8, 0x1F, 0x83, 0xFE, 0x07, 0xE0, 0xFF, 0x81, 0xF8,
  0x3F, 0xE0, 0xFC, 0x0F, 0xF0, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07,
  0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xE7,
  0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0x7E, 0x03, 0xFB, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x1F, 0x83, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0xFF, 0x87, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC,
  0x7F, 0x1F, 0xCF, 0xE1, 0xFD, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F,
  0x87, 0xF0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xDF,
  0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0x80,
  0xFE, 0x7E, 0x03, 0xFB, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x1F, 0x83, 0xFC,
  0x7E, 0x0F, 0xE1, 0xFE, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC,
  0x7F, 0x1F, 0xCF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x07,
  0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x1F, 0xC7, 0xE1, 0xFC,
  0xFE, 0x1F, 0xCF, 0xE1, 0xFE, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0xE0, 0xFE, 0x04,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x40, 0x3F, 0x86, 0x07, 0xE1, 0xFB, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0xFC,
  0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xE7,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x83, 0xF9, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0,
  0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFC, 0x07, 0xEF,
  0xE0, 0x3F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x07, 0xEF, 0xC1, 0xFC, 0x3F, 0xBF,
  0x07, 0xF0, 0xFC, 0xFC, 0x3F, 0xC3, 0xF3, 0xF0, 0xFF, 0x1F, 0xCF, 0xC3,
  0xFC, 0x7E, 0x3F, 0x1F, 0xF1, 0xF8, 0xFC, 0x7F, 0xCF, 0xC3, 0xF3, 0xFF,
  0x3F, 0x0F, 0xCF, 0xFD, 0xFC, 0x3F, 0x7F, 0xF7, 0xE0, 0xFD, 0xFF, 0x9F,
  0x83, 0xF7, 0xFE, 0xFC, 0x0F, 0xFF, 0xFB, 0xF0, 0x3F, 0xFB, 0xEF, 0xC0,
  0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F,
  0xF3, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0xEF, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xFD, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x0F, 0xF7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0x7F, 0x3F,
  0x87, 0xF3, 0xF0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xF8,
  0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0xC7, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x02, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF0,
  0x1F, 0x3E, 0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF3,
  0xF0, 0x1F, 0xFC, 0x03, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xEF, 0xFF, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x03,
  0xC0, 0x20, 0xFC, 0xF8, 0x3F, 0xDF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0x7F, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x9F, 0xC3, 0xF3, 0xF8,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xBF, 0x03, 0xE7,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x78, 0x0F, 0xDF, 0x81, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xE3,
  0xF9, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F,
  0xE7, 0xF1, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7C, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xDC, 0x7F, 0x04, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x08, 0xFE, 0x30, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3C, 0xFE, 0x07, 0xEF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xBF, 0xC7, 0xF1,
  0xF8, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x7E, 0x03, 0xE7, 0xC0,
  0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF9, 0xF8,
  0xFD, 0xFC, 0x7E, 0xFC, 0x3F, 0x7E, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F,
  0xFF, 0x0F, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x08, 0xFF, 0x7C,
  0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x17, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x08, 0x0F, 0xCF, 0x80, 0xFF, 0x7C, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xF7, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE1, 0xFC,
  0x3F, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x7F, 0x07, 0xE7, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xBF, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x10,
  0x0F, 0xE0, 0xF0, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x78, 0x0F, 0xDF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0x9F, 0xC7, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F,
  0x80, 0x01, 0xC0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x7E, 0x3F, 0x87, 0xF3, 0xF8, 0x3F,
  0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xBF, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x3F, 0x07,
  0xF1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x80, 0x03, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F,
  0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0xF9, 0xFC, 0xFE, 0x0F, 0xBF, 0xDF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F,
  0xCF, 0xE3, 0xF1, 0xF8, 0xFE, 0x3F, 0x3F, 0x8F, 0xC7, 0xF3, 0xF8, 0xFC,
  0x7F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x1F, 0x87, 0xE7,
  0xF1, 0xF8, 0xFE, 0x7E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x3F,
  0x8F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFE, 0x3F, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8,
  0xFC, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0x01, 0xF7, 0xF0, 0x3E, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xF3, 0xF8, 0xFC, 0x7E, 0x3F,
  0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0xFE,
  0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE3, 0xF8,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF9, 0xFD, 0xFD, 0xFC, 0x7E, 0xFE, 0x3F, 0x7E,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB,
  0xF1, 0xFD, 0xF8, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x7F, 0x00, 0xFB, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFD, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF9, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7E, 0xFE, 0x03, 0xF3, 0xE0, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0,
  0x20, 0xFC, 0xF8, 0x3F, 0xDF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x7F,
  0x9F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE7, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xBF, 0x03, 0xEF, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x0F, 0x9E, 0x0F, 0xBE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3F, 0x8C, 0x3F, 0x84, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0xC1, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF7, 0xFF, 0x9F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0x7F, 0x80, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x87,
  0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC7, 0xF1, 0xF8, 0xFE, 0x7F, 0x1F, 0x8F, 0xE3, 0xF1, 0xFC, 0xFE,
  0x3F, 0x9F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFE, 0xF8,
  0x1F, 0x9F, 0x00, 0xFC, 0x1F, 0xFF, 0x07, 0xEF, 0xC3, 0xFB, 0xF0, 0xFC,
  0xFC, 0x7F, 0x3F, 0x1F, 0x87, 0xCF, 0xE1, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F,
  0x7E, 0x07, 0xDF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x3F, 0x8F, 0xFF, 0x8F, 0xF1, 0xFB, 0xF1, 0xFE, 0x7F, 0x7E, 0x7F,
  0xCF, 0xCF, 0xCF, 0xF9, 0xF9, 0xF9, 0xFE, 0x7E, 0x3F, 0x7F, 0xCF, 0xC7,
  0xEF, 0x7B, 0xF0, 0xFD, 0xEF, 0x7E, 0x1F, 0xFD, 0xEF, 0xC3, 0xFF, 0x3F,
  0xF0, 0x7F, 0xEF, 0xFE, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0x3F, 0xF0, 0x3F,
  0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xE3, 0xFC, 0x1F,
  0xCF, 0xE0, 0x7F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0x9F, 0x80, 0xFC, 0x7E, 0x07, 0xF1, 0xFC,
  0x3F, 0x87, 0xF0, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x83,
  0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x3E, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x9F, 0xC0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0x01, 0xFC,
};

const GFXglyph NotoSans_Condensed_BlackItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 26, 10, 0, -26 },
  { 40, 16, 9, 17, 3, -26 },
  { 58, 22, 26, 21, 0, -26 },
  { 130, 18, 30, 19, 1, -28 },
  { 198, 28, 27, 31, 2, -27 },
  { 293, 24, 27, 24, 0, -27 },
  { 374, 8, 9, 9, 3, -26 },
  { 383, 13, 33, 11, 1, -27 },
  { 437, 14, 33, 11, -3, -27 },
  { 495, 16, 17, 17, 3, -28 },
  { 529, 16, 18, 19, 2, -22 },
  { 565, 9, 10, 10, -2, -5 },
  { 577, 11, 6, 12, 0, -13 },
  { 586, 7, 6, 10, 0, -6 },
  { 592, 21, 27, 15, -2, -27 },
  { 663, 18, 27, 19, 1, -27 },
  { 724, 15, 26, 19, 3, -26 },
  { 773, 19, 27, 19, -1, -27 },
  { 838, 19, 27, 19, 0, -27 },
  { 903, 19, 26, 19, 0, -26 },
  { 965, 18, 26, 19, 1, -26 },
  { 1024, 19, 27, 19, 1, -27 },
  { 1089, 20, 26, 19, 1, -26 },
  { 1154, 19, 27, 19, 0, -27 },
  { 1219, 18, 27, 19, 1, -27 },
  { 1280, 10, 21, 10, 0, -21 },
  { 1307, 12, 26, 10, -2, -21 },
  { 1346, 16, 19, 19, 2, -23 },
  { 1384, 16, 14, 19, 2, -20 },
  { 1412, 16, 19, 19, 2, -23 },
  { 1450, 15, 27, 15, 2, -27 },
  { 1501, 27, 30, 28, 1, -27 },
  { 1603, 21, 26, 21, -2, -26 },
  { 1672, 21, 26, 20, 0, -26 },
  { 1741, 20, 27, 19, 1, -27 },
  { 1809, 21, 26, 22, 0, -26 },
  { 1878, 19, 26, 17, 0, -26 },
  { 1940, 19, 26, 17, 0, -26 },
  { 2002, 22, 27, 22, 1, -27 },
  { 2077, 24, 26, 23, 0, -26 },
  { 2155, 18, 26, 14, -1, -26 },
  { 2214, 18, 34, 11, -6, -26 },
  { 2291, 24, 26, 21, 0, -26 },
  { 2369, 15, 26, 16, 0, -26 },
  { 2418, 30, 26, 29, 0, -26 },
  { 2516, 26, 26, 24, 0, -26 },
  { 2601, 22, 27, 23, 1, -27 },
  { 2676, 20, 26, 19, 0, -26 },
  { 2741, 22, 33, 23, 1, -27 },
  { 2832, 20, 26, 20, 0, -26 },
  { 2897, 19, 27, 17, 0, -27 },
  { 2962, 17, 26, 17, 3, -26 },
  { 3018, 21, 26, 22, 2, -26 },
  { 3087, 21, 26, 20, 3, -26 },
  { 3156, 30, 26, 30, 3, -26 },
  { 3254, 25, 26, 20, -2, -26 },
  { 3336, 20, 26, 19, 3, -26 },
  { 3401, 22, 26, 17, -2, -26 },
  { 3473, 16, 33, 11, -2, -27 },
  { 3539, 9, 27, 15, 4, -27 },
  { 3570, 16, 33, 11, -3, -27 },
  { 3636, 19, 17, 18, -1, -26 },
  { 3677, 17, 5, 15, -4, 2 },
  { 3688, 9, 6, 12, 5, -28 },
  { 3695, 19, 21, 19, 1, -21 },
  { 3745, 19, 28, 19, 0, -28 },
  { 3812, 16, 21, 16, 1, -21 },
  { 3854, 20, 28, 19, 1, -28 },
  { 3924, 17, 21, 18, 1, -21 },
  { 3969, 21, 37, 13, -4, -28 },
  { 4067, 21, 30, 19, -1, -21 },
  { 4146, 19, 28, 20, 0, -28 },
  { 4213, 12, 29, 10, 0, -29 },
  { 4257, 17, 38, 10, -5, -29 },
  { 4338, 21, 28, 19, 0, -28 },
  { 4412, 12, 28, 10, 0, -28 },
  { 4454, 28, 21, 29, 0, -21 },
  { 4528, 19, 21, 20, 0, -21 },
  { 4578, 17, 21, 19, 1, -21 },
  { 4623, 21, 30, 19, -2, -21 },
  { 4702, 19, 30, 19, 1, -21 },
  { 4774, 16, 21, 14, 0, -21 },
  { 4816, 16, 21, 16, 0, -21 },
  { 4858, 13, 25, 14, 2, -25 },
  { 4899, 19, 20, 20, 1, -20 },
  { 4947, 18, 20, 18, 2, -20 },
  { 4992, 27, 20, 27, 2, -20 },
  { 5060, 22, 20, 18, -2, -20 },
  { 5115, 22, 29, 18, -2, -20 },
  { 5195, 18, 20, 16, -1, -20 },
  { 5240, 16, 32, 13, 0, -26 },
  { 5304, 5, 36, 16, 6, -28 },
  { 5327, 15, 32, 13, -2, -26 },
  { 5387, 17, 7, 19, 1, -17 },
};

const GFXfont NotoSans_Condensed_BlackItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC37PT7B_H_
