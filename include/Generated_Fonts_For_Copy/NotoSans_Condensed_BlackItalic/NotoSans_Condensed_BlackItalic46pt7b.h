#ifndef _NOTOSANS_CONDENSED_BLACKITALIC46PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7E, 0x00, 0x30, 0x00, 0x3F, 0xCF, 0xE7, 0xF3, 0xFC, 0xFE, 0x7F,
  0xBF, 0xCF, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFC,
  0x7E, 0x3F, 0x8F, 0xC7, 0xF3, 0xF8, 0xFC, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x3E, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0x7E, 0x3F,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x0F, 0xC7, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0x38, 0xC0, 0xFE, 0x60,
  0x81, 0xFD, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3B, 0xF8, 0x40,
  0x77, 0xF0, 0xC0, 0xCF, 0xE1, 0xF3, 0xBF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0x7E,
  0x01, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F, 0xFE, 0x07,
  0xE0, 0x1F, 0x9F, 0x81, 0xF8, 0x07, 0xE7, 0xE0, 0xFC, 0x03, 0xF1, 0xF8,
  0x3E, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE3, 0xF0, 0x03, 0xE3, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0xFC, 0x00, 0x3E,
  0x3F, 0x3F, 0x1F, 0x8F, 0x9F, 0x9F, 0x8F, 0xFB, 0xFF, 0xE7, 0xE7, 0xFE,
  0xFF, 0xF3, 0xF3, 0xFF, 0xFF, 0xF9, 0xF9, 0xFF, 0xF7, 0xFE, 0x7E, 0x7E,
  0xFC, 0xFE, 0x3F, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0xC7, 0xC0, 0x07, 0xE3,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x7E,
  0x1F, 0x8F, 0xC0, 0x3F, 0x07, 0xE3, 0xE0, 0x0F, 0xC1, 0xF9, 0xF8, 0x07,
  0xE0, 0x7E, 0x7E, 0x01, 0xF8, 0x1F, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0xC0,
  0x7E, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0xFF, 0x07,
  0xFF, 0x87, 0xF8, 0x7F, 0xFE, 0x7F, 0x87, 0xFF, 0xFB, 0xFC, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFD, 0xFF, 0xFE, 0x3F, 0xCF, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF,
  0x1F, 0xE1, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x3F, 0xF8, 0x3F,
  0xE3, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xF8, 0x0F, 0xFC, 0x7F,
  0xE0, 0x3F, 0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E,
  0x1F, 0x8F, 0xE3, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x02, 0x0F, 0xC0, 0x30, 0xFC, 0x03, 0xCF, 0xC0, 0x7F, 0xFC, 0x77, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFC, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFB, 0xF0, 0x7F, 0xBF, 0x81,
  0xF3, 0xF8, 0x0F, 0x1F, 0xC0, 0x61, 0xF0, 0x02, 0x1C, 0x00, 0x01, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0x7F,
  0xF9, 0xFF, 0xEF, 0xFF, 0x00, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x0F, 0xE3,
  0xFC, 0x7F, 0x87, 0xF1, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC,
  0xFF, 0x0F, 0xF3, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE,
  0x1F, 0xE7, 0xF8, 0x7F, 0x9F, 0xC1, 0xFE, 0x7F, 0x07, 0xF9, 0xFC, 0x3F,
  0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F, 0x87,
  0xFB, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xCF, 0xF0, 0x71, 0xFE, 0x04, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xF1, 0xFF, 0x01, 0xC0, 0xFF, 0x00, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFD,
  0xFF, 0x80, 0xC0, 0xFF, 0x01, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x80, 0x0F, 0xF1, 0x80, 0x3F, 0xE3, 0xE1, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xDF, 0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0xFF, 0x01, 0xF9, 0xFC, 0x03,
  0xF7, 0xF8, 0x0F, 0xCF, 0xF0, 0x3F, 0x1F, 0xE0, 0x7E, 0x3F, 0xC1, 0xF8,
  0x7F, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x40, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x30, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x80, 0x1F, 0xE1, 0x80, 0x7F, 0xC3, 0xE3, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xE1, 0x83, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE3, 0xC0, 0x7F,
  0xBF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xF8, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3,
  0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC,
  0xFF, 0x8F, 0xF3, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC3,
  0xFD, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0x9F, 0xF1, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE,
  0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xF1, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC,
  0xFF, 0x1F, 0xF3, 0xFC, 0x7F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x08,
  0x1F, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0xFE, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x03,
  0xF0, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xDF, 0xF8, 0xC0, 0xFF, 0x10, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0x83, 0xF0, 0xFF, 0xF3, 0xE1, 0xF8, 0x7F, 0xFC, 0xFC, 0x7E,
  0x3F, 0xFF, 0x1F, 0x3F, 0x1F, 0xFF, 0xC7, 0xCF, 0xC7, 0xE3, 0xE1, 0xF3,
  0xE3, 0xF0, 0xF8, 0xFD, 0xF8, 0xF8, 0x7E, 0x3F, 0x7C, 0x7E, 0x1F, 0x8F,
  0x9F, 0x1F, 0x87, 0xC3, 0xE7, 0xC7, 0xC1, 0xF0, 0xFB, 0xF1, 0xF0, 0xFC,
  0x7E, 0xFC, 0xFC, 0x3F, 0x1F, 0x3F, 0x3F, 0x0F, 0x8F, 0xCF, 0xCF, 0xC7,
  0xE3, 0xE3, 0xE1, 0xFF, 0xFF, 0xF8, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0x1F,
  0xF7, 0xFE, 0x0F, 0xC3, 0xF8, 0xFF, 0x01, 0xF0, 0x7C, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x30, 0x00,
  0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFF,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xC0,
  0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F,
  0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0xC1,
  0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x8F, 0xF8, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC3, 0xFE, 0x0F, 0xF1, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xF8, 0x18, 0x1F, 0xF0, 0x08, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xC0,
  0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xC7, 0xFE,
  0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFC,
  0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8, 0x7F, 0x81,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0,
  0x18, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0xF1,
  0xFE, 0x3F, 0xFC, 0xFF, 0x8F, 0xFF, 0x3F, 0xE3, 0xFF, 0x8F, 0xF0, 0xFF,
  0xE3, 0xFC, 0x7F, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0,
  0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F,
  0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x07, 0xFC,
  0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x01,
  0xFE, 0x3F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x0F,
  0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0xBF, 0x1F, 0xBF, 0x80, 0xFE,
  0xFC, 0x7F, 0xFE, 0x03, 0xFB, 0xF3, 0xF7, 0xF8, 0x0F, 0xEF, 0xCF, 0xDF,
  0xC0, 0x7F, 0xBF, 0x7F, 0x7F, 0x01, 0xFE, 0xFD, 0xFB, 0xFC, 0x07, 0xF3,
  0xFF, 0xEF, 0xF0, 0x1F, 0xCF, 0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0xFC, 0xFE,
  0x03, 0xFC, 0xFF, 0xE7, 0xF8, 0x0F, 0xE3, 0xFF, 0x9F, 0xE0, 0x3F, 0x8F,
  0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0xF1, 0xFC, 0x07, 0xF8, 0xFF, 0xC7, 0xF0,
  0x1F, 0xE3, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xF8, 0xFF, 0x01, 0xFC, 0x3F,
  0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x3F, 0x80,
  0xFF, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x03, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x81,
  0xFE, 0x03, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xC1,
  0xFC, 0x07, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0xC3,
  0xFC, 0x07, 0xFF, 0xC3, 0xF8, 0x0F, 0xFF, 0xE3, 0xF8, 0x0F, 0xEF, 0xE3,
  0xF8, 0x0F, 0xEF, 0xE7, 0xF8, 0x0F, 0xEF, 0xE7, 0xF8, 0x0F, 0xEF, 0xF7,
  0xF0, 0x1F, 0xE7, 0xF7, 0xF0, 0x1F, 0xC7, 0xF7, 0xF0, 0x1F, 0xC7, 0xF7,
  0xF0, 0x1F, 0xC7, 0xFF, 0xE0, 0x3F, 0xC7, 0xFF, 0xE0, 0x3F, 0xC3, 0xFF,
  0xE0, 0x3F, 0x83, 0xFF, 0xE0, 0x3F, 0x83, 0xFF, 0xE0, 0x3F, 0x83, 0xFF,
  0xC0, 0x7F, 0x83, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xC0, 0x7F, 0x01, 0xFF,
  0xC0, 0x7F, 0x01, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0x3F, 0xCF, 0xF8,
  0x0F, 0xF3, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF,
  0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00,
  0xFF, 0xBF, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF,
  0x03, 0xFE, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFE, 0x03,
  0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xF8,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F,
  0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0x3F, 0xE1,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x8F, 0xF8, 0x3F,
  0xDF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0x80,
  0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F,
  0xE1, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFC, 0x1C, 0x0F, 0xF0,
  0x10, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x40, 0x0F, 0xF0, 0x40, 0x1F, 0xE0, 0xF0,
  0x7F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F,
  0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xF3,
  0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF,
  0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F,
  0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0xFE, 0x03, 0xFD, 0xFE, 0x03, 0xF8, 0x1F, 0xF7, 0xF8,
  0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x81, 0xFE, 0x7F, 0x83, 0xFE, 0x0F,
  0xF1, 0xFC, 0x0F, 0xF8, 0x3F, 0xC7, 0xF0, 0x3F, 0xE0, 0xFF, 0x1F, 0xC1,
  0xFF, 0x87, 0xF8, 0x7F, 0x07, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xF8, 0xFF,
  0x07, 0xF0, 0xFF, 0xE3, 0xFC, 0x1F, 0xC7, 0xFF, 0x8F, 0xF0, 0x7F, 0x1F,
  0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0xF9, 0xFE, 0x07, 0xF3, 0xFF, 0xE7, 0xF0,
  0x1F, 0xCF, 0xFF, 0x3F, 0xC0, 0x7F, 0x7F, 0xFC, 0xFF, 0x01, 0xFD, 0xFB,
  0xF7, 0xF8, 0x07, 0xF7, 0xEF, 0xDF, 0xE0, 0x1F, 0xFF, 0xBF, 0x7F, 0x00,
  0x7F, 0xFC, 0xFF, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x07, 0xFF, 0xCF,
  0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0x83, 0xFE, 0x7F,
  0x83, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F,
  0x8F, 0xF0, 0x3F, 0x9F, 0xE0, 0x3F, 0xBF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF8, 0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F,
  0x01, 0xFC, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8,
  0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0x3F, 0xC7, 0xF8, 0xFE, 0x3F, 0x87, 0xF0, 0xFC,
  0x00, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x1F, 0xFB, 0xF8, 0x7F, 0xF7, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F,
  0xC3, 0xFC, 0xFF, 0x87, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8,
  0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xC7, 0xF8, 0xFF, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xF7, 0xE0, 0x3F, 0xCF, 0xC0,
  0x3F, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF3, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xFC, 0x7F, 0x07, 0xF8, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F, 0xC7,
  0xFC, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFE,
  0xFF, 0xC1, 0xFD, 0xFF, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFE, 0x08, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0x0F, 0xF8, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x78, 0x7F, 0x00, 0xFF, 0x3F, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xEF, 0xE0, 0x1F, 0xE7, 0xE0, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x8F, 0xE7, 0xF8, 0x7F,
  0x3F, 0xC3, 0xFB, 0xFC, 0x3F, 0xDF, 0xEF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x11, 0xFE, 0x03, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x10, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x7F, 0xEF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF7, 0xF0,
  0x03, 0xF7, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x06, 0x00, 0xFF, 0x03, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF3, 0xE0, 0x1F, 0xDF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x0F, 0xF1, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8,
  0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC0, 0x00, 0x78, 0x01, 0xF8, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x04, 0x1F, 0xE1, 0xFF, 0x03, 0xF8, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0xBF,
  0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0xFF, 0x8F, 0xF0, 0x1F, 0xBF, 0xF3,
  0xFF, 0x03, 0xF7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x8F, 0xF8, 0xFF, 0x1F,
  0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F,
  0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8,
  0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3,
  0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xCF, 0xF0,
  0x1F, 0xBF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x1F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0x7F, 0x8F, 0xF8, 0xFF, 0x3F, 0xC3, 0xFD, 0xFE, 0x0F,
  0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFB, 0xFC, 0x1F, 0xEF,
  0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0xCF, 0xF0,
  0xFF, 0x3F, 0xC7, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0x3F, 0xC0, 0x0F, 0xDF, 0xF8, 0x03, 0xF7, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x03,
  0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF,
  0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1,
  0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x3F,
  0xE7, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF9, 0xFC, 0x1F, 0xFB, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x9F,
  0xE0, 0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE,
  0x1F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFD, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFC, 0x41, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xE3, 0xC1, 0xFE, 0x08, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x80,
  0x7F, 0x8E, 0x0F, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x84, 0x7F, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xC3, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x10,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF,
  0xE0, 0x1F, 0xCF, 0xC0, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF,
  0x3F, 0x83, 0xFC, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F,
  0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F,
  0xC0, 0xFE, 0xFF, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF8, 0x7F, 0xBF, 0x87, 0xFC,
  0x3F, 0xDF, 0xC7, 0xFE, 0x3F, 0xCF, 0xE3, 0xFF, 0x1F, 0xE7, 0xF1, 0xFF,
  0x8F, 0xE3, 0xF9, 0xFF, 0xCF, 0xF1, 0xFC, 0xFF, 0xE7, 0xF0, 0xFE, 0xFF,
  0xF3, 0xF8, 0x7F, 0x7F, 0xFB, 0xFC, 0x3F, 0xBE, 0xFD, 0xFC, 0x1F, 0xFF,
  0x7F, 0xFE, 0x0F, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0x03, 0xFF,
  0xCF, 0xBF, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F,
  0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F,
  0xFC, 0x7F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF8, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xDF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F,
  0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x3F,
  0xCF, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFD, 0xFC,
  0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x0B, 0xFE, 0x00, 0x7F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFE, 0x80, 0x0F, 0xE0,
};

const GFXglyph NotoSans_Condensed_BlackItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 34, 13, 0, -33 },
  { 65, 19, 12, 21, 4, -33 },
  { 94, 27, 33, 26, 0, -33 },
  { 206, 23, 38, 23, 1, -35 },
  { 316, 34, 33, 38, 3, -33 },
  { 457, 29, 33, 29, 0, -33 },
  { 577, 10, 12, 11, 4, -33 },
  { 592, 17, 41, 14, 1, -34 },
  { 680, 18, 41, 14, -4, -34 },
  { 773, 20, 22, 22, 3, -35 },
  { 828, 21, 22, 24, 2, -27 },
  { 886, 12, 12, 13, -3, -6 },
  { 904, 14, 7, 14, 0, -16 },
  { 917, 9, 9, 13, 0, -8 },
  { 928, 25, 33, 19, -2, -33 },
  { 1032, 22, 33, 23, 1, -33 },
  { 1123, 19, 33, 23, 4, -33 },
  { 1202, 24, 33, 23, -1, -33 },
  { 1301, 23, 33, 23, 0, -33 },
  { 1396, 23, 33, 23, 0, -33 },
  { 1491, 23, 33, 23, 1, -33 },
  { 1586, 22, 33, 23, 2, -33 },
  { 1677, 25, 33, 23, 1, -33 },
  { 1781, 22, 33, 23, 1, -33 },
  { 1872, 22, 33, 23, 1, -33 },
  { 1963, 13, 27, 13, 0, -26 },
  { 2007, 16, 32, 13, -3, -26 },
  { 2071, 21, 23, 24, 2, -28 },
  { 2132, 21, 16, 24, 2, -24 },
  { 2174, 21, 23, 24, 2, -28 },
  { 2235, 19, 34, 19, 2, -33 },
  { 2316, 34, 37, 35, 1, -33 },
  { 2474, 27, 33, 26, -3, -33 },
  { 2586, 26, 33, 25, 0, -33 },
  { 2694, 24, 33, 24, 2, -33 },
  { 2793, 27, 33, 27, 0, -33 },
  { 2905, 23, 33, 21, 0, -33 },
  { 3000, 23, 33, 21, 0, -33 },
  { 3095, 26, 33, 27, 2, -33 },
  { 3203, 29, 33, 28, 0, -33 },
  { 3323, 23, 33, 18, -2, -33 },
  { 3418, 22, 43, 14, -7, -33 },
  { 3537, 30, 33, 26, 0, -33 },
  { 3661, 18, 33, 20, 0, -33 },
  { 3736, 38, 33, 36, 0, -33 },
  { 3893, 32, 33, 30, 0, -33 },
  { 4025, 26, 33, 29, 2, -33 },
  { 4133, 25, 33, 24, 0, -33 },
  { 4237, 26, 41, 29, 2, -33 },
  { 4371, 25, 33, 25, 0, -33 },
  { 4475, 23, 33, 22, 0, -33 },
  { 4570, 21, 33, 21, 4, -33 },
  { 4657, 27, 33, 27, 2, -33 },
  { 4769, 25, 33, 25, 4, -33 },
  { 4873, 38, 33, 37, 3, -33 },
  { 5030, 32, 33, 25, -3, -33 },
  { 5162, 24, 33, 24, 4, -33 },
  { 5261, 27, 33, 22, -2, -33 },
  { 5373, 20, 42, 14, -2, -34 },
  { 5478, 11, 33, 19, 5, -33 },
  { 5524, 19, 42, 14, -3, -34 },
  { 5624, 23, 22, 22, -1, -33 },
  { 5688, 20, 6, 19, -4, 3 },
  { 5703, 10, 7, 16, 7, -35 },
  { 5712, 23, 26, 24, 1, -26 },
  { 5787, 23, 35, 24, 0, -35 },
  { 5888, 20, 26, 20, 1, -26 },
  { 5953, 25, 35, 24, 1, -35 },
  { 6063, 21, 26, 23, 1, -26 },
  { 6132, 26, 46, 16, -5, -35 },
  { 6282, 25, 37, 24, -1, -26 },
  { 6398, 23, 35, 24, 0, -35 },
  { 6499, 15, 36, 13, 0, -36 },
  { 6567, 21, 47, 13, -6, -36 },
  { 6691, 27, 35, 24, 0, -35 },
  { 6810, 15, 35, 13, 0, -35 },
  { 6876, 35, 26, 36, 0, -26 },
  { 6990, 23, 26, 24, 0, -26 },
  { 7065, 22, 26, 24, 1, -26 },
  { 7137, 26, 37, 24, -3, -26 },
  { 7258, 23, 37, 24, 1, -26 },
  { 7365, 20, 26, 17, 0, -26 },
  { 7430, 20, 26, 19, 0, -26 },
  { 7495, 17, 31, 17, 2, -31 },
  { 7561, 24, 25, 24, 1, -25 },
  { 7636, 22, 25, 22, 3, -25 },
  { 7705, 33, 25, 33, 3, -25 },
  { 7809, 27, 25, 23, -2, -25 },
  { 7894, 28, 36, 22, -3, -25 },
  { 8020, 23, 25, 19, -2, -25 },
  { 8092, 20, 40, 16, 0, -33 },
  { 8192, 6, 45, 20, 7, -35 },
  { 8226, 19, 40, 16, -3, -33 },
  { 8321, 21, 9, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_BlackItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC46PT7B_H_
