#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_Condensed_BlackItalic
// Headers: 67

#include "NotoSans_Condensed_BlackItalic6pt7b.h"
#include "NotoSans_Condensed_BlackItalic7pt7b.h"
#include "NotoSans_Condensed_BlackItalic8pt7b.h"
#include "NotoSans_Condensed_BlackItalic9pt7b.h"
#include "NotoSans_Condensed_BlackItalic10pt7b.h"
#include "NotoSans_Condensed_BlackItalic11pt7b.h"
#include "NotoSans_Condensed_BlackItalic12pt7b.h"
#include "NotoSans_Condensed_BlackItalic13pt7b.h"
#include "NotoSans_Condensed_BlackItalic14pt7b.h"
#include "NotoSans_Condensed_BlackItalic15pt7b.h"
#include "NotoSans_Condensed_BlackItalic16pt7b.h"
#include "NotoSans_Condensed_BlackItalic17pt7b.h"
#include "NotoSans_Condensed_BlackItalic18pt7b.h"
#include "NotoSans_Condensed_BlackItalic19pt7b.h"
#include "NotoSans_Condensed_BlackItalic20pt7b.h"
#include "NotoSans_Condensed_BlackItalic21pt7b.h"
#include "NotoSans_Condensed_BlackItalic22pt7b.h"
#include "NotoSans_Condensed_BlackItalic23pt7b.h"
#include "NotoSans_Condensed_BlackItalic24pt7b.h"
#include "NotoSans_Condensed_BlackItalic25pt7b.h"
#include "NotoSans_Condensed_BlackItalic26pt7b.h"
#include "NotoSans_Condensed_BlackItalic27pt7b.h"
#include "NotoSans_Condensed_BlackItalic28pt7b.h"
#include "NotoSans_Condensed_BlackItalic29pt7b.h"
#include "NotoSans_Condensed_BlackItalic30pt7b.h"
#include "NotoSans_Condensed_BlackItalic31pt7b.h"
#include "NotoSans_Condensed_BlackItalic32pt7b.h"
#include "NotoSans_Condensed_BlackItalic33pt7b.h"
#include "NotoSans_Condensed_BlackItalic34pt7b.h"
#include "NotoSans_Condensed_BlackItalic35pt7b.h"
#include "NotoSans_Condensed_BlackItalic36pt7b.h"
#include "NotoSans_Condensed_BlackItalic37pt7b.h"
#include "NotoSans_Condensed_BlackItalic38pt7b.h"
#include "NotoSans_Condensed_BlackItalic39pt7b.h"
#include "NotoSans_Condensed_BlackItalic40pt7b.h"
#include "NotoSans_Condensed_BlackItalic41pt7b.h"
#include "NotoSans_Condensed_BlackItalic42pt7b.h"
#include "NotoSans_Condensed_BlackItalic43pt7b.h"
#include "NotoSans_Condensed_BlackItalic44pt7b.h"
#include "NotoSans_Condensed_BlackItalic45pt7b.h"
#include "NotoSans_Condensed_BlackItalic46pt7b.h"
#include "NotoSans_Condensed_BlackItalic47pt7b.h"
#include "NotoSans_Condensed_BlackItalic48pt7b.h"
#include "NotoSans_Condensed_BlackItalic49pt7b.h"
#include "NotoSans_Condensed_BlackItalic50pt7b.h"
#include "NotoSans_Condensed_BlackItalic51pt7b.h"
#include "NotoSans_Condensed_BlackItalic52pt7b.h"
#include "NotoSans_Condensed_BlackItalic53pt7b.h"
#include "NotoSans_Condensed_BlackItalic54pt7b.h"
#include "NotoSans_Condensed_BlackItalic55pt7b.h"
#include "NotoSans_Condensed_BlackItalic56pt7b.h"
#include "NotoSans_Condensed_BlackItalic57pt7b.h"
#include "NotoSans_Condensed_BlackItalic58pt7b.h"
#include "NotoSans_Condensed_BlackItalic59pt7b.h"
#include "NotoSans_Condensed_BlackItalic60pt7b.h"
#include "NotoSans_Condensed_BlackItalic61pt7b.h"
#include "NotoSans_Condensed_BlackItalic62pt7b.h"
#include "NotoSans_Condensed_BlackItalic63pt7b.h"
#include "NotoSans_Condensed_BlackItalic64pt7b.h"
#include "NotoSans_Condensed_BlackItalic65pt7b.h"
#include "NotoSans_Condensed_BlackItalic66pt7b.h"
#include "NotoSans_Condensed_BlackItalic67pt7b.h"
#include "NotoSans_Condensed_BlackItalic68pt7b.h"
#include "NotoSans_Condensed_BlackItalic69pt7b.h"
#include "NotoSans_Condensed_BlackItalic70pt7b.h"
#include "NotoSans_Condensed_BlackItalic71pt7b.h"
#include "NotoSans_Condensed_BlackItalic72pt7b.h"
