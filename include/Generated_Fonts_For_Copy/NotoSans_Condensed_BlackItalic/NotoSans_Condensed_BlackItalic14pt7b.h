#ifndef _NOTOSANS_CONDENSED_BLACKITALIC14PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x9C, 0xE6, 0x30, 0x00, 0xE6, 0x00, 0x6D, 0xBD, 0xB6, 0x1B,
  0x1A, 0x16, 0x7F, 0x36, 0x3C, 0xFE, 0x6C, 0x68, 0xD8, 0x08, 0x38, 0xFB,
  0xD7, 0x87, 0x07, 0x0E, 0xDD, 0xF8, 0x81, 0x00, 0x71, 0xB4, 0xCD, 0x23,
  0xD8, 0xFD, 0xFB, 0xD1, 0xB4, 0x4B, 0x33, 0xD8, 0xE0, 0x1E, 0x1F, 0x0D,
  0x87, 0xC3, 0xFB, 0xFF, 0xFD, 0xDC, 0xFE, 0x3F, 0x80, 0x6F, 0x60, 0x19,
  0x8C, 0xC6, 0x33, 0x98, 0xC6, 0x30, 0xC0, 0x18, 0xC6, 0x31, 0x8C, 0x66,
  0x31, 0x99, 0xC0, 0x3A, 0xCF, 0xDF, 0x73, 0xE5, 0x00, 0x30, 0xCF, 0xFF,
  0x30, 0xC0, 0x76, 0x6C, 0x7F, 0xF8, 0x03, 0x06, 0x0E, 0x0C, 0x1C, 0x18,
  0x30, 0x30, 0x60, 0xE0, 0x1C, 0x7D, 0xDB, 0x36, 0x6D, 0xFB, 0x76, 0x7C,
  0xF0, 0x1C, 0xF7, 0xB6, 0x58, 0xE3, 0x0C, 0x31, 0xC0, 0x3C, 0xFC, 0xB8,
  0x70, 0xC3, 0x0C, 0x30, 0xFD, 0xF8, 0x3C, 0x7C, 0x98, 0x73, 0x87, 0x83,
  0x46, 0xFD, 0xF0, 0x06, 0x1C, 0x79, 0xE2, 0xCD, 0xBF, 0xFE, 0x18, 0x30,
  0x3E, 0x7C, 0xC3, 0xC7, 0xCB, 0x83, 0x46, 0xFD, 0xF0, 0x1E, 0x7C, 0xC3,
  0x67, 0xCD, 0xFB, 0xF6, 0x7C, 0xF0, 0x3F, 0x7E, 0x06, 0x0C, 0x1C, 0x18,
  0x38, 0x30, 0x70, 0xE0, 0x1E, 0x7D, 0xD9, 0xF3, 0xCF, 0xBB, 0x66, 0xFC,
  0xF0, 0x3C, 0x7D, 0xDB, 0x36, 0xEF, 0xCB, 0x0E, 0xF9, 0xE0, 0x37, 0x60,
  0x00, 0xEC, 0x19, 0xCC, 0x00, 0x01, 0xCC, 0x66, 0x00, 0x04, 0x37, 0xF8,
  0xF0, 0xF0, 0xC1, 0xFC, 0x00, 0x3F, 0xFC, 0x83, 0x0F, 0x0F, 0x3F, 0xCC,
  0x20, 0x7F, 0xE6, 0x77, 0x32, 0x00, 0xC6, 0x00, 0x0F, 0x83, 0x18, 0xC9,
  0x37, 0xB5, 0xB6, 0xB6, 0xB6, 0xB6, 0xFC, 0x40, 0x0C, 0x40, 0xF8, 0x00,
  0x0F, 0x0F, 0x0F, 0x1B, 0x1B, 0x3B, 0x3F, 0x7F, 0x63, 0xE3, 0x3E, 0x3F,
  0x37, 0x76, 0x7E, 0x7E, 0x66, 0x6E, 0xFE, 0xF8, 0x3E, 0xFD, 0x97, 0x0C,
  0x18, 0x30, 0x62, 0xF8, 0xF0, 0x3E, 0x3F, 0x37, 0x73, 0x77, 0x67, 0x67,
  0x6E, 0xFC, 0xF8, 0x3E, 0x7C, 0xC3, 0x87, 0xCF, 0x98, 0x30, 0xF9, 0xF0,
  0x3E, 0x7C, 0xC3, 0x87, 0xCF, 0x98, 0x30, 0xE1, 0xC0, 0x3F, 0x7E, 0x62,
  0xE0, 0xDE, 0xDE, 0xCE, 0xCC, 0xFC, 0x7C, 0x3B, 0x99, 0xCC, 0xCE, 0x67,
  0xF3, 0xF9, 0x9C, 0xCC, 0xE6, 0x77, 0x00, 0x3E, 0x3C, 0x70, 0xC1, 0x83,
  0x0E, 0x1C, 0x7D, 0xF0, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38,
  0x70, 0xC7, 0x8E, 0x00, 0x3B, 0x9B, 0x8D, 0x8F, 0xC7, 0xC3, 0xE1, 0xB0,
  0xD8, 0xEE, 0x77, 0x00, 0x38, 0xC3, 0x1C, 0x71, 0x86, 0x19, 0xFB, 0xE0,
  0x38, 0xF3, 0x9E, 0x39, 0xE7, 0x9E, 0x6B, 0xE6, 0xBC, 0x6E, 0xC6, 0xEC,
  0xED, 0xCC, 0xD8, 0x39, 0xCE, 0x63, 0x99, 0xF6, 0x6F, 0x9B, 0xE6, 0xF1,
  0xBC, 0xEF, 0x31, 0xC0, 0x3E, 0x7E, 0x67, 0xE7, 0xC7, 0xC6, 0xCE, 0xCE,
  0xFC, 0x78, 0x3E, 0x3E, 0x37, 0x77, 0x7E, 0x7E, 0x78, 0x60, 0xE0, 0xE0,
  0x3E, 0x7E, 0x67, 0xE7, 0xC7, 0xC6, 0xCE, 0xCE, 0xFC, 0x78, 0x38, 0x1C,
  0x3E, 0x3E, 0x37, 0x77, 0x7E, 0x7C, 0x6C, 0x6C, 0xEE, 0xEE, 0x3E, 0x7D,
  0xCB, 0x87, 0x87, 0x87, 0x4E, 0xFD, 0xF0, 0xFF, 0xF8, 0xC1, 0x87, 0x0E,
  0x18, 0x30, 0x61, 0xC0, 0x77, 0x66, 0x66, 0xE6, 0xEE, 0xCE, 0xCC, 0xCC,
  0xFC, 0xF8, 0xE7, 0xE6, 0xEE, 0xEC, 0xFC, 0xF8, 0xF8, 0xF0, 0x70, 0x70,
  0xE6, 0x7D, 0xDF, 0x3B, 0x6F, 0x6D, 0xFD, 0xBF, 0x3D, 0xE7, 0xBC, 0xE7,
  0x1C, 0xE0, 0x39, 0xC6, 0xE1, 0xB0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xD8,
  0x76, 0x39, 0xC0, 0xE7, 0x6E, 0x6C, 0x78, 0x78, 0x70, 0x70, 0x70, 0x60,
  0x60, 0x1F, 0x3F, 0x07, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x7E, 0xFE, 0x1C,
  0x63, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x3C, 0xE6, 0x66, 0x66, 0x67,
  0x33, 0x3C, 0x31, 0x86, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x38, 0x08, 0x38,
  0xF1, 0xE6, 0xDC, 0xF1, 0x80, 0xFF, 0xE0, 0xED, 0x80, 0x3E, 0xFD, 0xBB,
  0x7E, 0xFD, 0xBF, 0x36, 0x38, 0x60, 0xC1, 0xE7, 0xEE, 0xD9, 0xB7, 0xEF,
  0xFB, 0xE0, 0x1C, 0xF7, 0x58, 0xE3, 0x8F, 0x9E, 0x03, 0x07, 0x07, 0x3E,
  0x7E, 0x6E, 0x6E, 0xEE, 0xEC, 0xFC, 0x7C, 0x1C, 0x7D, 0x9B, 0xEF, 0x9C,
  0x1F, 0x3E, 0x07, 0x0F, 0x0C, 0x0E, 0x1E, 0x1C, 0x1C, 0x18, 0x18, 0x18,
  0x38, 0x30, 0xF0, 0xF0, 0x3E, 0xFD, 0xBB, 0x7E, 0xFD, 0xBF, 0x36, 0x1D,
  0xF3, 0xE0, 0x38, 0x60, 0xC1, 0xE7, 0xEE, 0xD9, 0xB7, 0xED, 0xDB, 0x30,
  0x33, 0x23, 0x76, 0x66, 0xEE, 0xC0, 0x0C, 0x30, 0x43, 0x1C, 0x61, 0x86,
  0x38, 0xE3, 0x0C, 0xF3, 0x80, 0x38, 0x30, 0x30, 0x37, 0x76, 0x6C, 0x78,
  0x7C, 0xFC, 0xEC, 0xCE, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0xE7, 0x30, 0x2E,
  0xCF, 0xFD, 0xDB, 0xB7, 0x66, 0xED, 0xD9, 0xBB, 0x76, 0x6E, 0x2C, 0xFD,
  0xDB, 0x76, 0xFD, 0xBB, 0x66, 0x1C, 0x7D, 0xBB, 0x7E, 0xFD, 0x9F, 0x3C,
  0x16, 0x3F, 0x3B, 0x33, 0x37, 0x77, 0x7E, 0x6C, 0x60, 0x60, 0xE0, 0x3E,
  0xFD, 0xBB, 0x7E, 0xFD, 0xBF, 0x36, 0x1C, 0x30, 0x60, 0x2D, 0xF7, 0x98,
  0x63, 0x8E, 0x30, 0x39, 0xF6, 0x5C, 0x38, 0x6F, 0xBC, 0x63, 0xFD, 0xCC,
  0x63, 0x1C, 0xE0, 0x77, 0x76, 0x66, 0x6E, 0x6E, 0xEC, 0xFC, 0x7C, 0xCF,
  0x9B, 0x66, 0xCF, 0x1E, 0x3C, 0x70, 0xDD, 0xF7, 0x6D, 0xDB, 0xFE, 0xFF,
  0x3B, 0xCE, 0xE3, 0xB8, 0x3B, 0x9F, 0x87, 0x83, 0x81, 0xC1, 0xE1, 0xF9,
  0xDC, 0x33, 0x99, 0x8D, 0x86, 0xC3, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x78,
  0x38, 0x00, 0x7D, 0xF1, 0x8E, 0x71, 0x8F, 0xBE, 0x1C, 0x73, 0x0C, 0x33,
  0xCE, 0x18, 0x61, 0x87, 0x1C, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xE1, 0x86,
  0x18, 0x71, 0xCC, 0x31, 0xCE, 0x38, 0xF7, 0xF0,
};

const GFXglyph NotoSans_Condensed_BlackItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 10, 4, 0, -10 },
  { 8, 6, 4, 6, 1, -10 },
  { 11, 8, 10, 8, 0, -10 },
  { 21, 7, 12, 7, 0, -11 },
  { 32, 10, 10, 12, 1, -10 },
  { 45, 9, 10, 9, 0, -10 },
  { 57, 3, 4, 3, 1, -10 },
  { 59, 5, 12, 4, 0, -10 },
  { 67, 5, 12, 4, -1, -10 },
  { 75, 6, 7, 7, 1, -11 },
  { 81, 6, 6, 7, 1, -8 },
  { 86, 4, 4, 4, -1, -2 },
  { 88, 4, 2, 4, 0, -5 },
  { 89, 3, 2, 4, 0, -2 },
  { 90, 8, 10, 6, -1, -10 },
  { 100, 7, 10, 7, 0, -10 },
  { 109, 6, 10, 7, 1, -10 },
  { 117, 7, 10, 7, 0, -10 },
  { 126, 7, 10, 7, 0, -10 },
  { 135, 7, 10, 7, 0, -10 },
  { 144, 7, 10, 7, 0, -10 },
  { 153, 7, 10, 7, 0, -10 },
  { 162, 8, 10, 7, 0, -10 },
  { 172, 7, 10, 7, 0, -10 },
  { 181, 7, 10, 7, 0, -10 },
  { 190, 4, 8, 4, 0, -8 },
  { 194, 5, 10, 4, -1, -8 },
  { 201, 6, 8, 7, 1, -9 },
  { 207, 6, 5, 7, 1, -7 },
  { 211, 6, 8, 7, 1, -9 },
  { 217, 5, 10, 6, 1, -10 },
  { 224, 11, 11, 11, 0, -10 },
  { 240, 8, 10, 8, -1, -10 },
  { 250, 8, 10, 8, 0, -10 },
  { 260, 7, 10, 7, 1, -10 },
  { 269, 8, 10, 8, 0, -10 },
  { 279, 7, 10, 6, 0, -10 },
  { 288, 7, 10, 6, 0, -10 },
  { 297, 8, 10, 8, 1, -10 },
  { 307, 9, 10, 9, 0, -10 },
  { 319, 7, 10, 5, -1, -10 },
  { 328, 7, 13, 4, -2, -10 },
  { 340, 9, 10, 8, 0, -10 },
  { 352, 6, 10, 6, 0, -10 },
  { 360, 12, 10, 11, 0, -10 },
  { 375, 10, 10, 9, 0, -10 },
  { 388, 8, 10, 9, 1, -10 },
  { 398, 8, 10, 7, 0, -10 },
  { 408, 8, 12, 9, 1, -10 },
  { 420, 8, 10, 8, 0, -10 },
  { 430, 7, 10, 7, 0, -10 },
  { 439, 7, 10, 7, 1, -10 },
  { 448, 8, 10, 8, 1, -10 },
  { 458, 8, 10, 8, 1, -10 },
  { 468, 11, 10, 11, 1, -10 },
  { 482, 10, 10, 8, -1, -10 },
  { 495, 8, 10, 7, 1, -10 },
  { 505, 8, 10, 7, -1, -10 },
  { 515, 6, 12, 4, -1, -10 },
  { 524, 4, 10, 6, 1, -10 },
  { 529, 6, 12, 4, -1, -10 },
  { 538, 7, 7, 7, 0, -10 },
  { 545, 6, 2, 6, -1, 1 },
  { 547, 3, 3, 5, 2, -11 },
  { 549, 7, 8, 7, 0, -8 },
  { 556, 7, 11, 7, 0, -11 },
  { 566, 6, 8, 6, 0, -8 },
  { 572, 8, 11, 7, 0, -11 },
  { 583, 7, 8, 7, 0, -8 },
  { 590, 8, 14, 5, -2, -11 },
  { 604, 7, 11, 7, 0, -8 },
  { 614, 7, 11, 7, 0, -11 },
  { 624, 4, 11, 4, 0, -11 },
  { 630, 6, 14, 4, -2, -11 },
  { 641, 8, 11, 7, 0, -11 },
  { 652, 5, 11, 4, 0, -11 },
  { 659, 11, 8, 11, 0, -8 },
  { 670, 7, 8, 7, 0, -8 },
  { 677, 7, 8, 7, 0, -8 },
  { 684, 8, 11, 7, -1, -8 },
  { 695, 7, 11, 7, 0, -8 },
  { 705, 6, 8, 5, 0, -8 },
  { 711, 6, 8, 6, 0, -8 },
  { 717, 5, 9, 5, 1, -9 },
  { 723, 8, 8, 7, 0, -8 },
  { 731, 7, 8, 7, 1, -8 },
  { 738, 10, 8, 10, 1, -8 },
  { 748, 9, 8, 7, -1, -8 },
  { 757, 9, 11, 7, -1, -8 },
  { 770, 6, 8, 6, 0, -8 },
  { 776, 6, 12, 5, 0, -10 },
  { 785, 2, 14, 6, 2, -11 },
  { 789, 6, 12, 5, -1, -10 },
  { 798, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_BlackItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC14PT7B_H_
