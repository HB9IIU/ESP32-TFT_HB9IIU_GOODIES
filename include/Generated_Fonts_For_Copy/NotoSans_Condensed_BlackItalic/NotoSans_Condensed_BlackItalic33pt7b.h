#ifndef _NOTOSANS_CONDENSED_BLACKITALIC33PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0x7E, 0xFD,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF1, 0xE0, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xC7, 0x91, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF1,
  0xE0, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1E,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07,
  0x9F, 0x00, 0x00, 0x30, 0x00, 0x60, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0xC4, 0x3E, 0xC0, 0x3E, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0x7C,
  0x83, 0x7C, 0xE3, 0x7C, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0x3F, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x7C, 0x0F,
  0xE0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xFC, 0x1E, 0x07, 0x9E, 0x1E, 0x03,
  0xCF, 0x1F, 0x03, 0xC7, 0x8F, 0x01, 0xE7, 0xCF, 0x00, 0xF3, 0xCF, 0x80,
  0x79, 0xE7, 0x80, 0x3D, 0xF7, 0x9F, 0x9F, 0xF3, 0xDF, 0xEF, 0xFB, 0xDF,
  0xFB, 0xFB, 0xEF, 0xFC, 0xF1, 0xE7, 0x9E, 0x01, 0xE7, 0xCF, 0x01, 0xF3,
  0xCF, 0x80, 0xF1, 0xE7, 0x80, 0xF8, 0xF3, 0xC0, 0x78, 0x79, 0xE0, 0x78,
  0x3D, 0xE0, 0x7C, 0x1F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF3, 0xF1, 0xFF, 0x9F, 0x1F, 0xFD, 0xF9,
  0xFF, 0xFF, 0xCF, 0xDF, 0xFC, 0xFC, 0xFF, 0xC7, 0xE3, 0xFE, 0x3F, 0x0F,
  0xE1, 0xFD, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03,
  0xFD, 0xFC, 0x7E, 0xF9, 0xF3, 0xE7, 0xDF, 0x3E, 0x7C, 0xF0, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x8F, 0x03,
  0x9E, 0x07, 0xFC, 0x4F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x3F,
  0xC0, 0xFF, 0x83, 0xFF, 0x83, 0xCF, 0x83, 0x1E, 0x02, 0x30, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x00, 0x7F, 0xDF, 0xF7, 0xF9, 0xFE, 0xFF, 0x80, 0x39,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xBE, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C,
  0x3E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0xFC, 0xF8,
  0xFC, 0xFD, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F,
  0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x1F, 0xF9, 0xFF,
  0xDF, 0xFE, 0xFB, 0xF3, 0x9F, 0x09, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3C, 0xFC, 0x0C, 0x7E, 0x04, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x31, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x20, 0x3F, 0x9F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xDF, 0x83, 0xEF, 0x81,
  0xE7, 0xC1, 0xE7, 0xE1, 0xF3, 0xF0, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xFC, 0x11, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x81, 0xF8, 0xF7, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x60, 0x3F, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xF3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC,
  0x7C, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF3, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7C, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E,
  0x0F, 0xBF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x3F, 0x1F, 0x9F,
  0x8F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x01, 0xF0,
  0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x3E, 0x3E, 0x3E,
  0x7E, 0x3F, 0x7E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFC, 0x1E, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0xCF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x02, 0x07,
  0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC1, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x00, 0x80, 0x7C, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0x00, 0xFE, 0x07, 0xFC, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3E,
  0x00, 0x70, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0xFF,
  0x3F, 0xFC, 0xE3, 0xF2, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFD, 0xFC, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x1E, 0x0F, 0x0F, 0x3E, 0x3F, 0xEF, 0x3C,
  0x7F, 0xCF, 0x78, 0xFB, 0xCF, 0x79, 0xE3, 0xCF, 0x79, 0xE3, 0xCF, 0xF3,
  0xC7, 0x8F, 0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x9E, 0xF3, 0xCF, 0x9E, 0xF3,
  0xCF, 0x3C, 0xF3, 0xFF, 0xF8, 0xF3, 0xFF, 0xF8, 0xF1, 0xF3, 0xE0, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x81, 0xF3,
  0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xEF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xF3, 0xF0, 0xFC, 0x7E, 0x3E, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xF0,
  0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xBF, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F,
  0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xF3, 0xF0, 0x7E,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0xC7, 0xF1,
  0xF9, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xC3, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF9, 0xFF, 0x3F, 0x3F,
  0xE7, 0xE7, 0xF9, 0xF8, 0xFF, 0x3F, 0x3F, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F,
  0x9F, 0x83, 0xE1, 0xF8, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0,
  0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x7F, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0xDF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xE1,
  0xFC, 0x1F, 0x8F, 0xE0, 0x7C, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0,
  0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3E, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF8,
  0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xE7, 0xBE, 0x0F, 0xFD, 0xFF, 0xC3,
  0xFF, 0xBF, 0xF8, 0x7F, 0xF7, 0xBE, 0x0F, 0xBF, 0xF7, 0xC1, 0xF7, 0xFD,
  0xF8, 0x3E, 0xFF, 0xBF, 0x0F, 0xDF, 0xE7, 0xC1, 0xFB, 0xFC, 0xF8, 0x3E,
  0x7F, 0x1F, 0x07, 0xCF, 0xE7, 0xE0, 0xF9, 0xF8, 0xFC, 0x3F, 0x3F, 0x1F,
  0x07, 0xC7, 0xE3, 0xE0, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF0, 0x7F, 0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xFF, 0x1F, 0x83, 0xFE, 0x3F,
  0x07, 0xFC, 0x7C, 0x1F, 0xF8, 0xF8, 0x3F, 0xF1, 0xF0, 0x7F, 0xF7, 0xE0,
  0xFB, 0xEF, 0x83, 0xF7, 0xDF, 0x07, 0xEF, 0xBE, 0x0F, 0x9F, 0xFC, 0x1F,
  0x1F, 0xF8, 0x3E, 0x3F, 0xE0, 0xFC, 0x7F, 0xC1, 0xF8, 0xFF, 0x83, 0xE1,
  0xFF, 0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7C, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFE, 0x3F, 0x8F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xEF, 0xC0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0xDF, 0x83, 0xF1, 0xF8, 0xFE, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF7, 0xF0,
  0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF9, 0xF8, 0x7F,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x8F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0xDF, 0x83, 0xF1, 0xF8,
  0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xF7, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE7, 0xF1, 0xFB, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9,
  0xF8, 0x7E, 0x7F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFE, 0x00, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFE, 0x70, 0x7E,
  0x08, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x40, 0x7E,
  0x38, 0x7F, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC1, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0x0F,
  0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0x83, 0xF7,
  0xE0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x07, 0xFE, 0x0F, 0xC3, 0xFF, 0x83,
  0xF0, 0xFF, 0xE1, 0xF8, 0x3E, 0xF8, 0x7E, 0x1F, 0xBE, 0x1F, 0x87, 0xCF,
  0x8F, 0xE3, 0xF3, 0xE3, 0xF8, 0xFC, 0xF9, 0xFE, 0x3E, 0x3E, 0x7F, 0x9F,
  0x8F, 0x9F, 0xE7, 0xC3, 0xEF, 0xFB, 0xF0, 0xFB, 0xDE, 0xFC, 0x3F, 0xF7,
  0xBE, 0x0F, 0xFD, 0xFF, 0x83, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F,
  0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0xFE, 0x3F, 0xC0,
  0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE0,
  0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F,
  0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0xBE, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3,
  0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xDF, 0x8F, 0xC7, 0xC7, 0xE3, 0xE7, 0xE1, 0xFB, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x00,
  0xF8, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xDE,
  0x03, 0xEF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF1, 0xF0, 0x79, 0xF0,
  0x3F, 0xF8, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xF9,
  0xF1, 0xF1, 0xE0, 0x01, 0x00, 0x0F, 0xDF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC,
  0x7C, 0xFC, 0x7C, 0xF8, 0xFC, 0xF8, 0xFC, 0xFD, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7E, 0xF8, 0x3C, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x20, 0x1F, 0x7C, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xF7, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8,
  0x7C, 0x7C, 0x3E, 0x3E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xCF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF7, 0xF0, 0xFB, 0xF0, 0x00, 0x00,
  0xC0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF9, 0xFC, 0x47, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x8F,
  0xCE, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x21,
  0xF8, 0x3F, 0x7C, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFD, 0xF8,
  0x7E, 0x7E, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F,
  0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xF0, 0xFD, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x3C, 0xF8, 0x00, 0x00, 0x40, 0x0F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xFF, 0xEF, 0xC7, 0xDF, 0x8F, 0xBE, 0x3F, 0xFF, 0xFD, 0xFF,
  0xF3, 0xFF, 0xC7, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x0C, 0x7F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xE8, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xFD, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xF7, 0xE1, 0xF9, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF0, 0xFC, 0x7C, 0x3E, 0x3F, 0x0F, 0xCF, 0xC3, 0xF7, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x30, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x20, 0x1F, 0x7C, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0xE3, 0xF7, 0xF3, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x7E,
  0x3E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC7, 0xE3, 0xE3,
  0xF3, 0xF1, 0xF1, 0xF8, 0xF8, 0xFC, 0xFC, 0x00, 0x01, 0x80, 0xF8, 0x1F,
  0x87, 0xE0, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x18, 0x00, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0,
  0x7C, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7E, 0x07,
  0xCF, 0xC0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7F, 0x00,
  0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x0C, 0x04, 0x07, 0x9F, 0x9F, 0x87, 0xDF, 0xDF, 0xE3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0xFD, 0xFE, 0xFC, 0xFC, 0x7E, 0x7E, 0x7E, 0x3E, 0x3F,
  0x3F, 0x1F, 0x1F, 0x9F, 0x1F, 0x8F, 0x8F, 0x8F, 0xC7, 0xCF, 0xC7, 0xC7,
  0xE7, 0xE3, 0xE3, 0xF3, 0xF3, 0xF1, 0xF9, 0xF1, 0xF8, 0xF8, 0xF8, 0xFC,
  0x7C, 0xFC, 0x7C, 0x7E, 0x7E, 0x3E, 0x3F, 0x3F, 0x3F, 0x1F, 0x80, 0x00,
  0x08, 0x07, 0xBF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xFC, 0xFC,
  0xFC, 0x7E, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x1F, 0x8F, 0x8F, 0xCF, 0xC7,
  0xE7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF1, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E,
  0x3E, 0x3F, 0x3F, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xE7, 0xCF, 0xDF, 0x8F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0x87, 0xDF, 0x1F, 0xBF, 0x7E, 0x7F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xC0, 0x7F, 0x00, 0x00, 0x02, 0x00, 0x7B, 0xF0, 0x1F, 0x7F, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F,
  0x3F, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xF9,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x0F,
  0xDF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0x7C, 0xF8, 0xFC, 0xFC,
  0xFC, 0xFD, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x7E, 0xF8, 0x7D, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x00, 0x0C, 0x3C, 0xF1, 0xF7, 0xC7, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE3, 0xFC, 0x8F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0x80, 0x3F, 0xE1, 0xFF, 0xC7, 0xFE, 0x3F, 0xF8, 0xFC, 0x43,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF2,
  0x0F, 0xCE, 0x3F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x1F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0xE8, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x1F, 0x9F, 0x8F,
  0x8F, 0xC7, 0xC7, 0xC7, 0xE3, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC,
  0xFC, 0x7C, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x7C, 0x00, 0xF8,
  0x3F, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF8, 0xF9,
  0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0x7B, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xF8,
  0xFE, 0x3F, 0xF8, 0xFE, 0x7E, 0xF8, 0xFE, 0x7C, 0xF9, 0xFE, 0x7C, 0xF9,
  0xFE, 0xFC, 0xFB, 0xFC, 0xF8, 0xFB, 0xFD, 0xF8, 0xFB, 0xFD, 0xF0, 0xFF,
  0xFD, 0xF0, 0xFF, 0xBF, 0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF,
  0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF,
  0xC0, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xBE, 0x03, 0xF3, 0xF0, 0x7E, 0x3F, 0x0F,
  0xE3, 0xF0, 0x0F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC,
  0x0F, 0xCF, 0x80, 0xFD, 0xF8, 0x0F, 0xDF, 0x80, 0xFD, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x04, 0x03, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xFE,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x3E, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xE0, 0x7F, 0x07, 0xF8, 0x7F,
  0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x07,
  0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x1C, 0x02, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_BlackItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 24, 9, 0, -24 },
  { 34, 14, 9, 15, 3, -24 },
  { 50, 20, 24, 19, 0, -24 },
  { 110, 16, 27, 17, 1, -25 },
  { 164, 25, 24, 27, 2, -24 },
  { 239, 21, 24, 21, 0, -24 },
  { 302, 7, 9, 8, 3, -24 },
  { 310, 12, 29, 10, 1, -24 },
  { 354, 13, 29, 10, -3, -24 },
  { 402, 15, 15, 16, 2, -25 },
  { 431, 15, 16, 17, 1, -20 },
  { 461, 9, 9, 9, -2, -5 },
  { 472, 10, 5, 10, 0, -11 },
  { 479, 6, 6, 9, 0, -6 },
  { 484, 19, 24, 14, -2, -24 },
  { 541, 16, 24, 17, 1, -24 },
  { 589, 13, 24, 17, 3, -24 },
  { 628, 17, 24, 17, -1, -24 },
  { 679, 17, 24, 17, 0, -24 },
  { 730, 17, 24, 17, 0, -24 },
  { 781, 16, 24, 17, 1, -24 },
  { 829, 17, 24, 17, 1, -24 },
  { 880, 17, 24, 17, 1, -24 },
  { 931, 17, 24, 17, 0, -24 },
  { 982, 16, 24, 17, 1, -24 },
  { 1030, 9, 19, 9, 0, -19 },
  { 1052, 11, 23, 9, -2, -19 },
  { 1084, 15, 17, 17, 1, -20 },
  { 1116, 15, 11, 17, 1, -17 },
  { 1137, 15, 17, 17, 1, -20 },
  { 1169, 14, 24, 14, 1, -24 },
  { 1211, 24, 27, 25, 1, -24 },
  { 1292, 19, 24, 19, -2, -24 },
  { 1349, 18, 24, 18, 0, -24 },
  { 1403, 18, 24, 17, 1, -24 },
  { 1457, 19, 24, 19, 0, -24 },
  { 1514, 17, 24, 15, 0, -24 },
  { 1565, 17, 24, 15, 0, -24 },
  { 1616, 19, 24, 20, 1, -24 },
  { 1673, 21, 24, 20, 0, -24 },
  { 1736, 16, 24, 13, -1, -24 },
  { 1784, 16, 31, 10, -5, -24 },
  { 1846, 22, 24, 18, 0, -24 },
  { 1912, 13, 24, 14, 0, -24 },
  { 1951, 27, 24, 26, 0, -24 },
  { 2032, 23, 24, 22, 0, -24 },
  { 2101, 19, 24, 21, 1, -24 },
  { 2158, 18, 24, 17, 0, -24 },
  { 2212, 19, 30, 21, 1, -24 },
  { 2284, 18, 24, 18, 0, -24 },
  { 2338, 17, 24, 15, 0, -24 },
  { 2389, 15, 24, 15, 3, -24 },
  { 2434, 20, 24, 20, 1, -24 },
  { 2494, 18, 24, 18, 3, -24 },
  { 2548, 26, 24, 26, 3, -24 },
  { 2626, 23, 24, 18, -2, -24 },
  { 2695, 17, 24, 17, 3, -24 },
  { 2746, 19, 24, 15, -1, -24 },
  { 2803, 14, 30, 10, -1, -24 },
  { 2856, 8, 24, 14, 3, -24 },
  { 2880, 14, 30, 10, -2, -24 },
  { 2933, 17, 16, 16, -1, -24 },
  { 2967, 14, 4, 13, -3, 2 },
  { 2974, 7, 5, 11, 5, -25 },
  { 2979, 16, 19, 17, 1, -19 },
  { 3017, 17, 25, 17, 0, -25 },
  { 3071, 14, 19, 14, 1, -19 },
  { 3105, 18, 25, 17, 1, -25 },
  { 3162, 15, 19, 16, 1, -19 },
  { 3198, 19, 33, 11, -4, -25 },
  { 3277, 18, 27, 17, -1, -19 },
  { 3338, 17, 25, 17, 0, -25 },
  { 3392, 11, 26, 9, 0, -26 },
  { 3428, 15, 34, 9, -4, -26 },
  { 3492, 19, 25, 17, 0, -25 },
  { 3552, 11, 25, 9, 0, -25 },
  { 3587, 25, 19, 26, 0, -19 },
  { 3647, 17, 19, 17, 0, -19 },
  { 3688, 15, 19, 17, 1, -19 },
  { 3724, 19, 27, 17, -2, -19 },
  { 3789, 16, 27, 17, 1, -19 },
  { 3843, 14, 19, 12, 0, -19 },
  { 3877, 14, 19, 14, 0, -19 },
  { 3911, 12, 22, 12, 1, -22 },
  { 3944, 17, 18, 17, 1, -18 },
  { 3983, 16, 18, 16, 2, -18 },
  { 4019, 24, 18, 24, 2, -18 },
  { 4073, 20, 18, 16, -2, -18 },
  { 4118, 20, 26, 16, -2, -18 },
  { 4183, 16, 18, 14, -1, -18 },
  { 4219, 14, 29, 12, 0, -24 },
  { 4270, 5, 33, 15, 5, -25 },
  { 4291, 13, 29, 12, -2, -24 },
  { 4339, 15, 7, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_BlackItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC33PT7B_H_
