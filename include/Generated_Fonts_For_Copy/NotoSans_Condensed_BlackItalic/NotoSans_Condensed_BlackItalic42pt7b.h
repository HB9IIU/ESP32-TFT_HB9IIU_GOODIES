#ifndef _NOTOSANS_CONDENSED_BLACKITALIC42PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x01, 0xF0, 0x01, 0x00, 0x00, 0x7F, 0x3F, 0xBF, 0x9F,
  0xDF, 0xCF, 0xEF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF3, 0xFB, 0xF9, 0xF9, 0xF8,
  0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF1, 0xF0, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE7,
  0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xC7, 0xC0, 0x03,
  0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0xC7, 0x07, 0xE6, 0x10, 0x3F,
  0x70, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x77, 0xE1, 0x03, 0xBF, 0x1C, 0x19, 0xF8, 0xFC, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xE0, 0x1F, 0xFC, 0x07, 0xE0,
  0x1F, 0xFC, 0x07, 0xC0, 0x3F, 0x7C, 0x0F, 0x80, 0x3E, 0x7C, 0x1F, 0x80,
  0x7E, 0x7C, 0x1F, 0x00, 0x7C, 0x7C, 0x3F, 0x00, 0x7C, 0x7C, 0x7E, 0x00,
  0xFC, 0x7C, 0x7C, 0x00, 0xFC, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0xF8, 0x00,
  0xFC, 0xF9, 0xF1, 0xFC, 0xFD, 0xFB, 0xF3, 0xFE, 0x7F, 0xF3, 0xE7, 0xFE,
  0x7F, 0xF7, 0xEF, 0xFF, 0x7F, 0xE7, 0xCF, 0xBF, 0x3F, 0x8F, 0x9F, 0x9F,
  0x00, 0x1F, 0x9F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x3F, 0x3F, 0x1F,
  0x00, 0x7E, 0x3F, 0x3F, 0x00, 0x7C, 0x3E, 0x3F, 0x00, 0xFC, 0x3E, 0x3E,
  0x00, 0xF8, 0x3E, 0x7E, 0x01, 0xF0, 0x3F, 0x7C, 0x03, 0xF0, 0x3F, 0xFC,
  0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xC1,
  0xFF, 0xC7, 0xF0, 0x7F, 0xF8, 0xFE, 0x1F, 0xFF, 0xBF, 0xC7, 0xFF, 0xF7,
  0xF1, 0xFE, 0xFF, 0xFE, 0x3F, 0x9F, 0xFF, 0x8F, 0xF1, 0xFF, 0xE1, 0xFE,
  0x3F, 0xFC, 0x3F, 0xC3, 0xFF, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0xFE, 0xFC, 0xFC, 0xFC, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x87, 0xE0, 0x71, 0xF8, 0x1F, 0x7C, 0x17, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xEF, 0x1F, 0xF8, 0x0F, 0xFF,
  0x07, 0xF7, 0xC0, 0xFD, 0xF8, 0x1E, 0x7F, 0x03, 0x0F, 0x80, 0x43, 0x80,
  0x00, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xFC,
  0x7E, 0x3F, 0x8F, 0xC3, 0xE0, 0x3F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7,
  0xFF, 0x7F, 0xF0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x10, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF3, 0xFC, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF7, 0xF0,
  0x7F, 0x7F, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0xFF,
  0x1F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE3, 0xFC, 0xFE, 0x3F, 0x8F,
  0xE7, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7F, 0x7F, 0x1F, 0x7F, 0x0F, 0x3F, 0x83, 0x1F, 0xC1, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3E, 0x3F, 0xC0, 0x70, 0xFF, 0x01, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0C, 0x1F, 0xE0, 0x40, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF2, 0x00, 0x7F, 0x98, 0x07, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xDF, 0xC0, 0x7E,
  0xFE, 0x03, 0xE7, 0xF0, 0x3E, 0x7F, 0x03, 0xF3, 0xF8, 0x3F, 0x1F, 0xC1,
  0xF0, 0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x1E, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE2, 0x00, 0xFF, 0x18, 0x0F,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE7, 0xC0, 0x7F, 0x7F,
  0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0x9F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xF1, 0xFE,
  0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE7, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFE, 0x7F, 0x0F, 0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x0F, 0xEF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xBF, 0xCF, 0xF1,
  0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE,
  0x7F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC7, 0xF3, 0xFC, 0x7F, 0x3F, 0x87,
  0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF7, 0xF8, 0xFF, 0x7F, 0x8F, 0xF7, 0xF9,
  0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0xF9, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x20, 0x07, 0xE0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x0F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xE0,
  0xFE, 0x40, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x70, 0x3E, 0x0F,
  0x87, 0xFF, 0x3C, 0x3E, 0x1F, 0xFE, 0x7C, 0x7C, 0x7F, 0xF8, 0xF9, 0xF1,
  0xFD, 0xF1, 0xF3, 0xE3, 0xE3, 0xE3, 0xEF, 0x8F, 0x87, 0xC7, 0xDF, 0x1F,
  0x1F, 0x0F, 0x3E, 0x7C, 0x3E, 0x3E, 0x78, 0xF8, 0x7C, 0x7D, 0xF1, 0xF0,
  0xF8, 0xFB, 0xE3, 0xE3, 0xF1, 0xE7, 0xC7, 0xC7, 0xC7, 0xCF, 0x8F, 0x9F,
  0x9F, 0x1F, 0x1F, 0xFF, 0xFE, 0x3E, 0x3F, 0xFF, 0xF8, 0x7C, 0x3F, 0xBF,
  0xE0, 0xF8, 0x7E, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x20, 0x03, 0xF8, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F,
  0xC7, 0xF0, 0x7F, 0x3F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x9F, 0xF0, 0xFF, 0x1F,
  0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE,
  0x3F, 0xC7, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0x06, 0x07, 0xF8, 0x08, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x08,
  0x3F, 0xC0, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xF3, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x83, 0xFC, 0x3F,
  0x87, 0xFC, 0x3F, 0x8F, 0xF8, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xF8,
  0x38, 0x1F, 0xF0, 0x08, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xFC, 0xFF, 0x1F, 0xFC, 0xFF, 0x1F,
  0xFC, 0xFF, 0x1F, 0xF8, 0xFF, 0x3F, 0xF8, 0xFE, 0x3F, 0xF8, 0xFE, 0x07,
  0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81,
  0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x07,
  0xF8, 0x0F, 0xE1, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF3, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x07, 0xF7, 0xF8,
  0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F,
  0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x01, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0xFD, 0xF1, 0xFF,
  0xF0, 0x1F, 0xBE, 0x3E, 0xFE, 0x07, 0xF7, 0xCF, 0xDF, 0x80, 0xFE, 0xF9,
  0xFF, 0xF0, 0x1F, 0xDF, 0x7E, 0xFE, 0x03, 0xF3, 0xEF, 0xDF, 0xC0, 0xFE,
  0x7F, 0xF3, 0xF8, 0x1F, 0xCF, 0xFE, 0xFE, 0x03, 0xF9, 0xFF, 0x9F, 0xC0,
  0x7F, 0x3F, 0xF3, 0xF8, 0x0F, 0xC7, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x8F,
  0xC0, 0x7F, 0x1F, 0xE3, 0xF8, 0x0F, 0xE3, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x8F, 0xE0, 0x3F, 0x0F, 0xE1, 0xFC, 0x0F, 0xE1, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0,
  0xFF, 0x80, 0xFC, 0x07, 0xFC, 0x07, 0xE0, 0x7F, 0xF0, 0x7F, 0x03, 0xFF,
  0x83, 0xF8, 0x1F, 0xFC, 0x1F, 0xC0, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0x0F,
  0xE0, 0x7F, 0xFC, 0x7F, 0x03, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0x1F, 0xC0,
  0xFD, 0xF8, 0xFC, 0x07, 0xEF, 0xEF, 0xE0, 0x7F, 0x7F, 0x7F, 0x03, 0xFB,
  0xFB, 0xF8, 0x1F, 0xCF, 0xDF, 0xC0, 0xFC, 0x7E, 0xFC, 0x0F, 0xE3, 0xFF,
  0xE0, 0x7F, 0x1F, 0xFF, 0x03, 0xF8, 0xFF, 0xF8, 0x1F, 0xC3, 0xFF, 0x80,
  0xFC, 0x1F, 0xFC, 0x0F, 0xE0, 0xFF, 0xE0, 0x7F, 0x07, 0xFF, 0x03, 0xF8,
  0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0x80, 0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x3F,
  0xE0, 0x7F, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xF1, 0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0xFF, 0x83, 0xF8, 0xFF, 0x07, 0xF1,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F,
  0xC1, 0xFC, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFE, 0x1F,
  0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF,
  0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC,
  0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F,
  0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8,
  0x7F, 0x8F, 0xF0, 0x7F, 0x9F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xC3, 0x81, 0xFC, 0x04, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x40, 0x1F, 0xE1, 0x80, 0xFF, 0x1F, 0x0F, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xF8,
  0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0,
  0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x3F, 0xCF,
  0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFE,
  0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE,
  0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0x07, 0xF7,
  0xF0, 0x7F, 0x83, 0xFD, 0xFC, 0x1F, 0xE0, 0xFE, 0x7F, 0x07, 0xF8, 0x7F,
  0x9F, 0x83, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0x07, 0xF1, 0xF8, 0x7F, 0xC3,
  0xFC, 0x7E, 0x1F, 0xF0, 0xFE, 0x1F, 0x87, 0xFC, 0x3F, 0x8F, 0xE3, 0xFF,
  0x1F, 0xC3, 0xF8, 0xFF, 0xC7, 0xF0, 0xFE, 0x7F, 0xF3, 0xFC, 0x3F, 0x9F,
  0xFC, 0xFE, 0x0F, 0xEF, 0xDF, 0x3F, 0x83, 0xFB, 0xFF, 0xDF, 0xC0, 0xFE,
  0xFF, 0xF7, 0xF0, 0x3F, 0xFE, 0xFD, 0xFC, 0x0F, 0xFF, 0xBF, 0xFE, 0x03,
  0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xF0,
  0x0F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFD, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0x7F,
  0x1F, 0xE1, 0xFC, 0x7F, 0x07, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x7F,
  0x81, 0xFD, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xE7, 0xC0, 0x7E,
  0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x3E, 0x3F, 0x81, 0xF9,
  0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x01, 0xF0, 0x7F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0x9F, 0xC7,
  0xF1, 0xF8, 0x7C, 0x3E, 0x00, 0x40, 0x00, 0x1F, 0xCF, 0xC1, 0xFE, 0x7E,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x3F, 0xC7, 0xF1,
  0xFE, 0x7F, 0x8F, 0xF3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF,
  0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF1, 0xFE, 0x3F, 0xDF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xEF, 0xC1, 0xFE, 0x7E, 0x07, 0xE3, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF1, 0x80, 0x3F, 0x7F, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xDF, 0xE3, 0xFC,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x7F, 0x0F, 0xF3,
  0xF8, 0x7F, 0x9F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFE, 0x7F, 0x8F,
  0xF3, 0xFC, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xF7, 0xFC, 0x1F, 0x9F, 0xC0, 0x00, 0x38, 0x00, 0x7F, 0xE0,
  0x3F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFE, 0x70, 0xFF,
  0x04, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC3, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0xE3, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xF7, 0xE0, 0x1F, 0x8F, 0x80, 0x00, 0x18, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF,
  0xF1, 0xF9, 0xFC, 0x3F, 0x7F, 0x8F, 0xEF, 0xE3, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x23, 0xFC, 0x1C, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xFC, 0xFC, 0x07, 0xFD, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0x07, 0xF1, 0xFE, 0x1F,
  0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC,
  0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x06, 0x01, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF1, 0x80, 0x3F, 0x7F, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xCF, 0xF1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0x00, 0x60, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0xE3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xF0, 0x1F, 0xDF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xBF, 0xC0,
  0x7F, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0,
  0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x30, 0x07, 0xCF, 0xF1,
  0xFC, 0x0F, 0xDF, 0xF3, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xE3, 0xFC,
  0xFF, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF8,
  0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF0,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0x80, 0x3E, 0x7F, 0x03, 0xF7,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFE, 0x7F, 0x8F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFE, 0x7F,
  0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF, 0xF1, 0xFE,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x00, 0x18, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0xCF, 0xF3, 0xF8, 0xFF, 0x7F, 0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7,
  0xF0, 0xFF, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE,
  0xFE, 0x1F, 0xCF, 0xE3, 0xFC, 0xFF, 0x7F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x03,
  0xE7, 0xF0, 0x0F, 0xDF, 0xF0, 0x1F, 0xBF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFF, 0x7F, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xCF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xEF, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0xCF, 0xC1, 0xFF, 0x7E, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0x3F, 0xC7, 0xF1, 0xFE, 0x7F, 0x8F, 0xF3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0xFE, 0x07, 0xEF,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xC1, 0xF3, 0xF0, 0xFD, 0xF8, 0x3F,
  0x7E, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1,
  0xFC, 0x30, 0xFF, 0x04, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x20, 0x3F, 0x8F, 0xBF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF8, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0x3F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0x7E, 0x03, 0xF9, 0xF8,
  0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x9F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7,
  0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0, 0x7E, 0x7F,
  0x03, 0xF3, 0xF8, 0x1F, 0x9F, 0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x3F, 0xC3, 0xFF, 0xF0, 0xFF, 0x0F, 0xEF, 0xC7, 0xFC,
  0x7F, 0x3F, 0x1F, 0xF1, 0xFC, 0xFC, 0x7F, 0xC7, 0xF3, 0xF3, 0xFF, 0x3F,
  0x8F, 0xCF, 0xFC, 0xFE, 0x3F, 0x3F, 0xF3, 0xF0, 0xFD, 0xF7, 0xDF, 0xC3,
  0xF7, 0xDF, 0x7F, 0x0F, 0xDF, 0xFD, 0xF8, 0x3F, 0xFB, 0xFF, 0xE0, 0xFF,
  0xEF, 0xFF, 0x03, 0xFF, 0xBF, 0xFC, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF3,
  0xFF, 0x80, 0xFF, 0xCF, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0x80,
  0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xFC,
  0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0x80, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF4, 0x01,
  0xFC,
};

const GFXglyph NotoSans_Condensed_BlackItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 14, 31, 11, 0, -30 },
  { 56, 17, 11, 19, 4, -30 },
  { 80, 25, 30, 24, 0, -30 },
  { 174, 21, 34, 21, 1, -32 },
  { 264, 32, 30, 35, 2, -30 },
  { 384, 27, 30, 27, 0, -30 },
  { 486, 8, 11, 10, 4, -30 },
  { 497, 15, 38, 13, 1, -31 },
  { 569, 15, 38, 13, -3, -31 },
  { 641, 18, 20, 20, 3, -32 },
  { 686, 19, 20, 22, 2, -25 },
  { 734, 10, 12, 12, -2, -6 },
  { 749, 13, 6, 13, 0, -14 },
  { 759, 8, 8, 12, 0, -7 },
  { 767, 23, 30, 18, -2, -30 },
  { 854, 20, 30, 21, 1, -30 },
  { 929, 17, 30, 21, 4, -30 },
  { 993, 22, 30, 21, -1, -30 },
  { 1076, 21, 30, 21, 0, -30 },
  { 1155, 21, 30, 21, 0, -30 },
  { 1234, 21, 30, 21, 1, -30 },
  { 1313, 21, 30, 21, 1, -30 },
  { 1392, 22, 30, 21, 1, -30 },
  { 1475, 20, 30, 21, 1, -30 },
  { 1550, 20, 30, 21, 1, -30 },
  { 1625, 12, 25, 12, 0, -24 },
  { 1663, 14, 30, 12, -2, -24 },
  { 1716, 19, 22, 22, 2, -26 },
  { 1769, 19, 15, 22, 2, -22 },
  { 1805, 19, 22, 22, 2, -26 },
  { 1858, 17, 31, 17, 2, -30 },
  { 1924, 31, 33, 32, 1, -30 },
  { 2052, 24, 30, 24, -2, -30 },
  { 2142, 23, 30, 23, 0, -30 },
  { 2229, 22, 30, 22, 2, -30 },
  { 2312, 24, 30, 25, 0, -30 },
  { 2402, 21, 30, 19, 0, -30 },
  { 2481, 21, 30, 19, 0, -30 },
  { 2560, 24, 30, 25, 2, -30 },
  { 2650, 27, 30, 26, 0, -30 },
  { 2752, 21, 30, 16, -2, -30 },
  { 2831, 21, 39, 13, -7, -30 },
  { 2934, 27, 30, 23, 0, -30 },
  { 3036, 17, 30, 18, 0, -30 },
  { 3100, 35, 30, 33, 0, -30 },
  { 3232, 29, 30, 28, 0, -30 },
  { 3341, 24, 30, 26, 2, -30 },
  { 3431, 23, 30, 22, 0, -30 },
  { 3518, 24, 37, 26, 2, -30 },
  { 3629, 23, 30, 23, 0, -30 },
  { 3716, 21, 30, 20, 0, -30 },
  { 3795, 20, 30, 20, 3, -30 },
  { 3870, 24, 30, 25, 2, -30 },
  { 3960, 23, 30, 23, 4, -30 },
  { 4047, 34, 30, 34, 3, -30 },
  { 4175, 29, 30, 23, -3, -30 },
  { 4284, 22, 30, 22, 4, -30 },
  { 4367, 24, 30, 20, -2, -30 },
  { 4457, 18, 38, 13, -2, -31 },
  { 4543, 11, 30, 18, 4, -30 },
  { 4585, 18, 38, 13, -3, -31 },
  { 4671, 21, 20, 20, -1, -30 },
  { 4724, 18, 5, 17, -4, 3 },
  { 4736, 9, 7, 14, 6, -32 },
  { 4744, 21, 24, 22, 1, -24 },
  { 4807, 21, 32, 22, 0, -32 },
  { 4891, 18, 24, 18, 1, -24 },
  { 4945, 23, 32, 22, 1, -32 },
  { 5037, 19, 24, 21, 1, -24 },
  { 5094, 24, 42, 14, -5, -32 },
  { 5220, 23, 34, 22, -1, -24 },
  { 5318, 21, 32, 22, 0, -32 },
  { 5402, 13, 33, 12, 0, -33 },
  { 5456, 18, 43, 12, -5, -33 },
  { 5553, 24, 32, 22, 0, -32 },
  { 5649, 14, 32, 11, 0, -32 },
  { 5705, 32, 24, 33, 0, -24 },
  { 5801, 21, 24, 22, 0, -24 },
  { 5864, 20, 24, 22, 1, -24 },
  { 5924, 23, 34, 22, -2, -24 },
  { 6022, 21, 34, 22, 1, -24 },
  { 6112, 18, 24, 16, 0, -24 },
  { 6166, 18, 24, 18, 0, -24 },
  { 6220, 15, 28, 16, 2, -28 },
  { 6273, 22, 23, 22, 1, -23 },
  { 6337, 21, 23, 20, 2, -23 },
  { 6398, 30, 23, 30, 3, -23 },
  { 6485, 25, 23, 21, -2, -23 },
  { 6557, 26, 33, 20, -3, -23 },
  { 6665, 20, 23, 18, -1, -23 },
  { 6723, 18, 37, 15, 0, -30 },
  { 6807, 6, 42, 19, 6, -32 },
  { 6839, 17, 37, 15, -2, -30 },
  { 6918, 19, 8, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_BlackItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC42PT7B_H_
