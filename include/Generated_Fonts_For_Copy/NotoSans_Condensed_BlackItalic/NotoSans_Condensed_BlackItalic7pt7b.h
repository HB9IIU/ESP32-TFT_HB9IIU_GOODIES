#ifndef _NOTOSANS_CONDENSED_BLACKITALIC7PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5C, 0x80, 0xF8, 0x37, 0xEF, 0xA0, 0x74, 0x6E, 0xC0, 0x6A, 0xCD,
  0xCD, 0x58, 0x77, 0x7B, 0xF0, 0xC0, 0x6A, 0x49, 0x00, 0x24, 0x95, 0x80,
  0x6F, 0x60, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x32, 0x4C, 0x80, 0x67, 0xEA,
  0xE0, 0x77, 0x80, 0x6C, 0xAE, 0x72, 0x62, 0xE0, 0x36, 0x6E, 0x60, 0x74,
  0x62, 0xE0, 0x74, 0xEA, 0xE0, 0x72, 0x24, 0xC0, 0x67, 0x6A, 0xE0, 0x6F,
  0xE2, 0xC0, 0x42, 0x42, 0x80, 0x38, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0x65,
  0x0C, 0x3B, 0xF7, 0xF9, 0x30, 0x26, 0x7F, 0xB0, 0x75, 0x6F, 0xE0, 0x74,
  0xCC, 0x60, 0x75, 0x5F, 0xE0, 0x74, 0x6C, 0xE0, 0x74, 0x6C, 0x80, 0x74,
  0xFF, 0x60, 0x55, 0x7D, 0xB0, 0x69, 0x2C, 0x24, 0xB5, 0xA0, 0x5B, 0x19,
  0xCB, 0x00, 0x49, 0x6E, 0x6D, 0xE7, 0xAE, 0xA8, 0x6B, 0xDD, 0x6B, 0x00,
  0x75, 0xDD, 0x60, 0x75, 0x6C, 0x80, 0x75, 0xDD, 0x62, 0x75, 0x6E, 0xB0,
  0x74, 0x62, 0xE0, 0xFA, 0x48, 0x55, 0x5F, 0xE0, 0xB7, 0x68, 0xAF, 0xFD,
  0x6A, 0x00, 0x56, 0x66, 0xA0, 0xBB, 0x48, 0x72, 0x4C, 0xE0, 0x6B, 0x49,
  0x80, 0xF8, 0x24, 0x95, 0x80, 0x2E, 0x80, 0xE0, 0xC0, 0x5E, 0xAE, 0x46,
  0xFA, 0xE0, 0x7A, 0x70, 0x17, 0xEA, 0xE0, 0x7E, 0x70, 0x37, 0x26, 0x44,
  0xC0, 0x5E, 0xAE, 0xAC, 0x46, 0xFA, 0xA0, 0x56, 0x80, 0x24, 0xA4, 0xA0,
  0x47, 0xEE, 0xA0, 0x5E, 0x80, 0x6F, 0xEB, 0x50, 0x6F, 0xAA, 0x7E, 0xF0,
  0x6F, 0xAE, 0x88, 0x5E, 0xAE, 0x26, 0x7A, 0x40, 0x79, 0xE0, 0x5D, 0x6C,
  0x7E, 0xAE, 0xFE, 0x64, 0xFF, 0x75, 0xE0, 0xF6, 0x6A, 0xF6, 0x64, 0xC8,
  0xEF, 0x70, 0x6B, 0x6D, 0x80, 0xFE, 0x55, 0xA0, 0xF0,
};

const GFXglyph NotoSans_Condensed_BlackItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 6, 5, 6, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 2, 1, -5 },
  { 18, 3, 6, 2, 0, -5 },
  { 21, 3, 6, 2, -1, -5 },
  { 24, 4, 3, 3, 0, -5 },
  { 26, 3, 3, 4, 0, -4 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 2, 1, 2, 0, -2 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 4, 5, 3, 0, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 2, 5, 4, 1, -5 },
  { 39, 3, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 4, 5, 4, 0, -5 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 3, 3, 4, 0, -4 },
  { 67, 3, 3, 4, 0, -4 },
  { 69, 3, 3, 4, 0, -4 },
  { 71, 3, 5, 3, 0, -5 },
  { 73, 5, 6, 5, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 3, 0, -5 },
  { 92, 4, 5, 3, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 3, 5, 3, 0, -5 },
  { 103, 3, 7, 2, -1, -5 },
  { 106, 5, 5, 4, 0, -5 },
  { 110, 3, 5, 3, 0, -5 },
  { 112, 6, 5, 6, 0, -5 },
  { 116, 5, 5, 5, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 6, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 4, 5, 3, 0, -5 },
  { 135, 3, 5, 3, 1, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 3, 5, 4, 1, -5 },
  { 142, 5, 5, 6, 1, -5 },
  { 146, 4, 5, 4, 0, -5 },
  { 149, 3, 5, 4, 1, -5 },
  { 151, 4, 5, 3, 0, -5 },
  { 154, 3, 6, 2, 0, -5 },
  { 157, 1, 5, 3, 1, -5 },
  { 158, 3, 6, 2, -1, -5 },
  { 161, 3, 3, 3, 0, -5 },
  { 163, 3, 1, 3, -1, 0 },
  { 164, 2, 1, 2, 1, -5 },
  { 165, 4, 4, 4, 0, -4 },
  { 167, 4, 5, 4, 0, -5 },
  { 170, 3, 4, 3, 0, -4 },
  { 172, 4, 5, 4, 0, -5 },
  { 175, 3, 4, 3, 0, -4 },
  { 177, 4, 7, 2, -1, -5 },
  { 181, 4, 6, 4, 0, -4 },
  { 184, 4, 5, 4, 0, -5 },
  { 187, 2, 5, 2, 0, -5 },
  { 189, 3, 7, 2, -1, -5 },
  { 192, 4, 5, 4, 0, -5 },
  { 195, 2, 5, 2, 0, -5 },
  { 197, 5, 4, 6, 0, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 3, 4, 4, 0, -4 },
  { 204, 4, 6, 4, 0, -4 },
  { 207, 4, 6, 4, 0, -4 },
  { 210, 3, 4, 3, 0, -4 },
  { 212, 3, 4, 3, 0, -4 },
  { 214, 3, 5, 3, 0, -5 },
  { 216, 4, 4, 4, 0, -4 },
  { 218, 4, 4, 3, 0, -4 },
  { 220, 5, 4, 5, 0, -4 },
  { 223, 4, 4, 3, 0, -4 },
  { 225, 4, 6, 3, 0, -4 },
  { 228, 3, 4, 3, 0, -4 },
  { 230, 3, 6, 2, 0, -5 },
  { 233, 1, 7, 3, 1, -5 },
  { 234, 2, 6, 2, 0, -5 },
  { 236, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_BlackItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC7PT7B_H_
