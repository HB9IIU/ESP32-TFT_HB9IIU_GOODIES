#ifndef _NOTOSANS_CONDENSED_BLACKITALIC28PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F,
  0x0F, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x00,
  0xFB, 0xFF, 0x7F, 0xEF, 0xF9, 0xEF, 0x3D, 0xE7, 0xB9, 0xE0, 0x01, 0xCF,
  0x00, 0xE7, 0x00, 0xF3, 0x80, 0x73, 0xC0, 0x39, 0xC1, 0xFF, 0xFC, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x07, 0xBC, 0x03, 0x9E, 0x0F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x79, 0xC0, 0x39, 0xE0, 0x1C, 0xE0,
  0x1E, 0x70, 0x0E, 0x78, 0x00, 0x00, 0x60, 0x01, 0x00, 0x7F, 0xC3, 0xFF,
  0x1F, 0xFC, 0x7F, 0xE1, 0xE8, 0x87, 0xA0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE4, 0x37, 0x98, 0xFC, 0x7F, 0xF1, 0xFF,
  0xCF, 0xFE, 0x0F, 0xE0, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x1F, 0x03,
  0xC1, 0xF8, 0x1C, 0x1F, 0xE1, 0xE1, 0xEF, 0x1E, 0x0F, 0x78, 0xE0, 0x73,
  0xCF, 0x03, 0x9E, 0xF0, 0x1C, 0xE7, 0x00, 0xEF, 0x7B, 0xE7, 0xFB, 0xBF,
  0xBF, 0xBD, 0xFE, 0xFB, 0xDE, 0xF0, 0x1C, 0xE7, 0x81, 0xE7, 0x3C, 0x1E,
  0x79, 0xC0, 0xF3, 0xCE, 0x0F, 0x1E, 0xF0, 0x70, 0x7F, 0x07, 0x83, 0xF8,
  0x78, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0xF8,
  0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF9, 0xF3, 0xFE, 0xF9, 0xFF, 0xBE, 0x7D, 0xFF, 0x3E, 0x7F, 0xCF, 0x8F,
  0xE3, 0xE3, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFE, 0xFC,
  0xFF, 0xFF, 0xEF, 0x7B, 0x80, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x00,
  0x04, 0x00, 0x78, 0x07, 0x86, 0x70, 0x77, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0x1F, 0x03, 0xF8, 0xFB, 0xC3, 0xBE, 0x11, 0x80, 0x10, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0x1E, 0x3E, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0x7F, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x3F, 0xF3, 0xEF, 0x9E,
  0x7D, 0xF3, 0xEF, 0x9F, 0x78, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xEF, 0x9F,
  0x7C, 0xFB, 0xC7, 0x9F, 0x7C, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00,
  0x01, 0xF0, 0x3E, 0x07, 0xE1, 0xFE, 0x3F, 0xE7, 0xFE, 0xFB, 0xC7, 0x7C,
  0x27, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF0, 0xE3, 0xE0, 0x87, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC3, 0xFF, 0x08, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x7E, 0x0F, 0xF0,
  0x3E, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0xA0, 0x7C,
  0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x1E, 0xF0, 0x73,
  0xC3, 0xDF, 0x1E, 0x7C, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x30, 0x7C, 0xFF, 0xF3,
  0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFE,
  0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xFF, 0xE1, 0xFF,
  0x87, 0xFC, 0x0F, 0xC0, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0xFF, 0xC7,
  0xFF, 0x1F, 0x3C, 0x78, 0xF1, 0xF7, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x81,
  0xFF, 0x0F, 0xFC, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xFF, 0xF1,
  0xFF, 0xC7, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0x7F, 0xF7,
  0xCF, 0xBE, 0x7D, 0xF3, 0xEF, 0x9F, 0x7C, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF,
  0xE3, 0xFF, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xC1,
  0xF8, 0x00, 0x06, 0x1F, 0x1F, 0x3F, 0x1E, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0xF8, 0xF8, 0xF8, 0xF0, 0x01, 0x81, 0xF0, 0x7C, 0x3F, 0x07,
  0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0x83,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x00, 0x18, 0x03, 0xC0, 0x7E,
  0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x81,
  0xFE, 0x03, 0xF0, 0x07, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x07, 0x80, 0x3F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x7F,
  0x0F, 0xF3, 0xFE, 0x3F, 0xC1, 0xF8, 0x0F, 0x00, 0x40, 0x00, 0x1F, 0xC3,
  0xFE, 0x7F, 0xE3, 0xFF, 0x31, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0xC1,
  0xF8, 0x3E, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0xF0, 0x1E, 0x1E, 0x00, 0xF3, 0xC7, 0xF7, 0x39, 0xFE, 0x77, 0x9F, 0xE7,
  0x73, 0xCE, 0x7F, 0x79, 0xE7, 0xE7, 0x9C, 0x7E, 0x71, 0xCE, 0xE7, 0x1C,
  0xEE, 0x73, 0xDE, 0xE7, 0xFF, 0xCE, 0x7F, 0xF8, 0xE3, 0xCF, 0x0F, 0x00,
  0x00, 0x78, 0x04, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xEF, 0x03,
  0xEF, 0x03, 0xEF, 0x03, 0xCF, 0x07, 0xCF, 0x07, 0x8F, 0x0F, 0x8F, 0x0F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C,
  0x1F, 0xFC, 0x1F, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F,
  0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xE3, 0xF0, 0x87, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x10, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7C,
  0x7E, 0x7C, 0x7C, 0x7D, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xE1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x01,
  0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x84, 0x3F, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0xFE, 0x7C, 0xFE, 0xF9, 0xFE, 0xF9, 0xFC, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0x78, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xE0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x3C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x7C, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC3, 0xFC,
  0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF9,
  0xF8, 0x3C, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0x7E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3F, 0x0F, 0x8F,
  0xC3, 0xE1, 0xF0, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7F, 0xEF, 0xFF, 0xFF, 0x7F, 0xE0, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0x87, 0xF9, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xE7, 0x78, 0x7F, 0xDF, 0xF0,
  0xFF, 0xBF, 0xE1, 0xEF, 0xF7, 0xC3, 0xDF, 0xEF, 0x0F, 0xBF, 0xBE, 0x1F,
  0x7F, 0x7C, 0x3E, 0xFC, 0xF8, 0x79, 0xF9, 0xE0, 0xF3, 0xE3, 0xC3, 0xE7,
  0xCF, 0x87, 0xCF, 0x9F, 0x00, 0x0F, 0xC1, 0xE1, 0xF8, 0x3C, 0x3F, 0x0F,
  0x87, 0xF1, 0xF1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF9, 0xF0, 0xFF, 0x3E,
  0x3F, 0xF7, 0xC7, 0xFE, 0xF0, 0xF3, 0xDE, 0x1E, 0x7B, 0xC3, 0xCF, 0xF8,
  0xF9, 0xFF, 0x1F, 0x3F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x0F, 0xE3,
  0xE1, 0xF8, 0x7C, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFC,
  0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F,
  0x3E, 0x7E, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xFE, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x03,
  0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFC, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x9F, 0x3E, 0x7E, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83,
  0xFF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0x7C, 0x7C, 0xF8, 0xF1, 0xF3, 0xE3,
  0xF7, 0xC3, 0xE0, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0x18,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xC8, 0x1F, 0x38, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC,
  0x1F, 0xC0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xC0, 0xF8, 0x3F, 0xF8, 0x3E, 0x78, 0x3E, 0x78, 0x7C, 0x78,
  0x7C, 0x78, 0xF8, 0x78, 0xF8, 0x79, 0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x7B,
  0xE0, 0x7B, 0xE0, 0x7B, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8,
  0x7B, 0xE1, 0xF1, 0xF7, 0xC7, 0xE3, 0xEF, 0x8F, 0xCF, 0x9F, 0x3F, 0x9F,
  0x3E, 0x7F, 0x3C, 0x7C, 0xFE, 0xF8, 0xFB, 0xFD, 0xF1, 0xF7, 0xFF, 0xC3,
  0xFE, 0xEF, 0x87, 0xFD, 0xDE, 0x0F, 0x7B, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F,
  0xDF, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF1,
  0xFC, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFD, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC1,
  0xF8, 0xF8, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7,
  0xC7, 0xDF, 0x0F, 0xBE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0xF1, 0xE3, 0xC7, 0x8F, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xF0, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x07,
  0xBC, 0x1E, 0x78, 0xF1, 0xE7, 0x87, 0x9E, 0x1E, 0xF0, 0x3C, 0x7F, 0xF7,
  0xFF, 0xFF, 0xF0, 0xF9, 0xF3, 0xCF, 0x06, 0x00, 0x7D, 0xF3, 0xFF, 0x8F,
  0xFE, 0x7F, 0xF9, 0xF3, 0xEF, 0x8F, 0xBE, 0x3C, 0xF8, 0xF3, 0xE7, 0xCF,
  0x1F, 0x3E, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xDE, 0x1E, 0x78, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7D, 0xC1, 0xEF, 0x87, 0xFF,
  0x3F, 0xFC, 0xFD, 0xF3, 0xE7, 0xCF, 0x1F, 0x3C, 0x7D, 0xF1, 0xF7, 0xC7,
  0x9F, 0x3E, 0x7C, 0xF9, 0xFF, 0xCF, 0xFF, 0x3D, 0xF8, 0xF7, 0xC0, 0x03,
  0xC0, 0xFF, 0x3F, 0xE3, 0xFE, 0x7E, 0x47, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x88, 0xFF, 0x8F, 0xF8, 0x7F, 0x83, 0xF0, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC1, 0xCF, 0x87, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF8, 0xFB, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0x1F,
  0x1E, 0x3E, 0x7C, 0x78, 0xF8, 0xFB, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xEF,
  0x07, 0x9E, 0x00, 0x03, 0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xF7, 0xCF, 0xBC,
  0x7F, 0xEF, 0xDF, 0xFE, 0xFF, 0xE7, 0xF8, 0x3C, 0x01, 0xE0, 0x4F, 0xDC,
  0x7F, 0xE1, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0xBF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xEF, 0xC7, 0xCF,
  0x9F, 0x1F, 0x3E, 0x3C, 0x7C, 0x78, 0xF9, 0xF1, 0xE3, 0xE3, 0xEF, 0xC7,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1E, 0xF8, 0x01, 0xE0, 0x07, 0xC3, 0x0F,
  0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7D, 0xC1, 0xEF, 0x87, 0xFF, 0x3F,
  0xFC, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x7D, 0xF1, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0x3E, 0x7C, 0xF9, 0xF0, 0x03, 0x07,
  0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0xC3,
  0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0xC0, 0x00,
  0x30, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x9F, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0x1F,
  0x3E, 0x1E, 0x7E, 0x3E, 0x7C, 0x3E, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7D, 0xF0, 0x79, 0xF0, 0xF9,
  0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3C, 0x3E, 0x1F, 0x0F, 0x80, 0x00, 0x70, 0xE0, 0xF7, 0xCF, 0xC7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x9F, 0x7C, 0x78, 0xFB, 0xE7, 0xC7, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0x8F, 0x9F, 0x7C, 0x78, 0xFB, 0xE7, 0xC7, 0x9F, 0x3E, 0x7C, 0x00,
  0x70, 0x7B, 0xE1, 0xFF, 0xCF, 0xFF, 0x3F, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x1F, 0x7C, 0x79, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xFB, 0xE3, 0xCF,
  0x9F, 0x3E, 0x7C, 0x03, 0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xE7, 0xCF, 0xBE,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0xBC, 0x7D, 0xF3, 0xEF, 0xFE,
  0x7F, 0xE1, 0xFF, 0x07, 0xE0, 0x00, 0x1C, 0x07, 0xBE, 0x07, 0xFF, 0x0F,
  0xFF, 0x0F, 0xDF, 0x0F, 0x9F, 0x0F, 0x9F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3E,
  0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0x7F, 0xF3, 0xFF, 0x8F, 0xFE, 0x7F, 0xF9,
  0xF3, 0xEF, 0x8F, 0xBE, 0x3C, 0xF8, 0xF3, 0xE7, 0xCF, 0x1F, 0x3E, 0xFC,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x1E, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x71, 0xEF, 0x1F,
  0xE3, 0xFE, 0x3F, 0xE3, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x07, 0x81, 0xFF, 0x3F,
  0xF3, 0xFE, 0x3E, 0x63, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xC8, 0x7C, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x07, 0x03, 0xC0, 0xF0,
  0x78, 0x7F, 0xDF, 0xFF, 0xFC, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x83, 0xFC, 0xFF, 0x1F, 0xC7, 0xF0, 0x3E, 0x7C, 0xF1, 0xF7,
  0xC7, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0xBE, 0x3C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x87, 0xDE, 0x00, 0xF0,
  0xFF, 0x8F, 0xBC, 0x7D, 0xE7, 0xCF, 0x3E, 0x79, 0xE3, 0xDF, 0x1E, 0xF0,
  0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x00,
  0xF1, 0xF1, 0xFF, 0x3F, 0x3E, 0xF3, 0xF3, 0xCF, 0x3F, 0x7C, 0xF7, 0xF7,
  0xCF, 0x7F, 0x78, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF,
  0xF0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8,
  0xF8, 0x00, 0x0F, 0x9F, 0x87, 0xCF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x03, 0xFF, 0x03, 0xE7, 0x81, 0xF3, 0xE3, 0xF1, 0xF0, 0x0F, 0x0F,
  0x87, 0x8F, 0x83, 0xC7, 0xC1, 0xE7, 0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x2F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x7F,
  0xE1, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x01, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0x3C, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F,
  0xC0, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x0F, 0x80, 0x10, 0x0B, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x70,
};

const GFXglyph NotoSans_Condensed_BlackItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 20, 8, 0, -20 },
  { 24, 11, 7, 13, 3, -20 },
  { 34, 17, 20, 16, 0, -20 },
  { 77, 14, 23, 14, 0, -21 },
  { 118, 21, 20, 23, 2, -20 },
  { 171, 18, 20, 18, 0, -20 },
  { 216, 5, 7, 7, 3, -20 },
  { 221, 11, 25, 9, 0, -21 },
  { 256, 10, 25, 9, -2, -21 },
  { 288, 12, 14, 13, 2, -22 },
  { 309, 13, 14, 15, 1, -17 },
  { 332, 8, 8, 8, -2, -4 },
  { 340, 8, 5, 9, 0, -10 },
  { 345, 5, 5, 8, 0, -5 },
  { 349, 15, 20, 12, -1, -20 },
  { 387, 13, 20, 14, 1, -20 },
  { 420, 12, 20, 14, 2, -20 },
  { 450, 15, 20, 14, -1, -20 },
  { 488, 14, 20, 14, 0, -20 },
  { 523, 14, 20, 14, 0, -20 },
  { 558, 14, 20, 14, 0, -20 },
  { 593, 14, 20, 14, 1, -20 },
  { 628, 15, 20, 14, 1, -20 },
  { 666, 14, 20, 14, 0, -20 },
  { 701, 13, 20, 14, 1, -20 },
  { 734, 8, 16, 8, 0, -16 },
  { 750, 10, 20, 8, -2, -16 },
  { 775, 13, 14, 15, 1, -17 },
  { 798, 13, 10, 15, 1, -15 },
  { 815, 13, 14, 15, 1, -17 },
  { 838, 12, 20, 11, 1, -20 },
  { 868, 20, 22, 21, 1, -20 },
  { 923, 16, 20, 16, -2, -20 },
  { 963, 16, 20, 15, 0, -20 },
  { 1003, 15, 20, 15, 1, -20 },
  { 1041, 16, 20, 16, 0, -20 },
  { 1081, 14, 20, 13, 0, -20 },
  { 1116, 14, 20, 13, 0, -20 },
  { 1151, 16, 20, 17, 1, -20 },
  { 1191, 18, 20, 17, 0, -20 },
  { 1236, 14, 20, 11, -1, -20 },
  { 1271, 13, 26, 9, -4, -20 },
  { 1314, 18, 20, 16, 0, -20 },
  { 1359, 11, 20, 12, 0, -20 },
  { 1387, 23, 20, 22, 0, -20 },
  { 1445, 19, 20, 18, 0, -20 },
  { 1493, 16, 20, 17, 1, -20 },
  { 1533, 15, 20, 15, 0, -20 },
  { 1571, 16, 25, 17, 1, -20 },
  { 1621, 15, 20, 15, 0, -20 },
  { 1659, 14, 20, 13, 0, -20 },
  { 1694, 13, 20, 13, 2, -20 },
  { 1727, 16, 20, 17, 1, -20 },
  { 1767, 16, 20, 15, 2, -20 },
  { 1807, 23, 20, 22, 2, -20 },
  { 1865, 19, 20, 15, -2, -20 },
  { 1913, 15, 20, 15, 2, -20 },
  { 1951, 16, 20, 13, -1, -20 },
  { 1991, 12, 26, 9, -1, -21 },
  { 2030, 7, 20, 12, 3, -20 },
  { 2048, 12, 26, 9, -2, -21 },
  { 2087, 14, 13, 14, 0, -20 },
  { 2110, 12, 3, 11, -3, 2 },
  { 2115, 6, 4, 9, 4, -21 },
  { 2118, 14, 16, 15, 1, -16 },
  { 2146, 14, 21, 15, 0, -21 },
  { 2183, 12, 16, 12, 1, -16 },
  { 2207, 15, 21, 15, 1, -21 },
  { 2247, 13, 16, 14, 1, -16 },
  { 2273, 16, 28, 9, -3, -21 },
  { 2329, 15, 23, 15, 0, -16 },
  { 2373, 14, 21, 15, 0, -21 },
  { 2410, 9, 22, 8, 0, -22 },
  { 2435, 13, 29, 8, -4, -22 },
  { 2483, 16, 21, 15, 0, -21 },
  { 2525, 9, 21, 8, 0, -21 },
  { 2549, 21, 16, 22, 0, -16 },
  { 2591, 14, 16, 15, 0, -16 },
  { 2619, 13, 16, 14, 1, -16 },
  { 2645, 16, 23, 15, -2, -16 },
  { 2691, 14, 23, 15, 1, -16 },
  { 2732, 12, 16, 11, 0, -16 },
  { 2756, 12, 16, 12, 0, -16 },
  { 2780, 10, 19, 11, 1, -19 },
  { 2804, 14, 15, 15, 1, -15 },
  { 2831, 13, 15, 14, 2, -15 },
  { 2856, 20, 15, 20, 2, -15 },
  { 2894, 17, 15, 14, -2, -15 },
  { 2926, 17, 22, 14, -2, -15 },
  { 2973, 14, 15, 12, -1, -15 },
  { 3000, 12, 24, 10, 0, -20 },
  { 3036, 4, 27, 12, 4, -21 },
  { 3050, 12, 24, 10, -2, -20 },
  { 3086, 13, 6, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_BlackItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC28PT7B_H_
