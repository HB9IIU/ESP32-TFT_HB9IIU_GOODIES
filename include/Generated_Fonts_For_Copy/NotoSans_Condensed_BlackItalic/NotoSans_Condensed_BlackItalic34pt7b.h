#ifndef _NOTOSANS_CONDENSED_BLACKITALIC34PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0x7E, 0xFD,
  0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0x3E, 0x7C,
  0xF9, 0xF0, 0x00, 0xF9, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x1F, 0x3C,
  0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x07, 0x8F, 0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0xF1,
  0xE0, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x1E,
  0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07,
  0x8F, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x7F, 0xE0, 0xFF,
  0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7E, 0xDC, 0x3E, 0xC2, 0x1F, 0x60, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFC, 0x01, 0xBE, 0x20, 0xDF, 0x1C, 0x6F, 0x8F, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x03, 0xFE, 0x07, 0x80,
  0xFF, 0x83, 0xE0, 0x7D, 0xE0, 0xF0, 0x1E, 0x78, 0x78, 0x0F, 0x9E, 0x3E,
  0x03, 0xE7, 0x8F, 0x00, 0xF1, 0xE7, 0xC0, 0x3C, 0xF9, 0xE0, 0x0F, 0x3C,
  0xF1, 0xE3, 0xDF, 0x7D, 0xFE, 0xFF, 0x9E, 0xFF, 0xBF, 0xEF, 0xBF, 0xE7,
  0xF7, 0xDF, 0x7C, 0x21, 0xE7, 0x9F, 0x00, 0xF9, 0xE7, 0xC0, 0x3C, 0xF9,
  0xE0, 0x1E, 0x3E, 0x78, 0x0F, 0x8F, 0x9E, 0x03, 0xC3, 0xCF, 0x81, 0xF0,
  0xFF, 0xC0, 0x78, 0x1F, 0xF0, 0x3C, 0x07, 0xF8, 0x1F, 0x00, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xDF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x3F, 0x0F, 0xF9, 0xF8,
  0x7F, 0xE7, 0xE3, 0xFF, 0xDF, 0x1F, 0xBF, 0xFC, 0x7E, 0xFF, 0xE3, 0xF1,
  0xFF, 0x8F, 0xC7, 0xFC, 0x3F, 0x0F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xEF, 0xF0, 0x7E, 0xFD, 0xF3,
  0xE7, 0xCF, 0x3E, 0x7C, 0xF8, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x81, 0x9F, 0x07, 0xBC,
  0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xC0, 0x7F, 0x83,
  0xFF, 0x83, 0xEF, 0x83, 0x9F, 0x02, 0x3C, 0x00, 0x20, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x00, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0xFF, 0x80,
  0x39, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFF, 0x1F, 0xBF, 0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E,
  0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x7F,
  0x83, 0xFE, 0x1F, 0xF8, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x7B, 0xF0, 0xCF,
  0xC2, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x70, 0xFC, 0x08, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x70,
  0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3D, 0xFC, 0x10,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x81, 0xFF, 0x80, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x90, 0x1F, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xDF, 0x03, 0xDF, 0x83, 0xEF, 0xC3, 0xE7, 0xE1, 0xE3, 0xE1, 0xE3, 0xF0,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x87,
  0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x20, 0x7F, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0x08, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x7C, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F,
  0x3F, 0x1F, 0x9F, 0x9F, 0x8F, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x3F, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7E, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x87, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xF8, 0x7E, 0xFC, 0x7E, 0x3E, 0x3E, 0x1F,
  0x3F, 0x0F, 0x9F, 0x87, 0xCF, 0xEF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x60, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFE, 0x3F, 0xBF, 0x3F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE,
  0x1E, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0x87, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF1, 0xFC,
  0xFC, 0x7E, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x03, 0xFF, 0x0F,
  0xFE, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x07, 0xFF, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x3F,
  0xE3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xF3, 0xF1, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x7E, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7E, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0x3C, 0x3C, 0x3F, 0xDE, 0x3C, 0x7F, 0xE7, 0x9E, 0x7F, 0xF3,
  0xDE, 0x3C, 0xF1, 0xEF, 0x3C, 0x78, 0xF7, 0x9E, 0x3C, 0x77, 0x9F, 0x1E,
  0x7B, 0xCF, 0x1F, 0x3D, 0xE7, 0x8F, 0x1E, 0xF3, 0xC7, 0x9E, 0x79, 0xE7,
  0xDF, 0x3C, 0xFF, 0xFF, 0x1E, 0x3F, 0x7F, 0x0F, 0x1F, 0x1F, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFB, 0xE0, 0x1F, 0xBE, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF3,
  0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF0, 0x7E, 0x3F,
  0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7F, 0x07, 0xFF, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFD, 0xFE, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7C, 0x7F, 0x1F, 0x8F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFC, 0x10, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xF8, 0x30, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xF8, 0x7F, 0x1F,
  0x87, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8,
  0x7E, 0x7F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC1, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xC0, 0x43, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE3, 0xFC, 0x7E, 0x7F, 0xC7, 0xE7, 0xFC, 0xFE, 0x7F, 0xCF, 0xE7,
  0xF8, 0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0xDF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0x78,
  0x00, 0x07, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xFC,
  0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xEF, 0xE0, 0x1F,
  0xBF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01,
  0xF9, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0,
  0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x80, 0xFF, 0xF7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xF7, 0x8F, 0xFC, 0x1F, 0x79, 0xFF,
  0xC1, 0xF7, 0x9E, 0xF8, 0x3F, 0x7B, 0xEF, 0x83, 0xF7, 0xBD, 0xF8, 0x3F,
  0x7F, 0xDF, 0x83, 0xE7, 0xFD, 0xF8, 0x3E, 0x7F, 0x9F, 0x07, 0xE7, 0xF9,
  0xF0, 0x7E, 0x7F, 0x3F, 0x07, 0xC7, 0xF3, 0xF0, 0x7C, 0x7E, 0x3F, 0x07,
  0xC7, 0xE3, 0xE0, 0xFC, 0x7C, 0x7E, 0x0F, 0xC7, 0xC7, 0xE0, 0x07, 0xF0,
  0x3F, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x7E, 0x0F, 0xF8, 0x7E, 0x0F, 0xF8,
  0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xFC, 0xFC, 0x1F, 0xFC,
  0xFC, 0x1F, 0x7C, 0xF8, 0x1F, 0x7C, 0xF8, 0x1F, 0x7C, 0xF8, 0x3F, 0x7F,
  0xF8, 0x3F, 0x7F, 0xF8, 0x3F, 0x3F, 0xF0, 0x3E, 0x3F, 0xF0, 0x3E, 0x3F,
  0xF0, 0x7E, 0x3F, 0xF0, 0x7E, 0x3F, 0xF0, 0x7C, 0x1F, 0xE0, 0x7C, 0x1F,
  0xE0, 0x7C, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x3C,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE,
  0xFE, 0x1F, 0xC7, 0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x7F,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0xFE, 0x07, 0xEF,
  0xE0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFE, 0x1F, 0xC7, 0xE3, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF9, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE, 0xFE, 0x1F, 0xC7,
  0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x7F, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFC,
  0x0F, 0xEF, 0xC0, 0xFC, 0xFE, 0x1F, 0xC7, 0xE3, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7C, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFB, 0xE0, 0x3F, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x1F,
  0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0xE7, 0xE1, 0xFC, 0x00, 0x30,
  0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7E,
  0x08, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x10, 0x3F, 0x1E, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFE, 0x3F,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x1F,
  0x07, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0xFC, 0x3F, 0x7E, 0x1F, 0x87, 0xEF,
  0x87, 0xF0, 0xF9, 0xF0, 0xFE, 0x3F, 0x3E, 0x3F, 0xC7, 0xE7, 0xC7, 0xF9,
  0xF8, 0xF8, 0xFF, 0x3F, 0x1F, 0x3F, 0xE7, 0xC3, 0xE7, 0xFD, 0xF8, 0x7D,
  0xFF, 0xBF, 0x0F, 0xBF, 0xF7, 0xC1, 0xFF, 0xBF, 0xF8, 0x3F, 0xF7, 0xFE,
  0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0x9F, 0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFC,
  0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0,
  0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x07, 0xE1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x83,
  0xF0, 0x7F, 0x07, 0xF0, 0xFC, 0x1F, 0xFF, 0x0F, 0xE7, 0xC3, 0xF1, 0xF9,
  0xFC, 0x7E, 0x7E, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xF8, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xFC,
  0x07, 0xDF, 0x03, 0xE7, 0xC0, 0xF8, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F,
  0x83, 0xE7, 0xC0, 0x7B, 0xF0, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7C, 0x7E, 0x3E, 0x1F, 0x07, 0xCF, 0x87, 0xF7, 0xC7, 0xFF,
  0xE7, 0xFF, 0xE3, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0xFC,
  0x3E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xC7, 0xE7, 0xE3,
  0xF7, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xBE, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x7C, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF,
  0xF1, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x9F,
  0x0F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE7, 0xF3, 0xFF, 0xF1, 0xFF, 0xF9,
  0xFF, 0xF8, 0xFB, 0xF8, 0x7C, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF9, 0xFC, 0x27, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x8F, 0xFE, 0x3F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x7E, 0x0F,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x7F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xBE, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE,
  0x3F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7D, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x08, 0xFC, 0x38, 0xFF, 0xF8,
  0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x7F, 0x7C, 0x1F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x3F, 0x0F,
  0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7E, 0x7E,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE1, 0x01, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x7C, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9, 0xF9,
  0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x1F, 0x1F, 0x9F, 0x8F,
  0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC,
  0x7E, 0x7E, 0x3E, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07,
  0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x7F, 0x1F, 0x8F, 0xE1, 0xF8, 0xFC, 0x1F, 0x9F, 0x81,
  0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC,
  0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x80, 0x0F, 0x1E, 0x1F, 0x03, 0xDF, 0xCF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xE7, 0xF3, 0xF3, 0xF1, 0xF8, 0xFC,
  0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE3, 0xF1,
  0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3,
  0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0x8F,
  0xC7, 0xC7, 0xE0, 0x0F, 0x3E, 0x07, 0xBF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1,
  0xFF, 0xF8, 0xFC, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F,
  0x8F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xF8, 0xF8,
  0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x00, 0x03, 0xF8, 0x0F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0xFC,
  0xFD, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x03, 0xCF,
  0x80, 0x7B, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xCF,
  0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F,
  0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFD, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xCF, 0x87, 0xF7, 0xC7, 0xFF, 0xE7, 0xFF, 0xE3,
  0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0xFC, 0x3E, 0x7E, 0x3F,
  0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xC7, 0xE7, 0xE3, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xBE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x0F, 0x1C, 0x3D, 0xF1, 0xF7, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xF3, 0x87, 0xE1, 0x0F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x90,
  0x3F, 0x3C, 0xFC, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC1, 0xFE, 0x00, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xFF, 0x9F, 0xF9, 0xFF, 0xCF, 0xFE,
  0xFF, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFE,
  0x00, 0x1F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF1,
  0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x3F, 0x1F,
  0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE7, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xBE, 0x1F, 0x9E, 0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E,
  0xFC, 0x7E, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xFD, 0xF8, 0xFD, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x1F, 0xFC,
  0xFE, 0x3F, 0xFC, 0xFE, 0x3E, 0xF8, 0xFE, 0x7E, 0xF9, 0xFE, 0x7E, 0xF9,
  0xFE, 0x7C, 0xF9, 0xFE, 0xFC, 0xFB, 0xDE, 0xF8, 0xFB, 0xDE, 0xF8, 0xFB,
  0xFF, 0xF0, 0xFF, 0xBF, 0xF0, 0xFF, 0xBF, 0xF0, 0xFF, 0xBF, 0xE0, 0xFF,
  0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE,
  0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x3F, 0x3F, 0x81, 0xF9,
  0xF8, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x3F,
  0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0x80, 0x7D, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFC,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0x80, 0xFE, 0x07, 0xF8,
  0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x01, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_Condensed_BlackItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 24, 9, 0, -24 },
  { 34, 14, 9, 15, 3, -24 },
  { 50, 20, 24, 19, 0, -24 },
  { 110, 17, 28, 17, 1, -26 },
  { 170, 26, 25, 28, 2, -25 },
  { 252, 22, 25, 22, 0, -25 },
  { 321, 7, 9, 8, 3, -24 },
  { 329, 12, 30, 11, 1, -25 },
  { 374, 13, 30, 11, -3, -25 },
  { 423, 15, 16, 16, 2, -26 },
  { 453, 16, 16, 18, 1, -20 },
  { 485, 9, 10, 9, -2, -5 },
  { 497, 10, 5, 11, 0, -12 },
  { 504, 6, 6, 9, 0, -6 },
  { 509, 19, 25, 14, -2, -25 },
  { 569, 16, 25, 17, 1, -25 },
  { 619, 14, 24, 17, 3, -24 },
  { 661, 18, 25, 17, -1, -25 },
  { 718, 17, 25, 17, 0, -25 },
  { 772, 17, 24, 17, 0, -24 },
  { 823, 17, 24, 17, 1, -24 },
  { 874, 17, 25, 17, 1, -25 },
  { 928, 18, 24, 17, 1, -24 },
  { 982, 17, 25, 17, 0, -25 },
  { 1036, 16, 25, 17, 1, -25 },
  { 1086, 9, 19, 9, 0, -19 },
  { 1108, 11, 24, 9, -2, -19 },
  { 1141, 16, 17, 18, 1, -21 },
  { 1175, 16, 12, 18, 1, -18 },
  { 1199, 16, 17, 18, 1, -21 },
  { 1233, 14, 25, 14, 1, -25 },
  { 1277, 25, 28, 26, 1, -25 },
  { 1365, 20, 24, 20, -2, -24 },
  { 1425, 19, 24, 19, 0, -24 },
  { 1482, 18, 25, 18, 1, -25 },
  { 1539, 20, 24, 20, 0, -24 },
  { 1599, 17, 24, 16, 0, -24 },
  { 1650, 17, 24, 16, 0, -24 },
  { 1701, 20, 25, 20, 1, -25 },
  { 1764, 22, 24, 21, 0, -24 },
  { 1830, 17, 24, 13, -1, -24 },
  { 1881, 16, 32, 10, -5, -24 },
  { 1945, 22, 24, 19, 0, -24 },
  { 2011, 13, 24, 15, 0, -24 },
  { 2050, 28, 24, 27, 0, -24 },
  { 2134, 24, 24, 22, 0, -24 },
  { 2206, 20, 25, 21, 1, -25 },
  { 2269, 18, 24, 18, 0, -24 },
  { 2323, 20, 31, 21, 1, -25 },
  { 2401, 19, 24, 19, 0, -24 },
  { 2458, 17, 25, 16, 0, -25 },
  { 2512, 15, 24, 16, 3, -24 },
  { 2557, 20, 24, 20, 1, -24 },
  { 2617, 19, 24, 19, 3, -24 },
  { 2674, 27, 24, 27, 3, -24 },
  { 2755, 23, 24, 19, -2, -24 },
  { 2824, 18, 24, 18, 3, -24 },
  { 2878, 19, 24, 16, -1, -24 },
  { 2935, 14, 31, 11, -1, -25 },
  { 2990, 9, 25, 14, 3, -25 },
  { 3019, 15, 31, 11, -3, -25 },
  { 3078, 18, 16, 17, -1, -24 },
  { 3114, 14, 4, 14, -3, 2 },
  { 3121, 8, 5, 11, 5, -26 },
  { 3126, 17, 19, 18, 1, -19 },
  { 3167, 17, 26, 18, 0, -26 },
  { 3223, 14, 19, 15, 1, -19 },
  { 3257, 18, 26, 18, 1, -26 },
  { 3316, 16, 19, 17, 1, -19 },
  { 3354, 19, 34, 12, -4, -26 },
  { 3435, 19, 27, 18, -1, -19 },
  { 3500, 17, 26, 18, 0, -26 },
  { 3556, 11, 26, 9, 0, -26 },
  { 3592, 15, 34, 9, -4, -26 },
  { 3656, 20, 26, 18, 0, -26 },
  { 3721, 11, 26, 9, 0, -26 },
  { 3757, 26, 19, 27, 0, -19 },
  { 3819, 17, 19, 18, 0, -19 },
  { 3860, 16, 19, 18, 1, -19 },
  { 3898, 19, 27, 18, -2, -19 },
  { 3963, 17, 27, 18, 1, -19 },
  { 4021, 14, 19, 13, 0, -19 },
  { 4055, 15, 19, 14, 0, -19 },
  { 4091, 13, 23, 13, 1, -23 },
  { 4129, 17, 19, 18, 1, -19 },
  { 4170, 16, 19, 16, 2, -19 },
  { 4208, 24, 19, 25, 2, -19 },
  { 4265, 21, 19, 17, -2, -19 },
  { 4315, 20, 27, 16, -2, -19 },
  { 4383, 16, 19, 14, -1, -19 },
  { 4421, 14, 29, 12, 0, -24 },
  { 4472, 5, 34, 15, 5, -26 },
  { 4494, 14, 29, 12, -2, -24 },
  { 4545, 16, 6, 18, 1, -15 },
};

const GFXfont NotoSans_Condensed_BlackItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC34PT7B_H_
