#ifndef _NOTOSANS_CONDENSED_BLACKITALIC69PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xE3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0x87,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07,
  0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0x8F, 0x80, 0x1F, 0xF9, 0xE0, 0x70, 0x03,
  0xFF, 0x3C, 0x02, 0x00, 0x7F, 0xE7, 0x80, 0x00, 0x1F, 0xFC, 0xF0, 0x00,
  0x03, 0xFF, 0xBC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0x3F, 0xF0, 0x20, 0x01,
  0xE7, 0xFE, 0x03, 0x00, 0x3C, 0xFF, 0xC0, 0x70, 0x07, 0x9F, 0xF8, 0x1F,
  0x81, 0xE7, 0xFF, 0x03, 0xFE, 0x3D, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F,
  0xE3, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF,
  0x00, 0x00, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F,
  0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0xFF, 0x81, 0xFE, 0x0F, 0xF0,
  0xFF, 0x8F, 0xF8, 0x7F, 0xF8, 0xFF, 0x9F, 0xF1, 0xFF, 0x0F, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0xC1, 0xFF, 0x1F, 0xF1, 0xFF, 0x03, 0xF0, 0x3F,
  0xE3, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x00,
  0x00, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFE, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x01, 0x80, 0xFF, 0x80, 0x0F, 0x03, 0xFE, 0x00, 0x3F, 0x0F, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x17, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFB, 0xFF,
  0x00, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xF8, 0x7F, 0xF0,
  0x07, 0xE0, 0xFF, 0x80, 0x0F, 0x03, 0xF8, 0x00, 0x18, 0x0F, 0xC0, 0x00,
  0x20, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFB, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x81,
  0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xE0,
  0x3F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8,
  0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xCF, 0xFF,
  0x03, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xF3, 0xFF,
  0xC0, 0x7F, 0xF9, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F,
  0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC1,
  0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF7,
  0xFF, 0x03, 0xFE, 0xFF, 0xF0, 0x3F, 0x8F, 0xFF, 0x01, 0xF0, 0xFF, 0xF0,
  0x0E, 0x0F, 0xFE, 0x00, 0xC1, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xFF,
  0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0xFF, 0x00, 0x0C, 0x00,
  0xFF, 0xF0, 0x00, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x1F, 0xFF, 0x80, 0x1E, 0x01, 0xFF, 0xF0, 0x03, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE1, 0x00, 0x00, 0x7F,
  0xFC, 0x30, 0x00, 0x1F, 0xFF, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xCF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x3F,
  0xE7, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0x3F, 0xFC, 0x00,
  0x7F, 0xC7, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xE0, 0x03, 0xFE, 0x3F, 0xFC,
  0x00, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xF0, 0x07, 0xFC, 0x1F,
  0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x08,
  0x00, 0x07, 0xFF, 0x81, 0x80, 0x01, 0xFF, 0xF0, 0x3E, 0x00, 0x7F, 0xFE,
  0x07, 0xFC, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x06, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC3, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0x80,
  0x0F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xDF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE7,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF3, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x07,
  0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x81,
  0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x7F, 0xF0, 0x0F,
  0xFF, 0x7F, 0xF0, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x1C, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xE1, 0xFF, 0xF0, 0xF8,
  0x0F, 0xFF, 0x0E, 0x00, 0x7F, 0xF0, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0x07,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0,
  0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x83, 0xFF, 0xFF, 0xF0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F,
  0xF3, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0,
  0xFF, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x3F, 0xDF, 0xE1, 0xFF, 0x03, 0xFC,
  0x0F, 0xE7, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xBF, 0xC3, 0xFE, 0x07,
  0xF8, 0x1F, 0xCF, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0xE0,
  0xFF, 0x83, 0xFC, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFE,
  0x1F, 0xF0, 0x7F, 0x8F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0xF7, 0xFF, 0xBF, 0xE0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xFE, 0xFF, 0xFE, 0x03, 0xFC,
  0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF,
  0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFF, 0x8F,
  0xFC, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x1F,
  0xFE, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC7,
  0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1E, 0x00, 0x7F, 0xFE, 0x00, 0x30, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFC, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x7F, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0x00, 0x7F, 0xFF, 0x00, 0x06, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x10, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x9F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xEF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF7, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFB, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xC7, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xE7, 0xFE, 0xFF, 0xE0,
  0x03, 0xFF, 0xBF, 0xF3, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xFB, 0xFF,
  0x3F, 0xF8, 0x00, 0xFF, 0xEF, 0xFD, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xF7,
  0xFE, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFE, 0x00,
  0x3F, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xE0, 0x03,
  0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0xFF, 0xE0, 0x03, 0xFF,
  0xBF, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF,
  0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF,
  0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF,
  0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE1, 0xFF, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0x8F,
  0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x03, 0xFF, 0xDF, 0xFF, 0x00,
  0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF7, 0xFF, 0xC0,
  0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFF,
  0xBF, 0xFC, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xF0,
  0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF,
  0xC7, 0xFF, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF8,
  0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x0F, 0xFF,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xF8,
  0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x01, 0xFF,
  0xEF, 0xFF, 0x80, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x0F, 0xFF, 0xBF, 0xFE,
  0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFF,
  0x80, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xF9, 0xFF,
  0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x1F,
  0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFF, 0x80,
  0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0xE0, 0x07,
  0xFF, 0x80, 0x04, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x04, 0x00, 0x0F, 0xFF, 0x80, 0xE0, 0x01, 0xFF, 0xF0,
  0x1F, 0x00, 0x3F, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0x00,
  0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xF3,
  0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x01, 0xFF,
  0xCF, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFF,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xBF, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xE1,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFC,
  0x00, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0xFF,
  0x9F, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x7F, 0xCF, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0x3F, 0xEF, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0xBF, 0xF7, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xCF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x7F,
  0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x3F, 0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFD,
  0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xC0, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x7F,
  0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x03, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF9,
  0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x20,
  0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0x00, 0x7F, 0xFE, 0x7F,
  0xE0, 0x1F, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xE7, 0xFE,
  0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC3, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8,
  0x01, 0xFF, 0xDF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF9, 0xFF, 0xF8, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0xF0, 0x3F, 0xFE,
  0x01, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x04, 0x0F,
  0xFF, 0x00, 0xE0, 0x7F, 0xFC, 0x3F, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00,
  0xFF, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC7, 0xFF,
  0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC3,
  0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xE0, 0x00,
  0xFF, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x1F,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x07, 0xFF, 0x1F, 0xFE, 0x07, 0xFE, 0x3F, 0xFC, 0x07, 0xFE, 0x3F,
  0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x7F, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xC0, 0xFF, 0xF0, 0x03, 0xC0, 0xFF, 0xFE, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x82, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x33, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x04, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xF1, 0xFF, 0x80, 0x07,
  0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xF3, 0xFF,
  0xC0, 0x00, 0x0C, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x20, 0x00, 0x3F, 0xFC,
  0x00, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC3, 0xF0, 0x00,
  0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xDF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x0E, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xC1,
  0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFF, 0x80, 0x03, 0xFF,
  0x8F, 0xFF, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x07, 0xFF, 0xBF, 0xFC,
  0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0xF8, 0xFF, 0xFE,
  0x01, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x3F,
  0xFC, 0x00, 0xFF, 0xCF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF,
  0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFE, 0x0F, 0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F,
  0xFC, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F,
  0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF,
  0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF,
  0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x00, 0xFF,
  0xCF, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFF, 0x00,
  0x03, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x10, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0xE7, 0xFE, 0x00, 0xFF,
  0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xF0, 0x00,
  0x0C, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x3F, 0xC0,
  0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF,
  0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x84, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFC, 0x3E, 0x03, 0xFF, 0xC0, 0x70, 0x1F, 0xFE, 0x00, 0x80, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF1, 0x00, 0x0F, 0xFF, 0x8E, 0x00, 0x7F, 0xF8, 0x7E,
  0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x8E, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0xBF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0xE3, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xDF, 0xFE, 0x03,
  0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xC0,
  0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0xC0, 0x1F,
  0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xEF, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFC, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0x8F,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0x0F, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xE0, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xFF, 0x1F,
  0xFC, 0x0F, 0xFE, 0x7F, 0xBF, 0xCF, 0xFE, 0x03, 0xFF, 0xBF, 0xEF, 0xF3,
  0xFF, 0x80, 0xFF, 0xEF, 0xFB, 0xFC, 0xFF, 0xE0, 0x3F, 0xFB, 0xFD, 0xFF,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0x7F, 0xDF, 0xFC, 0x03, 0xFF, 0x7F, 0xDF,
  0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xE7, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x8F, 0xFF,
  0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x8F, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0xFF, 0xE7,
  0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x02, 0x3F, 0xFC, 0x00, 0x05, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC8, 0x00, 0x03, 0xFE,
  0x00,
};

const GFXglyph NotoSans_Condensed_BlackItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 22, 50, 19, 0, -49 },
  { 139, 29, 18, 31, 6, -49 },
  { 205, 41, 49, 39, 0, -49 },
  { 457, 35, 56, 35, 1, -52 },
  { 702, 52, 51, 57, 4, -50 },
  { 1034, 44, 51, 44, 0, -50 },
  { 1315, 14, 18, 17, 6, -49 },
  { 1347, 26, 62, 21, 1, -51 },
  { 1549, 25, 62, 21, -5, -51 },
  { 1743, 30, 33, 33, 5, -53 },
  { 1867, 31, 33, 36, 3, -41 },
  { 1995, 18, 18, 19, -4, -9 },
  { 2036, 20, 11, 22, 1, -24 },
  { 2064, 13, 13, 19, 0, -12 },
  { 2086, 39, 51, 29, -4, -50 },
  { 2335, 33, 51, 35, 2, -50 },
  { 2546, 28, 49, 35, 6, -49 },
  { 2718, 36, 50, 35, -2, -50 },
  { 2943, 35, 51, 35, 0, -50 },
  { 3167, 35, 49, 35, 0, -49 },
  { 3382, 35, 50, 35, 1, -49 },
  { 3601, 35, 51, 35, 2, -50 },
  { 3825, 36, 49, 35, 2, -49 },
  { 4046, 34, 51, 35, 1, -50 },
  { 4263, 33, 51, 35, 2, -50 },
  { 4474, 19, 40, 19, 0, -39 },
  { 4569, 23, 48, 19, -4, -39 },
  { 4707, 31, 36, 36, 3, -43 },
  { 4847, 31, 25, 36, 3, -37 },
  { 4944, 31, 36, 36, 3, -43 },
  { 5084, 28, 51, 28, 3, -50 },
  { 5263, 50, 56, 53, 2, -50 },
  { 5613, 40, 49, 40, -4, -49 },
  { 5858, 38, 49, 38, 0, -49 },
  { 6091, 37, 51, 36, 3, -50 },
  { 6327, 40, 49, 40, 0, -49 },
  { 6572, 35, 49, 32, 0, -49 },
  { 6787, 35, 49, 31, 0, -49 },
  { 7002, 39, 51, 41, 3, -50 },
  { 7251, 44, 49, 42, 0, -49 },
  { 7521, 35, 49, 27, -3, -49 },
  { 7736, 34, 64, 21, -11, -49 },
  { 8008, 45, 49, 39, 0, -49 },
  { 8284, 27, 49, 30, 0, -49 },
  { 8450, 57, 49, 55, 0, -49 },
  { 8800, 48, 49, 46, 0, -49 },
  { 9094, 39, 51, 43, 3, -50 },
  { 9343, 37, 49, 36, 0, -49 },
  { 9570, 39, 62, 43, 3, -50 },
  { 9873, 38, 49, 38, 0, -49 },
  { 10106, 35, 51, 32, 0, -50 },
  { 10330, 32, 49, 32, 5, -49 },
  { 10526, 40, 50, 41, 3, -49 },
  { 10776, 38, 49, 38, 6, -49 },
  { 11009, 57, 49, 55, 5, -49 },
  { 11359, 47, 49, 38, -4, -49 },
  { 11647, 36, 49, 36, 6, -49 },
  { 11868, 40, 49, 32, -3, -49 },
  { 12113, 30, 63, 21, -3, -51 },
  { 12350, 17, 51, 29, 7, -50 },
  { 12459, 29, 63, 21, -5, -51 },
  { 12688, 35, 32, 34, -1, -49 },
  { 12828, 30, 9, 28, -7, 4 },
  { 12862, 15, 11, 23, 10, -53 },
  { 12883, 35, 40, 36, 2, -39 },
  { 13058, 35, 53, 36, 0, -52 },
  { 13290, 29, 40, 30, 2, -39 },
  { 13435, 38, 53, 36, 2, -52 },
  { 13687, 32, 40, 34, 2, -39 },
  { 13847, 38, 70, 23, -7, -53 },
  { 14180, 38, 56, 36, -1, -39 },
  { 14446, 35, 52, 37, 0, -52 },
  { 14674, 22, 54, 19, 0, -54 },
  { 14823, 31, 71, 19, -9, -54 },
  { 15099, 40, 52, 36, 0, -52 },
  { 15359, 22, 52, 19, 0, -52 },
  { 15502, 52, 39, 54, 0, -39 },
  { 15756, 35, 39, 37, 0, -39 },
  { 15927, 32, 40, 36, 2, -39 },
  { 16087, 39, 56, 36, -4, -39 },
  { 16360, 36, 56, 36, 1, -39 },
  { 16612, 29, 39, 26, 0, -39 },
  { 16754, 29, 40, 29, 0, -39 },
  { 16899, 25, 47, 26, 3, -46 },
  { 17046, 35, 39, 37, 2, -38 },
  { 17217, 33, 38, 33, 4, -38 },
  { 17374, 50, 38, 50, 4, -38 },
  { 17612, 42, 38, 34, -4, -38 },
  { 17812, 41, 55, 33, -4, -38 },
  { 18094, 33, 38, 29, -2, -38 },
  { 18251, 29, 60, 24, 0, -49 },
  { 18469, 10, 69, 31, 10, -53 },
  { 18556, 28, 60, 24, -4, -49 },
  { 18766, 31, 13, 36, 3, -31 },
};

const GFXfont NotoSans_Condensed_BlackItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC69PT7B_H_
