#ifndef _NOTOSANS_CONDENSED_BLACKITALIC17PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x77, 0x39, 0xCC, 0x03, 0x39, 0xC0, 0xEF, 0xDB, 0x76,
  0xE0, 0x0D, 0xC3, 0x61, 0xD9, 0xFF, 0x7F, 0xC6, 0xC3, 0x73, 0xFE, 0xFF,
  0x99, 0x86, 0xC1, 0xB0, 0x06, 0x07, 0x8F, 0xE7, 0xE3, 0x41, 0xC0, 0xF8,
  0x3C, 0x0F, 0x27, 0xBF, 0x9F, 0x81, 0x00, 0x80, 0x78, 0x63, 0xE6, 0x33,
  0x71, 0xBB, 0x0D, 0xB0, 0x7D, 0xFB, 0xDB, 0x61, 0xBB, 0x0D, 0x98, 0xCD,
  0x8E, 0x7C, 0xE1, 0xC0, 0x0F, 0x03, 0xF0, 0xEE, 0x1D, 0xC3, 0xF0, 0x7D,
  0xDF, 0xF7, 0x7E, 0xE7, 0x9C, 0xF3, 0xFE, 0x3F, 0xE0, 0xFF, 0x60, 0x1E,
  0x30, 0xE1, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x0C, 0x18,
  0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8C, 0x71, 0x8C,
  0x00, 0x1C, 0x58, 0x7A, 0xFF, 0x3F, 0x7C, 0xEE, 0x28, 0x38, 0x70, 0xE7,
  0xFF, 0xE7, 0x0E, 0x1C, 0x77, 0x6E, 0x7F, 0xFE, 0x7F, 0x80, 0x03, 0xC0,
  0xE0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x03,
  0x80, 0x3E, 0x7E, 0x76, 0xE7, 0xE7, 0xEE, 0xEE, 0xCE, 0xCE, 0xDC, 0xFC,
  0xF0, 0x0E, 0x3C, 0xFF, 0xF7, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC0,
  0x1F, 0x3F, 0x37, 0x27, 0x07, 0x0E, 0x1C, 0x3C, 0x78, 0xFE, 0xFE, 0xFE,
  0x3F, 0x1F, 0x89, 0xE0, 0xE0, 0xF1, 0xE0, 0xF8, 0x1E, 0x07, 0x47, 0x3F,
  0x9F, 0x80, 0x07, 0x83, 0x83, 0xC3, 0xE1, 0xF1, 0xB1, 0xB9, 0xFE, 0xFF,
  0x7F, 0x83, 0x03, 0x80, 0x1F, 0x8F, 0x8E, 0x07, 0x03, 0xE3, 0xF0, 0xBC,
  0x0E, 0x07, 0x67, 0x3F, 0x9F, 0x80, 0x1F, 0x3F, 0x78, 0x70, 0xFC, 0xFE,
  0xEE, 0xEE, 0xCE, 0xFE, 0xFC, 0x78, 0x3F, 0x9F, 0xC0, 0xE0, 0xE0, 0x70,
  0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x00, 0x1F, 0x1F, 0xCE, 0xE7,
  0x63, 0xF0, 0xF0, 0xF8, 0xEE, 0xE7, 0x73, 0xBF, 0x8F, 0x80, 0x1E, 0x1F,
  0x9E, 0xCE, 0x77, 0x73, 0xB9, 0xFC, 0x7E, 0x0E, 0x4F, 0x3F, 0x1F, 0x00,
  0x11, 0xDE, 0x60, 0x00, 0x0C, 0xE7, 0x00, 0x08, 0x73, 0xC6, 0x00, 0x00,
  0x00, 0x71, 0xC6, 0x38, 0x06, 0x3D, 0xF7, 0x8F, 0x07, 0xC3, 0x81, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0xC1, 0xE1, 0xF0, 0xF1, 0xFF, 0xB8, 0x40,
  0x7D, 0xFD, 0x38, 0x61, 0xC7, 0x1C, 0x30, 0x01, 0xC3, 0x87, 0x00, 0x07,
  0xE0, 0xF3, 0x8E, 0x0E, 0x6F, 0xB6, 0x6D, 0xB6, 0x6D, 0xB6, 0x6B, 0xB6,
  0xCF, 0xF3, 0x77, 0x18, 0x00, 0xE3, 0x03, 0xF8, 0x00, 0x07, 0x81, 0xE0,
  0xF8, 0x3E, 0x1D, 0x87, 0x71, 0x9C, 0xFF, 0x3F, 0xDF, 0xF7, 0x1F, 0x87,
  0x3F, 0x9F, 0xCE, 0xE7, 0x73, 0xBB, 0xF9, 0xFC, 0xEF, 0x77, 0x3F, 0xBF,
  0xDF, 0x80, 0x1F, 0x9F, 0x9E, 0x4E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x72, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0xE3, 0xBC, 0xE7, 0x39, 0xDC, 0x77,
  0x3D, 0xCE, 0x77, 0x9F, 0xCF, 0xE3, 0xF0, 0x3F, 0x9F, 0x8E, 0x07, 0x03,
  0xE3, 0xF1, 0xF8, 0xE0, 0x70, 0x3F, 0x3F, 0x1F, 0x80, 0x3F, 0x9F, 0x8E,
  0x07, 0x03, 0x83, 0xF1, 0xF8, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x00, 0x1F,
  0x9F, 0xDE, 0x4E, 0x0E, 0x07, 0x7F, 0xBD, 0xCE, 0xE7, 0x73, 0xBF, 0xCF,
  0xC0, 0x3C, 0xE7, 0x18, 0xE7, 0x1C, 0xE3, 0xFC, 0xFF, 0x9F, 0xE3, 0x9C,
  0x73, 0x8E, 0x73, 0x8E, 0x73, 0x80, 0x1F, 0x8F, 0x83, 0x81, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x1C, 0x1F, 0x9F, 0x80, 0x03, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC3, 0xE3,
  0xE1, 0xE0, 0x3D, 0xE7, 0x38, 0xEE, 0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0x77, 0x0E, 0xE3, 0x9C, 0x73, 0xC0, 0x3C, 0x70, 0xE1, 0xC3, 0x8E,
  0x1C, 0x38, 0x70, 0xFF, 0xF7, 0xE0, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F,
  0xBE, 0x3E, 0xF9, 0xFF, 0xE7, 0xFB, 0x9F, 0xEC, 0x6F, 0x71, 0xBD, 0xCE,
  0xF7, 0x3B, 0x98, 0x3C, 0x73, 0xC6, 0x3C, 0xE3, 0xEE, 0x3E, 0xE7, 0xEE,
  0x76, 0xC7, 0x7C, 0x67, 0xC6, 0x7C, 0xE3, 0xCE, 0x38, 0x1F, 0x1F, 0xDE,
  0xEE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0x77, 0xBF, 0x8F, 0x80, 0x3F,
  0x1F, 0xCE, 0xE7, 0x73, 0xBB, 0xFD, 0xFC, 0xFC, 0x70, 0x38, 0x38, 0x1C,
  0x00, 0x1F, 0x1F, 0xDE, 0xEE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0x77,
  0xBF, 0x8F, 0x81, 0xC0, 0x70, 0x38, 0x3F, 0x1F, 0xCE, 0xE7, 0x73, 0xBB,
  0xFD, 0xFC, 0xFC, 0x7E, 0x33, 0xB9, 0xDC, 0xF0, 0x1F, 0x9F, 0x8E, 0xCE,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x8E, 0x7F, 0x3F, 0x1F, 0x00, 0x7F, 0xFF,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x79, 0xDC,
  0xE7, 0x39, 0xCE, 0x73, 0xB9, 0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0x8F, 0xE1,
  0xF0, 0xE3, 0xD8, 0xE6, 0x39, 0x9C, 0x67, 0x1B, 0x86, 0xE1, 0xB0, 0x7C,
  0x1E, 0x07, 0x81, 0xC0, 0xE3, 0x9F, 0x9E, 0x7E, 0x73, 0xB9, 0xCE, 0xEF,
  0x73, 0xBD, 0xCF, 0xF7, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x0F, 0x3C, 0x3C,
  0xF0, 0x1C, 0xF1, 0xDE, 0x1D, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01,
  0xF0, 0x3F, 0x03, 0xB8, 0x73, 0x8F, 0x38, 0xE7, 0xEE, 0xEE, 0xFC, 0xFC,
  0x78, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x1F, 0xC7, 0xF2, 0x38, 0x1E,
  0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1F, 0xC7, 0xF3, 0xFC, 0x1F, 0x1E,
  0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x78,
  0xF0, 0xCC, 0xEE, 0xE6, 0x66, 0x67, 0x77, 0x1E, 0x3C, 0x30, 0x61, 0xC3,
  0x87, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x1E, 0x3C, 0x00, 0x0E, 0x0E, 0x1E,
  0x1E, 0x36, 0x77, 0x63, 0xC3, 0x7F, 0xFE, 0xF7, 0x30, 0x08, 0x1F, 0xDF,
  0xEE, 0xE7, 0x73, 0x3B, 0x9D, 0xDE, 0x7E, 0x3B, 0x00, 0x1C, 0x1C, 0x0E,
  0x07, 0x43, 0xF3, 0xF9, 0xCE, 0xE6, 0x77, 0x33, 0xBD, 0xDF, 0xCD, 0xC0,
  0x0C, 0x3F, 0x3E, 0x70, 0x70, 0x60, 0xE0, 0xF4, 0x7C, 0x7C, 0x01, 0xC0,
  0x60, 0x38, 0x2E, 0x3F, 0x9F, 0xE7, 0x71, 0xDC, 0x67, 0x39, 0xCE, 0xF1,
  0xF8, 0x76, 0x00, 0x04, 0x3F, 0x3F, 0x73, 0x7F, 0x7E, 0xE0, 0xE2, 0x7E,
  0x3E, 0x03, 0xC1, 0xE0, 0x68, 0x3A, 0x1F, 0x07, 0xC0, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x0B, 0x83, 0xC0, 0xF0, 0x00, 0x08,
  0x1F, 0xCF, 0xEE, 0xE7, 0x73, 0x3B, 0x9D, 0xDE, 0x7E, 0x3F, 0x03, 0x93,
  0xCF, 0xC7, 0xC0, 0x1C, 0x1C, 0x0E, 0x07, 0x43, 0xF3, 0xFD, 0xCE, 0xEE,
  0x77, 0x3B, 0xB9, 0xDC, 0xEE, 0xE0, 0x19, 0xC6, 0x03, 0x99, 0xCE, 0x73,
  0xB9, 0xCE, 0x00, 0x06, 0x1C, 0x18, 0x00, 0xE1, 0x87, 0x0E, 0x1C, 0x38,
  0xE1, 0xC3, 0x87, 0x3C, 0x78, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0xE1, 0x3B,
  0x9D, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xE3, 0xBC, 0xE7, 0x00, 0x1C,
  0xE3, 0x8E, 0x39, 0xC7, 0x1C, 0x71, 0xCE, 0x38, 0xE0, 0x02, 0x31, 0xFB,
  0xDF, 0xFE, 0xE7, 0x77, 0x73, 0xBB, 0x99, 0xDD, 0xDC, 0xEE, 0xE6, 0x77,
  0x73, 0x80, 0x02, 0x1F, 0x9F, 0xEE, 0x77, 0x73, 0xB9, 0xDD, 0xCE, 0xE7,
  0x77, 0x00, 0x0C, 0x3F, 0x3F, 0x77, 0x77, 0x67, 0xE7, 0xEF, 0x7E, 0x7C,
  0x01, 0x07, 0xE1, 0xF8, 0xE7, 0x39, 0x8E, 0xE3, 0x39, 0xEE, 0x7F, 0x1F,
  0x87, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x08, 0x1F, 0xCF, 0xEE, 0xE7, 0x73,
  0x3B, 0x9D, 0xDE, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x02, 0x6C,
  0xFB, 0xD7, 0x0E, 0x1C, 0x70, 0xE1, 0xC0, 0x18, 0x7D, 0xFB, 0x87, 0x87,
  0x87, 0x4E, 0xFD, 0xF0, 0x30, 0xCF, 0xFE, 0x63, 0x8E, 0x38, 0xEB, 0xCF,
  0x00, 0x3B, 0xB9, 0xDC, 0xEE, 0xE7, 0x73, 0x3B, 0xFC, 0xFC, 0x76, 0x00,
  0xE7, 0xEE, 0xEE, 0xFC, 0xFC, 0xF8, 0xF8, 0xF0, 0x70, 0xEF, 0x7E, 0xF6,
  0xFE, 0xEF, 0xEE, 0xFE, 0xCF, 0x7C, 0xF7, 0x8F, 0x78, 0xE7, 0x00, 0x3B,
  0xC7, 0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xF1, 0xDC, 0xF7, 0x00, 0x39,
  0xCE, 0xE3, 0xB8, 0xFC, 0x3F, 0x0F, 0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x0B,
  0x83, 0xC0, 0xE0, 0x00, 0x3F, 0x9F, 0x83, 0x81, 0xC1, 0xC1, 0xC1, 0xC0,
  0xFC, 0xFE, 0x00, 0x0E, 0x3C, 0x70, 0xC3, 0x87, 0x3C, 0x70, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x78,
  0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x3C, 0x70, 0xC3, 0x8F, 0x1E, 0x30, 0x00,
  0x63, 0xFF, 0xFC, 0x20,
};

const GFXglyph NotoSans_Condensed_BlackItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 12, 5, 0, -12 },
  { 9, 7, 4, 8, 2, -12 },
  { 13, 10, 12, 10, 0, -12 },
  { 28, 9, 14, 9, 0, -13 },
  { 44, 13, 12, 14, 1, -12 },
  { 64, 11, 12, 11, 0, -12 },
  { 81, 3, 4, 4, 2, -12 },
  { 83, 7, 15, 5, 0, -12 },
  { 97, 6, 15, 5, -1, -12 },
  { 109, 8, 8, 8, 1, -13 },
  { 117, 7, 8, 9, 1, -10 },
  { 124, 4, 4, 5, -1, -2 },
  { 126, 5, 3, 5, 0, -6 },
  { 128, 3, 3, 5, 0, -3 },
  { 130, 10, 12, 7, -1, -12 },
  { 145, 8, 12, 9, 1, -12 },
  { 157, 7, 12, 9, 1, -12 },
  { 168, 8, 12, 9, 0, -12 },
  { 180, 9, 12, 9, 0, -12 },
  { 194, 9, 12, 9, 0, -12 },
  { 208, 9, 12, 9, 0, -12 },
  { 222, 8, 12, 9, 1, -12 },
  { 234, 9, 12, 9, 0, -12 },
  { 248, 9, 12, 9, 0, -12 },
  { 262, 9, 12, 9, 0, -12 },
  { 276, 5, 10, 5, 0, -10 },
  { 283, 6, 12, 5, -1, -10 },
  { 292, 7, 8, 9, 1, -10 },
  { 299, 7, 6, 9, 1, -9 },
  { 305, 7, 8, 9, 1, -10 },
  { 312, 7, 12, 7, 1, -12 },
  { 323, 13, 13, 13, 0, -12 },
  { 345, 10, 12, 10, -1, -12 },
  { 360, 9, 12, 9, 0, -12 },
  { 374, 9, 12, 9, 1, -12 },
  { 388, 10, 12, 10, 0, -12 },
  { 403, 9, 12, 8, 0, -12 },
  { 417, 9, 12, 8, 0, -12 },
  { 431, 9, 12, 10, 1, -12 },
  { 445, 11, 12, 10, 0, -12 },
  { 462, 9, 12, 7, -1, -12 },
  { 476, 9, 16, 5, -3, -12 },
  { 494, 11, 12, 10, 0, -12 },
  { 511, 7, 12, 7, 0, -12 },
  { 522, 14, 12, 13, 0, -12 },
  { 543, 12, 12, 11, 0, -12 },
  { 561, 9, 12, 11, 1, -12 },
  { 575, 9, 12, 9, 0, -12 },
  { 589, 9, 15, 11, 1, -12 },
  { 606, 9, 12, 9, 0, -12 },
  { 620, 9, 12, 8, 0, -12 },
  { 634, 8, 12, 8, 1, -12 },
  { 646, 10, 12, 10, 1, -12 },
  { 661, 10, 12, 9, 1, -12 },
  { 676, 14, 12, 14, 1, -12 },
  { 697, 12, 12, 9, -1, -12 },
  { 715, 8, 12, 9, 2, -12 },
  { 727, 10, 12, 8, -1, -12 },
  { 742, 8, 15, 5, -1, -12 },
  { 757, 4, 12, 7, 2, -12 },
  { 763, 7, 15, 5, -1, -12 },
  { 777, 8, 8, 8, 0, -12 },
  { 785, 8, 2, 7, -2, 1 },
  { 787, 4, 3, 6, 2, -13 },
  { 789, 9, 10, 9, 0, -10 },
  { 801, 9, 13, 9, 0, -13 },
  { 816, 8, 10, 7, 0, -10 },
  { 826, 10, 13, 9, 0, -13 },
  { 843, 8, 10, 8, 0, -10 },
  { 853, 10, 17, 6, -2, -13 },
  { 875, 9, 14, 9, 0, -10 },
  { 891, 9, 13, 9, 0, -13 },
  { 906, 5, 13, 5, 0, -13 },
  { 915, 7, 17, 5, -2, -13 },
  { 930, 10, 13, 9, 0, -13 },
  { 947, 6, 13, 5, 0, -13 },
  { 957, 13, 10, 13, 0, -10 },
  { 974, 9, 10, 9, 0, -10 },
  { 986, 8, 10, 9, 0, -10 },
  { 996, 10, 14, 9, -1, -10 },
  { 1014, 9, 14, 9, 0, -10 },
  { 1030, 7, 10, 6, 0, -10 },
  { 1039, 7, 10, 7, 0, -10 },
  { 1048, 6, 11, 6, 1, -11 },
  { 1057, 9, 9, 9, 0, -9 },
  { 1068, 8, 9, 8, 1, -9 },
  { 1077, 12, 9, 12, 1, -9 },
  { 1091, 10, 9, 8, -1, -9 },
  { 1103, 10, 13, 8, -1, -9 },
  { 1120, 9, 9, 7, -1, -9 },
  { 1131, 7, 15, 6, 0, -12 },
  { 1145, 2, 17, 8, 3, -13 },
  { 1150, 7, 15, 6, -1, -12 },
  { 1164, 7, 4, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_BlackItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC17PT7B_H_
