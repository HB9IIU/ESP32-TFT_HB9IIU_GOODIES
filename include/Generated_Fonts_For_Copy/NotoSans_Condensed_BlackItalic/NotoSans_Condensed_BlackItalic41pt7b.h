#ifndef _NOTOSANS_CONDENSED_BLACKITALIC41PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xC0,
  0x00, 0x7F, 0x3F, 0xBF, 0x9F, 0x9F, 0x9F, 0xCF, 0xCF, 0xE7, 0xE7, 0xE7,
  0xF3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0x7C, 0x7E, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x03,
  0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x0F, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xDB,
  0xC1, 0xFB, 0x84, 0x1F, 0xB8, 0x01, 0xFB, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xDF, 0x88, 0x0C, 0xF8, 0xE0, 0xDF, 0x8F,
  0x9F, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x3F, 0xE0, 0x1F,
  0x00, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xC0, 0xF8, 0x07, 0xCF, 0x83, 0xE0,
  0x1F, 0x9F, 0x07, 0xC0, 0x3E, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x7E, 0x00,
  0xF8, 0xF8, 0xF8, 0x03, 0xF3, 0xF3, 0xE0, 0x07, 0xC7, 0xCF, 0xC0, 0x0F,
  0x8F, 0x9F, 0x1F, 0x1F, 0x3F, 0x7E, 0x7F, 0xBF, 0xFC, 0xF9, 0xFF, 0xBF,
  0xF3, 0xE7, 0xFF, 0x7F, 0xEF, 0xDF, 0xFE, 0x7F, 0x9F, 0x3E, 0x7C, 0x18,
  0x7C, 0xFC, 0xF8, 0x00, 0xF9, 0xF1, 0xF0, 0x03, 0xE3, 0xE3, 0xE0, 0x0F,
  0xC7, 0xC7, 0xC0, 0x1F, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x3E, 0x01, 0xF8,
  0x3E, 0x7C, 0x03, 0xE0, 0x7D, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0, 0x1F, 0x01,
  0xFF, 0x80, 0x7C, 0x01, 0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x07, 0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFC, 0x3F,
  0xFC, 0xFF, 0x1F, 0xFF, 0x3F, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1,
  0xFC, 0xFF, 0xFC, 0x7F, 0x3F, 0xFE, 0x3F, 0x87, 0xFF, 0x0F, 0xE1, 0xFF,
  0xC3, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0xFE, 0xFC, 0xFC, 0xFC, 0xF8, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x21,
  0xF0, 0x1E, 0x7C, 0x07, 0xFF, 0x09, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFD, 0xF0, 0x3E, 0x7E, 0x07, 0x1F, 0x80, 0xC3, 0x80, 0x00, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0x3F,
  0x8F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE0, 0x3F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xEF, 0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFE, 0xFE,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF3, 0xFC, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x8F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0,
  0xFE, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xBF, 0x87, 0x1F, 0xC1, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x78, 0x7F, 0x01, 0x83, 0xF8, 0x08, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0x3F, 0xE0, 0x40,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE2, 0x00, 0x7F, 0x18, 0x07, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFB, 0xF8, 0x07, 0xDF, 0x80, 0x7D, 0xFC, 0x07, 0xCF, 0xE0,
  0x7E, 0x7F, 0x03, 0xE3, 0xF8, 0x3E, 0x3F, 0x83, 0xF1, 0xFC, 0x1F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x88, 0x07, 0xF8, 0xC0,
  0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xF0, 0x41,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE1, 0x00, 0x7F, 0x7E,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0x9F, 0xC3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE7, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xBF, 0x87, 0xF3, 0xF8, 0xFE, 0x1F,
  0xCF, 0xE1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFE, 0x7F, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1F, 0xEF, 0xE3, 0xFC, 0xFE, 0x3F, 0x87, 0xE3, 0xF8, 0x7F,
  0x3F, 0x8F, 0xE7, 0xF8, 0xFE, 0x7F, 0x8F, 0xE7, 0xF9, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xF9,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0xE7,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x1F, 0x00, 0x00, 0xF0,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x3C, 0x00,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x07,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0x80, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3E, 0x7F, 0x30, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xBF, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x3E, 0x0F, 0x83, 0xFC, 0x7C, 0x7C, 0x3F, 0xF9, 0xF1, 0xF1, 0xFF,
  0xE7, 0xCF, 0x8F, 0xFF, 0x9F, 0x3E, 0x3E, 0x3C, 0x7D, 0xF1, 0xF1, 0xF1,
  0xF7, 0xC7, 0xC7, 0xC7, 0xDF, 0x3E, 0x1F, 0x1F, 0x78, 0xF8, 0x7C, 0x7B,
  0xE3, 0xE3, 0xE3, 0xEF, 0x9F, 0x0F, 0x8F, 0xBE, 0x7C, 0x3E, 0x3C, 0xF9,
  0xF1, 0xF9, 0xF3, 0xE7, 0xFF, 0xFF, 0x8F, 0x8F, 0xFF, 0xFC, 0x3E, 0x3F,
  0xDF, 0xE0, 0xF8, 0x7E, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x02, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F,
  0xCF, 0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE,
  0xFF, 0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFE, 0x7F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x7F, 0x8F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F,
  0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xF8, 0x18, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xFC, 0x3F,
  0x87, 0xF8, 0x3F, 0x8F, 0xF8, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xF8, 0x08, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE3, 0xFF, 0x3F, 0xC7, 0xFE, 0x7F, 0x9F, 0xFC, 0xFE, 0x3F,
  0xF9, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x3F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F,
  0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F,
  0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x0F,
  0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F,
  0x80, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFC,
  0x7D, 0xF8, 0x0F, 0xFF, 0x3F, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x81, 0xFF,
  0xF7, 0xEF, 0xE0, 0x7E, 0xFD, 0xFB, 0xF0, 0x1F, 0xBF, 0x7D, 0xFC, 0x0F,
  0xEF, 0xFF, 0x7F, 0x03, 0xFB, 0xFF, 0x9F, 0xC0, 0xFE, 0xFF, 0xE7, 0xE0,
  0x3F, 0x3F, 0xF3, 0xF8, 0x0F, 0xCF, 0xFC, 0xFE, 0x07, 0xF3, 0xFF, 0x3F,
  0x81, 0xFC, 0xFF, 0x8F, 0xE0, 0x7F, 0x3F, 0xE3, 0xF0, 0x1F, 0x8F, 0xF1,
  0xFC, 0x07, 0xE3, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F,
  0x87, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFE,
  0x07, 0xF0, 0x7F, 0xE0, 0x7F, 0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0xFE,
  0x07, 0xFF, 0x0F, 0xE0, 0x7F, 0xF0, 0xFE, 0x0F, 0xFF, 0x0F, 0xC0, 0xFF,
  0xF0, 0xFC, 0x0F, 0xFF, 0x9F, 0xC0, 0xFF, 0xF9, 0xFC, 0x0F, 0xDF, 0x9F,
  0xC1, 0xFD, 0xF9, 0xF8, 0x1F, 0xDF, 0xDF, 0x81, 0xF9, 0xFF, 0xF8, 0x1F,
  0x9F, 0xFF, 0x83, 0xF8, 0xFF, 0xF8, 0x3F, 0x8F, 0xFF, 0x03, 0xF8, 0xFF,
  0xF0, 0x3F, 0x0F, 0xFF, 0x03, 0xF0, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0x07,
  0xF0, 0x7F, 0xE0, 0x7F, 0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7E, 0x03,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xFE, 0xFF, 0x8F, 0xF0, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F,
  0x81, 0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF,
  0x3F, 0x83, 0xFC, 0x7F, 0x8F, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0x7F, 0x0F, 0xF1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE7, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xFE, 0xFF, 0x8F, 0xF0, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F, 0x81,
  0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F,
  0x83, 0xFC, 0x7F, 0x8F, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x3F, 0xC3, 0xF8, 0xFF, 0x0F, 0xEF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFB, 0xF8, 0x0F,
  0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x07, 0xF9, 0xFE, 0x1F, 0xC7,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x1C,
  0x1F, 0xE0, 0x40, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC1, 0x00, 0xFE, 0x1E, 0x0F, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83,
  0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x07,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC, 0xFE, 0x0F, 0xF3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8,
  0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0xDF, 0x81,
  0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x07, 0xF3, 0xF8, 0x1F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xF0, 0x7F, 0x3F, 0x83, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0x0F, 0xE3,
  0xF8, 0x7F, 0xC7, 0xF0, 0xFE, 0x3F, 0xF1, 0xFC, 0x3F, 0x8F, 0xFC, 0x7F,
  0x0F, 0xE3, 0xFF, 0x3F, 0x83, 0xF9, 0xFF, 0xCF, 0xE0, 0xFE, 0x7F, 0xF3,
  0xF8, 0x3F, 0xBF, 0xFD, 0xFC, 0x0F, 0xEF, 0xFF, 0x7F, 0x03, 0xFB, 0xEF,
  0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF,
  0x3F, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F,
  0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x1F, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xC7,
  0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xBF, 0x83, 0xF9,
  0xFC, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F, 0x9F, 0xE1, 0xFC, 0xFE, 0x0F, 0xEF,
  0xE0, 0x7F, 0x7F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E,
  0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x01, 0xF3, 0xF0,
  0x0F, 0xFF, 0x80, 0x7E, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0x9F, 0xC7, 0xE1, 0xF8, 0x7C, 0x01,
  0xF1, 0xF8, 0x3F, 0xDF, 0x83, 0xFE, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF9, 0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xFB, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0x80, 0xFC, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE7, 0xC0,
  0x7F, 0x7F, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0x9F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF8, 0xFC, 0x3F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x9F, 0xE3, 0xFD, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7E, 0xFF, 0x83, 0xF3, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFC, 0x21, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x0C,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x03, 0xE3, 0xF8, 0x0F, 0xF7, 0xE0, 0x3F, 0xEF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0x9F, 0xCF, 0xE1,
  0xFB, 0xF8, 0x7F, 0x7F, 0x1F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x01,
  0x1F, 0xE0, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x40, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0x03,
  0xFD, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xF7, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0x81,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE7, 0xC0, 0x7F, 0x7F, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x9F, 0xE3, 0xF8,
  0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF8, 0xFE, 0x00, 0x00, 0xE0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0x0F,
  0xE1, 0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F,
  0xCF, 0xE0, 0x1F, 0xDF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE,
  0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0xF8,
  0x1F, 0x9F, 0xE7, 0xF8, 0x3F, 0x7F, 0xDF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xF9, 0xFF, 0x3F, 0x8F,
  0xE3, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE,
  0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF1,
  0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE1,
  0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x7E, 0xFF, 0x03, 0xF7, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x9F, 0xE3, 0xF8, 0xFF, 0x1F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0x7F, 0x0F,
  0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x3F, 0x9F, 0xEF, 0xF3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xF1,
  0xF0, 0x07, 0xEF, 0xF0, 0x0F, 0xDF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFE,
  0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF7,
  0xF8, 0x0F, 0xE7, 0xC0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF1, 0xF8,
  0x3F, 0xDF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF9, 0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0x80, 0xFD, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xC7, 0x87, 0xE7, 0xC3, 0xF7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xE2, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x07, 0xF3, 0xC3, 0xF8, 0x20, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x80, 0xFE, 0x3C, 0x7F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFF, 0xE7, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0xFE, 0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xFD, 0xF8, 0x3F, 0xEF, 0xC0, 0xFC, 0x7C, 0x00, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xE7, 0xE1, 0xFE, 0x7E, 0x1F, 0xC7, 0xE1, 0xFC,
  0x7E, 0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0xFE,
  0x07, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xE1, 0xFF, 0xF8,
  0x7F, 0x8F, 0xEF, 0xE3, 0xFE, 0x3F, 0xBF, 0x8F, 0xF8, 0xFE, 0xFE, 0x3F,
  0xE7, 0xF3, 0xF9, 0xFF, 0x9F, 0xCF, 0xE7, 0xFE, 0x7E, 0x3F, 0x9F, 0xF3,
  0xF8, 0xFE, 0xFF, 0xCF, 0xC3, 0xFB, 0xFF, 0x7F, 0x0F, 0xFF, 0xFD, 0xFC,
  0x3F, 0xFD, 0xF7, 0xE0, 0xFF, 0xF7, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x0F,
  0xFE, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFF,
  0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87,
  0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF9, 0xFE, 0x03, 0xF9, 0xFC, 0x03, 0xFB,
  0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0xCF, 0xE0, 0x3F, 0x8F,
  0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x87, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF3, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0x80, 0x3E, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xF8, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8,
};

const GFXglyph NotoSans_Condensed_BlackItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 29, 11, 0, -29 },
  { 49, 17, 10, 18, 4, -29 },
  { 71, 24, 29, 23, 0, -29 },
  { 158, 20, 33, 21, 1, -31 },
  { 241, 31, 30, 34, 2, -30 },
  { 358, 26, 30, 26, 0, -30 },
  { 456, 8, 10, 10, 4, -29 },
  { 466, 15, 36, 13, 1, -30 },
  { 534, 15, 36, 13, -3, -30 },
  { 602, 18, 20, 19, 3, -32 },
  { 647, 18, 19, 22, 2, -24 },
  { 690, 10, 12, 11, -2, -6 },
  { 705, 12, 6, 13, 0, -14 },
  { 714, 8, 7, 11, 0, -7 },
  { 721, 23, 30, 17, -2, -30 },
  { 808, 20, 30, 21, 1, -30 },
  { 883, 17, 29, 21, 3, -29 },
  { 945, 21, 30, 21, -1, -30 },
  { 1024, 21, 30, 21, 0, -30 },
  { 1103, 21, 29, 21, 0, -29 },
  { 1180, 20, 29, 21, 1, -29 },
  { 1253, 21, 30, 21, 1, -30 },
  { 1332, 22, 29, 21, 1, -29 },
  { 1412, 20, 30, 21, 1, -30 },
  { 1487, 20, 30, 21, 1, -30 },
  { 1562, 11, 23, 11, 0, -23 },
  { 1594, 13, 29, 11, -2, -23 },
  { 1642, 18, 21, 22, 2, -25 },
  { 1690, 18, 15, 22, 2, -22 },
  { 1724, 18, 21, 22, 2, -25 },
  { 1772, 16, 30, 17, 2, -30 },
  { 1832, 30, 33, 31, 1, -30 },
  { 1956, 23, 29, 24, -2, -29 },
  { 2040, 23, 29, 23, 0, -29 },
  { 2124, 22, 30, 21, 2, -30 },
  { 2207, 24, 29, 24, 0, -29 },
  { 2294, 21, 29, 19, 0, -29 },
  { 2371, 21, 29, 19, 0, -29 },
  { 2448, 23, 30, 24, 2, -30 },
  { 2535, 26, 29, 25, 0, -29 },
  { 2630, 21, 29, 16, -2, -29 },
  { 2707, 21, 38, 12, -7, -29 },
  { 2807, 27, 29, 23, 0, -29 },
  { 2905, 16, 29, 18, 0, -29 },
  { 2963, 34, 29, 32, 0, -29 },
  { 3087, 28, 29, 27, 0, -29 },
  { 3189, 23, 30, 26, 2, -30 },
  { 3276, 22, 29, 21, 0, -29 },
  { 3356, 23, 37, 26, 2, -30 },
  { 3463, 22, 29, 22, 0, -29 },
  { 3543, 21, 30, 19, 0, -30 },
  { 3622, 19, 29, 19, 3, -29 },
  { 3691, 24, 29, 24, 2, -29 },
  { 3778, 22, 29, 22, 4, -29 },
  { 3858, 34, 29, 33, 3, -29 },
  { 3982, 28, 29, 23, -2, -29 },
  { 4084, 21, 29, 21, 4, -29 },
  { 4161, 24, 29, 19, -2, -29 },
  { 4248, 18, 37, 13, -2, -30 },
  { 4332, 10, 30, 17, 4, -30 },
  { 4370, 18, 37, 13, -3, -30 },
  { 4454, 21, 19, 20, -1, -29 },
  { 4504, 18, 5, 17, -4, 3 },
  { 4516, 9, 6, 14, 6, -31 },
  { 4523, 21, 23, 21, 1, -23 },
  { 4584, 21, 31, 21, 0, -31 },
  { 4666, 18, 23, 18, 1, -23 },
  { 4718, 23, 31, 21, 1, -31 },
  { 4808, 19, 23, 20, 1, -23 },
  { 4863, 22, 41, 14, -4, -31 },
  { 4976, 23, 33, 21, -1, -23 },
  { 5071, 21, 31, 22, 0, -31 },
  { 5153, 13, 32, 11, 0, -32 },
  { 5205, 18, 42, 11, -5, -32 },
  { 5300, 24, 31, 21, 0, -31 },
  { 5393, 13, 31, 11, 0, -31 },
  { 5444, 31, 23, 32, 0, -23 },
  { 5534, 21, 23, 22, 0, -23 },
  { 5595, 19, 23, 21, 1, -23 },
  { 5650, 23, 33, 21, -2, -23 },
  { 5745, 21, 33, 21, 1, -23 },
  { 5832, 17, 23, 15, 0, -23 },
  { 5881, 18, 23, 17, 0, -23 },
  { 5933, 15, 27, 15, 2, -27 },
  { 5984, 21, 23, 22, 1, -23 },
  { 6045, 20, 23, 20, 2, -23 },
  { 6103, 30, 23, 30, 2, -23 },
  { 6190, 24, 23, 20, -2, -23 },
  { 6259, 25, 33, 20, -3, -23 },
  { 6363, 19, 23, 17, -1, -23 },
  { 6418, 17, 35, 14, 0, -29 },
  { 6493, 6, 40, 18, 6, -31 },
  { 6523, 16, 35, 14, -2, -29 },
  { 6593, 18, 7, 22, 2, -18 },
};

const GFXfont NotoSans_Condensed_BlackItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC41PT7B_H_
