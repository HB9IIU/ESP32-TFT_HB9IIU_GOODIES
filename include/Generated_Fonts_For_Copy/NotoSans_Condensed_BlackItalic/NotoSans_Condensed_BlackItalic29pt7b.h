#ifndef _NOTOSANS_CONDENSED_BLACKITALIC29PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x7E, 0x3E, 0x1F, 0x0F,
  0x80, 0x7D, 0xF7, 0x9E, 0xF9, 0xEF, 0xBE, 0xF3, 0xEF, 0x3C, 0xF3, 0xCF,
  0x3C, 0x01, 0xE7, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x79, 0xC0, 0x3D, 0xE0,
  0x1C, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x87, 0x9E, 0x03, 0xCE,
  0x01, 0xCF, 0x07, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x39, 0xE0, 0x3C,
  0xE0, 0x1E, 0x70, 0x0E, 0x78, 0x0F, 0x38, 0x07, 0xBC, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0xE3, 0xD9, 0x0F, 0x60,
  0x3F, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x6F,
  0x21, 0xBC, 0xE7, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x1F, 0x01, 0xE0, 0xFE, 0x0F, 0x07, 0xF8, 0x38,
  0x1F, 0xE1, 0xE0, 0xF3, 0x8F, 0x03, 0xCE, 0x3C, 0x0E, 0x79, 0xE0, 0x39,
  0xE7, 0x00, 0xE7, 0xBC, 0xE3, 0xBD, 0xE7, 0xEF, 0xF7, 0xBF, 0xBF, 0xBD,
  0xFE, 0x7C, 0xE7, 0x3C, 0x07, 0xBC, 0xF0, 0x3C, 0xF3, 0x80, 0xE3, 0xCE,
  0x07, 0x8E, 0x78, 0x3C, 0x3D, 0xE0, 0xF0, 0xFF, 0x07, 0x83, 0xF8, 0x3C,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0xF9, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFE, 0xFC, 0x7F, 0x9F, 0x1F, 0xF3, 0xE7, 0xFF, 0xF8, 0xFB, 0xFF, 0x3E,
  0x7F, 0xC7, 0xC7, 0xF0, 0xF8, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xF9, 0xF8, 0x7D, 0xEF, 0xBE, 0xF3, 0xCF, 0x3C, 0x07, 0xC1,
  0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0,
  0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x11, 0xE0,
  0xEF, 0x07, 0xF7, 0x7F, 0xFC, 0xFF, 0xE3, 0xFF, 0x3F, 0x83, 0xFE, 0x1E,
  0xF0, 0x73, 0xC1, 0x18, 0x00, 0x80, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78,
  0xF8, 0x7F, 0xBF, 0x9F, 0xDF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xFF,
  0x87, 0xFE, 0x3F, 0xF8, 0xF9, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0x79, 0xF3,
  0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE7, 0xEF, 0x9F, 0x3E, 0x7C, 0xFB,
  0xE3, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0xF0, 0x3F, 0x07,
  0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0xFF, 0xE7, 0xBE, 0x33, 0xE2, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE0, 0xC7, 0xC1, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFF, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0xE7, 0xE1, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0F,
  0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0xC1, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xBC, 0x0F, 0xF8, 0x3D, 0xF0, 0x73, 0xE1, 0xE7, 0x87, 0x9F,
  0x0F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF8, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xC1, 0xF9,
  0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x1F, 0x84, 0xFC, 0x03, 0xE0, 0x1F, 0x38, 0x7F, 0xF1,
  0xFF, 0xCF, 0xFF, 0xBF, 0x7E, 0xFC, 0xFB, 0xE3, 0xEF, 0x9F, 0xBE, 0x7C,
  0xF9, 0xF3, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0xFE, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF1, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x0F, 0xBE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x83,
  0xFF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xFF, 0xF1, 0xFF,
  0xC3, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE,
  0x3E, 0xF9, 0xF1, 0xE7, 0xC7, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xFF,
  0x9F, 0xFE, 0x7F, 0xF0, 0xF7, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE3, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x0F, 0x1F, 0x1F, 0x3F, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xF8, 0xF8, 0x03, 0xC1,
  0xF0, 0x7C, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xC0, 0x00,
  0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x9F, 0xF3, 0xFC, 0x1F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0x03, 0xF8, 0xFF, 0x9F, 0xF1, 0xFE,
  0x0F, 0xC0, 0x70, 0x02, 0x00, 0x00, 0x0F, 0xC3, 0xFE, 0x7F, 0xF3, 0xFF,
  0x39, 0xF2, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0x78, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x03,
  0xE1, 0xF0, 0x0F, 0x0F, 0x1C, 0x3C, 0xF3, 0xFD, 0xEF, 0x3F, 0xE7, 0x71,
  0xEF, 0x3B, 0x9E, 0x71, 0xFC, 0xE3, 0x9F, 0xCF, 0x3C, 0xEE, 0x79, 0xE7,
  0x73, 0x8E, 0x7B, 0x9E, 0xF3, 0x9C, 0xFF, 0xFC, 0xE3, 0xEF, 0xC7, 0x8C,
  0x38, 0x3C, 0x00, 0x00, 0xF0, 0x0C, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x03, 0xE7,
  0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFF, 0x3F, 0xFF, 0x9F, 0x07, 0xDF, 0x83, 0xEF, 0x81, 0xFF, 0xC0, 0xF8,
  0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xBF, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC,
  0x3E, 0x7C, 0x3E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0x7F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1F, 0x9C, 0x3F, 0x04, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x30, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0xF8,
  0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x9F, 0x8F, 0xCF, 0x87, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF9, 0xF0, 0xF8, 0xF8, 0xFC, 0x7D, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFC, 0xE1, 0xF8, 0x10, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x7F, 0xBF, 0x3F, 0x9F, 0x9F, 0xCF, 0x9F, 0xE7, 0xC1, 0xF3, 0xE1,
  0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F,
  0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x87, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x01, 0x80, 0x00, 0x0F, 0x87,
  0xE1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0xC0, 0xFB, 0xF0, 0x3E, 0x7C,
  0x07, 0xDF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0xFC, 0x0F, 0x9F, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE0,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE3, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xE7, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F,
  0xEF, 0x7C, 0x3F, 0xEF, 0x78, 0x3F, 0xEF, 0xF8, 0x3D, 0xFE, 0xF8, 0x7D,
  0xFE, 0xF8, 0x7D, 0xFC, 0xF8, 0x7D, 0xFC, 0xF0, 0x79, 0xF9, 0xF0, 0x79,
  0xF9, 0xF0, 0xF9, 0xF1, 0xF0, 0xF9, 0xF1, 0xF0, 0x0F, 0xC1, 0xF0, 0xFC,
  0x1F, 0x0F, 0xE1, 0xF0, 0xFE, 0x1E, 0x0F, 0xE3, 0xE1, 0xFE, 0x3E, 0x1F,
  0xE3, 0xE1, 0xFF, 0x3E, 0x1F, 0xF3, 0xC3, 0xEF, 0x7C, 0x3E, 0xF7, 0xC3,
  0xEF, 0xFC, 0x3E, 0xFF, 0x83, 0xCF, 0xF8, 0x7C, 0x7F, 0x87, 0xC7, 0xF8,
  0x7C, 0x7F, 0x87, 0x87, 0xF0, 0x78, 0x7F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF9, 0xF1,
  0xF8, 0xFC, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x1F, 0xBE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xEF, 0x81, 0xF7, 0xC1, 0xFB, 0xE0, 0xF9, 0xF8, 0xFC, 0xFC,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0x3F, 0x1F, 0x3F,
  0x1F, 0x3F, 0x1F, 0x3E, 0x3F, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xE1, 0xF9, 0xF1, 0xF8, 0xFC, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x1F, 0xBE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xEF, 0x81, 0xF7, 0xC1, 0xFB, 0xE0, 0xF9,
  0xF8, 0xFC, 0xFC, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF0, 0x7D, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC,
  0x7C, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xE1, 0xFB, 0x83, 0xE1, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x40, 0xF8,
  0xF3, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xFD,
  0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x1F,
  0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC7, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xFC, 0xF8, 0x7F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE1, 0xF7, 0xC3, 0xEF, 0x8F, 0xDF, 0x1F, 0x3E, 0x7E, 0x7C, 0xF8, 0xF9,
  0xF1, 0xF7, 0xC3, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1E, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E,
  0xF8, 0xFC, 0x7C, 0xF8, 0xFC, 0x7C, 0xF9, 0xFC, 0xF8, 0xF9, 0xFC, 0xF8,
  0xF9, 0xFC, 0xF8, 0xFB, 0xFD, 0xF0, 0xFB, 0xFD, 0xF0, 0xFF, 0xFD, 0xE0,
  0xFF, 0xBF, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0, 0x3E,
  0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFB, 0xE0, 0x1F, 0xBE, 0x01, 0xF3, 0xE0,
  0x3E, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0x00, 0xF8, 0x7F, 0xF0, 0xFB,
  0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x0F, 0x7E, 0x1E, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x78,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF1, 0xE3, 0xC7,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x7C, 0xF8, 0xF1, 0xE0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xDE, 0x1E, 0x78, 0xF9,
  0xE3, 0xC7, 0x9E, 0x0F, 0xF8, 0x3F, 0xC0, 0xF0, 0x7F, 0xFB, 0xFF, 0xBF,
  0xFC, 0xFC, 0xF8, 0xF1, 0xF0, 0x0F, 0x3C, 0x7E, 0xF3, 0xFF, 0xDF, 0xFF,
  0x7C, 0xF9, 0xF3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x1F, 0x78, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF8, 0xFD, 0xF9, 0xF1, 0xF3, 0xE7, 0xC7, 0x8F, 0x9F,
  0x1F, 0x3E, 0x3E, 0x7C, 0xFC, 0xF9, 0xF1, 0xFF, 0xE7, 0xFF, 0x8F, 0x7E,
  0x1E, 0x78, 0x00, 0x0F, 0xF1, 0xFF, 0x3F, 0xE7, 0xFE, 0x7C, 0x27, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x88, 0xFF, 0x8F, 0xF8,
  0x7F, 0x83, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x0F, 0x7C, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C,
  0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF9,
  0xF0, 0xF9, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7D, 0xE0, 0x07,
  0xE0, 0xFF, 0x8F, 0xFE, 0x7D, 0xF7, 0xC7, 0xBE, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xE7, 0xF0, 0x3E, 0x01, 0xF0, 0x4F, 0xFE, 0x7F, 0xF1, 0xFF, 0x87,
  0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x07,
  0xDE, 0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xFF, 0x8F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xE2, 0x0F, 0x87, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC,
  0x7F, 0xFC, 0xFD, 0xF9, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E,
  0x3E, 0x7C, 0x78, 0xF9, 0xF1, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3E,
  0x00, 0x02, 0x03, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x0F,
  0x87, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F,
  0x87, 0xC3, 0xE0, 0x00, 0x20, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x3F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x7E, 0x3E, 0x7E, 0x1F, 0x7E, 0x1F,
  0x3E, 0x0F, 0xBE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1E, 0x7E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0xE0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x1F, 0x0F, 0x87, 0xC0, 0x1E, 0x7C, 0xF8, 0x7F, 0xF7, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0x7E, 0x7C, 0xF9, 0xF9, 0xF3, 0xE7, 0xC7, 0xCF,
  0x9F, 0x1E, 0x7C, 0x7C, 0xF9, 0xF1, 0xF3, 0xE7, 0xCF, 0x8F, 0x9F, 0x3E,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE3, 0xE7, 0xCF, 0x8F, 0x9F, 0x3E, 0x7C, 0x7C,
  0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF3, 0xF7, 0xE7, 0xCF, 0x8F,
  0x9F, 0x1F, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xE3, 0xE7, 0xC7, 0xCF,
  0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0xF8, 0x07, 0xE0, 0xFF, 0x8F, 0xFE, 0x7F,
  0xF7, 0xCF, 0xBE, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7D,
  0xF3, 0xEF, 0xFE, 0x7F, 0xF1, 0xFF, 0x07, 0xE0, 0x07, 0xBE, 0x03, 0xDF,
  0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1E,
  0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7D, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0xBC, 0x7E,
  0xF3, 0xFF, 0xDF, 0xFF, 0x7C, 0xF9, 0xF3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8,
  0xFB, 0xE3, 0xCF, 0x9F, 0x3E, 0x7C, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0x1E, 0x71, 0xEF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x0F, 0xE1, 0xFF, 0x3F, 0xF3, 0xEE, 0x3E, 0x23, 0xE0, 0x3F,
  0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE8, 0x3E, 0xFF, 0xCF, 0xFC, 0xFF,
  0x8F, 0xF0, 0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0xF7, 0xFD, 0xFF, 0xBF, 0xF1,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xF8,
  0xFF, 0x0F, 0xE1, 0xFC, 0x00, 0x3E, 0x3E, 0x7C, 0xF8, 0xF9, 0xF3, 0xE3,
  0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3,
  0xE7, 0xC7, 0xCF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x3E, 0xF0, 0xF8,
  0xFF, 0xE3, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0xBC, 0x3F,
  0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xF1, 0xF9, 0xFF, 0x8F, 0xCF, 0xBC, 0xFE, 0x79, 0xE7,
  0xF7, 0xCF, 0x3F, 0xBE, 0x7B, 0xF9, 0xE3, 0xDD, 0xDF, 0x1E, 0xEE, 0xF0,
  0xFF, 0x7F, 0x87, 0xF3, 0xFC, 0x3F, 0xBF, 0xC1, 0xFD, 0xFE, 0x0F, 0xCF,
  0xE0, 0x7E, 0x7F, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC3,
  0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0x7C, 0x0F, 0x9F, 0x07, 0xE7, 0xC3, 0xF1, 0xF8, 0x0F, 0x8F, 0xC3,
  0xE3, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x03, 0xEF, 0x80, 0xFB,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x09, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xF3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x00, 0x30, 0x1F, 0x03, 0xF0, 0x7F, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0x7C, 0x07, 0xC0, 0xFE, 0x07, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3F, 0x0F, 0xE0, 0xF8, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8,
  0x08, 0x00, 0x3C, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x30,
};

const GFXglyph NotoSans_Condensed_BlackItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 12, 8, 13, 3, -21 },
  { 37, 17, 21, 16, 0, -21 },
  { 82, 14, 24, 15, 1, -22 },
  { 124, 22, 21, 24, 2, -21 },
  { 182, 19, 21, 19, 0, -21 },
  { 232, 6, 8, 7, 3, -21 },
  { 238, 10, 26, 9, 1, -21 },
  { 271, 11, 26, 9, -2, -21 },
  { 307, 13, 14, 14, 2, -22 },
  { 330, 13, 14, 15, 1, -17 },
  { 353, 8, 8, 8, -2, -4 },
  { 361, 9, 4, 9, 0, -10 },
  { 366, 5, 5, 8, 0, -5 },
  { 370, 17, 21, 12, -2, -21 },
  { 415, 14, 21, 15, 1, -21 },
  { 452, 12, 21, 15, 2, -21 },
  { 484, 15, 21, 15, -1, -21 },
  { 524, 15, 21, 15, 0, -21 },
  { 564, 15, 21, 15, 0, -21 },
  { 604, 15, 21, 15, 0, -21 },
  { 644, 14, 21, 15, 1, -21 },
  { 681, 15, 21, 15, 1, -21 },
  { 721, 15, 21, 15, 0, -21 },
  { 761, 14, 21, 15, 1, -21 },
  { 798, 8, 16, 8, 0, -16 },
  { 814, 10, 20, 8, -2, -16 },
  { 839, 13, 15, 15, 1, -18 },
  { 864, 13, 10, 15, 1, -15 },
  { 881, 13, 15, 15, 1, -18 },
  { 906, 12, 21, 12, 1, -21 },
  { 938, 21, 23, 22, 1, -21 },
  { 999, 17, 21, 17, -2, -21 },
  { 1044, 16, 21, 16, 0, -21 },
  { 1086, 16, 21, 15, 1, -21 },
  { 1128, 17, 21, 17, 0, -21 },
  { 1173, 15, 21, 13, 0, -21 },
  { 1213, 15, 21, 13, 0, -21 },
  { 1253, 17, 21, 17, 1, -21 },
  { 1298, 19, 21, 18, 0, -21 },
  { 1348, 14, 21, 11, -1, -21 },
  { 1385, 15, 28, 9, -5, -21 },
  { 1438, 19, 21, 16, 0, -21 },
  { 1488, 11, 21, 13, 0, -21 },
  { 1517, 24, 21, 23, 0, -21 },
  { 1580, 20, 21, 19, 0, -21 },
  { 1633, 17, 21, 18, 1, -21 },
  { 1678, 16, 21, 15, 0, -21 },
  { 1720, 17, 26, 18, 1, -21 },
  { 1776, 16, 21, 16, 0, -21 },
  { 1818, 15, 21, 14, 0, -21 },
  { 1858, 14, 21, 14, 2, -21 },
  { 1895, 17, 21, 17, 1, -21 },
  { 1940, 15, 21, 16, 3, -21 },
  { 1980, 24, 21, 23, 2, -21 },
  { 2043, 20, 21, 16, -2, -21 },
  { 2096, 15, 21, 15, 3, -21 },
  { 2136, 16, 21, 14, -1, -21 },
  { 2178, 12, 26, 9, -1, -21 },
  { 2217, 7, 21, 12, 3, -21 },
  { 2236, 12, 26, 9, -2, -21 },
  { 2275, 14, 14, 14, 0, -21 },
  { 2300, 13, 3, 12, -3, 2 },
  { 2305, 7, 4, 10, 4, -22 },
  { 2309, 14, 16, 15, 1, -16 },
  { 2337, 15, 22, 15, 0, -22 },
  { 2379, 12, 16, 12, 1, -16 },
  { 2403, 16, 22, 15, 1, -22 },
  { 2447, 13, 16, 14, 1, -16 },
  { 2473, 16, 29, 10, -3, -22 },
  { 2531, 15, 23, 15, 0, -16 },
  { 2575, 15, 22, 15, 0, -22 },
  { 2617, 9, 23, 8, 0, -23 },
  { 2643, 13, 30, 8, -4, -23 },
  { 2692, 17, 22, 15, 0, -22 },
  { 2739, 9, 22, 8, 0, -22 },
  { 2764, 22, 16, 23, 0, -16 },
  { 2808, 15, 16, 15, 0, -16 },
  { 2838, 13, 16, 15, 1, -16 },
  { 2864, 17, 23, 15, -2, -16 },
  { 2913, 14, 23, 15, 1, -16 },
  { 2954, 12, 16, 11, 0, -16 },
  { 2978, 12, 16, 12, 0, -16 },
  { 3002, 11, 19, 11, 1, -19 },
  { 3029, 15, 16, 15, 1, -16 },
  { 3059, 14, 16, 14, 2, -16 },
  { 3087, 21, 16, 21, 2, -16 },
  { 3129, 18, 16, 14, -2, -16 },
  { 3165, 18, 23, 14, -2, -16 },
  { 3217, 14, 16, 12, -1, -16 },
  { 3245, 12, 26, 10, 0, -21 },
  { 3284, 4, 29, 13, 4, -22 },
  { 3299, 12, 26, 10, -2, -21 },
  { 3338, 13, 6, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_BlackItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC29PT7B_H_
