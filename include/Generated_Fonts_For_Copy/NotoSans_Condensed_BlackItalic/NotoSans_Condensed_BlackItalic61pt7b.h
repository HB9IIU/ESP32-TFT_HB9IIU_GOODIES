#ifndef _NOTOSANS_CONDENSED_BLACKITALIC61PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x9F, 0xF8, 0xFF,
  0xDF, 0xF8, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xFE, 0x3F, 0xF3, 0xFF, 0x1F,
  0xF9, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3,
  0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xEF, 0x3F, 0x00, 0xFF, 0x9E, 0x1C, 0x01, 0xFF, 0x38, 0x08,
  0x03, 0xFE, 0x70, 0x00, 0x07, 0xFD, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xEF, 0xF8, 0x00, 0x03,
  0xDF, 0xF8, 0x20, 0x07, 0x9F, 0xE0, 0x60, 0x0F, 0x3F, 0xC0, 0xF0, 0x1C,
  0xFF, 0x81, 0xF8, 0x3B, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF3, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC1,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x7F,
  0x00, 0x00, 0xFF, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC7, 0xF8,
  0x1F, 0x03, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x87, 0xF8, 0xFF, 0x3F, 0xC7,
  0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xF9, 0xFE, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0x8F, 0xF3, 0xFF,
  0xFE, 0x3F, 0xFE, 0x3F, 0xCF, 0xFB, 0xFC, 0x3F, 0xF8, 0xFF, 0x1F, 0xE3,
  0xF8, 0x1F, 0xC1, 0xFE, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x3F,
  0x80, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x87, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF9, 0xFE, 0x00,
  0x1F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFF, 0xFF, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x7F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xFF, 0xFF, 0x87, 0xFF, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0xFF, 0x80, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xCF, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x20, 0x3F, 0xC0, 0x07,
  0x07, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x27, 0xFF, 0xF8,
  0x79, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xEF, 0xF0, 0x0F, 0xFD, 0xFF, 0x00, 0xFF, 0x1F, 0xF0,
  0x0F, 0xC3, 0xFE, 0x00, 0xF8, 0x7F, 0xC0, 0x0E, 0x07, 0xE0, 0x00, 0x80,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x07, 0x01, 0xFC,
  0x3F, 0xE7, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC,
  0x7F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF9, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0x07,
  0xFF, 0x3F, 0xF8, 0x3F, 0xF9, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC,
  0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF,
  0x81, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0x03,
  0xFF, 0x3F, 0xF0, 0x3F, 0xF9, 0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC,
  0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xBF, 0xF0, 0xFF, 0xBF,
  0xF8, 0x3F, 0x9F, 0xFC, 0x0F, 0x8F, 0xFC, 0x07, 0x87, 0xFE, 0x01, 0x87,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0x87, 0xFF, 0x00, 0x3F, 0x07,
  0xFF, 0x00, 0x3C, 0x07, 0xFF, 0x00, 0x18, 0x07, 0xFF, 0x00, 0x10, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xF0, 0x3F, 0xFC, 0x01, 0x80, 0x3F, 0xF0, 0x02, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE1, 0x00, 0x03, 0xFF,
  0xC3, 0x80, 0x0F, 0xFF, 0x87, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xBF, 0xF0, 0x00, 0xFE, 0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0x80, 0x0F, 0xF3,
  0xFF, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x7F, 0x9F, 0xFC, 0x01, 0xFE, 0x3F,
  0xF0, 0x07, 0xF8, 0x7F, 0xE0, 0x0F, 0xF0, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF,
  0x80, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xB0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0x83, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC2, 0x00, 0x0F, 0xFF, 0x0E, 0x00, 0x7F, 0xF8, 0x3F, 0x87,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x3F, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC3,
  0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF,
  0xE3, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F,
  0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x8F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80,
  0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x8F, 0xFE, 0x07, 0xFE, 0x3F,
  0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFC, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x87,
  0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF,
  0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE1,
  0xFF, 0x83, 0xFF, 0x87, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xDF,
  0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x83, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x38, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x81, 0xFF, 0x87, 0x00, 0xFF,
  0xC1, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x87, 0xF0, 0xFF,
  0x03, 0xFF, 0xFC, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0xC7, 0xF1, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0x1F, 0xC1, 0xFF, 0xFF, 0x87, 0xF3, 0xFC, 0x3F, 0xE3,
  0xF8, 0x7F, 0x3F, 0x87, 0xF8, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x7F, 0x0F, 0xF0, 0x7F, 0x07, 0xF7, 0xF0, 0xFF, 0x07, 0xF0, 0x7F,
  0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xEF, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0xFE,
  0x1F, 0xC0, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0xFE, 0x1F,
  0xC0, 0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0x1F, 0xE1, 0xFC, 0xFE, 0x3F, 0xC1,
  0xFC, 0x1F, 0x8F, 0xE3, 0xFC, 0x3F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F,
  0xE0, 0x7F, 0xC7, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xF8,
  0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F,
  0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF,
  0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x7C, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0xFF,
  0xF0, 0x01, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x80, 0x1F, 0xFE, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF8,
  0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0x1F, 0xFF,
  0x80, 0x18, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F,
  0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x33, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xC3,
  0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xC7, 0xFF, 0x80,
  0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF,
  0x9F, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x1F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xCF,
  0xFB, 0xFF, 0x00, 0x7F, 0xDF, 0xF3, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFD,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x7F, 0x9F, 0xF8, 0x03, 0xFF, 0x7F,
  0xDF, 0xE7, 0xFE, 0x00, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0x80, 0x3F, 0xE7,
  0xFF, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0xFF, 0x3F, 0xF0, 0x07, 0xFE,
  0x7F, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0x00, 0x7F,
  0xE7, 0xFF, 0xF1, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0xFC, 0x7F, 0xE0, 0x0F,
  0xFC, 0x7F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x7F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0x87,
  0xFE, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0xFF, 0xC0,
  0x1F, 0xFB, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0xCF, 0xFC, 0x01, 0xFF,
  0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xCF, 0xFC, 0xFF, 0x80, 0x3F, 0xF1, 0xFF,
  0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xDF, 0xF8, 0x03, 0xFF, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x3F, 0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x83,
  0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0xC7, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xDF,
  0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0, 0x01, 0xFF,
  0xCF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF0, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xF8,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE1, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xF8,
  0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x80,
  0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x0F, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFB,
  0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87,
  0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xEF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xDF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F,
  0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F,
  0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x87, 0xE0, 0x1F, 0xFE, 0x03, 0xC0,
  0x3F, 0xF8, 0x01, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x20, 0x00, 0xFF, 0xE0, 0x60, 0x03, 0xFF,
  0xC0, 0xF0, 0x07, 0xFF, 0x01, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF,
  0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x7F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0,
  0x07, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xEF, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x3F,
  0xF0, 0x3F, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x0F,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0x87, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0xFC, 0x7F, 0xF0,
  0x3F, 0xF1, 0xFF, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xFF, 0x1F, 0xF8,
  0x0F, 0xFC, 0xFF, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xFF, 0xCF, 0xFC,
  0x03, 0xFF, 0x7F, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xBF, 0xFF, 0xF7, 0xFE,
  0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFF, 0x00, 0x7F, 0xDF, 0xF7, 0xFF, 0xFF,
  0x00, 0x3F, 0xEF, 0xF3, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF9, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x7F, 0xEF,
  0xFE, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF9, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x80, 0x1F,
  0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0,
  0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0xBF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x7F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xE0, 0x1F, 0xFE, 0x7F, 0xC0,
  0x1F, 0xF8, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF9, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xFF, 0xE0, 0xFF, 0xE1,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE1, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFC,
  0xFF, 0xF0, 0x0F, 0xF9, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0x3E, 0x0F, 0xFF, 0x01, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x40, 0xFF, 0xC0, 0x30,
  0x3F, 0xF8, 0x7C, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFF, 0x7F,
  0xE0, 0x07, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x7F, 0xFC, 0x07, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xFC,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xF8, 0x00,
  0xFF, 0xFB, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xFF, 0x0F, 0xFE,
  0x1F, 0xF8, 0xFF, 0xE0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x7F, 0xF0, 0x3F,
  0xE3, 0xFF, 0x07, 0xFF, 0x1F, 0xF9, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0x03,
  0xFF, 0x80, 0x78, 0x1F, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x40, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x87, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFF, 0x3F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xDF,
  0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x10, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x03, 0x00, 0x0F, 0xFE, 0x01, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF9,
  0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1,
  0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x08, 0x7F, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xFC, 0x00,
  0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0xE1, 0xFF,
  0xC0, 0x3F, 0xE7, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE1,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F,
  0xE0, 0x0F, 0xF9, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F,
  0xF3, 0xFF, 0x87, 0xFF, 0x3F, 0xF8, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x7F,
  0xF0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xEF,
  0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xEF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFC, 0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xFF, 0x80,
  0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x83, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xCF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x7F, 0xFC,
  0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF,
  0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1,
  0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x1F, 0xE7, 0xFE,
  0x00, 0x0E, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xE7, 0xF8, 0x0F, 0xFB, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x60, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x0E, 0x03, 0xFF, 0x00, 0x80, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xC0, 0x0F, 0xFE, 0x3E,
  0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x2E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF1, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xFF,
  0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xCF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xBF, 0xC0, 0x3F, 0xFE, 0xFF,
  0x80, 0x3F, 0xF9, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0x80, 0xFF, 0xE7, 0xFE, 0x03, 0xFF,
  0x9F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xF1, 0xFF, 0x81, 0xFF, 0x87,
  0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF,
  0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3,
  0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0x7F, 0xC1, 0xFF, 0xF0, 0x7F, 0xEF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFD,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xE7, 0xFC,
  0x3F, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0x1F, 0xF1, 0xFF,
  0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0x1F, 0xF8, 0x7F, 0xCF, 0xFF, 0xE3,
  0xFF, 0x0F, 0xF9, 0xFD, 0xFC, 0xFF, 0xC1, 0xFF, 0x3F, 0xBF, 0x9F, 0xF8,
  0x3F, 0xEF, 0xF7, 0xF3, 0xFE, 0x07, 0xFD, 0xFE, 0xFE, 0xFF, 0xC0, 0xFF,
  0xBF, 0xBF, 0xDF, 0xF8, 0x1F, 0xFF, 0xF7, 0xFB, 0xFE, 0x03, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x9F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x87, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE1,
  0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07,
  0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0x7F,
  0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00,
  0x7F, 0xDF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x13, 0xFF, 0xE0,
  0x03, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x80, 0x00, 0xFF, 0x80,
};

const GFXglyph NotoSans_Condensed_BlackItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 20, 45, 17, 0, -44 },
  { 114, 25, 16, 28, 6, -44 },
  { 164, 36, 44, 34, 0, -44 },
  { 362, 31, 50, 31, 1, -46 },
  { 556, 47, 45, 51, 3, -44 },
  { 821, 39, 45, 39, 0, -44 },
  { 1041, 12, 16, 15, 6, -44 },
  { 1065, 23, 55, 19, 1, -45 },
  { 1224, 23, 55, 19, -5, -45 },
  { 1383, 27, 29, 29, 4, -47 },
  { 1481, 27, 29, 32, 3, -36 },
  { 1579, 15, 16, 17, -3, -8 },
  { 1609, 17, 9, 19, 1, -21 },
  { 1629, 12, 12, 17, 0, -11 },
  { 1647, 34, 45, 26, -3, -44 },
  { 1839, 29, 45, 31, 2, -44 },
  { 2003, 25, 44, 31, 5, -44 },
  { 2141, 32, 44, 31, -2, -44 },
  { 2317, 31, 45, 31, 0, -44 },
  { 2492, 31, 44, 31, 0, -44 },
  { 2663, 30, 45, 31, 1, -44 },
  { 2832, 30, 45, 31, 2, -44 },
  { 3001, 33, 44, 31, 1, -44 },
  { 3183, 30, 45, 31, 1, -44 },
  { 3352, 30, 45, 31, 1, -44 },
  { 3521, 17, 35, 17, 0, -34 },
  { 3596, 21, 42, 17, -4, -34 },
  { 3707, 28, 32, 32, 2, -38 },
  { 3819, 27, 21, 32, 3, -32 },
  { 3890, 27, 32, 32, 3, -38 },
  { 3998, 25, 45, 25, 3, -44 },
  { 4139, 44, 49, 47, 2, -44 },
  { 4409, 35, 44, 35, -4, -44 },
  { 4602, 34, 44, 34, 0, -44 },
  { 4789, 33, 45, 32, 2, -44 },
  { 4975, 35, 44, 36, 0, -44 },
  { 5168, 31, 44, 28, 0, -44 },
  { 5339, 31, 44, 28, 0, -44 },
  { 5510, 35, 45, 36, 2, -44 },
  { 5707, 39, 44, 37, 0, -44 },
  { 5922, 30, 44, 24, -2, -44 },
  { 6087, 30, 58, 19, -10, -44 },
  { 6305, 40, 44, 34, 0, -44 },
  { 6525, 24, 44, 27, 0, -44 },
  { 6657, 50, 44, 48, 0, -44 },
  { 6932, 42, 44, 40, 0, -44 },
  { 7163, 35, 45, 38, 2, -44 },
  { 7360, 33, 44, 32, 0, -44 },
  { 7542, 35, 54, 38, 2, -44 },
  { 7779, 33, 44, 33, 0, -44 },
  { 7961, 31, 45, 29, 0, -44 },
  { 8136, 28, 44, 28, 5, -44 },
  { 8290, 35, 45, 36, 3, -44 },
  { 8487, 34, 44, 33, 5, -44 },
  { 8674, 49, 44, 49, 5, -44 },
  { 8944, 42, 44, 33, -4, -44 },
  { 9175, 32, 44, 32, 5, -44 },
  { 9351, 36, 44, 29, -3, -44 },
  { 9549, 27, 55, 19, -3, -45 },
  { 9735, 15, 45, 26, 6, -44 },
  { 9820, 27, 55, 19, -5, -45 },
  { 10006, 31, 29, 30, -1, -44 },
  { 10119, 27, 7, 25, -6, 4 },
  { 10143, 13, 10, 21, 9, -47 },
  { 10160, 31, 35, 32, 1, -34 },
  { 10296, 31, 47, 32, 0, -46 },
  { 10479, 26, 35, 26, 2, -34 },
  { 10593, 34, 47, 32, 1, -46 },
  { 10793, 29, 35, 30, 1, -34 },
  { 10920, 34, 62, 21, -7, -47 },
  { 11184, 33, 49, 32, -1, -34 },
  { 11387, 31, 46, 32, 0, -46 },
  { 11566, 19, 47, 17, 0, -47 },
  { 11678, 27, 62, 17, -8, -47 },
  { 11888, 35, 46, 32, 0, -46 },
  { 12090, 20, 46, 17, 0, -46 },
  { 12205, 46, 34, 48, 0, -34 },
  { 12401, 31, 34, 32, 0, -34 },
  { 12533, 28, 35, 32, 2, -34 },
  { 12656, 34, 49, 32, -3, -34 },
  { 12865, 31, 49, 32, 1, -34 },
  { 13055, 26, 34, 23, 0, -34 },
  { 13166, 26, 35, 26, 0, -34 },
  { 13280, 23, 42, 23, 2, -41 },
  { 13401, 31, 35, 32, 2, -34 },
  { 13537, 30, 34, 29, 3, -34 },
  { 13665, 43, 34, 44, 4, -34 },
  { 13848, 36, 34, 30, -3, -34 },
  { 14001, 37, 49, 29, -4, -34 },
  { 14228, 29, 34, 26, -2, -34 },
  { 14352, 26, 54, 21, 0, -44 },
  { 14528, 9, 61, 27, 9, -47 },
  { 14597, 25, 54, 21, -4, -44 },
  { 14766, 28, 11, 32, 2, -27 },
};

const GFXfont NotoSans_Condensed_BlackItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC61PT7B_H_
