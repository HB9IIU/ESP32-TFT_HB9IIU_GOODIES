#ifndef _NOTOSANS_CONDENSED_BLACKITALIC56PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xF3,
  0xFE, 0x7F, 0xC7, 0xFC, 0xFF, 0x8F, 0xF9, 0xFF, 0x3F, 0xE3, 0xFC, 0x7F,
  0xCF, 0xF8, 0xFF, 0x9F, 0xF1, 0xFF, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8,
  0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFD, 0xC7, 0x80, 0xFF, 0x9C,
  0x18, 0x0F, 0xFB, 0xC0, 0x00, 0xFF, 0xB8, 0x00, 0x0F, 0xFB, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1E, 0xFF, 0x04, 0x01, 0xEF, 0xF0, 0x60, 0x1C, 0xFF,
  0x07, 0x81, 0xCF, 0xF0, 0x7E, 0x3D, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0xC7, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0xCF, 0xF0, 0x30, 0x3F, 0x8F,
  0xE3, 0xF8, 0x7F, 0x8F, 0xE7, 0xF9, 0xFC, 0x7F, 0xF3, 0xFF, 0xFC, 0xFF,
  0x3F, 0xFE, 0xFF, 0xFF, 0x3F, 0x9F, 0xFF, 0xDF, 0xFF, 0x9F, 0xE7, 0xFF,
  0xF7, 0xFF, 0xC7, 0xF3, 0xFF, 0xFC, 0xFF, 0xE3, 0xF8, 0xFE, 0x7F, 0x1F,
  0xF1, 0xFE, 0x7F, 0x9F, 0xC0, 0x60, 0x7F, 0x1F, 0xC7, 0xF0, 0x00, 0x3F,
  0x87, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE,
  0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0x0F,
  0xE0, 0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xC7,
  0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0x07,
  0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xF0, 0x07, 0xFF,
  0x87, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87,
  0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x30, 0x3F, 0x80, 0x3C, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0xFF, 0x0F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xEF, 0xE0, 0x3F, 0xCF, 0xF0,
  0x1F, 0xCF, 0xF0, 0x0F, 0x87, 0xF8, 0x07, 0x07, 0xF0, 0x03, 0x07, 0xC0,
  0x01, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0x80, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x07, 0x07, 0xF9, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0x3F, 0xF0, 0xFF, 0xC7, 0xFC, 0x7F, 0xE1, 0xFF, 0x1F, 0xF8, 0x7F, 0xC7,
  0xFC, 0x1F, 0xF3, 0xFF, 0x07, 0xFC, 0xFF, 0xC1, 0xFF, 0x3F, 0xE0, 0x7F,
  0xDF, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xC0,
  0xFF, 0xDF, 0xF0, 0x3F, 0xEF, 0xFC, 0x1F, 0xFB, 0xFF, 0x07, 0xFE, 0xFF,
  0xC1, 0xFF, 0xBF, 0xE0, 0x7F, 0xCF, 0xF8, 0x3F, 0xF3, 0xFE, 0x0F, 0xFC,
  0xFF, 0x83, 0xFE, 0x3F, 0xE1, 0xFF, 0x8F, 0xF8, 0x7F, 0xE3, 0xFE, 0x3F,
  0xF0, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F,
  0xF7, 0xFE, 0x1F, 0xCF, 0xF8, 0x1F, 0x1F, 0xF0, 0x1C, 0x7F, 0xE0, 0x30,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0xF0, 0x07, 0xC0, 0xFF, 0xC0, 0x0E,
  0x03, 0xFE, 0x00, 0x30, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0x03, 0xFF, 0x00, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x88, 0x00, 0x3F, 0xF8, 0xF0, 0x07, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xBF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xDF, 0xF0, 0x01, 0xFC, 0xFF, 0x80, 0x0F, 0xEF, 0xFC, 0x00,
  0xFE, 0x7F, 0xE0, 0x0F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xF0,
  0xFF, 0x80, 0x7F, 0x0F, 0xFC, 0x07, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x02, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x80, 0x07, 0xFF, 0x0F, 0x00, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFB, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x60, 0x03,
  0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0xFF, 0xE1, 0xFF, 0x8F, 0xFC,
  0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF,
  0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1,
  0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF9, 0xFF, 0x83,
  0xFF, 0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0x9F,
  0xFD, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xDF, 0xF0, 0x1F,
  0xE7, 0xFC, 0x00, 0x70, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0x7F,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1E,
  0x07, 0xFC, 0x30, 0x0F, 0xF8, 0x40, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFE, 0x3F, 0x1F, 0xE1,
  0xFF, 0xFE, 0x3F, 0x1F, 0xC3, 0xFF, 0xFE, 0x3F, 0x3F, 0x83, 0xFF, 0xFC,
  0x3F, 0x3F, 0x87, 0xF9, 0xFC, 0x3F, 0x3F, 0x0F, 0xF1, 0xFC, 0x3F, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x7E, 0x1F, 0xC1, 0xF8, 0x3F, 0x7E, 0x1F, 0xC1,
  0xF8, 0x3F, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0xFE, 0x3F, 0x83, 0xF8, 0x7E,
  0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0xFC, 0x3F,
  0x07, 0xF0, 0xFC, 0xFC, 0x7F, 0x07, 0xF0, 0xFC, 0xFC, 0x7F, 0x0F, 0xF1,
  0xFC, 0xFC, 0x3F, 0x8F, 0xF3, 0xF8, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0xF9,
  0xFF, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x00, 0xFE, 0x03, 0xC0, 0x7C, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x10, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8,
  0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0,
  0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x81, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0x80, 0xFF, 0xF0, 0x04, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0x00, 0x7F, 0xF0, 0x3C, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x0F,
  0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x78, 0x07, 0xFF, 0x80, 0x18, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0xFC, 0x7F,
  0xE1, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xF8, 0xFF,
  0xE1, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x1F,
  0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xC7, 0xF7,
  0xFC, 0x03, 0xFE, 0xFF, 0x3F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFC, 0xFE, 0xFF,
  0xC0, 0x3F, 0xEF, 0xF7, 0xFB, 0xFE, 0x00, 0xFF, 0xBF, 0xDF, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0xFC, 0xFF, 0x80,
  0x7F, 0xCF, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0x9F, 0xF0, 0x07,
  0xFC, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xF3, 0xFF, 0xF1, 0xFF, 0x00, 0xFF,
  0x8F, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8,
  0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x0F,
  0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF,
  0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFF,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0xFF,
  0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xFF, 0x83, 0xFE, 0x01, 0xFF,
  0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0x3F,
  0xE0, 0x0F, 0xF7, 0xFC, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0xFF, 0x80, 0x7F,
  0xCF, 0xF9, 0xFF, 0x00, 0xFF, 0x9F, 0xF7, 0xFC, 0x01, 0xFF, 0x3F, 0xEF,
  0xF8, 0x03, 0xFE, 0x3F, 0xDF, 0xF0, 0x07, 0xFC, 0x7F, 0xFF, 0xE0, 0x1F,
  0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0xFF, 0x00, 0x7F, 0xC3, 0xFF,
  0xFE, 0x00, 0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xF8, 0x07,
  0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x1F, 0xFC, 0x03,
  0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07,
  0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFC, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0x9F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x1F,
  0xFC, 0x03, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x3F,
  0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x1F, 0xFC, 0x07, 0xFE,
  0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F,
  0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x0F, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x03,
  0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x7E, 0x01, 0xFF,
  0x80, 0x60, 0x0F, 0xFC, 0x01, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x20, 0x01, 0xFF, 0x81, 0x80,
  0x1F, 0xFC, 0x0F, 0x00, 0xFF, 0xC0, 0x7E, 0x1F, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC,
  0x03, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC7, 0xFE,
  0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0,
  0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x01,
  0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFD,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x9F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x1F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFF,
  0x87, 0xFE, 0x07, 0xFC, 0x7F, 0xFE, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0xF8,
  0xFF, 0xC0, 0x7F, 0xCF, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0x8F,
  0xF8, 0x07, 0xFC, 0xFF, 0xFE, 0x7F, 0xE0, 0x1F, 0xE7, 0xFF, 0xF9, 0xFF,
  0x00, 0x7F, 0x9F, 0xFF, 0xEF, 0xFC, 0x01, 0xFE, 0xFF, 0x7F, 0xBF, 0xE0,
  0x07, 0xFB, 0xFD, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF7, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01,
  0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xBF, 0xF0, 0x1F, 0xFC, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x0F, 0xFE,
  0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0x7F, 0xCF,
  0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFB, 0xF8, 0x00, 0xFF, 0x3F,
  0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF,
  0x1F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xF3, 0xFC, 0x03,
  0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x3F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF,
  0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xEF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFF,
  0x0F, 0xF8, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x3F, 0xF1, 0xFF,
  0x03, 0xFF, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F,
  0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F,
  0xF1, 0xFF, 0x87, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x3F, 0xFC, 0x0F,
  0xF3, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0x7C, 0x1F, 0xFC, 0x08, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x20, 0xFF, 0xE0, 0x60, 0x7F, 0xF3,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x40, 0xFF, 0xC0,
  0x07, 0xF1, 0xFF, 0x80, 0x3F, 0xFB, 0xFE, 0x00, 0xFF, 0xF7, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x07, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x87, 0xFE,
  0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F,
  0xF3, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xC1, 0xFF, 0x80, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x08, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0xCF,
  0xF0, 0x03, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFC, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFB,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x7F,
  0xC0, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0x41, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x04, 0x00, 0x1F, 0xF0, 0x0C, 0x00, 0x7F, 0xE0,
  0x1F, 0x83, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x40, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xEF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xF1,
  0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0x87, 0xFE,
  0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x8F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07,
  0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x07,
  0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x0F,
  0xF9, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F,
  0xC3, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF3, 0xFF, 0x8F, 0xFE, 0x01, 0xFE, 0xFF, 0xF3,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x1F,
  0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0xC0, 0x3F, 0xDF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F,
  0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x9F, 0xF8, 0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xC0, 0xFF, 0xDF,
  0xF8, 0x1F, 0xF3, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x1F,
  0xF9, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xCF, 0xFC, 0x1F, 0xF9, 0xFF,
  0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE7, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x1F, 0xE0,
  0x01, 0xFE, 0x7F, 0xE0, 0x03, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x1F,
  0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xF0,
  0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xF0, 0x20, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xF3, 0xFC, 0x03, 0xFF,
  0xDF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0x07,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE0, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0x00,
  0xFF, 0xDF, 0xF0, 0x01, 0xFC, 0xFF, 0x80, 0x01, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x04, 0x03, 0xFC,
  0x7F, 0x03, 0xFC, 0xFE, 0x03, 0xFD, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xF8, 0x38, 0x1F, 0xF8,
  0x08, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x80, 0x1F, 0xF8, 0xC0, 0x1F, 0xF8, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x02, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0x80, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F,
  0xF1, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F,
  0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0x87,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x8F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xFC, 0x07, 0xFF, 0x3F, 0xC0, 0x1F,
  0xE3, 0xFC, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x1F, 0xF8, 0xFF,
  0x83, 0xFF, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE7, 0xFE, 0x07, 0xFC,
  0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xBF, 0xE0, 0xFF, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xF0, 0x7F, 0xCF,
  0xF8, 0x7F, 0xF8, 0x7F, 0xE7, 0xFC, 0x3F, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F,
  0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xFF, 0x8F,
  0xF8, 0x7F, 0xCF, 0xFF, 0xCF, 0xFC, 0x3F, 0xE7, 0xFF, 0xE7, 0xFC, 0x1F,
  0xF3, 0xFF, 0xF3, 0xFE, 0x0F, 0xFB, 0xFB, 0xFB, 0xFE, 0x07, 0xFD, 0xFD,
  0xFD, 0xFF, 0x03, 0xFE, 0xFE, 0xFE, 0xFF, 0x01, 0xFF, 0xFE, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x7F, 0x7F, 0xC0, 0x7F, 0xFF, 0xBF, 0xBF, 0xC0, 0x3F,
  0xFF, 0x9F, 0xFF, 0xE0, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x03, 0xFF, 0xF1, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x4F, 0xFF, 0x00, 0x37, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xA0, 0x00, 0xFF, 0xC8, 0x00, 0x01, 0x00,
};

const GFXglyph NotoSans_Condensed_BlackItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 18, 41, 15, 0, -40 },
  { 94, 23, 14, 25, 5, -40 },
  { 135, 33, 40, 32, 0, -40 },
  { 300, 28, 46, 28, 1, -43 },
  { 461, 42, 42, 47, 3, -41 },
  { 682, 36, 42, 36, 0, -41 },
  { 871, 12, 14, 13, 5, -40 },
  { 892, 21, 50, 17, 1, -41 },
  { 1024, 20, 50, 17, -4, -41 },
  { 1149, 24, 27, 26, 4, -43 },
  { 1230, 26, 27, 29, 2, -33 },
  { 1318, 14, 16, 15, -3, -8 },
  { 1346, 16, 8, 18, 1, -19 },
  { 1362, 11, 11, 15, 0, -10 },
  { 1378, 31, 42, 23, -3, -41 },
  { 1541, 26, 42, 28, 2, -41 },
  { 1678, 23, 40, 28, 5, -40 },
  { 1793, 30, 41, 28, -2, -41 },
  { 1947, 28, 42, 28, 0, -41 },
  { 2094, 29, 40, 28, 0, -40 },
  { 2239, 28, 41, 28, 1, -40 },
  { 2383, 28, 42, 28, 2, -41 },
  { 2530, 30, 40, 28, 1, -40 },
  { 2680, 28, 42, 28, 1, -41 },
  { 2827, 27, 42, 28, 1, -41 },
  { 2969, 16, 32, 16, 0, -31 },
  { 3033, 19, 39, 16, -3, -31 },
  { 3126, 26, 29, 29, 2, -35 },
  { 3221, 26, 20, 29, 2, -30 },
  { 3286, 26, 29, 29, 2, -35 },
  { 3381, 23, 42, 23, 2, -41 },
  { 3502, 40, 44, 43, 2, -40 },
  { 3722, 32, 40, 32, -3, -40 },
  { 3882, 31, 40, 31, 0, -40 },
  { 4037, 30, 42, 29, 2, -41 },
  { 4195, 32, 40, 33, 0, -40 },
  { 4355, 28, 40, 26, 0, -40 },
  { 4495, 28, 40, 26, 0, -40 },
  { 4635, 32, 42, 33, 2, -41 },
  { 4803, 36, 40, 34, 0, -40 },
  { 4983, 28, 40, 22, -2, -40 },
  { 5123, 28, 53, 17, -9, -40 },
  { 5309, 37, 40, 31, 0, -40 },
  { 5494, 22, 40, 25, 0, -40 },
  { 5604, 46, 40, 44, 0, -40 },
  { 5834, 39, 40, 37, 0, -40 },
  { 6029, 32, 42, 35, 2, -41 },
  { 6197, 30, 40, 29, 0, -40 },
  { 6347, 32, 51, 35, 2, -41 },
  { 6551, 31, 40, 31, 0, -40 },
  { 6706, 29, 42, 26, 0, -41 },
  { 6859, 26, 40, 26, 4, -40 },
  { 6989, 33, 41, 33, 2, -40 },
  { 7159, 31, 40, 31, 5, -40 },
  { 7314, 46, 40, 45, 4, -40 },
  { 7544, 38, 40, 31, -3, -40 },
  { 7734, 29, 40, 29, 5, -40 },
  { 7879, 32, 40, 26, -2, -40 },
  { 8039, 24, 50, 17, -2, -41 },
  { 8189, 13, 42, 23, 6, -41 },
  { 8258, 24, 50, 17, -4, -41 },
  { 8408, 28, 26, 27, -1, -40 },
  { 8499, 24, 6, 23, -5, 4 },
  { 8517, 13, 9, 19, 8, -43 },
  { 8532, 29, 33, 29, 1, -32 },
  { 8652, 28, 44, 29, 0, -43 },
  { 8806, 24, 33, 24, 1, -32 },
  { 8905, 31, 44, 29, 1, -43 },
  { 9076, 26, 32, 28, 1, -31 },
  { 9180, 31, 56, 19, -6, -43 },
  { 9397, 31, 45, 29, -1, -32 },
  { 9572, 28, 43, 30, 0, -43 },
  { 9723, 18, 43, 15, 0, -43 },
  { 9820, 25, 56, 15, -7, -43 },
  { 9995, 32, 43, 29, 0, -43 },
  { 10167, 18, 43, 15, 0, -43 },
  { 10264, 43, 32, 44, 0, -32 },
  { 10436, 28, 32, 30, 0, -32 },
  { 10548, 27, 33, 29, 1, -32 },
  { 10660, 31, 45, 29, -3, -32 },
  { 10835, 29, 45, 29, 1, -32 },
  { 10999, 24, 32, 21, 0, -32 },
  { 11095, 24, 33, 24, 0, -32 },
  { 11194, 21, 38, 21, 2, -37 },
  { 11294, 28, 32, 30, 2, -31 },
  { 11406, 27, 31, 27, 3, -31 },
  { 11511, 41, 31, 40, 3, -31 },
  { 11670, 34, 31, 28, -3, -31 },
  { 11802, 33, 44, 27, -3, -31 },
  { 11984, 27, 31, 23, -2, -31 },
  { 12089, 24, 49, 20, 0, -40 },
  { 12236, 7, 56, 25, 9, -43 },
  { 12285, 22, 49, 20, -3, -40 },
  { 12420, 26, 11, 29, 2, -25 },
};

const GFXfont NotoSans_Condensed_BlackItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC56PT7B_H_
