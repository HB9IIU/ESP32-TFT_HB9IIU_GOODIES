#ifndef _NOTOSANS_CONDENSED_BLACKITALIC48PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xF3, 0xF8, 0xFE, 0x7F, 0x8F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC,
  0x7E, 0x1F, 0x8F, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xF6, 0xFC, 0x0F, 0xEE,
  0x18, 0x0F, 0xEE, 0x08, 0x0F, 0xEE, 0x00, 0x0F, 0xEE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x37, 0xF8, 0x40, 0x73, 0xF8, 0x60, 0x73, 0xF8, 0x78, 0x77,
  0xF0, 0x7E, 0x7F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x0F, 0xFC,
  0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0x3F, 0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x7E,
  0x00, 0x7E, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0xFC, 0x7F,
  0x1F, 0x80, 0x0F, 0xC7, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE7, 0xF0, 0x00, 0xFC, 0xFE, 0x7E, 0x1F, 0x8F, 0xCF, 0xCF, 0xC7,
  0xFC, 0xFF, 0xFD, 0xFC, 0xFF, 0xEF, 0xFF, 0x9F, 0x9F, 0xFE, 0xFF, 0xF3,
  0xF3, 0xFF, 0xF7, 0xFE, 0x3F, 0x3F, 0xFF, 0x3F, 0xC7, 0xE7, 0xF3, 0xF0,
  0xF0, 0xFE, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0x01, 0xF8, 0xFE,
  0x3F, 0x00, 0x1F, 0x8F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x7E, 0x00, 0x7F,
  0x0F, 0xC7, 0xE0, 0x07, 0xE0, 0xFC, 0x7E, 0x00, 0xFC, 0x0F, 0xCF, 0xE0,
  0x1F, 0xC0, 0xFC, 0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0x00, 0xFF,
  0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC,
  0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE3, 0xFE, 0x0F, 0xFF, 0x87,
  0xF8, 0x3F, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0xFF, 0xFF,
  0x87, 0xFB, 0xFF, 0xFE, 0x1F, 0xF7, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF, 0xF0,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0x83, 0xFE, 0x0F, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x02, 0x07,
  0xE0, 0x1C, 0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xFF, 0x8F, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFC, 0xFC, 0x07,
  0xE7, 0xF0, 0x1E, 0x3F, 0xC0, 0x70, 0xF8, 0x01, 0x07, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xDF,
  0xFF, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x3F, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFE, 0x3F,
  0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFD, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF,
  0xE0, 0xFF, 0x7F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1,
  0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0xEF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC,
  0xFE, 0x1F, 0xF3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0xF7,
  0xF8, 0x3E, 0x7F, 0x83, 0xCF, 0xF8, 0x18, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xF0, 0xFF,
  0x80, 0x70, 0x7F, 0xC0, 0x20, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xF3, 0xFF, 0x01, 0x81,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x80, 0x0F, 0xF8, 0xE0, 0x1F, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFB, 0xFC, 0x01, 0xFB,
  0xFC, 0x03, 0xF7, 0xF8, 0x07, 0xE7, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xC7,
  0xF8, 0x1F, 0x8F, 0xF8, 0x3F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0x7F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x80, 0x1F, 0xF0, 0xC0, 0x3F, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0x02, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x78, 0x07, 0xFB, 0xFC, 0x1F,
  0xEF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0x9F, 0xF1, 0xFF, 0x3F, 0xC3,
  0xFE, 0x7F, 0x87, 0xFC, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F,
  0xC7, 0xF8, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFC, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFC,
  0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xC3,
  0xFC, 0xFF, 0x87, 0xF9, 0xFF, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F,
  0xCF, 0xF0, 0xFF, 0x9F, 0xE3, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03,
  0xF9, 0xFE, 0x01, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x0F, 0x3F, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xF8, 0x3F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x20, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xF1, 0xFF, 0x1C, 0x0F, 0xF1, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x3F, 0x07, 0xFF, 0x9F, 0x87, 0xE1, 0xFF, 0xF1, 0xF1, 0xF8,
  0x7F, 0xFE, 0x3E, 0x3E, 0x1F, 0xFF, 0xC7, 0xCF, 0xC7, 0xF1, 0xF0, 0xF9,
  0xF8, 0xFC, 0x3E, 0x1F, 0x3E, 0x3F, 0x0F, 0xC3, 0xEF, 0xC7, 0xE1, 0xF8,
  0xFD, 0xF8, 0xF8, 0x3F, 0x1F, 0xBE, 0x3F, 0x07, 0xC3, 0xE7, 0xC7, 0xE1,
  0xF8, 0x7C, 0xF8, 0xFC, 0x3F, 0x1F, 0xBF, 0x1F, 0x87, 0xE3, 0xE7, 0xE3,
  0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x7F, 0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0xE3,
  0xF1, 0xFF, 0xFF, 0xF8, 0x7E, 0x1F, 0xF7, 0xFE, 0x07, 0xC1, 0xFC, 0x7F,
  0x80, 0xFC, 0x0E, 0x07, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F,
  0x9F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0xF8, 0x1F, 0xE1, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F,
  0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFD, 0xF8, 0x0F, 0xFC, 0x0C, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x02, 0x03, 0xFF, 0x03, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC7,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xC1, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF,
  0x83, 0xFC, 0x3F, 0xF0, 0x3F, 0xCF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFC, 0x03, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x3F, 0xFC, 0x7F, 0xC7, 0xFF, 0x8F, 0xF0, 0xFF, 0xF3, 0xFE, 0x1F, 0xFE,
  0x7F, 0xC7, 0xFF, 0x8F, 0xF8, 0xFF, 0xF1, 0xFF, 0x1F, 0xFE, 0x3F, 0xE0,
  0x3F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3,
  0xFE, 0x07, 0xF8, 0x7F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x67, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x1F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF1,
  0xFD, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xEF, 0xE7, 0xEF, 0xF0,
  0x1F, 0xDF, 0xDF, 0xDF, 0xE0, 0x7F, 0xBF, 0xBF, 0x3F, 0x80, 0xFF, 0x7F,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0xF9, 0xFE, 0x03, 0xF9, 0xFF, 0xF3, 0xFC,
  0x0F, 0xF3, 0xFF, 0xE7, 0xF8, 0x1F, 0xE7, 0xFF, 0x9F, 0xE0, 0x3F, 0xCF,
  0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0xF8, 0xFF,
  0x03, 0xFC, 0x7F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0xC7, 0xF8, 0x0F, 0xF1,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xFC, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xE1, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x7F, 0xF8, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xF0, 0x1F, 0xFE, 0x07, 0xF8,
  0x0F, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0xFE,
  0x03, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0xFC, 0x3F,
  0xC0, 0x7F, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0xCF,
  0xF0, 0x1F, 0xCF, 0xE7, 0xF8, 0x0F, 0xE7, 0xF3, 0xFC, 0x07, 0xF3, 0xFD,
  0xFC, 0x07, 0xF9, 0xFE, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0x01, 0xFE, 0x3F,
  0xFF, 0x80, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0x87,
  0xFF, 0xE0, 0x3F, 0xC3, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0xF8, 0x0F, 0xE0,
  0x7F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x07, 0xF8, 0x1F, 0xFE, 0x03, 0xFC,
  0x07, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xF7, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE3, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x9F, 0xF0, 0x0F,
  0xF3, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE,
  0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0,
  0x1F, 0xF7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xF3,
  0xFE, 0x07, 0xFC, 0x7F, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xDF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xF7,
  0xFF, 0x0F, 0xFC, 0x3F, 0xE3, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x9F,
  0xF0, 0x0F, 0xF3, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x07,
  0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF,
  0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0,
  0x3F, 0xF3, 0xFE, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xFC,
  0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xE0, 0xFF, 0xBF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFB, 0xFC, 0x03,
  0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFF,
  0x03, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0,
  0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x1C, 0x0F, 0xF8, 0x08, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x40, 0x0F, 0xF0, 0x60, 0x1F, 0xF0,
  0x7C, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF,
  0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0,
  0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0x7F,
  0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFD,
  0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xFB, 0xFC, 0x07,
  0xF8, 0x1F, 0xF7, 0xF8, 0x1F, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE0, 0x7F,
  0x9F, 0xE0, 0x7F, 0xC1, 0xFF, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x7F, 0x83,
  0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0xF1, 0xFE, 0x0F, 0xF1,
  0xFF, 0xE3, 0xFC, 0x1F, 0xE7, 0xFF, 0xCF, 0xF0, 0x3F, 0xCF, 0xFF, 0x9F,
  0xE0, 0x7F, 0xBF, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xFE, 0xFF, 0x01, 0xFC,
  0xFD, 0xFD, 0xFE, 0x03, 0xFB, 0xFB, 0xF7, 0xF8, 0x07, 0xF7, 0xF7, 0xEF,
  0xF0, 0x0F, 0xEF, 0xCF, 0xDF, 0xE0, 0x1F, 0xFF, 0x9F, 0xFF, 0x80, 0x3F,
  0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xBF, 0xC0,
  0xFF, 0x9F, 0xE0, 0x7F, 0xCF, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFE,
  0x3F, 0xE1, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x01, 0xFD, 0xFC, 0x03,
  0xF8, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0xFF,
  0x00, 0x3F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0x9F, 0xF1, 0xFE, 0x1F, 0xC3,
  0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xF8, 0x7F, 0x01, 0xFE, 0x7F, 0x03,
  0xFF, 0x7F, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0xFF,
  0x83, 0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x0F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xEF, 0xE0, 0x3F, 0xEF, 0xE0, 0x1F,
  0x8F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF9, 0xF0, 0x07, 0xFB, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFF, 0x1F, 0xC1, 0xFF, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xEF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xE0, 0xFE, 0x7F, 0xC0, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFE, 0x18, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x21, 0xFF, 0x02, 0x0F, 0xFC, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0x1F, 0xE0, 0x07,
  0xFB, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC,
  0x7F, 0xC0, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0xFF, 0x87,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F,
  0xF8, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0x80, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0x3F, 0xC7, 0xF8,
  0x7F, 0x3F, 0xC1, 0xFC, 0xFF, 0x0F, 0xF7, 0xFC, 0x7F, 0xDF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x10, 0xFF, 0x81,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x84, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x13, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xE7, 0xF0, 0x0F,
  0xFD, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC3, 0xFE, 0x0F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xEF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x08, 0x01, 0xFF, 0x03, 0xC0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F,
  0xE1, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF,
  0x87, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0x00,
  0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x04, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x87, 0xFC,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF,
  0x3F, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07,
  0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x87,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0xF8, 0x0F, 0x80, 0x7F, 0x3F, 0xE3, 0xFE, 0x07, 0xF7, 0xFE,
  0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x9F, 0xF8, 0xFF,
  0x0F, 0xF0, 0xFF, 0x8F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF,
  0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xF1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xFC, 0x3F, 0xC7, 0xF8,
  0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0xCF, 0xF8, 0x7F, 0x87, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x80, 0x07, 0xF1, 0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xF7, 0xFE, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F,
  0xE1, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xE1, 0xFE, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF,
  0x87, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0x3F, 0xE3,
  0xFE, 0x7F, 0x87, 0xFD, 0xFF, 0x0F, 0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F,
  0xCF, 0xF0, 0x7F, 0xBF, 0xE0, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x07, 0xFD,
  0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xFC, 0x7F, 0xCF, 0xF9, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x1F, 0xCF, 0xF0,
  0x03, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3,
  0xFE, 0x07, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x7F,
  0xC0, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0x9F, 0xC0,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x01, 0xFE, 0x7F, 0x03,
  0xFF, 0x7F, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0xFF,
  0x83, 0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x0F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0x9F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0xF0, 0x7F, 0x3F, 0x07, 0xF7, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFE,
  0x41, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xCF, 0x03, 0xFC, 0x08, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF1,
  0x80, 0xFF, 0x8F, 0x0F, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x7F, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE1, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xDC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC3,
  0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xF0, 0x1F,
  0xF3, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFB,
  0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0xC3, 0xFC,
  0xFF, 0x07, 0xF9, 0xFE, 0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x87,
  0xFB, 0xFC, 0x7F, 0xE1, 0xFE, 0xFF, 0x1F, 0xF8, 0x7F, 0xBF, 0xC7, 0xFE,
  0x3F, 0xCF, 0xE3, 0xFF, 0x8F, 0xF3, 0xF8, 0xFF, 0xE7, 0xF8, 0xFE, 0x7F,
  0xF9, 0xFE, 0x3F, 0x9F, 0xFE, 0x7F, 0x0F, 0xE7, 0xFF, 0xBF, 0xC3, 0xFB,
  0xF7, 0xEF, 0xF0, 0xFE, 0xFD, 0xFB, 0xF8, 0x3F, 0xBF, 0x7F, 0xFE, 0x0F,
  0xFF, 0x9F, 0xFF, 0x03, 0xFF, 0xE7, 0xDF, 0xC0, 0xFF, 0xFB, 0xFF, 0xE0,
  0x3F, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFE, 0x03, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3,
  0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x07,
  0xFD, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3,
  0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F,
  0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x05,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0x00, 0x17, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0x1F, 0xF2, 0x00, 0x06, 0x00,
};

const GFXglyph NotoSans_Condensed_BlackItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 16, 35, 13, 0, -34 },
  { 71, 20, 12, 22, 4, -34 },
  { 101, 28, 34, 27, 0, -34 },
  { 220, 24, 39, 24, 1, -36 },
  { 337, 36, 35, 40, 3, -35 },
  { 495, 31, 35, 31, 0, -35 },
  { 631, 10, 12, 12, 4, -34 },
  { 646, 18, 43, 15, 1, -35 },
  { 743, 18, 43, 15, -4, -35 },
  { 840, 21, 23, 23, 3, -37 },
  { 901, 22, 24, 25, 2, -29 },
  { 967, 13, 14, 13, -3, -7 },
  { 990, 14, 8, 15, 0, -17 },
  { 1004, 9, 9, 13, 0, -8 },
  { 1015, 27, 35, 20, -3, -35 },
  { 1134, 22, 35, 24, 2, -35 },
  { 1231, 20, 34, 24, 4, -34 },
  { 1316, 25, 35, 24, -1, -35 },
  { 1426, 24, 35, 24, 0, -35 },
  { 1531, 24, 34, 24, 0, -34 },
  { 1633, 24, 34, 24, 1, -34 },
  { 1735, 23, 35, 24, 2, -35 },
  { 1836, 26, 34, 24, 1, -34 },
  { 1947, 23, 35, 24, 1, -35 },
  { 2048, 23, 35, 24, 1, -35 },
  { 2149, 13, 28, 13, 0, -27 },
  { 2195, 16, 34, 13, -3, -27 },
  { 2263, 22, 25, 25, 2, -30 },
  { 2332, 22, 17, 25, 2, -25 },
  { 2379, 22, 25, 25, 2, -30 },
  { 2448, 20, 36, 20, 2, -35 },
  { 2538, 35, 39, 37, 1, -35 },
  { 2709, 28, 34, 28, -3, -34 },
  { 2828, 27, 34, 27, 0, -34 },
  { 2943, 26, 35, 25, 2, -35 },
  { 3057, 28, 34, 28, 0, -34 },
  { 3176, 24, 34, 22, 0, -34 },
  { 3278, 24, 34, 22, 0, -34 },
  { 3380, 27, 35, 28, 2, -35 },
  { 3499, 31, 34, 29, 0, -34 },
  { 3631, 24, 34, 19, -2, -34 },
  { 3733, 24, 45, 15, -8, -34 },
  { 3868, 31, 34, 27, 0, -34 },
  { 4000, 19, 34, 21, 0, -34 },
  { 4081, 39, 34, 38, 0, -34 },
  { 4247, 33, 34, 32, 0, -34 },
  { 4388, 27, 35, 30, 2, -35 },
  { 4507, 26, 34, 25, 0, -34 },
  { 4618, 27, 43, 30, 2, -35 },
  { 4764, 26, 34, 26, 0, -34 },
  { 4875, 24, 35, 23, 0, -35 },
  { 4980, 22, 34, 22, 4, -34 },
  { 5074, 28, 34, 28, 2, -34 },
  { 5193, 26, 34, 26, 4, -34 },
  { 5304, 39, 34, 38, 4, -34 },
  { 5470, 33, 34, 26, -3, -34 },
  { 5611, 25, 34, 25, 4, -34 },
  { 5718, 28, 34, 22, -2, -34 },
  { 5837, 21, 43, 15, -2, -35 },
  { 5950, 12, 35, 20, 5, -35 },
  { 6003, 21, 43, 15, -4, -35 },
  { 6116, 24, 22, 23, -1, -34 },
  { 6182, 21, 6, 19, -5, 3 },
  { 6198, 11, 8, 16, 7, -37 },
  { 6209, 24, 27, 25, 1, -27 },
  { 6290, 24, 36, 25, 0, -36 },
  { 6398, 21, 27, 21, 1, -27 },
  { 6469, 27, 36, 25, 1, -36 },
  { 6591, 22, 27, 24, 1, -27 },
  { 6666, 27, 49, 16, -5, -37 },
  { 6832, 26, 39, 25, -1, -27 },
  { 6959, 24, 36, 25, 0, -36 },
  { 7067, 15, 37, 13, 0, -37 },
  { 7137, 21, 49, 13, -6, -37 },
  { 7266, 28, 36, 25, 0, -36 },
  { 7392, 16, 36, 13, 0, -36 },
  { 7464, 36, 27, 38, 0, -27 },
  { 7586, 24, 27, 25, 0, -27 },
  { 7667, 23, 27, 25, 1, -27 },
  { 7745, 27, 39, 25, -3, -27 },
  { 7877, 24, 39, 25, 1, -27 },
  { 7994, 20, 27, 18, 0, -27 },
  { 8062, 21, 27, 20, 0, -27 },
  { 8133, 17, 32, 18, 2, -32 },
  { 8201, 25, 27, 25, 1, -27 },
  { 8286, 23, 27, 23, 3, -27 },
  { 8364, 34, 27, 35, 3, -27 },
  { 8479, 29, 27, 24, -3, -27 },
  { 8577, 29, 39, 23, -3, -27 },
  { 8719, 24, 27, 20, -2, -27 },
  { 8800, 20, 42, 17, 0, -34 },
  { 8905, 7, 48, 21, 7, -37 },
  { 8947, 20, 42, 17, -3, -34 },
  { 9052, 22, 10, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_BlackItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC48PT7B_H_
