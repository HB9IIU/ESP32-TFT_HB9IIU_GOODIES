#ifndef _NOTOSANS_CONDENSED_BLACKITALIC45PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x00, 0x10, 0x00, 0x3F, 0x9F, 0xE7, 0xF3, 0xF9, 0xFE, 0x7F, 0x3F, 0x8F,
  0xE7, 0xF1, 0xFC, 0xFE, 0x7F, 0x1F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F,
  0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE3,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE3, 0xF0, 0x00,
  0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE3, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x7E, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80,
  0x7E, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3E,
  0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xB3, 0xC1, 0xFD, 0xC1,
  0x07, 0xF7, 0x00, 0x1F, 0xDC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x10, 0x19, 0xF8,
  0x60, 0xE7, 0xE3, 0xE3, 0xBF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x07,
  0xE0, 0x07, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x7F, 0xFC,
  0x07, 0xC0, 0x0F, 0xCF, 0xC1, 0xF8, 0x01, 0xF1, 0xF8, 0x7E, 0x00, 0x7E,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xC3, 0xF0, 0x01, 0xF8, 0xF8, 0xFC, 0x00,
  0x3E, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0xF8,
  0x3C, 0x3F, 0x3F, 0x3F, 0x1F, 0xC3, 0xFF, 0xEF, 0xCF, 0xFC, 0x7F, 0xF9,
  0xFB, 0xFF, 0xCF, 0xFE, 0x7E, 0x7F, 0xF8, 0xFF, 0xCF, 0x9F, 0xFF, 0x0F,
  0xE3, 0xF3, 0xF3, 0xF0, 0x20, 0xFC, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x8F,
  0x80, 0x07, 0xE3, 0xF1, 0xF0, 0x01, 0xF8, 0x7C, 0x7E, 0x00, 0x3F, 0x0F,
  0x8F, 0xC0, 0x0F, 0xC3, 0xF1, 0xF8, 0x01, 0xF0, 0x7E, 0x3E, 0x00, 0x7E,
  0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0xFE, 0x00,
  0xFC, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0xFF, 0x07,
  0xFF, 0x8F, 0xF0, 0x7F, 0xFC, 0x7F, 0x87, 0xFF, 0xF3, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xCF, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE,
  0x1F, 0xE1, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0x3F,
  0xE3, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x7F,
  0xC0, 0x3F, 0x9F, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x7F,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x20, 0xFC, 0x03,
  0x8F, 0xC0, 0x7E, 0xF8, 0x07, 0xFF, 0x9E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xBF, 0x03, 0xF3, 0xF0, 0x1F, 0x3F, 0x80, 0xE1,
  0xF0, 0x04, 0x1C, 0x00, 0x01, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFD, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFE, 0x7F, 0xF3, 0xFF, 0xC0, 0x1E, 0x3F, 0x9F, 0xDF, 0xFF, 0xF7,
  0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFC, 0xFE, 0x0F,
  0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3,
  0xFC, 0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x87, 0xF9,
  0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC,
  0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF,
  0x07, 0xF3, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFB, 0xFC, 0x3C,
  0xFE, 0x0C, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xF8, 0xFF, 0x01, 0xE1, 0xFE, 0x03, 0x83,
  0xFC, 0x02, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xE1, 0xFF, 0x01, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF1, 0x00, 0x3F, 0xE3, 0xC1, 0xFF,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7F, 0x00, 0x7C, 0xFE, 0x01, 0xFB,
  0xFC, 0x07, 0xE7, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7F,
  0x83, 0xF0, 0xFF, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x39, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x80, 0x3F, 0xE3, 0xC3,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xBF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xF9, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF8,
  0xFE, 0x1F, 0xE3, 0xF8, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF9, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x9F, 0xE1, 0xFC,
  0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xE1, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xF9, 0xFE, 0x1F, 0xE3, 0xF8, 0xFF, 0x0F, 0xE3,
  0xFC, 0x3F, 0xCF, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF3, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x08, 0x1F, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFF, 0x81, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x78, 0xFF, 0x10,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x07,
  0xE0, 0xFF, 0x8F, 0xC3, 0xE1, 0xFF, 0xF3, 0xE3, 0xF1, 0xFF, 0xF1, 0xF1,
  0xF1, 0xFF, 0xF8, 0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0xF8, 0xFC, 0x7E, 0x3E,
  0xFC, 0x7C, 0x3E, 0x1F, 0x7C, 0x7E, 0x1F, 0x0F, 0xBE, 0x3E, 0x0F, 0x8F,
  0x9F, 0x1F, 0x0F, 0xC7, 0xCF, 0x9F, 0x87, 0xC3, 0xEF, 0xCF, 0xC3, 0xE1,
  0xF7, 0xC7, 0xE3, 0xF1, 0xF3, 0xE3, 0xF1, 0xF9, 0xF9, 0xF1, 0xFF, 0xFD,
  0xF8, 0xF8, 0x7F, 0xFF, 0xF8, 0x7C, 0x3F, 0xEF, 0xF8, 0x3F, 0x0F, 0xE7,
  0xF8, 0x0F, 0x83, 0xE1, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xF8, 0xFF, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0xFF,
  0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xE3,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07,
  0xF9, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x3F, 0xCF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFC, 0x78, 0x1F, 0xF0, 0x18, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x80, 0xFF, 0xC7, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFF,
  0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0x83, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0x87, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF8, 0x78,
  0x1F, 0xF8, 0x06, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0xF1, 0xFE,
  0x3F, 0xF8, 0xFF, 0x8F, 0xFE, 0x3F, 0xC3, 0xFF, 0x8F, 0xF1, 0xFF, 0xE3,
  0xFC, 0x7F, 0xF8, 0xFF, 0x1F, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFE, 0x0F, 0xFC,
  0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x7F,
  0xC0, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00,
  0xFF, 0x3F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFD,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFE,
  0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFF,
  0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0x81, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F,
  0xFE, 0x3F, 0x7F, 0x01, 0xFF, 0xF3, 0xFF, 0xF8, 0x1F, 0xFF, 0x9F, 0xBF,
  0x80, 0xFE, 0xFD, 0xFD, 0xFC, 0x07, 0xF7, 0xEF, 0xCF, 0xE0, 0x3F, 0xBF,
  0x7E, 0xFF, 0x03, 0xFD, 0xFF, 0xE7, 0xF8, 0x1F, 0xEF, 0xFF, 0x3F, 0x80,
  0xFE, 0x7F, 0xF1, 0xFC, 0x07, 0xF3, 0xFF, 0x8F, 0xE0, 0x3F, 0x9F, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0xC7, 0xF8, 0x1F, 0xC7, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0xE1, 0xFC, 0x07, 0xF1, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0xFF,
  0x03, 0xFC, 0x7F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x1F, 0xF8,
  0x0F, 0xE0, 0x3F, 0xF8, 0x1F, 0xC0, 0x7F, 0xF0, 0x3F, 0x81, 0xFF, 0xE0,
  0xFF, 0x03, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xC3, 0xF8, 0x0F, 0xFF, 0x87,
  0xF0, 0x1F, 0xFF, 0x0F, 0xE0, 0x7F, 0xFE, 0x3F, 0xC0, 0xFF, 0xFC, 0x7F,
  0x01, 0xFD, 0xFC, 0xFE, 0x03, 0xFB, 0xF9, 0xFC, 0x07, 0xF7, 0xF3, 0xF8,
  0x1F, 0xCF, 0xEF, 0xF0, 0x3F, 0x9F, 0xFF, 0xC0, 0x7F, 0x1F, 0xFF, 0x80,
  0xFE, 0x3F, 0xFF, 0x03, 0xFC, 0x7F, 0xFE, 0x07, 0xF8, 0xFF, 0xFC, 0x0F,
  0xE1, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0xE0, 0x3F, 0x83, 0xFF, 0xC0, 0xFF,
  0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFE, 0x03, 0xF8, 0x1F, 0xFC, 0x07, 0xF0,
  0x1F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xF3, 0xFE,
  0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xF7,
  0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x3F,
  0xE1, 0xFF, 0x0F, 0xFD, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xF7, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xF3, 0xFE,
  0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xF7,
  0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x3F,
  0xE1, 0xFF, 0x0F, 0xFD, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xE7, 0xFC, 0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0x81,
  0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x9F, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0x7F,
  0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xF8,
  0x3F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFE, 0x7C, 0x0F, 0xF0, 0x30, 0x1F, 0xE0,
  0x20, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x40, 0x1F, 0xE0, 0xE0, 0x7F, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F,
  0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x7F,
  0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F,
  0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC,
  0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F,
  0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xF7, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xFB,
  0xF8, 0x0F, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xF8,
  0x1F, 0xE7, 0xF0, 0x3F, 0xC0, 0xFE, 0x3F, 0x83, 0xFE, 0x0F, 0xF1, 0xFC,
  0x1F, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xFC, 0x3F,
  0xC3, 0xF8, 0x7F, 0xE1, 0xFC, 0x1F, 0xC7, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F,
  0xF8, 0xFF, 0x07, 0xF3, 0xFF, 0xCF, 0xF0, 0x3F, 0x9F, 0xFE, 0x7F, 0x81,
  0xFC, 0xFF, 0xF3, 0xF8, 0x0F, 0xEF, 0xFF, 0xBF, 0xC0, 0x7F, 0x7E, 0xFD,
  0xFE, 0x03, 0xFF, 0xF7, 0xEF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0xFD,
  0xFB, 0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xFC,
  0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0xF1,
  0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0x8F, 0xF0,
  0x7F, 0x9F, 0xE0, 0x3F, 0xBF, 0xC0, 0x3F, 0xBF, 0xC0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0,
  0x3F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0xFE, 0x1F,
  0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF3, 0xF8, 0x07, 0xFF, 0xE0,
  0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x81, 0xF8,
  0x01, 0xF8, 0xFE, 0x07, 0xF9, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF9, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F,
  0xC7, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF0,
  0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F,
  0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x1F, 0x9F, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF9, 0xFF, 0x1F, 0xE1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F,
  0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0x87, 0xF8,
  0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFE, 0x7F, 0x87, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFE, 0xFF, 0x81, 0xF8,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xF8, 0x61, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x43, 0xFE, 0x38, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0xFF, 0x00, 0xFF, 0x7F,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xCF, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFC,
  0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xCF, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x8F, 0xFB, 0xFC, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0x87,
  0xFB, 0xFC, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x61, 0xFF, 0xBF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x7F,
  0xEF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xE7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF3, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xEF, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x0C, 0x01, 0xFE, 0x07, 0xE3,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE7, 0xE0, 0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xC3,
  0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF1,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0xC0, 0x00,
  0x78, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0xC0, 0x3F, 0x9F, 0xE0,
  0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xF9, 0xFE, 0x01,
  0xFE, 0x7F, 0x80, 0x7F, 0x1F, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x7F, 0x01, 0xF9, 0xFF, 0x3F, 0xE0,
  0x7E, 0xFF, 0xDF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xBF, 0xF3, 0xFC, 0x7F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x8F, 0xF0,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F,
  0x87, 0xF8, 0x7F, 0x1F, 0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F,
  0x8F, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x0F, 0xDF, 0xF0, 0x1F, 0xBF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x8F, 0xF8,
  0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC,
  0x3F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87,
  0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0x9F, 0xE7, 0xF8, 0xFF, 0x3F,
  0x83, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8,
  0xFF, 0x3F, 0xC7, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x7F, 0xC0, 0x0F, 0xDF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07,
  0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0x7F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x07, 0xF9, 0xFC, 0x1F,
  0xFB, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF9,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xEF, 0xE0, 0x1F, 0xBF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x87, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x07, 0xF0, 0x60, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x90, 0x0F, 0xF3, 0x83, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x10, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F,
  0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0xFF,
  0x0F, 0xF1, 0xFE, 0x3F, 0xE3, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFB, 0xF0, 0x3F, 0xF7, 0xE0, 0x3F, 0x8F,
  0xC0, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFD, 0xFC, 0x1F, 0xEF,
  0xE1, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF8, 0xFE, 0x3F,
  0x87, 0xF3, 0xFC, 0x3F, 0x9F, 0xC1, 0xFD, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F,
  0x7F, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xF0, 0xFF, 0xFE,
  0x1F, 0xF0, 0xFE, 0xFE, 0x1F, 0xF1, 0xFE, 0xFE, 0x3F, 0xF1, 0xFE, 0xFE,
  0x3F, 0xF1, 0xFC, 0xFE, 0x7F, 0xF3, 0xFC, 0xFE, 0x7F, 0xF3, 0xF8, 0xFE,
  0x7F, 0xE3, 0xF8, 0xFE, 0xFF, 0xE7, 0xF0, 0xFE, 0xFB, 0xE7, 0xF0, 0xFE,
  0xFB, 0xEF, 0xF0, 0xFF, 0xFB, 0xEF, 0xE0, 0xFD, 0xFB, 0xEF, 0xE0, 0xFD,
  0xF7, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x80, 0xFF,
  0xE7, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x7F,
  0x80, 0x3F, 0xDF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x8F,
  0xE0, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFC,
  0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x02, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x17, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFE,
};

const GFXglyph NotoSans_Condensed_BlackItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 33, 12, 0, -32 },
  { 63, 19, 11, 20, 4, -32 },
  { 90, 27, 32, 25, 0, -32 },
  { 198, 22, 37, 23, 1, -34 },
  { 300, 35, 33, 37, 2, -33 },
  { 445, 29, 33, 29, 0, -33 },
  { 565, 9, 11, 11, 4, -32 },
  { 578, 17, 40, 14, 1, -33 },
  { 663, 16, 40, 14, -3, -33 },
  { 743, 20, 22, 21, 3, -35 },
  { 798, 20, 22, 24, 2, -27 },
  { 853, 12, 12, 12, -3, -6 },
  { 871, 14, 6, 14, 0, -15 },
  { 882, 9, 9, 12, 0, -8 },
  { 893, 25, 33, 19, -2, -33 },
  { 997, 22, 33, 23, 1, -33 },
  { 1088, 18, 32, 23, 4, -32 },
  { 1160, 23, 33, 23, -1, -33 },
  { 1255, 23, 33, 23, 0, -33 },
  { 1350, 23, 32, 23, 0, -32 },
  { 1442, 22, 32, 23, 1, -32 },
  { 1530, 22, 33, 23, 2, -33 },
  { 1621, 24, 32, 23, 1, -32 },
  { 1717, 22, 33, 23, 1, -33 },
  { 1808, 22, 33, 23, 1, -33 },
  { 1899, 12, 26, 13, 0, -25 },
  { 1938, 15, 31, 13, -3, -25 },
  { 1997, 20, 23, 24, 2, -28 },
  { 2055, 20, 16, 24, 2, -24 },
  { 2095, 20, 23, 24, 2, -28 },
  { 2153, 18, 34, 18, 2, -33 },
  { 2230, 33, 37, 34, 1, -33 },
  { 2383, 26, 32, 26, -3, -32 },
  { 2487, 25, 32, 25, 0, -32 },
  { 2587, 24, 33, 23, 2, -33 },
  { 2686, 26, 32, 26, 0, -32 },
  { 2790, 23, 32, 21, 0, -32 },
  { 2882, 23, 32, 21, 0, -32 },
  { 2974, 26, 33, 27, 2, -33 },
  { 3082, 29, 32, 27, 0, -32 },
  { 3198, 23, 32, 18, -2, -32 },
  { 3290, 22, 42, 14, -7, -32 },
  { 3406, 29, 32, 25, 0, -32 },
  { 3522, 18, 32, 20, 0, -32 },
  { 3594, 37, 32, 36, 0, -32 },
  { 3742, 31, 32, 30, 0, -32 },
  { 3866, 26, 33, 28, 2, -33 },
  { 3974, 24, 32, 24, 0, -32 },
  { 4070, 26, 41, 28, 2, -33 },
  { 4204, 25, 32, 25, 0, -32 },
  { 4304, 23, 33, 21, 0, -33 },
  { 4399, 21, 32, 21, 3, -32 },
  { 4483, 26, 32, 27, 2, -32 },
  { 4587, 25, 32, 25, 4, -32 },
  { 4687, 37, 32, 36, 3, -32 },
  { 4835, 31, 32, 25, -3, -32 },
  { 4959, 24, 32, 24, 4, -32 },
  { 5055, 26, 32, 21, -2, -32 },
  { 5159, 19, 41, 14, -2, -33 },
  { 5257, 11, 33, 19, 5, -33 },
  { 5303, 19, 41, 14, -3, -33 },
  { 5401, 23, 21, 22, -1, -32 },
  { 5462, 19, 5, 18, -4, 3 },
  { 5474, 11, 7, 15, 6, -34 },
  { 5484, 23, 25, 24, 1, -25 },
  { 5556, 23, 34, 24, 0, -34 },
  { 5654, 19, 25, 19, 1, -25 },
  { 5714, 25, 34, 23, 1, -34 },
  { 5821, 21, 25, 22, 1, -25 },
  { 5887, 25, 45, 15, -5, -34 },
  { 6028, 25, 36, 24, -1, -25 },
  { 6141, 23, 34, 24, 0, -34 },
  { 6239, 14, 35, 12, 0, -35 },
  { 6301, 20, 46, 12, -6, -35 },
  { 6416, 26, 34, 24, 0, -34 },
  { 6527, 15, 34, 12, 0, -34 },
  { 6591, 34, 25, 35, 0, -25 },
  { 6698, 23, 25, 24, 0, -25 },
  { 6770, 21, 25, 23, 1, -25 },
  { 6836, 26, 36, 24, -3, -25 },
  { 6953, 23, 36, 24, 1, -25 },
  { 7057, 19, 25, 17, 0, -25 },
  { 7117, 19, 25, 19, 0, -25 },
  { 7177, 16, 30, 17, 2, -30 },
  { 7237, 23, 25, 24, 1, -25 },
  { 7309, 21, 25, 22, 3, -25 },
  { 7375, 32, 25, 32, 3, -25 },
  { 7475, 27, 25, 22, -2, -25 },
  { 7560, 27, 36, 22, -3, -25 },
  { 7682, 22, 25, 19, -2, -25 },
  { 7751, 19, 39, 16, 0, -32 },
  { 7844, 6, 45, 20, 7, -35 },
  { 7878, 19, 39, 16, -3, -32 },
  { 7971, 20, 8, 24, 2, -20 },
};

const GFXfont NotoSans_Condensed_BlackItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC45PT7B_H_
