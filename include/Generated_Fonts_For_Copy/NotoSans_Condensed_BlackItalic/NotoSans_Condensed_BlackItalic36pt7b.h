#ifndef _NOTOSANS_CONDENSED_BLACKITALIC36PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0x80, 0x3F, 0x7E, 0xFC, 0xFD, 0xF9, 0xFB, 0xF3, 0xE7,
  0xC7, 0xCF, 0x9F, 0x9F, 0x3F, 0x3E, 0x7C, 0xF8, 0xF9, 0xF1, 0xF0, 0x00,
  0x78, 0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x07, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0x80,
  0x1E, 0x7C, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0xF9, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0,
  0x7D, 0x9C, 0x3F, 0x61, 0x0F, 0xD8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x6F,
  0x88, 0x1B, 0xE3, 0x06, 0xF8, 0xFB, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xC0, 0x1F, 0x03, 0xFC, 0x07, 0xC0, 0xFF, 0xC0, 0xF0,
  0x1F, 0xF8, 0x3E, 0x07, 0xDF, 0x07, 0x80, 0xF9, 0xE1, 0xF0, 0x1E, 0x7C,
  0x7C, 0x07, 0xCF, 0x8F, 0x00, 0xF9, 0xF3, 0xE0, 0x1F, 0x3E, 0xF8, 0x03,
  0xC7, 0x9F, 0x1C, 0x7D, 0xF7, 0xCF, 0xEF, 0xFC, 0xF3, 0xFF, 0xFF, 0xBE,
  0xFF, 0xDF, 0xEF, 0x9F, 0xF9, 0xF1, 0xE7, 0xCF, 0x00, 0x7C, 0xF1, 0xE0,
  0x0F, 0x3E, 0x3C, 0x03, 0xE7, 0xCF, 0x80, 0xF8, 0xF9, 0xF0, 0x1E, 0x1F,
  0x3C, 0x07, 0xC3, 0xEF, 0x81, 0xF0, 0x7F, 0xF0, 0x3E, 0x07, 0xFC, 0x0F,
  0x80, 0xFF, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xCF, 0xE3, 0xFF, 0x9F, 0x8F, 0xFF,
  0x3F, 0x3F, 0xFF, 0xFC, 0x7E, 0x7F, 0xF8, 0xFC, 0xFF, 0xE3, 0xF0, 0xFF,
  0xC7, 0xE1, 0xFF, 0x0F, 0xE3, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x21, 0xF0, 0x31, 0xE0, 0x7D, 0xE1, 0x7F, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0x07, 0xFF, 0x0F, 0xE1, 0x1F, 0xF0, 0x3F, 0xF8, 0x7E, 0xF8, 0x1E,
  0x7C, 0x0C, 0x78, 0x04, 0x60, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8,
  0xFC, 0x7C, 0x00, 0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0xEF, 0xFC, 0x7C, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0xFE, 0xFC, 0x7E, 0x7E,
  0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1,
  0xFB, 0xF1, 0xFF, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x3F, 0xBF,
  0x1F, 0x9F, 0x9F, 0xCF, 0xCF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF8, 0xFB, 0xF0,
  0xCF, 0xE1, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xE3, 0xF8, 0x10,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xC7, 0xF0, 0x40, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF2, 0x01, 0xFC, 0xC0, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0xF7, 0xC0, 0x7F, 0xF0, 0x3E, 0xFC, 0x0F, 0x3F,
  0x07, 0x8F, 0xC3, 0xE7, 0xE1, 0xF1, 0xF8, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x81, 0x8F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE2, 0x03, 0xF8, 0xC1, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xF8, 0x21, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xDF, 0x07, 0xEF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xF3, 0xF3, 0xF8, 0xFC, 0xFE, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xF3,
  0xF1, 0xF8, 0xFE, 0x7E, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF3, 0xF0, 0xFC, 0x7C, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF7, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1,
  0xF3, 0xF0, 0xFC, 0xFE, 0x3F, 0x1F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF1, 0xFD, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x7F, 0x1F,
  0xBF, 0x0F, 0xDF, 0x8F, 0xEF, 0xE7, 0xF7, 0xFF, 0xFB, 0xFF, 0xF8, 0xFF,
  0xFC, 0x7F, 0xFE, 0x1F, 0xBE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x3F, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80,
  0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0xFE, 0x3F, 0x8F,
  0xC3, 0xF0, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0xFF,
  0xE7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0xE3, 0xF2, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x7C, 0x7F, 0xCF, 0x3E, 0x3F, 0xF3,
  0xCF, 0x1F, 0xFC, 0xF7, 0xCF, 0x9F, 0x3D, 0xE3, 0xC7, 0x8F, 0x79, 0xF1,
  0xE3, 0xDE, 0x78, 0x78, 0xFF, 0x1E, 0x3E, 0x3F, 0xCF, 0x8F, 0x1E, 0xF3,
  0xE3, 0xC7, 0xBC, 0xF9, 0xF3, 0xCF, 0x3F, 0xFD, 0xF3, 0xC7, 0xFF, 0xF8,
  0xF1, 0xFD, 0xFC, 0x3E, 0x3E, 0x3C, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x7E, 0x03, 0xF7,
  0xF0, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0xFF, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F,
  0xC7, 0xF0, 0xFC, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xF9, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0x3C, 0x1F,
  0xC0, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x0E,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x1F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x7F,
  0x0F, 0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xE7, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE0,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFC, 0xF0,
  0x7F, 0x80, 0x83, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x7F, 0xE7, 0xF3, 0xFE, 0x3F, 0x1F, 0xF1, 0xF8, 0xFF, 0x9F,
  0xCF, 0xFC, 0xFE, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xF1, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0,
  0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83,
  0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x80, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x4F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFF,
  0x07, 0xE0, 0xFE, 0x07, 0xE1, 0xFC, 0x07, 0xE3, 0xF8, 0x07, 0xE3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0xDF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0,
  0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F,
  0xF1, 0xFF, 0xC1, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC,
  0xFF, 0xE0, 0x7D, 0xF7, 0xDF, 0x83, 0xF7, 0xDF, 0x7E, 0x0F, 0xDF, 0xFB,
  0xF0, 0x3F, 0x7F, 0xEF, 0xC0, 0xFD, 0xFF, 0x3F, 0x03, 0xE7, 0xFC, 0xFC,
  0x1F, 0x9F, 0xE3, 0xE0, 0x7E, 0x7F, 0x9F, 0x81, 0xF9, 0xFE, 0x7E, 0x07,
  0xE7, 0xF1, 0xF8, 0x1F, 0x1F, 0xC7, 0xE0, 0xFC, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0x83, 0xFC, 0x0F, 0xC1, 0xFE, 0x07,
  0xC0, 0xFF, 0x07, 0xE0, 0x7F, 0x83, 0xF0, 0x7F, 0xE1, 0xF8, 0x3F, 0xF0,
  0xFC, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x7E, 0x07, 0xFF, 0x3F, 0x07, 0xFF,
  0x9F, 0x83, 0xFF, 0xCF, 0xC1, 0xFF, 0xEF, 0xC0, 0xF9, 0xF7, 0xE0, 0xFC,
  0xFF, 0xF0, 0x7E, 0x7F, 0xF8, 0x3F, 0x3F, 0xF8, 0x1F, 0x8F, 0xFC, 0x0F,
  0x87, 0xFE, 0x0F, 0xC3, 0xFF, 0x07, 0xE1, 0xFF, 0x83, 0xF0, 0xFF, 0x81,
  0xF8, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0xFC, 0x0F, 0xF0, 0x7E, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFB, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x3F, 0x3F, 0x81,
  0xF9, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF,
  0x01, 0xFD, 0xF8, 0x0F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F,
  0xBF, 0x83, 0xF8, 0xFC, 0x3F, 0xC7, 0xF3, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F,
  0xCF, 0xE1, 0xF8, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFB, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x3F,
  0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFE, 0x07, 0xF7, 0xF0,
  0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0x3F, 0x83, 0xF8, 0xFC, 0x3F, 0xC7, 0xF3, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0xFF, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F,
  0xC7, 0xF0, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xFB, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xF0,
  0x3F, 0x7F, 0x07, 0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF8, 0x7E, 0x3F,
  0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0xCF, 0xC1, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFC, 0x10,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xE1, 0x01, 0xF8, 0xF9, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F,
  0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x87, 0xF3,
  0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F,
  0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0xFC, 0x0F, 0xEF,
  0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8,
  0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0xFC,
  0x07, 0xCF, 0xC0, 0x7D, 0xF8, 0x07, 0xDF, 0x80, 0x7D, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0x81,
  0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x07, 0xE0, 0xFD, 0xF8, 0x3F, 0x07, 0xEF,
  0xC3, 0xF8, 0x7E, 0x7E, 0x1F, 0xC3, 0xF3, 0xF1, 0xFE, 0x3F, 0x9F, 0x8F,
  0xF1, 0xF8, 0xFC, 0x7F, 0x8F, 0xC7, 0xE7, 0xFC, 0xFC, 0x3F, 0x3F, 0xE7,
  0xE1, 0xFB, 0xFF, 0x3F, 0x0F, 0xDF, 0xFB, 0xF0, 0x7E, 0xFF, 0xDF, 0x83,
  0xFF, 0xBF, 0xF8, 0x1F, 0x7D, 0xFF, 0xC0, 0xFF, 0xCF, 0xFE, 0x07, 0xFE,
  0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFC, 0x01, 0xF9, 0xFC, 0x01,
  0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F,
  0xCF, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0xFE,
  0x07, 0xF0, 0xFE, 0x0F, 0xFF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7,
  0xE3, 0xF0, 0xFC, 0xFE, 0x1F, 0x9F, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF,
  0x80, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xEF, 0x00, 0xFD, 0xF0, 0x1F,
  0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0,
  0x3E, 0xFC, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x7E, 0x7E, 0x3F, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xFB,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xF8, 0xFC, 0xFE, 0x3F, 0x3F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xF7, 0xC0, 0xF9, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x0F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xCF, 0xC7, 0xE3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xF3, 0xF1, 0xF9,
  0xF8, 0x7E, 0x7E, 0x3F, 0x9F, 0xCF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3E, 0xFF, 0x0F, 0x9F, 0x80, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8,
  0xFF, 0xE3, 0xFF, 0xC7, 0xE1, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x0C, 0x7F, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x7C, 0xFC, 0x0F, 0xEF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0,
  0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xCF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xF7,
  0xC0, 0x3E, 0x7C, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFB, 0xF1, 0xF8, 0xFD, 0xF8, 0x7C, 0xFC, 0x7E, 0xFF, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x11,
  0xFC, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xF4, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x3F,
  0xBF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0xFE, 0x1F,
  0xCF, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFB, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x80, 0x7E, 0x0F, 0x0F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x7C, 0x0F, 0xBF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0xCF, 0xC7, 0xE0, 0x01, 0xC0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E,
  0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x7F,
  0x0F, 0xC7, 0xF0, 0xFE, 0x7F, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xFB,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x3F,
  0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x9F, 0x0F, 0xC1, 0xF7,
  0xF3, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF9, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F,
  0xC7, 0xE7, 0xE3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7,
  0xE1, 0xF8, 0xFC, 0xFC, 0x7F, 0x1F, 0x9F, 0x8F, 0xC7, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0x87, 0xE3, 0xF3, 0xF1, 0xF8, 0x7E, 0x7E,
  0x3F, 0x1F, 0xC0, 0x0F, 0x9F, 0x03, 0xEF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0xFE, 0x3F, 0x3F, 0x0F, 0xCF,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7F, 0x1F, 0x9F, 0x8F, 0xE7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xF3, 0xF1, 0xF8,
  0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9,
  0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xDF,
  0x87, 0xEF, 0xC3, 0xF7, 0xE3, 0xF3, 0xF1, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x3E, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x3F, 0x07, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0xCF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xC3, 0xFB,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFB, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x0F, 0x9E, 0x1F, 0x7C, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE3,
  0xFB, 0xC7, 0xE1, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x20, 0x7E, 0x7F, 0xFC, 0xFF, 0xF9,
  0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xFF, 0xF8, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xF3, 0xF8, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0xCF, 0xEF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xF9, 0xF0, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xDF, 0x87, 0xEF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF3, 0xF0,
  0xF9, 0xF8, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x7F, 0x0F, 0xFF, 0x1F, 0xC7, 0xEF, 0xC7,
  0xF1, 0xFB, 0xF3, 0xFC, 0x7E, 0xFC, 0xFF, 0x3F, 0x3F, 0x3F, 0xCF, 0xCF,
  0xDF, 0xF7, 0xE3, 0xF7, 0xFD, 0xF8, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFD, 0xFF, 0xC3, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x3F, 0xE7,
  0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F,
  0xC7, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xFC,
  0x1F, 0x8F, 0xE0, 0x7E, 0x7F, 0x01, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x80, 0xFC, 0x7E, 0x07, 0xF1,
  0xF8, 0x3F, 0x87, 0xF0, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x3F, 0x00, 0xF9,
  0xF8, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC3, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x30, 0x00, 0x3F,
  0x00, 0xBF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFA,
  0x00, 0x70,
};

const GFXglyph NotoSans_Condensed_BlackItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 26, 10, 0, -26 },
  { 40, 15, 10, 16, 3, -26 },
  { 59, 21, 26, 20, 0, -26 },
  { 128, 18, 29, 18, 1, -27 },
  { 194, 27, 26, 30, 2, -26 },
  { 282, 23, 26, 23, 0, -26 },
  { 357, 8, 10, 9, 3, -26 },
  { 367, 13, 32, 11, 1, -26 },
  { 419, 14, 32, 11, -3, -26 },
  { 475, 16, 17, 17, 2, -28 },
  { 509, 16, 17, 19, 2, -21 },
  { 543, 9, 10, 10, -2, -5 },
  { 555, 11, 5, 11, 0, -12 },
  { 562, 7, 6, 10, 0, -6 },
  { 568, 20, 26, 15, -2, -26 },
  { 633, 17, 26, 18, 1, -26 },
  { 689, 15, 26, 18, 3, -26 },
  { 738, 19, 26, 18, -1, -26 },
  { 800, 18, 26, 18, 0, -26 },
  { 859, 18, 26, 18, 0, -26 },
  { 918, 18, 26, 18, 1, -26 },
  { 977, 18, 26, 18, 1, -26 },
  { 1036, 19, 26, 18, 1, -26 },
  { 1098, 18, 26, 18, 0, -26 },
  { 1157, 17, 26, 18, 1, -26 },
  { 1213, 10, 20, 10, 0, -20 },
  { 1238, 12, 25, 10, -2, -20 },
  { 1276, 17, 18, 19, 1, -22 },
  { 1315, 16, 13, 19, 2, -19 },
  { 1341, 16, 18, 19, 2, -22 },
  { 1377, 14, 26, 15, 2, -26 },
  { 1423, 26, 29, 27, 1, -26 },
  { 1518, 21, 26, 21, -2, -26 },
  { 1587, 20, 26, 20, 0, -26 },
  { 1652, 20, 26, 19, 1, -26 },
  { 1717, 21, 26, 21, 0, -26 },
  { 1786, 18, 26, 17, 0, -26 },
  { 1845, 18, 26, 16, 0, -26 },
  { 1904, 21, 26, 21, 1, -26 },
  { 1973, 23, 26, 22, 0, -26 },
  { 2048, 17, 26, 14, -1, -26 },
  { 2104, 18, 34, 11, -6, -26 },
  { 2181, 24, 26, 20, 0, -26 },
  { 2259, 14, 26, 16, 0, -26 },
  { 2305, 30, 26, 29, 0, -26 },
  { 2403, 25, 26, 24, 0, -26 },
  { 2485, 21, 26, 22, 1, -26 },
  { 2554, 20, 26, 19, 0, -26 },
  { 2619, 21, 32, 22, 1, -26 },
  { 2703, 20, 26, 20, 0, -26 },
  { 2768, 18, 26, 17, 0, -26 },
  { 2827, 16, 26, 17, 3, -26 },
  { 2879, 20, 26, 21, 2, -26 },
  { 2944, 20, 26, 20, 3, -26 },
  { 3009, 29, 26, 29, 3, -26 },
  { 3104, 24, 26, 20, -2, -26 },
  { 3182, 19, 26, 19, 3, -26 },
  { 3244, 20, 26, 17, -1, -26 },
  { 3309, 16, 32, 11, -2, -26 },
  { 3373, 9, 26, 15, 4, -26 },
  { 3403, 16, 32, 11, -3, -26 },
  { 3467, 19, 17, 18, -1, -26 },
  { 3508, 15, 5, 15, -3, 2 },
  { 3518, 8, 6, 12, 5, -28 },
  { 3524, 18, 20, 19, 1, -20 },
  { 3569, 18, 27, 19, 0, -27 },
  { 3630, 15, 20, 15, 1, -20 },
  { 3668, 20, 27, 19, 1, -27 },
  { 3736, 17, 20, 18, 1, -20 },
  { 3779, 20, 37, 12, -4, -28 },
  { 3872, 20, 29, 19, -1, -20 },
  { 3945, 18, 27, 19, 0, -27 },
  { 4006, 11, 28, 10, 0, -28 },
  { 4045, 16, 37, 10, -5, -28 },
  { 4119, 21, 27, 19, 0, -27 },
  { 4190, 12, 27, 10, 0, -27 },
  { 4231, 27, 20, 28, 0, -20 },
  { 4299, 18, 20, 19, 0, -20 },
  { 4344, 17, 20, 19, 1, -20 },
  { 4387, 20, 29, 19, -2, -20 },
  { 4460, 18, 29, 19, 1, -20 },
  { 4526, 15, 20, 14, 0, -20 },
  { 4564, 15, 20, 15, 0, -20 },
  { 4602, 14, 24, 14, 1, -24 },
  { 4644, 18, 20, 19, 1, -20 },
  { 4689, 17, 20, 17, 2, -20 },
  { 4732, 26, 20, 26, 2, -20 },
  { 4797, 22, 20, 18, -2, -20 },
  { 4852, 21, 29, 17, -2, -20 },
  { 4929, 17, 20, 15, -1, -20 },
  { 4972, 15, 32, 13, 0, -26 },
  { 5032, 5, 36, 16, 5, -28 },
  { 5055, 14, 32, 13, -2, -26 },
  { 5111, 17, 7, 19, 1, -16 },
};

const GFXfont NotoSans_Condensed_BlackItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC36PT7B_H_
