#ifndef _NOTOSANS_CONDENSED_BLACKITALIC55PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x3F, 0xE3, 0xFE, 0x7F, 0xCF,
  0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xCF, 0xF8, 0xFF,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xE3,
  0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xBC,
  0x78, 0x1F, 0xE7, 0x02, 0x03, 0xFC, 0xE0, 0x00, 0x7F, 0x9C, 0x00, 0x0F,
  0xFB, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xCF, 0xF0, 0x80, 0x39, 0xFE, 0x1C, 0x07,
  0x3F, 0xC3, 0xE1, 0xEF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xF0, 0x03, 0xFD, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x3F, 0x01, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC3, 0xF0, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF1,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x9F, 0xE7, 0xF1, 0xFF, 0x8F,
  0xF7, 0xF3, 0xFC, 0xFF, 0xF3, 0xFF, 0xFC, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0x3F, 0xFF, 0x9F, 0xFF, 0x3F, 0xCF, 0xFF, 0xE3, 0xFF, 0x8F, 0xE7,
  0xFB, 0xFC, 0x7F, 0xC7, 0xF1, 0xFC, 0x7F, 0x07, 0xC1, 0xFC, 0xFF, 0x1F,
  0xC0, 0x00, 0xFE, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x8F, 0xE1, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x3F, 0x80, 0x03, 0xF8,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF1, 0xFF,
  0x80, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xF9,
  0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF7,
  0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xF0, 0x3F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF7, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFB, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0xBF, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x20, 0x3F, 0x80, 0x38, 0x3F, 0x80, 0x3E, 0x7F, 0x00,
  0x7F, 0x7F, 0x02, 0x7F, 0xFF, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xCF, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0x8F, 0xF0, 0x0F, 0x0F, 0xF8,
  0x07, 0x07, 0xC0, 0x02, 0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x03, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFE, 0xFF, 0x83, 0xFF, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x7F, 0xE1,
  0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xFC, 0x3F, 0xF3, 0xFE, 0x0F, 0xFC, 0xFF,
  0x83, 0xFF, 0x7F, 0xE0, 0xFF, 0x9F, 0xF8, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9,
  0xFF, 0x03, 0xFE, 0x7F, 0xC1, 0xFF, 0xBF, 0xF0, 0x7F, 0xEF, 0xFC, 0x1F,
  0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0xFF, 0xCF, 0xF8,
  0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x87, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0xFF, 0xC3, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE1,
  0xFE, 0xFF, 0x83, 0xE7, 0xFE, 0x0F, 0x1F, 0xF8, 0x18, 0x7F, 0xC0, 0x41,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0xF8, 0x03, 0xF0, 0xFF,
  0xC0, 0x1E, 0x07, 0xFE, 0x00, 0x60, 0x3F, 0xF0, 0x02, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xF8, 0x7F, 0xF0, 0x0E, 0x03, 0xFF,
  0x00, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x80, 0x03,
  0xFF, 0x0E, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0x80, 0x0F, 0xEF, 0xF8, 0x01, 0xFD, 0xFF,
  0x80, 0x3F, 0x9F, 0xF0, 0x07, 0xF1, 0xFF, 0x00, 0x7F, 0x1F, 0xF0, 0x0F,
  0xE3, 0xFF, 0x01, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xF8, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF7, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0E, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE1, 0x00, 0x0F, 0xFC, 0x38,
  0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0xFC, 0x01,
  0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF8, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8, 0x7F,
  0xE3, 0xFF, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xF1, 0xFF,
  0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFE,
  0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF,
  0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE,
  0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xC1, 0xFF, 0x8F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x3F, 0xE0,
  0xFF, 0x8F, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0xFF, 0xC7,
  0xFE, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xC7, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03,
  0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x0C, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0x87, 0xFE, 0x1C, 0x07, 0xFC,
  0x20, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xE0,
  0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0x87, 0xE0, 0x7F, 0x07, 0xFF, 0xF3, 0xF0,
  0x7F, 0x07, 0xFF, 0xF1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0xFE, 0x3F, 0x87,
  0xFF, 0xFC, 0x7F, 0x1F, 0x87, 0xF8, 0xFC, 0x3F, 0x9F, 0xC3, 0xF8, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC7, 0xE1, 0xF8, 0x3F, 0x87, 0xE7,
  0xF1, 0xFC, 0x1F, 0xC3, 0xF3, 0xF8, 0xFE, 0x0F, 0xC1, 0xF9, 0xF8, 0x7E,
  0x07, 0xE1, 0xFC, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x7E, 0x3F, 0x83, 0xF8,
  0x7E, 0x3F, 0x1F, 0xC1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE1, 0xFC, 0x3F, 0x1F,
  0xC7, 0xF1, 0xFE, 0x3F, 0x0F, 0xE3, 0xFD, 0xFF, 0xFF, 0x87, 0xF0, 0xFF,
  0xFF, 0xFF, 0x81, 0xF8, 0x7F, 0xFF, 0xFF, 0x80, 0xFC, 0x3F, 0xFB, 0xFF,
  0x80, 0x7E, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0x81, 0xF0, 0x3F, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFC,
  0xFF, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7,
  0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x7F,
  0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xF7, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xEF, 0xE0, 0x1F, 0xFC, 0x07, 0x00, 0xFF, 0xE0, 0x04,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x40, 0x1F, 0xFC, 0x0F, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03,
  0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0x80, 0x30, 0x0F, 0xFF, 0x00, 0x10, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF1, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xF8, 0x7F,
  0xE1, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x01,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xFC, 0x00,
  0x3F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFB, 0xF8,
  0x7F, 0x7F, 0xC0, 0x3F, 0xDF, 0xC7, 0xFF, 0xFC, 0x03, 0xFE, 0xFE, 0x3F,
  0xBF, 0xE0, 0x1F, 0xF7, 0xF3, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0x9F, 0xEF,
  0xF8, 0x07, 0xFD, 0xFC, 0xFE, 0xFF, 0xC0, 0x3F, 0xCF, 0xEF, 0xF7, 0xFC,
  0x03, 0xFE, 0x7F, 0x7F, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0xF9, 0xFF, 0x00,
  0xFF, 0x9F, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0xFF, 0xFC, 0xFF, 0x80, 0x7F,
  0xC7, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1,
  0xFF, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F,
  0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xF8,
  0x1F, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0,
  0xFF, 0x80, 0x7F, 0xFF, 0xC3, 0xFE, 0x01, 0xFE, 0xFF, 0x8F, 0xF8, 0x07,
  0xFB, 0xFE, 0x3F, 0xC0, 0x1F, 0xEF, 0xF9, 0xFF, 0x00, 0xFF, 0x9F, 0xE7,
  0xFC, 0x03, 0xFE, 0x7F, 0x9F, 0xF0, 0x0F, 0xF9, 0xFF, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFD, 0xFE, 0x00, 0xFF, 0x1F, 0xF7, 0xF8, 0x07, 0xFC, 0x3F, 0xFF,
  0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0xFE, 0x01, 0xFF,
  0x0F, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xDF,
  0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x03,
  0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x03,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x03,
  0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07,
  0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0xFE,
  0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x03, 0xFF,
  0x1F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF,
  0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF8,
  0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x83,
  0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0x81, 0xFF, 0x8F, 0xFE, 0x07, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFB,
  0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE3, 0xFF,
  0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x78, 0x07, 0xFE, 0x01, 0x80, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x04, 0x00, 0x7F, 0xE0, 0x70, 0x07, 0xFE, 0x07, 0xE1, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xFC,
  0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F,
  0xF3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xF0,
  0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x3F,
  0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0x9F, 0xF0,
  0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xFB, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x7F, 0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xFB, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE7, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x1F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFE, 0x0F, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF,
  0x87, 0xFF, 0xC3, 0xFE, 0x07, 0xF8, 0x3F, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3,
  0xFF, 0xF1, 0xFF, 0x81, 0xFE, 0x1F, 0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF,
  0xFC, 0xFF, 0xC0, 0x7F, 0x8F, 0xFF, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0xFE,
  0x3F, 0xE0, 0x3F, 0xE7, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0x3F, 0xBF, 0x9F,
  0xF0, 0x0F, 0xFB, 0xFD, 0xFC, 0xFF, 0x80, 0x7F, 0xDF, 0xEF, 0xEF, 0xF8,
  0x03, 0xFE, 0xFE, 0x7F, 0x7F, 0xC0, 0x1F, 0xFF, 0xF3, 0xFB, 0xFE, 0x00,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x1F,
  0xF8, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFE, 0x01, 0xFF,
  0x3F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xDF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFE,
  0x3F, 0x80, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x83, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xC7,
  0xFC, 0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0xDF, 0xF0, 0x3F,
  0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F,
  0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFB, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xE0, 0x03, 0xFE,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE7, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x87,
  0xFF, 0x1F, 0xF8, 0x7F, 0xF3, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0x80,
  0xFF, 0x3F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFC, 0x18, 0x1F, 0xF8, 0x08, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x20, 0xFF, 0xC0, 0x60, 0x7F, 0xF3, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0xFF, 0x80, 0x0F, 0xF9,
  0xFF, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF,
  0xBF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFD, 0xFE, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF1, 0xFF,
  0x1F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF3, 0xFF, 0x07, 0xFC, 0xFF, 0x83,
  0xFE, 0x3F, 0xEF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x81, 0xFF, 0x80, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x8F, 0xF0,
  0x07, 0xFF, 0x3F, 0xC0, 0x3F, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFE,
  0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x20, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x08,
  0x00, 0x7F, 0xE0, 0x38, 0x01, 0xFF, 0x00, 0xFE, 0x1F, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xE7, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0x03, 0xFE, 0x07, 0xFE, 0x03,
  0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F,
  0xFD, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0xFF, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0x9F, 0xFC, 0x7F, 0xF8, 0x0F, 0xEF,
  0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFE, 0x7F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x83,
  0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xCF, 0xF8, 0x03, 0xFD, 0xFF, 0xC0,
  0x3F, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xFC, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x1F, 0xF3, 0xFF,
  0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xDF, 0xF8, 0x1F, 0xF7,
  0xFE, 0x0F, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0xFF, 0xDF, 0xF0, 0x3F,
  0xEF, 0xFC, 0x0F, 0xFB, 0xFF, 0x07, 0xFE, 0xFF, 0xC1, 0xFF, 0x3F, 0xF0,
  0xFF, 0xCF, 0xFC, 0x3F, 0xF1, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFE, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x0F,
  0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x7F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x00, 0x0F, 0xF8,
  0x10, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0xCF, 0xF0,
  0x3F, 0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE,
  0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFE, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xE7,
  0xFC, 0x00, 0x20, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF, 0xF0, 0x7F,
  0xBF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x0F, 0xFC, 0x7C, 0x1F, 0xF8, 0x18, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x30, 0x07, 0xFC, 0x7C,
  0x1F, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x10, 0x00,
  0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFB, 0xFC, 0x03, 0xFF, 0x9F, 0xC0, 0x0F, 0xF0, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB,
  0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8, 0x1F, 0xF1, 0xFF, 0x07,
  0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xF0, 0x7F, 0x87, 0xFC, 0x0F,
  0xF0, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF9, 0xFF,
  0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F,
  0xBF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFF,
  0x87, 0xFE, 0xFF, 0x87, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFF, 0x87, 0xFC,
  0xFF, 0x8F, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xFF, 0x9F, 0xF0, 0xFF, 0x9F, 0xFF, 0x1F, 0xF0, 0xFF, 0x9F, 0xFF, 0x1F,
  0xF0, 0xFF, 0x9F, 0xBF, 0x3F, 0xE0, 0xFF, 0xBF, 0xFF, 0x3F, 0xE0, 0xFF,
  0xBF, 0xFF, 0x3F, 0xC0, 0xFF, 0xBF, 0x7F, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F,
  0x7F, 0x80, 0xFF, 0x7F, 0x7F, 0x7F, 0x80, 0xFF, 0x7E, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC3,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x8F, 0xF8, 0x00, 0x5F, 0xFF, 0x80, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xA0, 0x00, 0x3E,
  0x00,
};

const GFXglyph NotoSans_Condensed_BlackItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 18, 40, 15, 0, -39 },
  { 91, 23, 14, 25, 5, -39 },
  { 132, 33, 39, 31, 0, -39 },
  { 293, 27, 45, 28, 1, -42 },
  { 445, 42, 41, 46, 3, -40 },
  { 661, 35, 41, 35, 0, -40 },
  { 841, 11, 14, 13, 5, -39 },
  { 861, 20, 49, 17, 1, -40 },
  { 984, 20, 49, 17, -4, -40 },
  { 1107, 24, 26, 26, 4, -42 },
  { 1185, 25, 27, 29, 2, -33 },
  { 1270, 14, 15, 15, -3, -8 },
  { 1297, 16, 8, 17, 1, -19 },
  { 1313, 10, 11, 15, 0, -10 },
  { 1327, 31, 41, 23, -3, -40 },
  { 1486, 26, 41, 28, 2, -40 },
  { 1620, 22, 39, 28, 5, -39 },
  { 1728, 29, 40, 28, -2, -40 },
  { 1873, 28, 41, 28, 0, -40 },
  { 2017, 28, 39, 28, 0, -39 },
  { 2154, 27, 40, 28, 1, -39 },
  { 2289, 27, 41, 28, 2, -40 },
  { 2428, 30, 39, 28, 1, -39 },
  { 2575, 27, 41, 28, 1, -40 },
  { 2714, 27, 41, 28, 1, -40 },
  { 2853, 15, 32, 15, 0, -31 },
  { 2913, 18, 38, 15, -3, -31 },
  { 2999, 25, 28, 29, 2, -34 },
  { 3087, 25, 19, 29, 2, -29 },
  { 3147, 25, 28, 29, 2, -34 },
  { 3235, 23, 41, 23, 2, -40 },
  { 3353, 41, 44, 42, 1, -40 },
  { 3579, 31, 39, 32, -3, -39 },
  { 3731, 31, 39, 30, 0, -39 },
  { 3883, 30, 41, 29, 2, -40 },
  { 4037, 32, 39, 32, 0, -39 },
  { 4193, 28, 39, 25, 0, -39 },
  { 4330, 28, 39, 25, 0, -39 },
  { 4467, 32, 41, 33, 2, -40 },
  { 4631, 35, 39, 33, 0, -39 },
  { 4802, 27, 39, 21, -2, -39 },
  { 4934, 27, 51, 17, -9, -39 },
  { 5107, 36, 39, 31, 0, -39 },
  { 5283, 22, 39, 24, 0, -39 },
  { 5391, 45, 39, 44, 0, -39 },
  { 5611, 38, 39, 36, 0, -39 },
  { 5797, 32, 41, 34, 2, -40 },
  { 5961, 30, 39, 29, 0, -39 },
  { 6108, 32, 49, 34, 2, -40 },
  { 6304, 30, 39, 30, 0, -39 },
  { 6451, 28, 41, 26, 0, -40 },
  { 6595, 26, 39, 26, 4, -39 },
  { 6722, 32, 40, 33, 2, -39 },
  { 6882, 30, 39, 30, 5, -39 },
  { 7029, 45, 39, 44, 4, -39 },
  { 7249, 37, 39, 30, -3, -39 },
  { 7430, 29, 39, 29, 5, -39 },
  { 7572, 31, 39, 26, -2, -39 },
  { 7724, 23, 49, 17, -2, -40 },
  { 7865, 13, 41, 23, 6, -40 },
  { 7932, 23, 49, 17, -4, -40 },
  { 8073, 28, 26, 27, -1, -39 },
  { 8164, 24, 6, 22, -5, 4 },
  { 8182, 12, 9, 19, 8, -42 },
  { 8196, 28, 32, 29, 1, -31 },
  { 8308, 28, 43, 29, 0, -42 },
  { 8459, 24, 32, 24, 1, -31 },
  { 8555, 31, 43, 29, 1, -42 },
  { 8722, 26, 32, 27, 1, -31 },
  { 8826, 31, 55, 19, -6, -42 },
  { 9040, 30, 44, 29, -1, -31 },
  { 9205, 28, 42, 29, 0, -42 },
  { 9352, 17, 43, 15, 0, -43 },
  { 9444, 25, 56, 15, -7, -43 },
  { 9619, 32, 42, 29, 0, -42 },
  { 9787, 18, 42, 15, 0, -42 },
  { 9882, 42, 31, 43, 0, -31 },
  { 10045, 28, 31, 29, 0, -31 },
  { 10154, 26, 32, 28, 1, -31 },
  { 10258, 31, 44, 29, -3, -31 },
  { 10429, 28, 44, 29, 1, -31 },
  { 10583, 23, 31, 21, 0, -31 },
  { 10673, 23, 32, 23, 0, -31 },
  { 10765, 20, 38, 21, 2, -37 },
  { 10860, 29, 31, 29, 1, -30 },
  { 10973, 27, 30, 27, 3, -30 },
  { 11075, 40, 30, 40, 3, -30 },
  { 11225, 33, 30, 27, -3, -30 },
  { 11349, 33, 43, 27, -3, -30 },
  { 11527, 27, 30, 23, -2, -30 },
  { 11629, 23, 48, 19, 0, -39 },
  { 11767, 8, 55, 24, 8, -42 },
  { 11822, 22, 48, 19, -3, -39 },
  { 11954, 25, 11, 29, 2, -25 },
};

const GFXfont NotoSans_Condensed_BlackItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC55PT7B_H_
