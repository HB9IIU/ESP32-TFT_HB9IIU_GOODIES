#ifndef _NOTOSANS_CONDENSED_BLACKITALIC47PT7B_H_
#define _NOTOSANS_CONDENSED_BLACKITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-BlackItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_BlackItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0x8F, 0xE3, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xB9, 0xE0, 0x7E,
  0x70, 0xC1, 0xFC, 0xE0, 0x03, 0xFD, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3B, 0xF8,
  0x00, 0x77, 0xF0, 0x80, 0xEF, 0xE1, 0xC1, 0xDF, 0xC7, 0xE3, 0x7F, 0x8F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0x00,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x00, 0xFE, 0xFC, 0x07, 0xE0, 0x1F, 0x9F,
  0x81, 0xF8, 0x03, 0xF3, 0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x0F, 0xC0, 0x1F,
  0x8F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE7, 0xE0, 0x01, 0xF1, 0xF8, 0xFC, 0x38, 0x3E, 0x3F, 0x3F,
  0x1F, 0xE7, 0xEF, 0xCF, 0xC7, 0xFE, 0xFF, 0xF9, 0xF9, 0xFF, 0xDF, 0xFE,
  0x7E, 0x7F, 0xFD, 0xFF, 0xDF, 0xDF, 0xFF, 0xBF, 0xE3, 0xF3, 0xF3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x8F, 0xC0, 0x07, 0xE3, 0xF1,
  0xF8, 0x01, 0xFC, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x3F, 0x00, 0x7E, 0x0F, 0xC7, 0xE0, 0x1F,
  0x81, 0xF9, 0xF8, 0x03, 0xF0, 0x1F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xE0, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0xFF, 0x03, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0x1F, 0xE1, 0xFF, 0xFE, 0x7F,
  0x87, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0x7F, 0xFF, 0x87,
  0xF8, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0x83, 0xFC,
  0x1F, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0x3F, 0xCF, 0xF3,
  0xF8, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0x07, 0xE0, 0x1E, 0x3E, 0x00, 0xFD,
  0xF0, 0x4F, 0xFF, 0xBE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xBF, 0x81, 0xFD, 0xFC, 0x07, 0xC7, 0xF0, 0x1E, 0x3F, 0x00,
  0x61, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0,
  0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0x7F, 0xF9, 0xFF, 0xEF, 0xFF,
  0x80, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x10, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xFC, 0xFE, 0x0F, 0xF1, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF,
  0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F,
  0xE7, 0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFE, 0x7F, 0x87, 0xF8,
  0xFF, 0x0F, 0xF0, 0xFE, 0x3F, 0xE1, 0xFC, 0x7F, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xBF, 0xC7, 0xE7, 0xF8,
  0x79, 0xFE, 0x06, 0x3F, 0xC0, 0x87, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xF9, 0xFF, 0x01, 0xE0, 0xFF, 0x00, 0xC0, 0xFF, 0x00, 0x80, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xC1, 0xFF, 0x01, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x80,
  0x0F, 0xF8, 0xC0, 0x1F, 0xF8, 0xFC, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x01, 0xFB, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xF8, 0x07,
  0xE7, 0xF8, 0x07, 0xE7, 0xF8, 0x0F, 0xCF, 0xF0, 0x1F, 0x8F, 0xF0, 0x3F,
  0x8F, 0xF0, 0x3F, 0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x40, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF1, 0x00, 0x3F, 0xE3, 0x00,
  0xFF, 0x87, 0xEF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x0F,
  0xF7, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xFF, 0x7F, 0xC7, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F,
  0xE3, 0xFC, 0x7F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFD, 0xFF, 0x0F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFC,
  0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF8, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xF9, 0xFE,
  0x1F, 0xE3, 0xFC, 0x7F, 0xC3, 0xF8, 0xFF, 0x0F, 0xF9, 0xFE, 0x1F, 0xE3,
  0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF1, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x81, 0xFE, 0xFE, 0x00, 0xF3, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x06, 0x0F, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0x07,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x03, 0xF0, 0x04, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00,
  0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xF0,
  0xFF, 0x18, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x3F, 0xE1,
  0xF0, 0xFC, 0x3F, 0xFE, 0x7C, 0x7E, 0x1F, 0xFF, 0x1F, 0x1F, 0x8F, 0xFF,
  0xC7, 0xCF, 0xC7, 0xF3, 0xF1, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0xF8, 0xFC,
  0x3F, 0x1F, 0x7E, 0x3F, 0x0F, 0x87, 0xDF, 0x1F, 0x87, 0xE1, 0xF7, 0xC7,
  0xE1, 0xF8, 0x7D, 0xF1, 0xF8, 0x7E, 0x3E, 0x7C, 0x7C, 0x1F, 0x0F, 0xBF,
  0x1F, 0x0F, 0xC7, 0xEF, 0xC7, 0xC3, 0xF1, 0xF3, 0xF1, 0xF9, 0xFC, 0xFC,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0x1F, 0xFF, 0xFF, 0x0F, 0xC3, 0xFE, 0xFF,
  0x83, 0xF0, 0xFF, 0x3F, 0xC0, 0x7C, 0x0F, 0x03, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x3F, 0xE0,
  0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFE,
  0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF,
  0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF8,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x07,
  0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xF8, 0x38, 0x1F,
  0xF8, 0x04, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x30, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF,
  0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8,
  0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x7F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x8F,
  0xF8, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x7F,
  0xE0, 0xFF, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x78, 0x0F, 0xF8, 0x01, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0xE3, 0xFC, 0x3F, 0xFC, 0x7F, 0x8F,
  0xFF, 0x1F, 0xF1, 0xFF, 0xE3, 0xFE, 0x3F, 0xFC, 0x7F, 0xC7, 0xFF, 0x8F,
  0xF0, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F,
  0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1D,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF,
  0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF3,
  0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F,
  0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFB, 0xF1, 0xFF, 0xFC, 0x07, 0xF7, 0xE3,
  0xF7, 0xF0, 0x0F, 0xEF, 0xCF, 0xFF, 0xE0, 0x1F, 0xDF, 0x9F, 0xBF, 0xC0,
  0x7F, 0xBF, 0x7F, 0x7F, 0x80, 0xFF, 0x7E, 0xFE, 0xFF, 0x01, 0xFC, 0xFD,
  0xF9, 0xFC, 0x03, 0xF9, 0xFF, 0xF7, 0xF8, 0x0F, 0xF3, 0xFF, 0xCF, 0xF0,
  0x1F, 0xE7, 0xFF, 0x9F, 0xE0, 0x3F, 0xCF, 0xFE, 0x3F, 0x80, 0x7F, 0x1F,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0xE3, 0xFC,
  0x07, 0xF8, 0xFF, 0xC7, 0xF8, 0x0F, 0xF1, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3,
  0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF,
  0x80, 0x7F, 0x01, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0x03, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xC0, 0xFE, 0x03, 0xFF,
  0xC1, 0xFE, 0x07, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xC1, 0xFE, 0x07, 0xFF,
  0xE1, 0xFC, 0x07, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF,
  0xE3, 0xFC, 0x0F, 0xEF, 0xE3, 0xFC, 0x0F, 0xEF, 0xF3, 0xF8, 0x0F, 0xEF,
  0xF3, 0xF8, 0x0F, 0xE7, 0xF7, 0xF8, 0x1F, 0xE7, 0xF7, 0xF8, 0x1F, 0xE7,
  0xFF, 0xF0, 0x1F, 0xC7, 0xFF, 0xF0, 0x1F, 0xC7, 0xFF, 0xF0, 0x3F, 0xC3,
  0xFF, 0xF0, 0x3F, 0xC3, 0xFF, 0xF0, 0x3F, 0xC3, 0xFF, 0xE0, 0x3F, 0x83,
  0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xE0, 0x7F, 0x81,
  0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xC0, 0x7F, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xE3,
  0xFE, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F,
  0xF0, 0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F,
  0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE,
  0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF,
  0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x1F, 0xF0,
  0x7F, 0xE3, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0x07, 0xFC, 0x7F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC7,
  0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xE3, 0xFE, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE,
  0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFC, 0x03, 0xFE,
  0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF,
  0xF0, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x07,
  0xFC, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xF3, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F,
  0x87, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x3F, 0xE0,
  0xFF, 0x1F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF8, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF, 0x83,
  0xFE, 0x3F, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFC, 0x7C, 0x0F, 0xF8, 0x18, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x40, 0x1F, 0xF0, 0x60, 0x1F, 0xF0, 0x78,
  0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3,
  0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07,
  0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xF8,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03,
  0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF1, 0xFE,
  0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x3F, 0xE0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3,
  0xFC, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF, 0x01, 0xFE, 0xFF, 0x03,
  0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xF0, 0x3F, 0xCF, 0xF0, 0x7F, 0xC1, 0xFF,
  0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xC3, 0xFC, 0x3F, 0xC7, 0xFF, 0x0F, 0xF0,
  0xFE, 0x1F, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0xF1, 0xFE, 0x0F, 0xE3, 0xFF,
  0xCF, 0xF0, 0x3F, 0x9F, 0xFF, 0x3F, 0xC0, 0xFE, 0x7E, 0xFC, 0xFF, 0x03,
  0xFB, 0xFB, 0xF7, 0xF8, 0x0F, 0xEF, 0xFF, 0xDF, 0xE0, 0x3F, 0xBF, 0x7F,
  0x7F, 0x00, 0xFF, 0xFD, 0xFF, 0xFC, 0x03, 0xFF, 0xF7, 0xFF, 0xF0, 0x0F,
  0xFF, 0x9F, 0xFF, 0x80, 0x3F, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF,
  0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x3F,
  0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF,
  0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0x7F, 0xCF, 0xF0,
  0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x1F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xFD, 0xF8, 0x01, 0xFD, 0xF8, 0x03, 0xF9, 0xFC,
  0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0x3F, 0xE7, 0xF8, 0xFE,
  0x3F, 0xC7, 0xF0, 0xFC, 0x1F, 0x01, 0xFC, 0x7F, 0x03, 0xFE, 0x7F, 0x07,
  0xFE, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xF7, 0xFC, 0x3F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0xFF, 0x87, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xF0, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xEF, 0xE0, 0x3F, 0xCF, 0xE0, 0x1F, 0x8F, 0xC0, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFB, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xF9, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFF, 0x1F,
  0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xFC, 0x7F,
  0xC7, 0xF8, 0x7F, 0xCF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFE, 0xFF, 0xE0, 0xFE, 0xFF, 0xC0, 0xFC, 0x3F, 0x00, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x1F, 0xF1, 0xC3, 0xFE, 0x04, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0x0F, 0xF8,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xFB, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF7, 0xFE, 0x0F,
  0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x1F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0xFE, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F,
  0xC3, 0xFD, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x04, 0x3F, 0xE0, 0x70, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x3F, 0xE7, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xE3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0xC0,
  0xFF, 0xBF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x30, 0x07, 0xF8, 0x0F,
  0x83, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x7F,
  0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0xDF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x83, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x7F, 0xC0, 0x7F, 0x9F, 0xF0, 0x0F, 0xF7, 0xFC, 0x01, 0xFC, 0xFF, 0x00,
  0x7F, 0xBF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xF9, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF3, 0xF8,
  0x3F, 0xC0, 0x7F, 0x7F, 0xC7, 0xFE, 0x07, 0xEF, 0xFE, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC1, 0xFE,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x3F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF7, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xF8, 0xFF, 0x3F, 0xC3,
  0xFD, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC,
  0x3F, 0xEF, 0xF0, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xF8,
  0x0F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xF8,
  0x03, 0xFC, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x03, 0xFE, 0x7F, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xF7, 0xFC, 0x3F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0xFF, 0x87, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xF0, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0x9F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF3, 0xF0, 0x7E,
  0x7F, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xE1, 0xC1, 0xFE, 0x04, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x80, 0x7F,
  0x8F, 0x0F, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x98, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xBF, 0xC3, 0xFE, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF7, 0xF8,
  0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0x83,
  0xFE, 0x1F, 0xEF, 0xE1, 0xFF, 0x87, 0xF3, 0xF8, 0x7F, 0xE3, 0xFC, 0xFE,
  0x3F, 0xF8, 0xFF, 0x3F, 0x8F, 0xFE, 0x7F, 0x8F, 0xE3, 0xFF, 0x9F, 0xE3,
  0xF9, 0xFF, 0xC7, 0xF0, 0xFE, 0x7F, 0xF3, 0xFC, 0x3F, 0x9F, 0x7C, 0xFF,
  0x0F, 0xEF, 0xFF, 0x3F, 0x83, 0xFB, 0xFF, 0xDF, 0xE0, 0xFE, 0xFB, 0xF7,
  0xF0, 0x3F, 0xFE, 0xFD, 0xFC, 0x0F, 0xFF, 0xBF, 0xFE, 0x03, 0xFF, 0xCF,
  0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE,
  0x3F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x1F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0x80,
  0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF,
  0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8,
  0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x1F,
  0xDF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x0B, 0xFF, 0x80, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x07, 0xFE, 0x80, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_BlackItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 35, 13, 0, -34 },
  { 67, 20, 13, 21, 4, -34 },
  { 100, 28, 34, 26, 0, -34 },
  { 219, 23, 39, 24, 1, -36 },
  { 332, 35, 34, 39, 3, -34 },
  { 481, 30, 34, 30, 0, -34 },
  { 609, 10, 13, 11, 4, -34 },
  { 626, 17, 42, 15, 1, -35 },
  { 716, 18, 42, 15, -4, -35 },
  { 811, 21, 22, 22, 3, -36 },
  { 869, 21, 23, 25, 2, -28 },
  { 930, 12, 12, 13, -3, -6 },
  { 948, 14, 7, 15, 0, -16 },
  { 961, 9, 9, 13, 0, -8 },
  { 972, 26, 34, 20, -2, -34 },
  { 1083, 23, 34, 24, 1, -34 },
  { 1181, 19, 34, 24, 4, -34 },
  { 1262, 24, 34, 24, -1, -34 },
  { 1364, 24, 34, 24, 0, -34 },
  { 1466, 24, 34, 24, 0, -34 },
  { 1568, 23, 34, 24, 1, -34 },
  { 1666, 23, 34, 24, 2, -34 },
  { 1764, 25, 34, 24, 1, -34 },
  { 1871, 23, 34, 24, 1, -34 },
  { 1969, 23, 34, 24, 1, -34 },
  { 2067, 13, 27, 13, 0, -26 },
  { 2111, 16, 32, 13, -3, -26 },
  { 2175, 21, 24, 25, 2, -29 },
  { 2238, 21, 17, 25, 2, -25 },
  { 2283, 21, 24, 25, 2, -29 },
  { 2346, 19, 35, 19, 2, -34 },
  { 2430, 34, 38, 36, 1, -34 },
  { 2592, 27, 34, 27, -3, -34 },
  { 2707, 26, 34, 26, 0, -34 },
  { 2818, 25, 34, 24, 2, -34 },
  { 2925, 27, 34, 28, 0, -34 },
  { 3040, 24, 34, 22, 0, -34 },
  { 3142, 24, 34, 21, 0, -34 },
  { 3244, 27, 34, 28, 2, -34 },
  { 3359, 30, 34, 29, 0, -34 },
  { 3487, 24, 34, 18, -2, -34 },
  { 3589, 23, 45, 14, -7, -34 },
  { 3719, 31, 34, 26, 0, -34 },
  { 3851, 19, 34, 21, 0, -34 },
  { 3932, 39, 34, 37, 0, -34 },
  { 4098, 32, 34, 31, 0, -34 },
  { 4234, 27, 34, 29, 2, -34 },
  { 4349, 25, 34, 25, 0, -34 },
  { 4456, 27, 42, 29, 2, -34 },
  { 4598, 26, 34, 26, 0, -34 },
  { 4709, 24, 34, 22, 0, -34 },
  { 4811, 21, 34, 22, 4, -34 },
  { 4901, 27, 34, 28, 2, -34 },
  { 5016, 26, 34, 26, 4, -34 },
  { 5127, 38, 34, 38, 4, -34 },
  { 5289, 32, 34, 26, -3, -34 },
  { 5425, 25, 34, 25, 4, -34 },
  { 5532, 27, 34, 22, -2, -34 },
  { 5647, 20, 43, 15, -2, -35 },
  { 5755, 11, 34, 20, 5, -34 },
  { 5802, 20, 43, 15, -3, -35 },
  { 5910, 24, 23, 23, -1, -34 },
  { 5979, 21, 6, 19, -5, 3 },
  { 5995, 10, 8, 16, 7, -36 },
  { 6005, 24, 26, 25, 1, -26 },
  { 6083, 24, 36, 25, 0, -36 },
  { 6191, 20, 26, 20, 1, -26 },
  { 6256, 26, 36, 25, 1, -36 },
  { 6373, 22, 26, 23, 1, -26 },
  { 6445, 26, 47, 16, -5, -36 },
  { 6598, 26, 37, 25, -1, -26 },
  { 6719, 24, 36, 25, 0, -36 },
  { 6827, 15, 36, 13, 0, -36 },
  { 6895, 21, 47, 13, -6, -36 },
  { 7019, 27, 36, 25, 0, -36 },
  { 7141, 15, 36, 13, 0, -36 },
  { 7209, 36, 26, 37, 0, -26 },
  { 7326, 24, 26, 25, 0, -26 },
  { 7404, 22, 26, 24, 1, -26 },
  { 7476, 27, 37, 25, -3, -26 },
  { 7601, 24, 37, 25, 1, -26 },
  { 7712, 20, 26, 18, 0, -26 },
  { 7777, 20, 26, 20, 0, -26 },
  { 7842, 17, 31, 18, 2, -31 },
  { 7908, 24, 26, 25, 1, -26 },
  { 7986, 22, 26, 23, 3, -26 },
  { 8058, 34, 26, 34, 3, -26 },
  { 8169, 29, 26, 23, -3, -26 },
  { 8264, 28, 37, 23, -3, -26 },
  { 8394, 23, 26, 20, -2, -26 },
  { 8469, 20, 41, 16, 0, -34 },
  { 8572, 7, 47, 21, 7, -36 },
  { 8614, 19, 41, 16, -3, -34 },
  { 8712, 21, 9, 25, 2, -21 },
};

const GFXfont NotoSans_Condensed_BlackItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_BlackItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_BlackItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_BLACKITALIC47PT7B_H_
