#ifndef _ROBOTOMONO_EXTRALIGHT10PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xFC, 0x28, 0xA7, 0xCA, 0xF9, 0x45, 0x00, 0x2D, 0x98, 0x61,
  0x9D, 0x20, 0xE2, 0xAF, 0x08, 0x3D, 0x51, 0xC0, 0xE5, 0x28, 0x8A, 0xCB,
  0xA0, 0xE0, 0x6A, 0xAA, 0x90, 0xA5, 0x55, 0x60, 0x2F, 0x25, 0x44, 0xF4,
  0x40, 0xC0, 0xF0, 0x80, 0x12, 0x22, 0x44, 0x48, 0xF9, 0x9F, 0x99, 0xF0,
  0xE4, 0x92, 0x48, 0xE9, 0x12, 0x48, 0xF0, 0x7C, 0x42, 0x60, 0xC5, 0xE0,
  0x11, 0x4A, 0x9F, 0x84, 0x20, 0xF8, 0xE1, 0x19, 0x70, 0x68, 0xE9, 0x99,
  0xF0, 0xF1, 0x22, 0x24, 0x40, 0xF9, 0x96, 0x99, 0xF0, 0xF9, 0x99, 0x71,
  0x60, 0x88, 0x8C, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0xF9, 0x12, 0x40, 0x40,
  0x7A, 0x5B, 0x75, 0xD6, 0xA7, 0x80, 0x23, 0x19, 0x2F, 0x4A, 0x20, 0xF9,
  0x9E, 0x99, 0xF0, 0xF9, 0x88, 0x89, 0xF0, 0xE9, 0x99, 0x99, 0xE0, 0xF8,
  0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0xF9, 0x8A, 0x99, 0xF0, 0x99,
  0x9F, 0x99, 0x90, 0xF4, 0x44, 0x44, 0xF0, 0x11, 0x11, 0x19, 0xE0, 0x9D,
  0x31, 0x8A, 0x4A, 0x20, 0x88, 0x88, 0x88, 0xF0, 0x99, 0xBF, 0xD9, 0x90,
  0x99, 0xDB, 0xB9, 0x90, 0xF9, 0x99, 0x99, 0xF0, 0xF4, 0x63, 0xE8, 0x42,
  0x00, 0xF9, 0x99, 0x99, 0xF1, 0xF9, 0x9D, 0xA9, 0x90, 0xF9, 0x86, 0x19,
  0xF0, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x00, 0x99, 0x99, 0x99, 0xF0, 0x8A,
  0x52, 0x93, 0x18, 0x80, 0x96, 0x57, 0x5D, 0x59, 0x24, 0x80, 0x9C, 0x98,
  0x46, 0x4A, 0x20, 0x8A, 0x54, 0x62, 0x10, 0x80, 0xF2, 0x24, 0x48, 0xF0,
  0xEA, 0xAA, 0xB0, 0x84, 0x44, 0x22, 0x11, 0xD5, 0x55, 0x70, 0x46, 0x99,
  0xF0, 0xC0, 0xF1, 0xF9, 0xF0, 0x88, 0xE9, 0x99, 0x9F, 0xF8, 0x89, 0xF0,
  0x11, 0x79, 0x99, 0x9F, 0xF9, 0xE8, 0xF0, 0x34, 0xF4, 0x44, 0x44, 0xF9,
  0x99, 0xF1, 0xF0, 0x88, 0xE9, 0x99, 0x99, 0x2C, 0x22, 0x22, 0xF0, 0x38,
  0x92, 0x49, 0xE0, 0x88, 0x8B, 0xCC, 0xA9, 0xC2, 0x22, 0x22, 0x2F, 0xFE,
  0x9A, 0x69, 0xA4, 0xF9, 0x99, 0x90, 0xF9, 0x99, 0xF0, 0xF9, 0x99, 0xF8,
  0x80, 0xF9, 0x99, 0xF1, 0x10, 0xF2, 0x48, 0xF8, 0x61, 0xF0, 0x4F, 0x44,
  0x44, 0x70, 0x99, 0x99, 0xF0, 0x99, 0x96, 0x40, 0xA6, 0xD7, 0x96, 0x48,
  0x96, 0x26, 0x90, 0x8D, 0x24, 0x8C, 0x10, 0x86, 0x00, 0xF2, 0x48, 0xF0,
  0x29, 0x29, 0x12, 0x4C, 0xFF, 0x89, 0x24, 0xD2, 0x50, 0x66, 0x60,
};

const GFXglyph RobotoMono_ExtraLight10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 7, 6, 2, -7 },
  { 2, 2, 3, 6, 2, -8 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 6, 7, 6, 0, -7 },
  { 20, 5, 7, 6, 1, -7 },
  { 25, 1, 3, 6, 2, -8 },
  { 26, 2, 10, 6, 2, -8 },
  { 29, 2, 10, 6, 2, -8 },
  { 32, 4, 4, 6, 1, -7 },
  { 34, 4, 5, 6, 1, -6 },
  { 37, 1, 2, 6, 2, -1 },
  { 38, 4, 1, 6, 1, -4 },
  { 39, 1, 1, 6, 3, -1 },
  { 40, 4, 8, 6, 1, -7 },
  { 44, 4, 7, 6, 1, -7 },
  { 48, 3, 7, 6, 1, -7 },
  { 51, 4, 7, 6, 1, -7 },
  { 55, 5, 7, 6, 0, -7 },
  { 60, 5, 7, 6, 0, -7 },
  { 65, 4, 7, 6, 1, -7 },
  { 69, 4, 7, 6, 1, -7 },
  { 73, 4, 7, 6, 1, -7 },
  { 77, 4, 7, 6, 1, -7 },
  { 81, 4, 7, 6, 1, -7 },
  { 85, 1, 5, 6, 3, -5 },
  { 86, 1, 6, 6, 3, -5 },
  { 87, 4, 4, 6, 1, -5 },
  { 89, 4, 2, 6, 1, -4 },
  { 90, 4, 4, 6, 1, -5 },
  { 92, 4, 7, 6, 1, -7 },
  { 96, 6, 7, 6, 0, -7 },
  { 102, 5, 7, 6, 1, -7 },
  { 107, 4, 7, 6, 1, -7 },
  { 111, 4, 7, 6, 1, -7 },
  { 115, 4, 7, 6, 1, -7 },
  { 119, 4, 7, 6, 1, -7 },
  { 123, 4, 7, 6, 1, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 4, 7, 6, 1, -7 },
  { 139, 4, 7, 6, 1, -7 },
  { 143, 5, 7, 6, 1, -7 },
  { 148, 4, 7, 6, 1, -7 },
  { 152, 4, 7, 6, 1, -7 },
  { 156, 4, 7, 6, 1, -7 },
  { 160, 4, 7, 6, 1, -7 },
  { 164, 5, 7, 6, 1, -7 },
  { 169, 4, 8, 6, 1, -7 },
  { 173, 4, 7, 6, 1, -7 },
  { 177, 4, 7, 6, 1, -7 },
  { 181, 6, 7, 6, 0, -7 },
  { 187, 4, 7, 6, 1, -7 },
  { 191, 5, 7, 6, 0, -7 },
  { 196, 6, 7, 6, 0, -7 },
  { 202, 5, 7, 6, 1, -7 },
  { 207, 5, 7, 6, 0, -7 },
  { 212, 4, 7, 6, 1, -7 },
  { 216, 2, 10, 6, 2, -8 },
  { 219, 4, 8, 6, 1, -7 },
  { 223, 2, 10, 6, 2, -8 },
  { 226, 4, 4, 6, 1, -7 },
  { 228, 4, 1, 6, 1, 0 },
  { 229, 2, 1, 6, 2, -7 },
  { 230, 4, 5, 6, 1, -5 },
  { 233, 4, 8, 6, 1, -8 },
  { 237, 4, 5, 6, 1, -5 },
  { 240, 4, 8, 6, 1, -8 },
  { 244, 4, 5, 6, 1, -5 },
  { 247, 4, 8, 6, 1, -8 },
  { 251, 4, 7, 6, 1, -5 },
  { 255, 4, 8, 6, 1, -8 },
  { 259, 4, 7, 6, 1, -7 },
  { 263, 3, 9, 6, 1, -7 },
  { 267, 4, 8, 6, 1, -8 },
  { 271, 4, 8, 6, 1, -8 },
  { 275, 6, 5, 6, 0, -5 },
  { 279, 4, 5, 6, 1, -5 },
  { 282, 4, 5, 6, 1, -5 },
  { 285, 4, 7, 6, 1, -5 },
  { 289, 4, 7, 6, 1, -5 },
  { 293, 3, 5, 6, 2, -5 },
  { 295, 4, 5, 6, 1, -5 },
  { 298, 4, 7, 6, 1, -7 },
  { 302, 4, 5, 6, 1, -5 },
  { 305, 4, 5, 6, 1, -5 },
  { 308, 6, 5, 6, 0, -5 },
  { 312, 4, 5, 6, 1, -5 },
  { 315, 6, 7, 6, 0, -5 },
  { 321, 4, 5, 6, 1, -5 },
  { 324, 3, 10, 6, 2, -8 },
  { 328, 1, 8, 6, 3, -7 },
  { 329, 3, 10, 6, 2, -8 },
  { 333, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_ExtraLight10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight10pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_EXTRALIGHT10PT7B_H_
