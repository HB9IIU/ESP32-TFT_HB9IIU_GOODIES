#ifndef _ROBOTOMONO_EXTRALIGHT14PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xFC, 0x12, 0x12, 0x12, 0x7F, 0x24, 0x24, 0xFF, 0x24,
  0x24, 0x28, 0x10, 0xA4, 0x61, 0x40, 0x81, 0x81, 0x86, 0x16, 0x84, 0x60,
  0x92, 0x94, 0x94, 0x68, 0x12, 0x15, 0x29, 0x29, 0x07, 0x30, 0x91, 0x22,
  0x82, 0x0A, 0x24, 0xC5, 0x84, 0xF4, 0xE0, 0x2A, 0x49, 0x24, 0x92, 0x44,
  0x40, 0xC4, 0x22, 0x21, 0x11, 0x12, 0x22, 0x4C, 0x10, 0x4F, 0xC4, 0x29,
  0x10, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0xE0, 0xF8, 0x80, 0x08,
  0x84, 0x22, 0x11, 0x08, 0x44, 0x20, 0x7A, 0x18, 0x63, 0x96, 0x9C, 0x61,
  0x85, 0xE0, 0x74, 0x92, 0x49, 0x24, 0x7A, 0x28, 0x41, 0x08, 0x42, 0x08,
  0x43, 0xF0, 0x7A, 0x18, 0x41, 0x38, 0x20, 0x61, 0x85, 0xE0, 0x08, 0x30,
  0xA1, 0x44, 0x91, 0x22, 0x3F, 0x08, 0x10, 0xFC, 0x21, 0x4D, 0x84, 0x31,
  0x8B, 0x80, 0x39, 0x08, 0x2C, 0xCE, 0x18, 0x61, 0x85, 0xE0, 0xFC, 0x10,
  0x42, 0x08, 0x41, 0x08, 0x21, 0x00, 0x78, 0x8A, 0x14, 0x27, 0x88, 0xA0,
  0xC1, 0x84, 0xF0, 0x7A, 0x18, 0x61, 0x85, 0x13, 0xC1, 0x09, 0xC0, 0x82,
  0x83, 0x80, 0x0D, 0xC8, 0x1C, 0x0C, 0xFC, 0x0F, 0xC0, 0xE0, 0x60, 0x46,
  0xE0, 0x74, 0x42, 0x11, 0x10, 0x80, 0x01, 0x00, 0x3E, 0x41, 0x5D, 0x95,
  0xA5, 0xA5, 0xA5, 0x9E, 0x40, 0x3C, 0x10, 0x20, 0xA1, 0x44, 0x88, 0x9F,
  0x42, 0x83, 0x04, 0xF9, 0x0A, 0x14, 0x2F, 0x90, 0xA0, 0xC1, 0x85, 0xF0,
  0x7A, 0x18, 0x60, 0x82, 0x08, 0x21, 0x85, 0xE0, 0xF9, 0x0A, 0x14, 0x18,
  0x30, 0x60, 0xC2, 0x85, 0xF0, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x83,
  0xF0, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x00, 0x7A, 0x18, 0x60,
  0x82, 0x78, 0x61, 0x85, 0xF0, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86,
  0x10, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x61, 0x85, 0xE0, 0x87, 0x0A, 0x24, 0x8A, 0x1A, 0x24, 0x44,
  0x85, 0x04, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0x87, 0x1C, 0xF3,
  0xAE, 0xD9, 0x61, 0x86, 0x10, 0x87, 0x1C, 0x69, 0xA6, 0x58, 0xE3, 0x86,
  0x10, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0xF2, 0x28, 0x61,
  0x8B, 0xC8, 0x20, 0x82, 0x00, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x84, 0xF0, 0x10, 0x10, 0xF9, 0x0A, 0x14, 0x28, 0x5F, 0x22, 0x42, 0x85,
  0x04, 0x79, 0x0A, 0x0C, 0x07, 0x01, 0x01, 0x41, 0x82, 0xF8, 0xFE, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x85, 0xE0, 0x83, 0x0A, 0x12, 0x24, 0x89, 0x0A, 0x18, 0x30, 0x20,
  0x93, 0x26, 0xCD, 0x9A, 0xB5, 0xAB, 0x26, 0x44, 0x88, 0x82, 0x89, 0x21,
  0x41, 0x02, 0x0A, 0x24, 0x45, 0x04, 0x83, 0x09, 0x12, 0x43, 0x06, 0x04,
  0x08, 0x10, 0x20, 0xFC, 0x10, 0x84, 0x10, 0x82, 0x10, 0x83, 0xF0, 0xEA,
  0xAA, 0xAA, 0xC0, 0x84, 0x10, 0x84, 0x10, 0x84, 0x10, 0x82, 0xD5, 0x55,
  0x55, 0xC0, 0x23, 0x15, 0x29, 0x80, 0xFC, 0xD0, 0x39, 0x18, 0x41, 0x7E,
  0x18, 0x5F, 0x82, 0x08, 0x2C, 0xCE, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x31,
  0x38, 0x60, 0x82, 0x08, 0x5E, 0x04, 0x10, 0x4D, 0x4E, 0x18, 0x61, 0x86,
  0x17, 0xC0, 0x31, 0x38, 0x7F, 0x82, 0x08, 0x1F, 0x0E, 0x20, 0x87, 0xE2,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x31, 0x38, 0x61, 0x86, 0x18, 0x5F,
  0x06, 0x17, 0x80, 0x82, 0x08, 0x2E, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x40,
  0x20, 0x30, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x08, 0x1C, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x2E, 0x00, 0x82, 0x08, 0x22, 0x92, 0x8C, 0x28, 0xA2, 0x48,
  0xC0, 0xE1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x6D, 0x26, 0x4C, 0x99,
  0x32, 0x64, 0xC9, 0x3B, 0x18, 0x61, 0x86, 0x18, 0x61, 0x31, 0x38, 0x61,
  0x86, 0x18, 0x5E, 0x33, 0x38, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x00,
  0x31, 0x38, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x10, 0x40, 0x3C, 0x88, 0x88,
  0x88, 0x39, 0x18, 0x50, 0x38, 0x18, 0x5F, 0x23, 0xF2, 0x08, 0x20, 0x82,
  0x08, 0x1C, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x87, 0x09, 0x12, 0x42,
  0x86, 0x04, 0x00, 0x89, 0x49, 0x59, 0x56, 0x56, 0x26, 0x22, 0xC4, 0x90,
  0xC0, 0x82, 0x88, 0xA1, 0x80, 0x83, 0x09, 0x12, 0x42, 0x86, 0x04, 0x10,
  0x21, 0x80, 0xFC, 0x10, 0x41, 0x02, 0x08, 0x3F, 0x80, 0x19, 0x08, 0x42,
  0x13, 0x08, 0x21, 0x08, 0x42, 0x0C, 0xFF, 0xF0, 0xC1, 0x08, 0x42, 0x10,
  0x43, 0x21, 0x08, 0x42, 0x60, 0x71, 0x8E,
};

const GFXglyph RobotoMono_ExtraLight14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 10, 8, 4, -10 },
  { 3, 2, 3, 8, 3, -11 },
  { 4, 8, 10, 8, 0, -10 },
  { 14, 6, 12, 8, 1, -11 },
  { 23, 8, 10, 8, 0, -10 },
  { 33, 7, 10, 8, 1, -10 },
  { 42, 1, 3, 8, 3, -11 },
  { 43, 3, 14, 8, 3, -11 },
  { 49, 4, 14, 8, 2, -11 },
  { 56, 6, 6, 8, 1, -10 },
  { 61, 7, 7, 8, 1, -8 },
  { 68, 1, 3, 8, 3, -1 },
  { 69, 5, 1, 8, 2, -5 },
  { 70, 1, 1, 8, 4, -1 },
  { 71, 5, 11, 8, 2, -10 },
  { 78, 6, 10, 8, 1, -10 },
  { 86, 3, 10, 8, 2, -10 },
  { 90, 6, 10, 8, 1, -10 },
  { 98, 6, 10, 8, 1, -10 },
  { 106, 7, 10, 8, 1, -10 },
  { 115, 5, 10, 8, 2, -10 },
  { 122, 6, 10, 8, 1, -10 },
  { 130, 6, 10, 8, 1, -10 },
  { 138, 7, 10, 8, 1, -10 },
  { 147, 6, 10, 8, 1, -10 },
  { 155, 1, 7, 8, 4, -7 },
  { 156, 1, 9, 8, 4, -7 },
  { 158, 6, 5, 8, 1, -7 },
  { 162, 6, 3, 8, 1, -6 },
  { 165, 6, 5, 8, 1, -7 },
  { 169, 5, 10, 8, 2, -10 },
  { 176, 8, 10, 8, 0, -10 },
  { 186, 7, 10, 8, 1, -10 },
  { 195, 7, 10, 8, 1, -10 },
  { 204, 6, 10, 8, 1, -10 },
  { 212, 7, 10, 8, 1, -10 },
  { 221, 6, 10, 8, 1, -10 },
  { 229, 6, 10, 8, 1, -10 },
  { 237, 6, 10, 8, 1, -10 },
  { 245, 6, 10, 8, 1, -10 },
  { 253, 6, 10, 8, 1, -10 },
  { 261, 6, 10, 8, 1, -10 },
  { 269, 7, 10, 8, 1, -10 },
  { 278, 5, 10, 8, 2, -10 },
  { 285, 6, 10, 8, 1, -10 },
  { 293, 6, 10, 8, 1, -10 },
  { 301, 6, 10, 8, 1, -10 },
  { 309, 6, 10, 8, 2, -10 },
  { 317, 7, 12, 8, 1, -10 },
  { 328, 7, 10, 8, 1, -10 },
  { 337, 7, 10, 8, 1, -10 },
  { 346, 7, 10, 8, 1, -10 },
  { 355, 6, 10, 8, 1, -10 },
  { 363, 7, 10, 8, 1, -10 },
  { 372, 7, 10, 8, 1, -10 },
  { 381, 7, 10, 8, 1, -10 },
  { 390, 7, 10, 8, 1, -10 },
  { 399, 6, 10, 8, 1, -10 },
  { 407, 2, 13, 8, 3, -11 },
  { 411, 5, 11, 8, 2, -10 },
  { 418, 2, 13, 8, 3, -11 },
  { 422, 5, 5, 8, 2, -10 },
  { 426, 6, 1, 8, 1, 0 },
  { 427, 2, 2, 8, 3, -10 },
  { 428, 6, 8, 8, 1, -8 },
  { 434, 6, 11, 8, 1, -11 },
  { 443, 6, 8, 8, 1, -8 },
  { 449, 6, 11, 8, 1, -11 },
  { 458, 6, 8, 8, 1, -8 },
  { 464, 7, 11, 8, 1, -11 },
  { 474, 6, 11, 8, 1, -8 },
  { 483, 6, 11, 8, 1, -11 },
  { 492, 5, 10, 8, 2, -10 },
  { 499, 5, 13, 8, 1, -10 },
  { 508, 6, 11, 8, 2, -11 },
  { 517, 5, 11, 8, 2, -11 },
  { 524, 7, 8, 8, 1, -8 },
  { 531, 6, 8, 8, 1, -8 },
  { 537, 6, 8, 8, 1, -8 },
  { 543, 6, 11, 8, 1, -8 },
  { 552, 6, 11, 8, 1, -8 },
  { 561, 4, 8, 8, 3, -8 },
  { 565, 6, 8, 8, 1, -8 },
  { 571, 6, 9, 8, 1, -9 },
  { 578, 6, 7, 8, 1, -7 },
  { 584, 7, 7, 8, 1, -7 },
  { 591, 8, 7, 8, 0, -7 },
  { 598, 7, 7, 8, 1, -7 },
  { 605, 7, 10, 8, 1, -7 },
  { 614, 7, 7, 8, 1, -7 },
  { 621, 5, 14, 8, 2, -11 },
  { 630, 1, 12, 8, 4, -10 },
  { 632, 5, 14, 8, 2, -11 },
  { 641, 8, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_ExtraLight14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight14pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_EXTRALIGHT14PT7B_H_
