#ifndef _ROBOTOMONO_EXTRALIGHT8PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x32, 0x9E, 0xAF, 0x30, 0x4E, 0xC7, 0x6A, 0x46, 0xB8,
  0x66, 0x9C, 0x4A, 0xCD, 0xAF, 0xC0, 0xFF, 0xD5, 0x56, 0x5D, 0x50, 0x22,
  0xF2, 0xC0, 0xE0, 0x80, 0x25, 0x25, 0x00, 0x56, 0xFB, 0xC0, 0x75, 0x50,
  0x69, 0x12, 0x4F, 0x69, 0x13, 0x97, 0x12, 0x55, 0xF1, 0xF3, 0x1B, 0xC0,
  0x53, 0x5B, 0xC0, 0xE4, 0xA5, 0x00, 0x56, 0xFB, 0xC0, 0xD6, 0xF3, 0x80,
  0x90, 0x98, 0x71, 0x80, 0xFC, 0xC7, 0x00, 0x54, 0xA0, 0x80, 0x75, 0x77,
  0xBA, 0xB8, 0x22, 0x55, 0x79, 0xD6, 0xFB, 0xC0, 0x56, 0x4B, 0xC0, 0xD6,
  0xDB, 0xC0, 0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00, 0x69, 0x8B, 0x97, 0xB6,
  0xFB, 0x40, 0xE9, 0x25, 0xC0, 0x11, 0x11, 0x97, 0x9A, 0xCC, 0xA9, 0x92,
  0x49, 0xC0, 0xB6, 0xFB, 0x40, 0xB6, 0xFB, 0x40, 0xD6, 0xDB, 0xC0, 0xF6,
  0xE9, 0x00, 0x69, 0x99, 0x97, 0x10, 0xD6, 0xEB, 0x40, 0xD6, 0x3B, 0xC0,
  0xF2, 0x22, 0x22, 0xB6, 0xDB, 0xC0, 0x99, 0x55, 0x62, 0xAD, 0x6B, 0xA5,
  0x28, 0x95, 0x22, 0x59, 0x95, 0x52, 0x22, 0xE5, 0x29, 0xC0, 0xFF, 0x91,
  0x24, 0x40, 0xFF, 0x5A, 0x80, 0xE0, 0x80, 0xEE, 0xF0, 0x9A, 0xDB, 0xC0,
  0xF2, 0x70, 0x2E, 0xDB, 0xC0, 0xFE, 0x70, 0x7D, 0x24, 0x80, 0xF6, 0xF3,
  0x80, 0x9A, 0xDB, 0x40, 0x51, 0x25, 0xC0, 0x65, 0x56, 0x92, 0xED, 0x40,
  0xC9, 0x25, 0xC0, 0xFB, 0xBB, 0xF6, 0xD0, 0xF6, 0xF0, 0xF6, 0xF9, 0x00,
  0xF6, 0xF2, 0x40, 0xF2, 0x40, 0xF8, 0xF0, 0xE9, 0x26, 0xB6, 0xF0, 0x95,
  0x52, 0xAD, 0x54, 0xA0, 0xAB, 0x50, 0x95, 0x52, 0x24, 0xEA, 0x70, 0x69,
  0x44, 0x91, 0xFE, 0xC9, 0x14, 0x94, 0xF8,
};

const GFXglyph RobotoMono_ExtraLight8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 1, 2, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 8, 5, 1, -7 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 4, 6, 5, 1, -6 },
  { 17, 1, 2, 5, 2, -6 },
  { 18, 1, 8, 5, 2, -6 },
  { 19, 2, 8, 5, 1, -6 },
  { 21, 3, 4, 5, 1, -6 },
  { 23, 4, 4, 5, 0, -5 },
  { 25, 1, 2, 5, 1, -1 },
  { 26, 3, 1, 5, 1, -3 },
  { 27, 1, 1, 5, 2, -1 },
  { 28, 3, 6, 5, 1, -6 },
  { 31, 3, 6, 5, 1, -6 },
  { 34, 2, 6, 5, 1, -6 },
  { 36, 4, 6, 5, 0, -6 },
  { 39, 4, 6, 5, 0, -6 },
  { 42, 4, 6, 5, 0, -6 },
  { 45, 3, 6, 5, 1, -6 },
  { 48, 3, 6, 5, 1, -6 },
  { 51, 3, 6, 5, 1, -6 },
  { 54, 3, 6, 5, 1, -6 },
  { 57, 3, 6, 5, 1, -6 },
  { 60, 1, 4, 5, 2, -4 },
  { 61, 1, 5, 5, 2, -4 },
  { 62, 3, 3, 5, 1, -4 },
  { 64, 3, 2, 5, 1, -4 },
  { 65, 3, 3, 5, 1, -4 },
  { 67, 3, 6, 5, 1, -6 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 4, 6, 5, 0, -6 },
  { 77, 3, 6, 5, 1, -6 },
  { 80, 3, 6, 5, 1, -6 },
  { 83, 3, 6, 5, 1, -6 },
  { 86, 3, 6, 5, 1, -6 },
  { 89, 3, 6, 5, 1, -6 },
  { 92, 4, 6, 5, 0, -6 },
  { 95, 3, 6, 5, 1, -6 },
  { 98, 3, 6, 5, 1, -6 },
  { 101, 4, 6, 5, 0, -6 },
  { 104, 4, 6, 5, 1, -6 },
  { 107, 3, 6, 5, 1, -6 },
  { 110, 3, 6, 5, 1, -6 },
  { 113, 3, 6, 5, 1, -6 },
  { 116, 3, 6, 5, 1, -6 },
  { 119, 3, 6, 5, 1, -6 },
  { 122, 4, 7, 5, 0, -6 },
  { 126, 3, 6, 5, 1, -6 },
  { 129, 3, 6, 5, 1, -6 },
  { 132, 4, 6, 5, 0, -6 },
  { 135, 3, 6, 5, 1, -6 },
  { 138, 4, 6, 5, 0, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 4, 6, 5, 0, -6 },
  { 148, 4, 6, 5, 0, -6 },
  { 151, 3, 6, 5, 1, -6 },
  { 154, 1, 8, 5, 2, -7 },
  { 155, 3, 6, 5, 1, -6 },
  { 158, 1, 8, 5, 2, -7 },
  { 159, 3, 3, 5, 1, -6 },
  { 161, 3, 1, 5, 1, 0 },
  { 162, 1, 1, 5, 2, -6 },
  { 163, 3, 4, 5, 1, -4 },
  { 165, 3, 6, 5, 1, -6 },
  { 168, 3, 4, 5, 1, -4 },
  { 170, 3, 6, 5, 1, -6 },
  { 173, 3, 4, 5, 1, -4 },
  { 175, 3, 6, 5, 1, -6 },
  { 178, 3, 6, 5, 1, -4 },
  { 181, 3, 6, 5, 1, -6 },
  { 184, 3, 6, 5, 1, -6 },
  { 187, 2, 8, 5, 1, -6 },
  { 189, 3, 6, 5, 1, -6 },
  { 192, 3, 6, 5, 1, -6 },
  { 195, 4, 4, 5, 0, -4 },
  { 197, 3, 4, 5, 1, -4 },
  { 199, 3, 4, 5, 1, -4 },
  { 201, 3, 6, 5, 1, -4 },
  { 204, 3, 6, 5, 1, -4 },
  { 207, 3, 4, 5, 1, -4 },
  { 209, 3, 4, 5, 1, -4 },
  { 211, 3, 5, 5, 1, -5 },
  { 213, 3, 4, 5, 1, -4 },
  { 215, 4, 4, 5, 0, -4 },
  { 217, 5, 4, 5, 0, -4 },
  { 220, 3, 4, 5, 1, -4 },
  { 222, 4, 6, 5, 0, -4 },
  { 225, 3, 4, 5, 1, -4 },
  { 227, 3, 8, 5, 1, -6 },
  { 230, 1, 7, 5, 2, -6 },
  { 231, 3, 8, 5, 1, -6 },
  { 234, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_ExtraLight8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight8pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_EXTRALIGHT8PT7B_H_
