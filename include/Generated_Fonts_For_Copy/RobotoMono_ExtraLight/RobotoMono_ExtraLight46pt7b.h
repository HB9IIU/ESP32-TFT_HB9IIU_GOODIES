#ifndef _ROBOTOMONO_EXTRALIGHT46PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight46pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x00, 0x00,
  0x3F, 0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x82, 0x82,
  0x00, 0x10, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x20, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x0F, 0xFF, 0xFF, 0xE0, 0x08,
  0x06, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x10, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x08, 0x06, 0x03, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x40, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x08, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0x00, 0xE0, 0x38, 0x18, 0x00, 0xC3, 0x00, 0x0E, 0x30, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x37, 0x00, 0x06, 0x30, 0x00, 0xE1,
  0xC0, 0x1C, 0x0F, 0x8F, 0x80, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x10,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0xC0, 0x30, 0x18, 0x30, 0x0C, 0x06, 0x18, 0x01, 0x81, 0x06, 0x00, 0x60,
  0xC3, 0x00, 0x0F, 0xE0, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1,
  0xF8, 0x00, 0x30, 0xC3, 0x00, 0x18, 0x60, 0x60, 0x06, 0x18, 0x18, 0x03,
  0x04, 0x02, 0x00, 0x83, 0x00, 0xC0, 0x60, 0xC0, 0x30, 0x10, 0x30, 0x0C,
  0x0C, 0x0C, 0x02, 0x06, 0x01, 0x00, 0x80, 0x80, 0x60, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0E,
  0x60, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x38, 0x0C, 0x30, 0x18, 0x0C, 0x60,
  0x0C, 0x0C, 0x60, 0x06, 0x0C, 0xC0, 0x07, 0x0C, 0xC0, 0x03, 0x98, 0xC0,
  0x01, 0x98, 0xC0, 0x00, 0xF0, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0x30,
  0x00, 0xF8, 0x38, 0x03, 0x98, 0x1F, 0x1F, 0x0C, 0x07, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x40, 0x20, 0x1F, 0x82, 0x0F, 0x3E, 0x27,
  0xE0, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xD8, 0x00, 0x18,
  0xC0, 0x03, 0x06, 0x00, 0x70, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0x1C, 0x08,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x33, 0x33, 0x33, 0x66,
  0x6C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1C, 0x03, 0x03, 0x80,
  0x18, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3B, 0xC0, 0x07, 0x3C,
  0x00, 0xC3, 0xC0, 0x18, 0x3C, 0x03, 0x03, 0xC0, 0x60, 0x3C, 0x0C, 0x03,
  0xC1, 0x80, 0x3C, 0x30, 0x03, 0xC6, 0x00, 0x3C, 0xC0, 0x03, 0xD8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x1C, 0x03, 0x80, 0xF0, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xB7, 0xC7, 0xC0, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x00,
  0x0E, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x66,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0xF0, 0x30,
  0x01, 0x83, 0x00, 0x06, 0x38, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD8,
  0x00, 0x0C, 0xC0, 0x00, 0x67, 0x00, 0x07, 0x1C, 0x00, 0x30, 0x70, 0x07,
  0x01, 0xF1, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x03,
  0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x1F, 0x00,
  0xDF, 0xFC, 0x1F, 0x87, 0xC3, 0x80, 0x3C, 0x20, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xB0, 0x00, 0x66,
  0x00, 0x1C, 0x70, 0x03, 0x87, 0x01, 0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x06, 0x1F, 0xE0, 0x33, 0xC3,
  0xC1, 0xB0, 0x07, 0x0B, 0x00, 0x1C, 0x70, 0x00, 0x67, 0x00, 0x01, 0xB8,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0x6C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60,
  0x00, 0xE3, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x38, 0x07, 0x00, 0xF0, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0x80, 0xE0, 0x70, 0x01, 0x83, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0,
  0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x30, 0x0E, 0x00, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x78, 0x3C, 0x06, 0x00, 0x70, 0x60, 0x00, 0xC6, 0x00,
  0x03, 0x30, 0x00, 0x1B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x38, 0x00,
  0x30, 0xE0, 0x07, 0x01, 0xF1, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x1C, 0x07, 0x03, 0x80, 0x38, 0x70, 0x01, 0xC6, 0x00, 0x0C,
  0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x60, 0x00, 0x76, 0x00, 0x0F, 0x30, 0x01, 0xB3, 0x80, 0x72, 0x0F,
  0x3E, 0x60, 0x7F, 0x86, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xEF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xE0, 0x38, 0xF3, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC6, 0x18, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0C, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xC0, 0x70, 0xC0, 0x0C, 0x60,
  0x01, 0x98, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x70, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x30, 0x1F, 0x02, 0x30, 0x3F, 0xC1, 0x98, 0x30, 0x20,
  0xC8, 0x10, 0x10, 0x6C, 0x18, 0x08, 0x36, 0x08, 0x04, 0x0A, 0x0C, 0x06,
  0x05, 0x06, 0x03, 0x03, 0x83, 0x01, 0x81, 0xC1, 0x00, 0xC0, 0xE0, 0x80,
  0x40, 0x70, 0x40, 0x20, 0x78, 0x20, 0x10, 0x3C, 0x10, 0x18, 0x1E, 0x08,
  0x0C, 0x09, 0x06, 0x0E, 0x0C, 0x83, 0x05, 0x86, 0x60, 0xCC, 0xC6, 0x30,
  0x7C, 0x3E, 0x08, 0x08, 0x04, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x80, 0x07, 0xE7, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0x80, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x08, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x0C, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xC0, 0x1E, 0x0C, 0x00, 0x38, 0xC0, 0x01,
  0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0,
  0x0F, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0C, 0x00, 0x70, 0xC0, 0x01, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0xCC, 0x00, 0x1C, 0xC0, 0x07, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x18, 0x00,
  0x70, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x6C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x60, 0x00, 0x19, 0x80, 0x00, 0x67, 0x00,
  0x01, 0x8C, 0x00, 0x0C, 0x38, 0x00, 0x70, 0x70, 0x01, 0x80, 0xE0, 0x1C,
  0x01, 0xE1, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x30,
  0x07, 0x81, 0x80, 0x0E, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x03, 0xB0, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0x60, 0x01,
  0xC3, 0x00, 0x3C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x98, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xFC, 0x03, 0x80, 0x70, 0x38, 0x01, 0xC1, 0x80, 0x07,
  0x18, 0x00, 0x19, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x5C, 0x00, 0x02, 0x60, 0x00,
  0x11, 0x80, 0x00, 0x8E, 0x00, 0x0C, 0x38, 0x01, 0xC0, 0xF8, 0x7C, 0x01,
  0xFF, 0x80, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6E,
  0x00, 0x06, 0x60, 0x00, 0xC7, 0x00, 0x1C, 0x38, 0x03, 0x81, 0xF1, 0xF0,
  0x07, 0xFC, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x30, 0x00, 0x39, 0x80,
  0x03, 0x8C, 0x00, 0x38, 0x60, 0x03, 0x83, 0x00, 0x38, 0x18, 0x01, 0x80,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x18, 0x01, 0x81, 0xC0, 0x0C, 0x1C,
  0x00, 0x61, 0xC0, 0x03, 0x1C, 0x00, 0x19, 0xE0, 0x00, 0xDF, 0x80, 0x06,
  0xCE, 0x00, 0x3C, 0x30, 0x01, 0xC0, 0xC0, 0x0C, 0x07, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x38, 0x30,
  0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x73, 0x00, 0x01,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFD, 0x80, 0x1B, 0xD8, 0x01, 0xBD, 0x80, 0x1B, 0xCC, 0x03, 0x3C,
  0xC0, 0x33, 0xCC, 0x06, 0x3C, 0x60, 0x63, 0xC6, 0x06, 0x3C, 0x20, 0xC3,
  0xC3, 0x0C, 0x3C, 0x31, 0x83, 0xC1, 0x98, 0x3C, 0x19, 0x83, 0xC1, 0xB0,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3D, 0x80, 0x03, 0xD8, 0x00, 0x3C, 0xC0, 0x03, 0xCC, 0x00, 0x3C, 0x60,
  0x03, 0xC6, 0x00, 0x3C, 0x30, 0x03, 0xC3, 0x80, 0x3C, 0x18, 0x03, 0xC0,
  0xC0, 0x3C, 0x0C, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x30, 0x3C,
  0x03, 0x03, 0xC0, 0x18, 0x3C, 0x01, 0xC3, 0xC0, 0x0C, 0x3C, 0x00, 0x63,
  0xC0, 0x06, 0x3C, 0x00, 0x33, 0xC0, 0x03, 0x3C, 0x00, 0x1B, 0xC0, 0x01,
  0xBC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x01,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x30, 0x18, 0x00,
  0x60, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0x90, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x67, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x60, 0x70, 0x03, 0x00, 0xE0, 0x1C,
  0x01, 0xE3, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xC0,
  0x07, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01,
  0xCC, 0x01, 0xF8, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x03,
  0x98, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0x70, 0x60, 0x03, 0x80, 0xE0, 0x1C, 0x01, 0xE3, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xC0, 0x0F,
  0x0C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xEC, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x07, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00, 0xC0,
  0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00,
  0x07, 0xC0, 0x00, 0x30, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1E,
  0x07, 0x00, 0x1C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x30, 0x00, 0x18,
  0xE0, 0x00, 0xC1, 0xC0, 0x07, 0x01, 0xF1, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00, 0xC3, 0x00,
  0x1C, 0x1C, 0x03, 0x80, 0xF1, 0xF0, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x20, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x01, 0xC0,
  0x18, 0x03, 0xC0, 0x1C, 0x03, 0x40, 0x1C, 0x03, 0x60, 0x1C, 0x03, 0x60,
  0x3C, 0x03, 0x60, 0x34, 0x02, 0x60, 0x36, 0x02, 0x60, 0x36, 0x06, 0x60,
  0x26, 0x06, 0x20, 0x66, 0x06, 0x30, 0x62, 0x06, 0x30, 0x63, 0x06, 0x30,
  0x63, 0x04, 0x30, 0x43, 0x04, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x10,
  0xC1, 0x0C, 0x18, 0xC1, 0x8C, 0x18, 0x81, 0x8C, 0x19, 0x81, 0x88, 0x19,
  0x81, 0x98, 0x19, 0x80, 0x98, 0x09, 0x80, 0xD8, 0x09, 0x00, 0xD8, 0x0D,
  0x00, 0xD8, 0x0F, 0x00, 0xD0, 0x0F, 0x00, 0x50, 0x0F, 0x00, 0x70, 0x0F,
  0x00, 0x70, 0x06, 0x00, 0x70, 0x06, 0x00, 0x70, 0x06, 0x00, 0x70, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x38, 0x07, 0x00, 0x60, 0x06, 0x01,
  0x80, 0x06, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x1C, 0x60, 0x00,
  0x30, 0xE0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x1C,
  0x01, 0x80, 0x30, 0x03, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x06, 0x00,
  0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xF0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x0C,
  0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x18, 0x30, 0x18, 0x30,
  0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x01, 0xF0, 0x00,
  0x7F, 0xE0, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xC6, 0x00, 0x06,
  0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x1F, 0xFE, 0x0F, 0xFF, 0xE3, 0xC0, 0x06, 0x70, 0x00, 0x66, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0,
  0x00, 0xE6, 0x00, 0x1E, 0x70, 0x07, 0x63, 0xE3, 0xE6, 0x0F, 0xF8, 0x70,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x07, 0xC0, 0x63, 0xFE, 0x0D, 0xC0, 0xE1, 0xF0, 0x0E, 0x38, 0x00, 0xE7,
  0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB8,
  0x00, 0x67, 0x00, 0x1C, 0xF8, 0x07, 0x1B, 0xE7, 0xC3, 0x1F, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x81, 0x80, 0x1C, 0x30, 0x00,
  0xC7, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x80, 0x0C, 0x1C, 0x01, 0x80, 0xF0, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x07, 0x81, 0x83, 0xFE, 0x31, 0xE0, 0xE6, 0x70, 0x06,
  0xCC, 0x00, 0x7B, 0x00, 0x07, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x36, 0x00, 0x06,
  0xC0, 0x00, 0xDC, 0x00, 0x39, 0x80, 0x0F, 0x1C, 0x03, 0x61, 0xE3, 0xCC,
  0x1F, 0xF1, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x81, 0xC0,
  0x1C, 0x30, 0x00, 0xC7, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x23, 0x80, 0x06, 0x1C, 0x00,
  0xC0, 0xF8, 0x78, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0xFF,
  0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x8C, 0x78, 0x39, 0x8C, 0x01, 0xB3,
  0x00, 0x1E, 0xE0, 0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x80, 0x01, 0xB0,
  0x00, 0x37, 0x00, 0x0E, 0x60, 0x03, 0xC7, 0x00, 0xD8, 0x78, 0xF3, 0x07,
  0xFC, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x40,
  0x01, 0x98, 0x00, 0x61, 0xC0, 0x1C, 0x1E, 0x0F, 0x00, 0xFF, 0x80, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x07, 0x83, 0x0F, 0xF8, 0xCE, 0x07, 0x36, 0x00, 0xEF, 0x00, 0x1B,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0xE3, 0xFF, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x2C,
  0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x0E, 0x00, 0xC1, 0xC0, 0x0C, 0x38, 0x00, 0xC7, 0x00,
  0x0C, 0xF0, 0x00, 0xDF, 0x80, 0x0F, 0x9C, 0x00, 0xE0, 0xC0, 0x0C, 0x06,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0xC0,
  0x07, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x70,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x80, 0xF0, 0xDF, 0xE3, 0xFC, 0xF8, 0x77, 0x0E, 0xE0, 0x3C, 0x06,
  0xE0, 0x18, 0x06, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x21, 0xFF, 0x88, 0xE0, 0x72, 0x60, 0x0E,
  0xB0, 0x01, 0xA8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x38, 0x07, 0x00, 0x70, 0x38,
  0x00, 0x60, 0xC0, 0x01, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x03, 0x9C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0x60, 0x03,
  0x80, 0xE0, 0x1C, 0x01, 0xE1, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x18,
  0xFF, 0x83, 0x70, 0x38, 0x78, 0x03, 0x8E, 0x00, 0x39, 0x80, 0x03, 0x30,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x19, 0xC0,
  0x07, 0x3E, 0x01, 0xC6, 0xF0, 0xF0, 0xC7, 0xF8, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x8C, 0x78,
  0x39, 0x9C, 0x01, 0xB3, 0x00, 0x1E, 0xC0, 0x01, 0xD8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0D, 0x80, 0x01, 0xB0, 0x00, 0x37, 0x00, 0x0E, 0x60, 0x03, 0xC7, 0x00,
  0xD8, 0x78, 0xF3, 0x07, 0xFC, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x3E, 0xC1, 0xFF, 0xC7, 0xC1, 0xCE, 0x00, 0xD8,
  0x00, 0xD0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x1E, 0x07,
  0x83, 0x80, 0x0C, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x37, 0x00, 0x06,
  0x38, 0x00, 0xE1, 0xF0, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x07, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0xC0, 0x0F, 0xF8, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x03, 0xDC, 0x01, 0xB3,
  0xC7, 0xCC, 0x3F, 0xC3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x66, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00, 0x06, 0x06,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x60, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80,
  0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x3C,
  0x06, 0x60, 0x24, 0x06, 0x60, 0x24, 0x06, 0x60, 0x66, 0x06, 0x20, 0x66,
  0x04, 0x30, 0x46, 0x0C, 0x30, 0x42, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x08, 0x10, 0x81, 0x08, 0x18, 0x81, 0x18, 0x19, 0x81, 0x98, 0x19, 0x81,
  0x98, 0x09, 0x00, 0x90, 0x0D, 0x00, 0xB0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x70, 0x00,
  0x1C, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x00, 0x38, 0x0E, 0x01, 0xC0,
  0x1C, 0x06, 0x00, 0x30, 0x30, 0x00, 0x61, 0x80, 0x01, 0xCE, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x0C, 0xE0, 0x00, 0x61, 0x80, 0x03, 0x03, 0x00, 0x1C, 0x06, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0xE0, 0x00, 0xC7, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x18, 0x00,
  0x38, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x01, 0x81,
  0x80, 0x01, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xCF, 0x3C, 0x00, 0x6E, 0x07, 0x00, 0x36, 0x00,
  0xC0, 0x33, 0x00, 0x38, 0x19, 0x00, 0x0F, 0xF9, 0x80, 0x01, 0xF8,
};

const GFXglyph RobotoMono_ExtraLight46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 3, 33, 28, 12, -33 },
  { 14, 8, 10, 28, 10, -35 },
  { 24, 25, 33, 28, 1, -33 },
  { 128, 20, 43, 28, 4, -38 },
  { 236, 26, 33, 28, 1, -33 },
  { 344, 24, 33, 28, 3, -33 },
  { 443, 2, 10, 28, 12, -35 },
  { 446, 10, 48, 28, 9, -37 },
  { 506, 10, 48, 28, 8, -37 },
  { 566, 20, 19, 28, 4, -33 },
  { 614, 22, 24, 28, 3, -27 },
  { 680, 4, 10, 28, 9, -4 },
  { 685, 16, 2, 28, 6, -16 },
  { 689, 3, 3, 28, 13, -3 },
  { 691, 15, 36, 28, 7, -33 },
  { 759, 20, 33, 28, 4, -33 },
  { 842, 11, 33, 28, 5, -33 },
  { 888, 21, 33, 28, 2, -33 },
  { 975, 21, 33, 28, 2, -33 },
  { 1062, 23, 33, 28, 2, -33 },
  { 1157, 19, 33, 28, 5, -33 },
  { 1236, 21, 33, 28, 3, -33 },
  { 1323, 21, 33, 28, 3, -33 },
  { 1410, 21, 33, 28, 4, -33 },
  { 1497, 20, 33, 28, 4, -33 },
  { 1580, 4, 23, 28, 14, -23 },
  { 1592, 6, 29, 28, 12, -23 },
  { 1614, 19, 18, 28, 4, -24 },
  { 1657, 20, 11, 28, 4, -20 },
  { 1685, 20, 18, 28, 4, -24 },
  { 1730, 18, 33, 28, 5, -33 },
  { 1805, 25, 33, 28, 1, -33 },
  { 1909, 23, 33, 28, 3, -33 },
  { 2004, 20, 33, 28, 5, -33 },
  { 2087, 22, 33, 28, 3, -33 },
  { 2178, 21, 33, 28, 4, -33 },
  { 2265, 19, 33, 28, 5, -33 },
  { 2344, 19, 33, 28, 5, -33 },
  { 2423, 21, 33, 28, 3, -33 },
  { 2510, 20, 33, 28, 4, -33 },
  { 2593, 18, 33, 28, 5, -33 },
  { 2668, 20, 33, 28, 3, -33 },
  { 2751, 21, 33, 28, 5, -33 },
  { 2838, 19, 33, 28, 5, -33 },
  { 2917, 20, 33, 28, 4, -33 },
  { 3000, 20, 33, 28, 4, -33 },
  { 3083, 22, 33, 28, 3, -33 },
  { 3174, 20, 33, 28, 5, -33 },
  { 3257, 22, 39, 28, 3, -33 },
  { 3365, 20, 33, 28, 5, -33 },
  { 3448, 22, 33, 28, 3, -33 },
  { 3539, 23, 33, 28, 2, -33 },
  { 3634, 20, 33, 28, 4, -33 },
  { 3717, 23, 33, 28, 2, -33 },
  { 3812, 24, 33, 28, 2, -33 },
  { 3911, 23, 33, 28, 3, -33 },
  { 4006, 23, 33, 28, 2, -33 },
  { 4101, 21, 33, 28, 3, -33 },
  { 4188, 8, 44, 28, 10, -37 },
  { 4232, 16, 36, 28, 6, -33 },
  { 4304, 7, 44, 28, 10, -37 },
  { 4343, 16, 18, 28, 6, -33 },
  { 4379, 20, 2, 28, 4, 0 },
  { 4384, 6, 6, 28, 11, -34 },
  { 4389, 20, 25, 28, 4, -25 },
  { 4452, 19, 35, 28, 5, -35 },
  { 4536, 20, 25, 28, 4, -25 },
  { 4599, 19, 35, 28, 4, -35 },
  { 4683, 20, 25, 28, 4, -25 },
  { 4746, 21, 35, 28, 4, -35 },
  { 4838, 19, 35, 28, 4, -25 },
  { 4922, 18, 35, 28, 5, -35 },
  { 5001, 19, 33, 28, 5, -33 },
  { 5080, 14, 43, 28, 4, -33 },
  { 5156, 20, 35, 28, 5, -35 },
  { 5244, 19, 35, 28, 5, -35 },
  { 5328, 24, 25, 28, 2, -25 },
  { 5403, 18, 25, 28, 5, -25 },
  { 5460, 22, 25, 28, 3, -25 },
  { 5529, 19, 34, 28, 5, -25 },
  { 5610, 19, 34, 28, 4, -25 },
  { 5691, 16, 25, 28, 8, -25 },
  { 5741, 20, 25, 28, 4, -25 },
  { 5804, 19, 31, 28, 4, -31 },
  { 5878, 18, 24, 28, 5, -24 },
  { 5932, 22, 24, 28, 3, -24 },
  { 5998, 24, 24, 28, 2, -24 },
  { 6070, 22, 24, 28, 3, -24 },
  { 6136, 24, 34, 28, 2, -24 },
  { 6238, 22, 24, 28, 3, -24 },
  { 6304, 14, 45, 28, 8, -36 },
  { 6383, 2, 40, 28, 13, -33 },
  { 6393, 15, 45, 28, 7, -36 },
  { 6478, 25, 8, 28, 1, -18 },
};

const GFXfont RobotoMono_ExtraLight46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight46pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_EXTRALIGHT46PT7B_H_
