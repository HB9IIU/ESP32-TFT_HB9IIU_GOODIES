#ifndef _ROBOTOMONO_EXTRALIGHT57PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight57pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xE0, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x03,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x03, 0x00, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x30, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x0F, 0x80, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x1C, 0x01, 0x80, 0xE0,
  0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0xE0,
  0x0C, 0x1C, 0x00, 0x60, 0x18, 0x18, 0x00, 0x70, 0x18, 0x38, 0x00, 0x30,
  0x30, 0x30, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x0F, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x03, 0xF0, 0x00,
  0x06, 0x07, 0xF8, 0x00, 0x0E, 0x0E, 0x1C, 0x00, 0x0C, 0x1C, 0x0E, 0x00,
  0x1C, 0x18, 0x06, 0x00, 0x18, 0x18, 0x06, 0x00, 0x30, 0x30, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x00, 0x60, 0x30, 0x03, 0x00, 0x60, 0x30, 0x03, 0x00,
  0xC0, 0x30, 0x03, 0x01, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x38, 0x07, 0x00,
  0x80, 0x18, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x03,
  0x00, 0x18, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x0C, 0x38, 0x07, 0x00, 0x61, 0xC0, 0x38, 0x03, 0x1C, 0x00, 0xE0,
  0x18, 0xC0, 0x03, 0x80, 0xCE, 0x00, 0x0E, 0x0E, 0x70, 0x00, 0x38, 0x73,
  0x80, 0x01, 0xC3, 0x1C, 0x00, 0x07, 0x38, 0xE0, 0x00, 0x1D, 0x87, 0x00,
  0x00, 0x7C, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x01,
  0xF8, 0x1E, 0x00, 0x1C, 0xE0, 0x78, 0x03, 0xC3, 0x81, 0xFF, 0xFC, 0x0E,
  0x03, 0xFF, 0x80, 0x38, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x10, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x80, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x60, 0x0C,
  0x03, 0xBE, 0x06, 0x07, 0xEF, 0xE3, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x70, 0x0E, 0x00,
  0x38, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x08, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0xC6, 0x31,
  0x8C, 0xE7, 0x33, 0x99, 0xC4, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x7C, 0x01, 0xC0, 0x0F, 0x01, 0xC0,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0xF6, 0x00, 0x00, 0xDF, 0x00, 0x01, 0xCF, 0x80, 0x01, 0xC7,
  0xC0, 0x01, 0xC3, 0xE0, 0x01, 0xC1, 0xF0, 0x01, 0xC0, 0xF8, 0x01, 0xC0,
  0x7C, 0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x1F, 0x01, 0xC0, 0x0F, 0x81, 0xC0,
  0x07, 0xC1, 0xC0, 0x03, 0xE1, 0xC0, 0x01, 0xF1, 0xC0, 0x00, 0xF9, 0xC0,
  0x00, 0x7D, 0xC0, 0x00, 0x37, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x0D, 0xC0,
  0x00, 0x0E, 0x60, 0x00, 0x07, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x70, 0x07, 0xC0, 0x7F, 0x0F, 0xCC, 0xFC, 0x3F, 0x80, 0xF8, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x3C,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18,
  0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0x3C, 0x01, 0xC0, 0x07,
  0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0xE0, 0x00,
  0x0E, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x3C,
  0x01, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x01,
  0xC0, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x7E, 0x00, 0x33, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3E,
  0x01, 0xF0, 0x38, 0x00, 0x78, 0x10, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F,
  0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0xC1, 0xFF,
  0xC0, 0x63, 0xFF, 0xF0, 0x33, 0xC0, 0x3C, 0x1B, 0x80, 0x07, 0x1F, 0x80,
  0x01, 0xCF, 0x80, 0x00, 0x77, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x0D, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0E,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x01,
  0xC3, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x3C,
  0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x38, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x3C, 0x70, 0x00, 0x36, 0x3C, 0x00, 0x3B, 0x0F, 0x00, 0x79,
  0x83, 0xF1, 0xF0, 0xC0, 0x7F, 0xF0, 0xE0, 0x0F, 0xC0, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77, 0xFE, 0xE0, 0x1C, 0x7C, 0xF8,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0E,
  0x18, 0x30, 0xE3, 0x82, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xC1, 0xF0,
  0x78, 0x03, 0xC7, 0x00, 0x07, 0x30, 0x00, 0x3B, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x0C, 0x0C, 0x03, 0xF8, 0x0C, 0x18, 0x07, 0xFC, 0x06,
  0x18, 0x0E, 0x06, 0x06, 0x30, 0x1C, 0x06, 0x06, 0x30, 0x18, 0x06, 0x06,
  0x30, 0x30, 0x06, 0x06, 0x60, 0x30, 0x06, 0x02, 0x60, 0x70, 0x04, 0x02,
  0x60, 0x60, 0x0C, 0x03, 0x60, 0x60, 0x0C, 0x03, 0x60, 0x60, 0x0C, 0x03,
  0x60, 0x60, 0x0C, 0x02, 0x60, 0x60, 0x0C, 0x02, 0x60, 0x40, 0x0C, 0x06,
  0x60, 0xC0, 0x0C, 0x06, 0x60, 0xC0, 0x0C, 0x06, 0x60, 0x60, 0x1C, 0x06,
  0x60, 0x60, 0x1C, 0x06, 0x60, 0x60, 0x3C, 0x0C, 0x60, 0x60, 0x2C, 0x0C,
  0x60, 0x70, 0x6C, 0x18, 0x70, 0x39, 0xC6, 0x38, 0x30, 0x3F, 0x87, 0xF0,
  0x30, 0x0F, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0x00,
  0x03, 0xE0, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0x80,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x38, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x18, 0x00, 0x3E, 0x0C, 0x00, 0x07, 0x86, 0x00, 0x01, 0xE3,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x07,
  0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x38, 0x60, 0x00,
  0x38, 0x30, 0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x06, 0x00,
  0x0F, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x60,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xCC, 0x00, 0x01,
  0xC6, 0x00, 0x01, 0xC3, 0x00, 0x07, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x0F, 0x80,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x30, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x7E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x98, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x60, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xD0, 0x00, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xF0,
  0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x30,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x78,
  0x03, 0x00, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x01, 0x80,
  0x38, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00,
  0x18, 0x3C, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x63, 0xE0, 0x00, 0x0C, 0x7E,
  0x00, 0x01, 0x9C, 0xE0, 0x00, 0x37, 0x0E, 0x00, 0x07, 0xC1, 0xC0, 0x00,
  0xF0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xDE, 0xC0, 0x00, 0x6F, 0x60, 0x00, 0x77, 0xB8,
  0x00, 0x33, 0xCC, 0x00, 0x39, 0xE7, 0x00, 0x18, 0xF1, 0x80, 0x0C, 0x78,
  0xC0, 0x0E, 0x3C, 0x70, 0x06, 0x1E, 0x18, 0x07, 0x0F, 0x0C, 0x03, 0x07,
  0x87, 0x01, 0x83, 0xC1, 0x81, 0xC1, 0xE0, 0xC0, 0xC0, 0xF0, 0x70, 0xE0,
  0x78, 0x18, 0x60, 0x3C, 0x0E, 0x30, 0x1E, 0x03, 0x38, 0x0F, 0x01, 0x98,
  0x07, 0x80, 0xEC, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x60, 0x00, 0x0F, 0xB8, 0x00, 0x07, 0xCE,
  0x00, 0x03, 0xE3, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0xF8, 0x60, 0x00, 0x7C,
  0x38, 0x00, 0x3E, 0x0C, 0x00, 0x1F, 0x07, 0x00, 0x0F, 0x81, 0x80, 0x07,
  0xC0, 0xE0, 0x03, 0xE0, 0x38, 0x01, 0xF0, 0x0C, 0x00, 0xF8, 0x07, 0x00,
  0x7C, 0x01, 0x80, 0x3E, 0x00, 0xE0, 0x1F, 0x00, 0x30, 0x0F, 0x80, 0x1C,
  0x07, 0xC0, 0x07, 0x03, 0xE0, 0x03, 0x81, 0xF0, 0x00, 0xE0, 0xF8, 0x00,
  0x30, 0x7C, 0x00, 0x1C, 0x3E, 0x00, 0x06, 0x1F, 0x00, 0x03, 0x8F, 0x80,
  0x00, 0xC7, 0xC0, 0x00, 0x73, 0xE0, 0x00, 0x1D, 0xF0, 0x00, 0x06, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1C, 0x00, 0x0F,
  0x8E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0xC7, 0x00, 0x07, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x61, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x18, 0x00, 0x3E, 0x0C, 0x00, 0x07,
  0x86, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x0E, 0x60, 0x00, 0x07, 0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x06, 0x00, 0x1F, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0x81, 0xF0, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x30,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0x3C,
  0x00, 0x0E, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0x30,
  0x00, 0x03, 0x9C, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60,
  0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0x70, 0x01, 0xB0, 0x01, 0xC0, 0x06, 0xC0, 0x07, 0x80, 0x1B, 0x80,
  0x1E, 0x00, 0x6E, 0x00, 0xF8, 0x01, 0x98, 0x03, 0x60, 0x0E, 0x60, 0x0D,
  0x80, 0x39, 0x80, 0x37, 0x00, 0xC6, 0x00, 0xCC, 0x03, 0x18, 0x07, 0x30,
  0x0C, 0x70, 0x18, 0xC0, 0x31, 0xC0, 0x63, 0x00, 0xC3, 0x01, 0x8C, 0x07,
  0x0C, 0x06, 0x38, 0x18, 0x30, 0x38, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x83,
  0x83, 0x06, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x70, 0x60, 0x60,
  0xC0, 0xC3, 0x81, 0x87, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60,
  0x30, 0xC0, 0x71, 0x80, 0xE3, 0x01, 0xC6, 0x01, 0x8C, 0x03, 0x38, 0x06,
  0x30, 0x0C, 0xC0, 0x19, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0xD8,
  0x03, 0x30, 0x07, 0x60, 0x0F, 0xC0, 0x0D, 0x80, 0x3E, 0x00, 0x36, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFF, 0xFE, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF8, 0x00, 0x19, 0x80, 0x01, 0x9C, 0x00, 0x38, 0xC0, 0x03,
  0x0C, 0x00, 0x70, 0xE0, 0x06, 0x06, 0x00, 0x60, 0x70, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x03, 0x81, 0x80, 0x18, 0x18, 0x01, 0xC3, 0x80, 0x0C,
  0x30, 0x00, 0xE7, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xC0, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x18, 0x0C,
  0x0E, 0x07, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x1F, 0x80, 0x07, 0x3C, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x70, 0x00, 0x3F, 0x70,
  0x00, 0x77, 0x3C, 0x01, 0xE7, 0x1F, 0xFF, 0x87, 0x07, 0xFE, 0x03, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x3C, 0x00, 0xC1, 0xFF, 0x80, 0xC7, 0xFF, 0xC0, 0xCE,
  0x01, 0xE0, 0xDC, 0x00, 0x70, 0xF8, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xF0, 0x00, 0x38, 0xDC,
  0x00, 0x70, 0xCE, 0x01, 0xE0, 0xC7, 0xFF, 0xC0, 0xC1, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0x00, 0x78, 0x1E, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x06, 0x70, 0x00, 0x07, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x03, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1E,
  0x00, 0x1C, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x07, 0x80, 0x60, 0x7F, 0xF0, 0xC1, 0xFF, 0xF1, 0x87, 0x80, 0x73,
  0x1C, 0x00, 0x36, 0x70, 0x00, 0x3C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x76,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x37, 0x00, 0x00,
  0xE7, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x8E, 0x00, 0x1B, 0x0F, 0x00, 0xF6,
  0x0F, 0xFF, 0x8C, 0x07, 0xFE, 0x18, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x1E, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x30,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07,
  0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x40, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x0C, 0x1F, 0xFF,
  0x18, 0x78, 0x07, 0x31, 0xC0, 0x03, 0x67, 0x00, 0x03, 0xCE, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x78, 0xE0, 0x01,
  0xB0, 0xF0, 0x0F, 0x60, 0xFF, 0xF8, 0xC0, 0x7F, 0xE1, 0x80, 0x08, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x72,
  0x00, 0x00, 0xCE, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0F,
  0x83, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x01, 0xE0, 0x18, 0x1F, 0xF8,
  0x30, 0xFF, 0xFC, 0x63, 0x80, 0x3C, 0xCE, 0x00, 0x39, 0xB0, 0x00, 0x3B,
  0x40, 0x00, 0x37, 0x80, 0x00, 0x6E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x83, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0xC0, 0x00, 0x78,
  0xC0, 0x00, 0xF0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x07, 0x00,
  0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x78, 0x00, 0xC0, 0xF0, 0x00,
  0xC1, 0xE0, 0x00, 0xC3, 0xC0, 0x00, 0xC7, 0x00, 0x00, 0xCF, 0x80, 0x00,
  0xDD, 0xC0, 0x00, 0xF8, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x78, 0x00,
  0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00,
  0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xF0,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x03,
  0x83, 0x9F, 0xF0, 0x7F, 0x8E, 0xFF, 0xE7, 0xFF, 0x3F, 0x03, 0xB8, 0x0E,
  0xF0, 0x07, 0xC0, 0x1B, 0xC0, 0x0E, 0x00, 0x6E, 0x00, 0x38, 0x01, 0xF8,
  0x00, 0xC0, 0x07, 0xE0, 0x03, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x7E, 0x00,
  0x30, 0x01, 0xF8, 0x00, 0xC0, 0x07, 0xE0, 0x03, 0x00, 0x1F, 0x80, 0x0C,
  0x00, 0x7E, 0x00, 0x30, 0x01, 0xF8, 0x00, 0xC0, 0x07, 0xE0, 0x03, 0x00,
  0x1F, 0x80, 0x0C, 0x00, 0x7E, 0x00, 0x30, 0x01, 0xF8, 0x00, 0xC0, 0x07,
  0xE0, 0x03, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x3E, 0x00, 0x30, 0x00, 0xF8,
  0x00, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3E, 0x00,
  0x30, 0x00, 0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x0C,
  0x00, 0x3E, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x1E, 0x01, 0x81, 0xFF, 0x83,
  0x0F, 0xFF, 0x86, 0x38, 0x03, 0x8C, 0xE0, 0x03, 0x9B, 0x00, 0x03, 0xBC,
  0x00, 0x07, 0x78, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x01,
  0xF0, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0x98, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x07, 0x80, 0x78, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x38, 0x01, 0x83,
  0xFF, 0x03, 0x1F, 0xFF, 0x06, 0x70, 0x0F, 0x0D, 0x80, 0x07, 0x1E, 0x00,
  0x07, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x33, 0xC0,
  0x00, 0xE6, 0xC0, 0x03, 0x8C, 0xE0, 0x1E, 0x18, 0xFF, 0xF8, 0x30, 0x7F,
  0xE0, 0x60, 0x08, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0xFF, 0x0C, 0x1F, 0xFF, 0x18, 0x78, 0x07, 0x31,
  0xC0, 0x03, 0x67, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x60,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x70, 0x00, 0x06,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x78, 0xE0, 0x01, 0xF0, 0xF0, 0x0F, 0x60,
  0xFF, 0xF8, 0xC0, 0x7F, 0xE1, 0x80, 0x08, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x07, 0xCE, 0x07, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3C, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xE0, 0x07, 0x81, 0xC0,
  0x01, 0xE1, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x03, 0x38, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xC7, 0x80,
  0x01, 0xC1, 0xF0, 0x03, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x60, 0x00, 0x1E, 0xE0,
  0x00, 0x7C, 0xE0, 0x01, 0xB9, 0xE0, 0x0E, 0x70, 0xFF, 0xF8, 0xE0, 0xFF,
  0xC1, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x18, 0x01,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xC0, 0x07, 0x00, 0x19, 0x80, 0x0E,
  0x00, 0x33, 0x00, 0x3C, 0x00, 0x66, 0x00, 0x78, 0x01, 0xCE, 0x00, 0xD8,
  0x03, 0x1C, 0x01, 0xB0, 0x06, 0x18, 0x07, 0x60, 0x0C, 0x30, 0x0C, 0xC0,
  0x38, 0x60, 0x18, 0xC0, 0x70, 0xE0, 0x31, 0x80, 0xC0, 0xC0, 0xE3, 0x01,
  0x81, 0x81, 0x86, 0x03, 0x03, 0x03, 0x06, 0x0E, 0x06, 0x06, 0x0C, 0x18,
  0x0E, 0x1C, 0x18, 0x30, 0x0C, 0x30, 0x30, 0x60, 0x18, 0x60, 0x30, 0xC0,
  0x30, 0xC0, 0x63, 0x00, 0x73, 0x00, 0xC6, 0x00, 0x66, 0x01, 0x8C, 0x00,
  0xCC, 0x01, 0x98, 0x01, 0x98, 0x03, 0x30, 0x03, 0x20, 0x06, 0xC0, 0x07,
  0xC0, 0x0D, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30, 0x00, 0x60, 0x00, 0xF0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x30, 0x0E,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x33,
  0xFF, 0xC0, 0x00, 0xDC, 0x07, 0x80, 0x03, 0x60, 0x07, 0x00, 0x0F, 0x80,
  0x0E, 0x00, 0x6C, 0x00, 0x1E, 0x03, 0xB0, 0x00, 0x3E, 0x3C, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoMono_ExtraLight57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 4, 41, 34, 15, -41 },
  { 22, 10, 12, 34, 12, -43 },
  { 37, 31, 41, 34, 2, -41 },
  { 196, 25, 52, 34, 5, -46 },
  { 359, 32, 42, 34, 1, -41 },
  { 527, 29, 42, 34, 4, -41 },
  { 680, 2, 12, 34, 15, -43 },
  { 683, 13, 58, 34, 11, -45 },
  { 778, 13, 58, 34, 10, -45 },
  { 873, 25, 24, 34, 5, -41 },
  { 948, 28, 30, 34, 3, -34 },
  { 1053, 5, 13, 34, 11, -5 },
  { 1062, 20, 2, 34, 7, -19 },
  { 1067, 4, 4, 34, 16, -4 },
  { 1069, 19, 44, 34, 8, -41 },
  { 1174, 25, 42, 34, 5, -41 },
  { 1306, 14, 41, 34, 6, -41 },
  { 1378, 26, 41, 34, 3, -41 },
  { 1512, 25, 42, 34, 3, -41 },
  { 1644, 29, 41, 34, 2, -41 },
  { 1793, 24, 42, 34, 6, -41 },
  { 1919, 25, 42, 34, 4, -41 },
  { 2051, 26, 41, 34, 4, -41 },
  { 2185, 26, 42, 34, 5, -41 },
  { 2322, 25, 41, 34, 4, -41 },
  { 2451, 5, 28, 34, 17, -28 },
  { 2469, 7, 36, 34, 15, -28 },
  { 2501, 24, 23, 34, 5, -30 },
  { 2570, 25, 13, 34, 5, -25 },
  { 2611, 24, 23, 34, 5, -30 },
  { 2680, 21, 41, 34, 7, -41 },
  { 2788, 32, 41, 34, 1, -41 },
  { 2952, 29, 41, 34, 3, -41 },
  { 3101, 25, 41, 34, 6, -41 },
  { 3230, 26, 42, 34, 4, -41 },
  { 3367, 26, 41, 34, 5, -41 },
  { 3501, 23, 41, 34, 6, -41 },
  { 3619, 24, 41, 34, 6, -41 },
  { 3742, 27, 42, 34, 3, -41 },
  { 3884, 25, 41, 34, 5, -41 },
  { 4013, 23, 41, 34, 6, -41 },
  { 4131, 25, 42, 34, 3, -41 },
  { 4263, 27, 41, 34, 6, -41 },
  { 4402, 24, 41, 34, 6, -41 },
  { 4525, 25, 41, 34, 5, -41 },
  { 4654, 25, 41, 34, 5, -41 },
  { 4783, 26, 42, 34, 4, -41 },
  { 4920, 25, 41, 34, 6, -41 },
  { 5049, 28, 48, 34, 3, -41 },
  { 5217, 25, 41, 34, 6, -41 },
  { 5346, 27, 42, 34, 4, -41 },
  { 5488, 28, 41, 34, 3, -41 },
  { 5632, 25, 42, 34, 5, -41 },
  { 5764, 28, 41, 34, 3, -41 },
  { 5908, 30, 41, 34, 3, -41 },
  { 6062, 29, 41, 34, 3, -41 },
  { 6211, 29, 41, 34, 2, -41 },
  { 6360, 25, 41, 34, 4, -41 },
  { 6489, 9, 55, 34, 13, -46 },
  { 6551, 20, 44, 34, 7, -41 },
  { 6661, 9, 55, 34, 12, -46 },
  { 6723, 20, 23, 34, 7, -41 },
  { 6781, 24, 2, 34, 5, 0 },
  { 6787, 8, 7, 34, 13, -42 },
  { 6794, 24, 32, 34, 5, -31 },
  { 6890, 24, 44, 34, 6, -43 },
  { 7022, 24, 32, 34, 5, -31 },
  { 7118, 23, 44, 34, 5, -43 },
  { 7245, 26, 32, 34, 4, -31 },
  { 7349, 26, 44, 34, 5, -44 },
  { 7492, 23, 43, 34, 5, -31 },
  { 7616, 23, 43, 34, 6, -43 },
  { 7740, 24, 41, 34, 6, -41 },
  { 7863, 18, 53, 34, 5, -41 },
  { 7983, 24, 43, 34, 7, -43 },
  { 8112, 24, 43, 34, 6, -43 },
  { 8241, 30, 31, 34, 2, -31 },
  { 8358, 23, 31, 34, 6, -31 },
  { 8448, 26, 32, 34, 4, -31 },
  { 8552, 23, 43, 34, 6, -31 },
  { 8676, 23, 43, 34, 5, -31 },
  { 8800, 20, 31, 34, 10, -31 },
  { 8878, 25, 32, 34, 5, -31 },
  { 8978, 24, 39, 34, 5, -38 },
  { 9095, 23, 31, 34, 6, -30 },
  { 9185, 28, 30, 34, 3, -30 },
  { 9290, 31, 30, 34, 2, -30 },
  { 9407, 27, 30, 34, 4, -30 },
  { 9509, 30, 42, 34, 2, -30 },
  { 9667, 27, 30, 34, 4, -30 },
  { 9769, 19, 56, 34, 9, -44 },
  { 9902, 2, 49, 34, 16, -41 },
  { 9915, 19, 56, 34, 9, -44 },
  { 10048, 30, 10, 34, 2, -22 },
};

const GFXfont RobotoMono_ExtraLight57pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight57pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOMONO_EXTRALIGHT57PT7B_H_
