#ifndef _ROBOTOMONO_EXTRALIGHT35PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xC7, 0x8B, 0x16, 0x2C,
  0x58, 0xB1, 0x00, 0x00, 0x81, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0xC1,
  0x80, 0x10, 0x20, 0x02, 0x04, 0x00, 0x40, 0x83, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0x40, 0xC0, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x20, 0x40, 0x04, 0x08, 0x1F, 0xFF, 0xF8, 0x30, 0x20,
  0x06, 0x0C, 0x00, 0x81, 0x80, 0x10, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80,
  0x18, 0x30, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x7F,
  0x03, 0x87, 0x0C, 0x03, 0x10, 0x02, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0B,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x40, 0x02, 0xC0, 0x0C, 0xC0, 0x30, 0xC0, 0xC0, 0xFF, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x3C, 0x00, 0x08, 0x40, 0x03, 0x0C, 0x00,
  0x40, 0x81, 0x08, 0x10, 0x61, 0x02, 0x08, 0x20, 0x43, 0x04, 0x08, 0x40,
  0xC3, 0x10, 0x0C, 0xC6, 0x00, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x21, 0xE0, 0x0C, 0x66, 0x01, 0x18, 0x60, 0x62, 0x04,
  0x08, 0x40, 0x82, 0x08, 0x10, 0xC1, 0x02, 0x10, 0x20, 0x42, 0x06, 0x18,
  0x00, 0x42, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0C, 0x30, 0x0C, 0x08, 0x06,
  0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0x80, 0x60, 0xC0, 0x10, 0xC0,
  0x0C, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0xE0, 0x01, 0x98, 0x01, 0x86,
  0x04, 0x81, 0x82, 0xC0, 0x41, 0x40, 0x31, 0xA0, 0x0C, 0xD0, 0x03, 0xC8,
  0x00, 0xE6, 0x00, 0x61, 0x80, 0x78, 0xE0, 0xE6, 0x1F, 0xC1, 0x80, 0xFE,
  0xA8, 0x02, 0x07, 0x04, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x06,
  0x03, 0x80, 0xC0, 0x20, 0x30, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x06, 0x06,
  0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x40,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xE1,
  0x87, 0x3D, 0xBC, 0x07, 0xE0, 0x01, 0x80, 0x02, 0x40, 0x06, 0x60, 0x0C,
  0x30, 0x18, 0x18, 0x10, 0x0C, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x7F, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x6D, 0xB6,
  0xB4, 0xFF, 0xF8, 0x7C, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x30,
  0x60, 0xC0, 0x63, 0x00, 0x64, 0x00, 0x58, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x1B, 0x00, 0x66, 0x01, 0x8C, 0x06, 0x18, 0x18, 0x30, 0x60, 0x61,
  0x80, 0xC6, 0x01, 0x90, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x34, 0x00,
  0x4C, 0x01, 0x8C, 0x06, 0x0C, 0x18, 0x0F, 0xE0, 0x01, 0x07, 0x1D, 0xF1,
  0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x0F, 0xE0, 0x38,
  0x70, 0x60, 0x18, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x04, 0x80, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x0F,
  0xE0, 0x30, 0x70, 0xC0, 0x23, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xF0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x07, 0x80, 0x7E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x68, 0x00, 0xD8, 0x03, 0x1C, 0x1C, 0x0F, 0xE0, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x04, 0xC0, 0x06,
  0x60, 0x06, 0x30, 0x02, 0x18, 0x03, 0x0C, 0x03, 0x06, 0x01, 0x03, 0x01,
  0x81, 0x81, 0x80, 0xC0, 0x80, 0x60, 0xC0, 0x30, 0xC0, 0x18, 0x7F, 0xFF,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x3F, 0xFC, 0xFF, 0xF2, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x1E, 0x07, 0xFE, 0x18,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x01, 0x8F, 0x1C, 0x0F, 0xE0,
  0x01, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x1F, 0xC2, 0x60, 0xC5, 0x00, 0xCC, 0x00,
  0xD8, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x4C, 0x01, 0x8C, 0x06, 0x0C, 0x18, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0F, 0xE0, 0x1C, 0x38, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x06, 0x40,
  0x06, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x0E,
  0xF0, 0x0F, 0xE0, 0x18, 0x18, 0x60, 0x0C, 0x40, 0x06, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x06, 0x60, 0x06, 0x38,
  0x1C, 0x0F, 0xF0, 0x0F, 0xE0, 0x30, 0xE0, 0xC0, 0x63, 0x00, 0x6C, 0x00,
  0xD8, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x34, 0x00, 0x6C, 0x01, 0x4C, 0x05, 0x8E, 0xF3, 0x0F, 0x86, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x23, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x22, 0x22, 0x6C, 0x40, 0x00, 0x0E, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x30, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xC1, 0xC3, 0x18, 0x0C, 0x80,
  0x3C, 0x00, 0xE0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x01,
  0xFC, 0x00, 0xF0, 0xE0, 0x30, 0x06, 0x0C, 0x00, 0x43, 0x00, 0x0C, 0x40,
  0xE0, 0x98, 0x77, 0x1A, 0x08, 0x23, 0x42, 0x0C, 0x38, 0x41, 0x06, 0x18,
  0x20, 0xC2, 0x04, 0x18, 0x40, 0x83, 0x08, 0x10, 0x61, 0x02, 0x0C, 0x20,
  0xC3, 0x84, 0x18, 0x58, 0xC5, 0x0B, 0x09, 0xB2, 0x21, 0xE3, 0x86, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x70, 0x07, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x05, 0x80, 0x01, 0x60, 0x00, 0xC8,
  0x00, 0x23, 0x00, 0x08, 0xC0, 0x06, 0x10, 0x01, 0x06, 0x00, 0x41, 0x80,
  0x30, 0x20, 0x08, 0x0C, 0x02, 0x03, 0x01, 0x80, 0x40, 0x40, 0x18, 0x1F,
  0xFE, 0x0F, 0xFF, 0x83, 0x00, 0x20, 0x80, 0x0C, 0x60, 0x01, 0x18, 0x00,
  0x44, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xC0, 0xFF, 0x81, 0x07, 0xC2,
  0x00, 0xC4, 0x00, 0xC8, 0x00, 0xD0, 0x01, 0xA0, 0x03, 0x40, 0x06, 0x80,
  0x0D, 0x00, 0x32, 0x00, 0xC4, 0x1F, 0x0F, 0xFE, 0x10, 0x07, 0x20, 0x03,
  0x40, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x50,
  0x01, 0xA0, 0x06, 0x40, 0x78, 0xFF, 0xC0, 0x07, 0xF0, 0x07, 0x0E, 0x06,
  0x01, 0x86, 0x00, 0xC2, 0x00, 0x33, 0x00, 0x09, 0x00, 0x04, 0x80, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0xD0, 0x00, 0x4C,
  0x00, 0x22, 0x00, 0x31, 0x80, 0x10, 0x60, 0x18, 0x18, 0x38, 0x07, 0xF0,
  0x00, 0xFF, 0x80, 0xC1, 0xE0, 0xC0, 0x38, 0xC0, 0x08, 0xC0, 0x0C, 0xC0,
  0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x38, 0xC1,
  0xE0, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xFC,
  0xFF, 0xF2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFA, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x07, 0x0E, 0x06,
  0x01, 0x86, 0x00, 0x42, 0x00, 0x33, 0x00, 0x09, 0x00, 0x07, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x6C,
  0x00, 0x32, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x0C, 0x1C, 0x1C, 0x07, 0xF8,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x6C, 0x00, 0x88, 0x03, 0x1C, 0x1C, 0x0F, 0xE0, 0x80, 0x06,
  0x80, 0x0C, 0x80, 0x18, 0x80, 0x30, 0x80, 0x30, 0x80, 0x60, 0x80, 0xC0,
  0x81, 0x80, 0x83, 0x00, 0x86, 0x00, 0x8C, 0x00, 0x9C, 0x00, 0xB6, 0x00,
  0xE6, 0x00, 0xC3, 0x00, 0x81, 0x80, 0x80, 0xC0, 0x80, 0x40, 0x80, 0x60,
  0x80, 0x30, 0x80, 0x18, 0x80, 0x08, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x03,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x3D, 0x00, 0x5B, 0x00, 0xB2, 0x03, 0x64, 0x04, 0xCC, 0x19, 0x88,
  0x23, 0x10, 0x46, 0x31, 0x8C, 0x22, 0x18, 0x6C, 0x30, 0x58, 0x60, 0xA0,
  0xC1, 0xC1, 0x81, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0D, 0x00, 0x1B, 0x00, 0x32, 0x00, 0x66, 0x00, 0xC4, 0x01, 0x8C, 0x03,
  0x0C, 0x06, 0x08, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x30, 0x60, 0x20, 0xC0,
  0x61, 0x80, 0x43, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0x98, 0x01, 0xB0, 0x01,
  0x60, 0x03, 0xC0, 0x03, 0x80, 0x06, 0x07, 0xF0, 0x07, 0x1C, 0x06, 0x03,
  0x06, 0x00, 0xC2, 0x00, 0x23, 0x00, 0x19, 0x00, 0x04, 0x80, 0x02, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x4C, 0x00,
  0x62, 0x00, 0x21, 0x80, 0x30, 0x60, 0x30, 0x18, 0x30, 0x07, 0xF0, 0x00,
  0xFF, 0xC1, 0x01, 0xE2, 0x00, 0x64, 0x00, 0x68, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x68, 0x01,
  0x9F, 0xFE, 0x3F, 0xE0, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x07,
  0xF0, 0x07, 0x1C, 0x06, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x09,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xD0, 0x00, 0x68, 0x00, 0x26, 0x00, 0x31, 0x80, 0x10, 0x60, 0x18,
  0x18, 0x38, 0x07, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0xFF, 0x81, 0x03, 0xC2, 0x00, 0xC4, 0x00, 0xC8, 0x00, 0xD0, 0x01,
  0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x34, 0x00, 0xC8,
  0x03, 0x1F, 0xFC, 0x20, 0x30, 0x40, 0x60, 0x80, 0x61, 0x00, 0x42, 0x00,
  0xC4, 0x00, 0x88, 0x01, 0x90, 0x01, 0x20, 0x03, 0x40, 0x02, 0x80, 0x06,
  0x0F, 0xE0, 0x1C, 0x38, 0x70, 0x0C, 0x60, 0x06, 0xC0, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x38, 0x1C,
  0x0F, 0xF0, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x34, 0x00, 0x6C,
  0x01, 0x8C, 0x06, 0x0C, 0x18, 0x0F, 0xE0, 0x80, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x48, 0x00, 0x26, 0x00, 0x33, 0x00, 0x10, 0x80, 0x08, 0x60, 0x0C,
  0x30, 0x06, 0x08, 0x02, 0x06, 0x03, 0x03, 0x01, 0x80, 0x80, 0x80, 0x40,
  0xC0, 0x30, 0x60, 0x08, 0x20, 0x04, 0x30, 0x03, 0x18, 0x00, 0x88, 0x00,
  0x4C, 0x00, 0x36, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x00, 0x80,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x03, 0x03, 0xC1, 0xC0,
  0xB0, 0x58, 0x24, 0x16, 0x09, 0x04, 0x82, 0x41, 0x21, 0x90, 0xC8, 0x66,
  0x33, 0x19, 0x88, 0xC4, 0x62, 0x11, 0x08, 0x84, 0x42, 0x61, 0x10, 0x98,
  0x4C, 0x24, 0x1B, 0x0D, 0x06, 0x83, 0x40, 0xA0, 0xF0, 0x28, 0x1C, 0x0A,
  0x06, 0x03, 0x81, 0x80, 0xE0, 0x60, 0x18, 0x18, 0x04, 0x00, 0xC0, 0x01,
  0x98, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x18, 0x18, 0x06, 0x02, 0x03, 0x00,
  0xC0, 0x80, 0x18, 0x60, 0x06, 0x30, 0x00, 0xC8, 0x00, 0x16, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x16, 0x00, 0x0C, 0xC0, 0x06, 0x10,
  0x01, 0x06, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x0C, 0x00, 0x82,
  0x00, 0x31, 0x80, 0x06, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xD8, 0x00, 0x22,
  0x00, 0x18, 0xC0, 0x04, 0x10, 0x03, 0x06, 0x00, 0x80, 0x80, 0x60, 0x30,
  0x10, 0x04, 0x0C, 0x01, 0x82, 0x00, 0x21, 0x80, 0x0C, 0x40, 0x01, 0x30,
  0x00, 0x68, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0xF8, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0xF8, 0x02, 0x00, 0x38, 0x01, 0x40, 0x0B, 0x00, 0xD8, 0x04, 0x40,
  0x63, 0x02, 0x08, 0x30, 0x61, 0x83, 0x08, 0x08, 0xC0, 0x64, 0x01, 0x60,
  0x0C, 0xFF, 0xFE, 0xC3, 0x08, 0x21, 0x80, 0x07, 0xC0, 0x3F, 0xE0, 0xC0,
  0x63, 0x00, 0x64, 0x00, 0x58, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0xFE,
  0x3F, 0xFC, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x40, 0x1E, 0xE0, 0xEC, 0x7F, 0x18, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x21, 0xE0, 0x9F, 0xE2, 0x80,
  0xCC, 0x01, 0xB0, 0x02, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x2C, 0x01, 0xB8,
  0x0C, 0xB0, 0x72, 0x7F, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xC0, 0x61, 0x00,
  0x66, 0x00, 0x48, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xD0, 0x01, 0xB0, 0x02, 0x30,
  0x0C, 0x30, 0x70, 0x3F, 0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x41, 0xE1, 0x1F, 0xE4, 0xC0, 0x56, 0x00,
  0xD0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x01, 0xC0, 0x05, 0x00, 0x16, 0x00, 0xCC, 0x07, 0x18,
  0x34, 0x3F, 0x90, 0x03, 0xC0, 0x1F, 0xE0, 0xE0, 0x61, 0x00, 0x66, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x02, 0x30, 0x06, 0x38,
  0x38, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x80, 0x7F,
  0x93, 0x01, 0x58, 0x03, 0x40, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x14, 0x00, 0x58,
  0x03, 0x30, 0x1C, 0x60, 0xD0, 0xFE, 0x40, 0x01, 0x00, 0x04, 0x00, 0x34,
  0x00, 0xD8, 0x06, 0x38, 0x30, 0x3F, 0x80, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0xE0, 0xCF, 0xF9,
  0xB0, 0x1B, 0x40, 0x37, 0x00, 0x2C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0C, 0x03, 0x00, 0x07, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x00, 0x60, 0x1C, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0xE7, 0xF0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x02, 0xC0, 0x19, 0x80, 0x63, 0x01, 0x86,
  0x06, 0x0C, 0x38, 0x18, 0xC0, 0x33, 0x00, 0x6E, 0x00, 0xFC, 0x01, 0xCC,
  0x03, 0x0C, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x60, 0x0C,
  0xC0, 0x19, 0x80, 0x1C, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x01, 0xFF, 0xFC, 0x0F, 0x0F, 0x1B, 0xF3, 0xF3, 0x83, 0x83,
  0x60, 0x30, 0x2C, 0x04, 0x07, 0x80, 0x80, 0xF0, 0x10, 0x1E, 0x02, 0x03,
  0xC0, 0x40, 0x78, 0x08, 0x0F, 0x01, 0x01, 0xE0, 0x20, 0x3C, 0x04, 0x07,
  0x80, 0x80, 0xF0, 0x10, 0x1E, 0x02, 0x03, 0xC0, 0x40, 0x78, 0x08, 0x0F,
  0x01, 0x01, 0x80, 0x01, 0xC1, 0x9F, 0xF3, 0x60, 0x37, 0x80, 0x6E, 0x00,
  0x58, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x18, 0x03, 0xE0, 0x07, 0xFC, 0x06, 0x03, 0x06, 0x00, 0xC6,
  0x00, 0x33, 0x00, 0x19, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x34, 0x00, 0x12, 0x00, 0x09, 0x80, 0x0C, 0x60,
  0x0C, 0x30, 0x06, 0x0E, 0x0E, 0x01, 0xFC, 0x00, 0x07, 0x82, 0x7F, 0x8A,
  0x03, 0x30, 0x06, 0x80, 0x1A, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xB0, 0x06,
  0xC0, 0x32, 0xC1, 0x89, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07, 0x80, 0x7F, 0x93, 0x01, 0x58,
  0x03, 0x60, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x14, 0x00, 0x58, 0x03, 0x30, 0x1C,
  0x60, 0xD0, 0xFE, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x01, 0xFC, 0x7F, 0xDC, 0x0D, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x3F,
  0xF0, 0xC0, 0x33, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x58, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0xA0, 0x03, 0x60, 0x06, 0x70, 0x38, 0x3F, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x1F, 0xFF, 0x81, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x3F, 0x80, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x01, 0xD0, 0x0F, 0x70, 0x6C, 0xFE,
  0x30, 0xC0, 0x01, 0xA0, 0x00, 0x98, 0x00, 0xC4, 0x00, 0x43, 0x00, 0x61,
  0x80, 0x20, 0x40, 0x30, 0x30, 0x18, 0x08, 0x08, 0x06, 0x0C, 0x01, 0x04,
  0x00, 0xC6, 0x00, 0x62, 0x00, 0x11, 0x00, 0x0D, 0x80, 0x02, 0x80, 0x01,
  0xC0, 0x00, 0x40, 0x00, 0xC0, 0x40, 0x68, 0x0C, 0x0D, 0x02, 0x81, 0x30,
  0x50, 0x26, 0x0A, 0x04, 0x41, 0x61, 0x88, 0x64, 0x21, 0x08, 0x84, 0x31,
  0x10, 0x86, 0x23, 0x30, 0x4C, 0x26, 0x09, 0x04, 0x81, 0x20, 0x90, 0x34,
  0x1A, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x03, 0x98, 0x03, 0x06, 0x03, 0x01, 0x81, 0x80, 0x41, 0x80, 0x31, 0x80,
  0x0D, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0x46,
  0x00, 0x61, 0x80, 0x60, 0x60, 0x60, 0x30, 0x60, 0x0C, 0x20, 0x03, 0x70,
  0x00, 0xC0, 0xE0, 0x00, 0xEC, 0x00, 0x18, 0x80, 0x02, 0x18, 0x00, 0xC1,
  0x00, 0x10, 0x30, 0x06, 0x02, 0x00, 0x80, 0x60, 0x30, 0x04, 0x06, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x01, 0x84, 0x00, 0x31, 0x80, 0x03, 0x20, 0x00,
  0x6C, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0xE0, 0x1C, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x18, 0x01, 0xE0, 0x3C, 0x0C, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x70, 0x18, 0x00, 0x3F, 0x00, 0x2C, 0x30, 0x0D,
  0x03, 0x01, 0x60, 0x38, 0x68, 0x01, 0xF8, 0x00, 0x0C, 0x00,
};

const GFXglyph RobotoMono_ExtraLight35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 2, 25, 21, 9, -25 },
  { 8, 7, 7, 21, 7, -26 },
  { 15, 19, 25, 21, 1, -25 },
  { 75, 15, 33, 21, 3, -29 },
  { 137, 19, 25, 21, 1, -25 },
  { 197, 17, 25, 21, 3, -25 },
  { 251, 2, 7, 21, 9, -26 },
  { 253, 8, 36, 21, 7, -28 },
  { 289, 8, 36, 21, 6, -28 },
  { 325, 16, 14, 21, 3, -25 },
  { 353, 17, 19, 21, 2, -21 },
  { 394, 3, 8, 21, 7, -3 },
  { 397, 13, 1, 21, 4, -12 },
  { 399, 2, 3, 21, 10, -3 },
  { 400, 12, 27, 21, 5, -25 },
  { 441, 15, 25, 21, 3, -25 },
  { 488, 8, 25, 21, 4, -25 },
  { 513, 16, 25, 21, 2, -25 },
  { 563, 15, 25, 21, 2, -25 },
  { 610, 17, 25, 21, 2, -25 },
  { 664, 14, 25, 21, 4, -25 },
  { 708, 15, 25, 21, 3, -25 },
  { 755, 16, 25, 21, 2, -25 },
  { 805, 16, 25, 21, 3, -25 },
  { 855, 15, 25, 21, 3, -25 },
  { 902, 2, 18, 21, 11, -18 },
  { 907, 4, 23, 21, 9, -18 },
  { 919, 15, 14, 21, 3, -18 },
  { 946, 15, 9, 21, 3, -16 },
  { 963, 15, 14, 21, 3, -18 },
  { 990, 13, 25, 21, 4, -25 },
  { 1031, 19, 25, 21, 1, -25 },
  { 1091, 18, 25, 21, 2, -25 },
  { 1148, 15, 25, 21, 4, -25 },
  { 1195, 17, 25, 21, 2, -25 },
  { 1249, 16, 25, 21, 3, -25 },
  { 1299, 14, 25, 21, 4, -25 },
  { 1343, 14, 25, 21, 4, -25 },
  { 1387, 17, 25, 21, 2, -25 },
  { 1441, 15, 25, 21, 3, -25 },
  { 1488, 15, 25, 21, 3, -25 },
  { 1535, 15, 25, 21, 2, -25 },
  { 1582, 16, 25, 21, 4, -25 },
  { 1632, 14, 25, 21, 4, -25 },
  { 1676, 15, 25, 21, 3, -25 },
  { 1723, 15, 25, 21, 3, -25 },
  { 1770, 17, 25, 21, 2, -25 },
  { 1824, 15, 25, 21, 4, -25 },
  { 1871, 17, 29, 21, 2, -25 },
  { 1933, 15, 25, 21, 4, -25 },
  { 1980, 16, 25, 21, 3, -25 },
  { 2030, 17, 25, 21, 2, -25 },
  { 2084, 15, 25, 21, 3, -25 },
  { 2131, 17, 25, 21, 2, -25 },
  { 2185, 18, 25, 21, 2, -25 },
  { 2242, 18, 25, 21, 2, -25 },
  { 2299, 18, 25, 21, 1, -25 },
  { 2356, 16, 25, 21, 2, -25 },
  { 2406, 5, 33, 21, 8, -28 },
  { 2427, 11, 27, 21, 5, -25 },
  { 2465, 5, 33, 21, 8, -28 },
  { 2486, 13, 14, 21, 4, -25 },
  { 2509, 15, 1, 21, 3, 0 },
  { 2511, 5, 5, 21, 8, -26 },
  { 2515, 15, 19, 21, 3, -19 },
  { 2551, 14, 26, 21, 4, -26 },
  { 2597, 15, 19, 21, 3, -19 },
  { 2633, 14, 26, 21, 3, -26 },
  { 2679, 15, 19, 21, 3, -19 },
  { 2715, 16, 27, 21, 3, -27 },
  { 2769, 14, 26, 21, 3, -19 },
  { 2815, 15, 26, 21, 3, -26 },
  { 2864, 15, 25, 21, 4, -25 },
  { 2911, 11, 32, 21, 3, -25 },
  { 2955, 15, 26, 21, 4, -26 },
  { 3004, 15, 26, 21, 4, -26 },
  { 3053, 19, 19, 21, 1, -19 },
  { 3099, 15, 19, 21, 3, -19 },
  { 3135, 17, 19, 21, 2, -19 },
  { 3176, 14, 26, 21, 4, -19 },
  { 3222, 14, 26, 21, 3, -19 },
  { 3268, 12, 19, 21, 6, -19 },
  { 3297, 15, 19, 21, 3, -19 },
  { 3333, 15, 23, 21, 3, -23 },
  { 3377, 14, 18, 21, 4, -18 },
  { 3409, 17, 18, 21, 2, -18 },
  { 3448, 19, 18, 21, 1, -18 },
  { 3491, 17, 18, 21, 2, -18 },
  { 3530, 19, 25, 21, 1, -18 },
  { 3590, 17, 18, 21, 2, -18 },
  { 3629, 11, 34, 21, 6, -27 },
  { 3676, 1, 30, 21, 10, -25 },
  { 3680, 11, 34, 21, 6, -27 },
  { 3727, 19, 6, 21, 1, -13 },
};

const GFXfont RobotoMono_ExtraLight35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight35pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_EXTRALIGHT35PT7B_H_
