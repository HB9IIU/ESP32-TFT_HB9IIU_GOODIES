#ifndef _ROBOTOMONO_EXTRALIGHT37PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x00, 0xC0, 0x80, 0x08, 0x08, 0x00, 0x81, 0x80, 0x08, 0x18,
  0x01, 0x81, 0x00, 0x18, 0x10, 0x01, 0x01, 0x07, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x10, 0x20, 0x03, 0x02, 0x00, 0x30, 0x20, 0x02, 0x02, 0x00, 0x20,
  0x60, 0x02, 0x06, 0x00, 0x60, 0x40, 0x06, 0x04, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x40, 0xC0, 0x04, 0x08, 0x00, 0xC0, 0x80, 0x0C, 0x08, 0x00,
  0x81, 0x80, 0x08, 0x18, 0x01, 0x81, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0xE0, 0x0F, 0xF8, 0x1C, 0x0C, 0x30, 0x06, 0x20, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x01, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x60, 0x03, 0x60,
  0x03, 0x30, 0x06, 0x1C, 0x1C, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x43, 0x00, 0x0C, 0x10,
  0x00, 0x81, 0x83, 0x08, 0x18, 0x20, 0x81, 0x86, 0x08, 0x18, 0x40, 0x81,
  0x8C, 0x0C, 0x10, 0x80, 0x63, 0x18, 0x03, 0xE1, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x87, 0xE0, 0x18, 0xC3,
  0x01, 0x08, 0x10, 0x30, 0x81, 0x02, 0x18, 0x10, 0x61, 0x81, 0x04, 0x18,
  0x10, 0xC0, 0x81, 0x00, 0x08, 0x30, 0x00, 0xC2, 0x00, 0x07, 0xC0, 0x01,
  0x80, 0x03, 0xF8, 0x01, 0x83, 0x00, 0x40, 0x40, 0x30, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x00, 0xC0, 0xC0, 0x30, 0x20, 0x06, 0x10, 0x01, 0x98, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xB0, 0x00, 0xC6, 0x02, 0x60,
  0xC0, 0xB0, 0x18, 0x2C, 0x02, 0x1A, 0x00, 0xC6, 0x80, 0x19, 0x20, 0x03,
  0xCC, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x0F, 0x0E, 0x0E, 0x61, 0xFE, 0x0C,
  0xFF, 0x01, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x40, 0x40, 0x60, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x0C, 0x04,
  0x02, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02,
  0x01, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x81, 0x02, 0xE1, 0x0F, 0x7D, 0x3C, 0x07, 0xE0,
  0x03, 0x80, 0x06, 0xC0, 0x04, 0x60, 0x0C, 0x30, 0x18, 0x30, 0x30, 0x1C,
  0x10, 0x08, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x24, 0x96, 0xD6,
  0xFF, 0xFF, 0xFF, 0xF0, 0x5F, 0x80, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C,
  0x60, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0D,
  0xC0, 0x19, 0xC0, 0x31, 0xC0, 0x61, 0xC0, 0xC1, 0xC1, 0x81, 0xC3, 0x01,
  0xC4, 0x01, 0xC8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x40, 0x03,
  0x60, 0x02, 0x20, 0x06, 0x30, 0x0C, 0x1C, 0x18, 0x07, 0xF0, 0x01, 0x83,
  0xCF, 0x3E, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x03, 0xC0, 0x07, 0xF8, 0x0E, 0x06, 0x0C, 0x01,
  0x86, 0x00, 0x66, 0x00, 0x33, 0x00, 0x09, 0x80, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0xF8, 0x38, 0x1C, 0x30, 0x06, 0x60, 0x06,
  0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x60, 0x02, 0x30, 0x06, 0x1C, 0x1C, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x18, 0xC0,
  0x04, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x00, 0x40, 0xC0, 0x30, 0x30, 0x18,
  0x0C, 0x04, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C, 0x30, 0x03,
  0x0F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xFE, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x63, 0xC0, 0x7F, 0xF0, 0x70, 0x38, 0x40, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x02, 0xC0,
  0x06, 0x40, 0x06, 0x60, 0x0C, 0x30, 0x1C, 0x1C, 0x78, 0x0F, 0xF0, 0x00,
  0x08, 0x01, 0xF8, 0x07, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC7, 0xF0, 0xDC, 0x38, 0xB0,
  0x0C, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x60, 0x06, 0x30,
  0x0C, 0x1C, 0x38, 0x07, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0xFC, 0x06, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x04, 0x80, 0x02, 0x60, 0x01, 0x30, 0x01, 0x88, 0x00,
  0x86, 0x00, 0xC0, 0xE1, 0xC0, 0x1F, 0x80, 0x78, 0xF0, 0x60, 0x0C, 0x60,
  0x03, 0x20, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D,
  0x00, 0x06, 0xC0, 0x06, 0x30, 0x06, 0x0E, 0x0E, 0x03, 0xFE, 0x00, 0x03,
  0xC0, 0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x06, 0xC0,
  0x02, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x40, 0x03, 0x60, 0x07, 0x30, 0x0F, 0x18, 0x3B, 0x0F, 0xE3, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xE0, 0x1F, 0x80, 0x5F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x5F,
  0x80, 0x27, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x26, 0x66,
  0xC8, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0x00, 0x7F, 0xC3, 0x03,
  0x98, 0x02, 0x40, 0x0F, 0x00, 0x3C, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF0,
  0x07, 0x01, 0x80, 0xC0, 0x0C, 0x18, 0x00, 0x61, 0x00, 0x02, 0x30, 0x78,
  0x22, 0x0C, 0xE3, 0x61, 0x84, 0x14, 0x30, 0x41, 0x42, 0x04, 0x1C, 0x20,
  0x41, 0xC6, 0x04, 0x18, 0x60, 0x41, 0x84, 0x04, 0x18, 0x40, 0x41, 0x84,
  0x0C, 0x18, 0x60, 0xC2, 0xC6, 0x1C, 0x2C, 0x21, 0x46, 0x43, 0xE7, 0xC4,
  0x1C, 0x38, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x60,
  0x03, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0xD0,
  0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xC4, 0x00, 0x18, 0xC0, 0x02, 0x18,
  0x00, 0xC1, 0x00, 0x18, 0x30, 0x02, 0x06, 0x00, 0xC0, 0x40, 0x18, 0x0C,
  0x02, 0x01, 0x80, 0xC0, 0x10, 0x18, 0x03, 0x03, 0xFF, 0xE0, 0xC0, 0x04,
  0x18, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x01, 0x18, 0x00, 0x32, 0x00, 0x06,
  0x40, 0x00, 0x58, 0x00, 0x0C, 0xFF, 0xE0, 0x80, 0x78, 0x80, 0x1C, 0x80,
  0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80,
  0x0C, 0x80, 0x18, 0x80, 0x70, 0xFF, 0xE0, 0x80, 0x38, 0x80, 0x0C, 0x80,
  0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x0C, 0x80, 0xF8, 0xFF, 0xE0, 0x00, 0xE0, 0x01,
  0xFF, 0x00, 0xC0, 0xE0, 0x60, 0x0C, 0x30, 0x01, 0x08, 0x00, 0x66, 0x00,
  0x09, 0x80, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x03, 0x60, 0x00, 0x98, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x0C, 0x18, 0x06, 0x03, 0x83, 0x80, 0x3F, 0x80, 0xFF, 0xE0,
  0x60, 0x3C, 0x30, 0x07, 0x18, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x1B, 0x00,
  0x05, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x33, 0x00, 0x31, 0x80,
  0x30, 0xC1, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0x90, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xD8, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xFF,
  0x00, 0xC0, 0xE0, 0x60, 0x0C, 0x30, 0x01, 0x88, 0x00, 0x66, 0x00, 0x09,
  0x80, 0x03, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0x34, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x0C,
  0x40, 0x03, 0x18, 0x01, 0x83, 0x81, 0xC0, 0x3F, 0xC0, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x06,
  0x30, 0x0C, 0x1C, 0x38, 0x0F, 0xF0, 0x80, 0x03, 0xC0, 0x03, 0x20, 0x03,
  0x10, 0x03, 0x08, 0x03, 0x04, 0x03, 0x02, 0x03, 0x81, 0x01, 0x80, 0x81,
  0x80, 0x41, 0x80, 0x21, 0x80, 0x11, 0x80, 0x09, 0xE0, 0x05, 0x98, 0x03,
  0x84, 0x01, 0x83, 0x00, 0x80, 0xC0, 0x40, 0x30, 0x20, 0x0C, 0x10, 0x06,
  0x08, 0x01, 0x84, 0x00, 0x62, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x03, 0x40,
  0x00, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0xFF, 0xFC, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x05, 0xD0,
  0x0D, 0xD0, 0x0D, 0xD8, 0x09, 0xC8, 0x19, 0xCC, 0x11, 0xCC, 0x31, 0xC4,
  0x31, 0xC6, 0x21, 0xC2, 0x61, 0xC2, 0x41, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1,
  0x81, 0xC1, 0x81, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xD0, 0x01, 0xD8, 0x01, 0xC8, 0x01, 0xCC, 0x01, 0xC6,
  0x01, 0xC6, 0x01, 0xC3, 0x01, 0xC1, 0x01, 0xC1, 0x81, 0xC0, 0x81, 0xC0,
  0xC1, 0xC0, 0x41, 0xC0, 0x61, 0xC0, 0x31, 0xC0, 0x31, 0xC0, 0x19, 0xC0,
  0x09, 0xC0, 0x0D, 0xC0, 0x05, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x01,
  0xE0, 0x01, 0xFE, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30, 0x03, 0x08, 0x00,
  0x46, 0x00, 0x19, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x02, 0x60, 0x01, 0x98, 0x00,
  0x63, 0x00, 0x10, 0xC0, 0x0C, 0x18, 0x06, 0x03, 0x87, 0x00, 0x3F, 0x80,
  0xFF, 0xF0, 0xC0, 0x3C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x06,
  0xC0, 0x0E, 0xC0, 0x78, 0xFF, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0xC0, 0xE0, 0x60,
  0x0C, 0x30, 0x01, 0x18, 0x00, 0x66, 0x00, 0x09, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0D, 0x00,
  0x03, 0x40, 0x00, 0xD8, 0x00, 0x22, 0x00, 0x18, 0xC0, 0x0C, 0x18, 0x06,
  0x03, 0x87, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x02, 0xFF, 0xE0, 0x80, 0x78, 0x80, 0x1C, 0x80, 0x0C,
  0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06,
  0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0xFF, 0xF0, 0xFF, 0xC0, 0x80, 0x60,
  0x80, 0x60, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80, 0x08, 0x80, 0x0C,
  0x80, 0x04, 0x80, 0x06, 0x80, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x07, 0xFC,
  0x0E, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x32, 0x00, 0x0B, 0x00, 0x07, 0x80,
  0x03, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x06, 0x30,
  0x07, 0x0E, 0x0F, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x60,
  0x02, 0x60, 0x06, 0x30, 0x0C, 0x1C, 0x38, 0x0F, 0xF0, 0xC0, 0x00, 0xF0,
  0x00, 0x34, 0x00, 0x09, 0x80, 0x06, 0x60, 0x01, 0x88, 0x00, 0x43, 0x00,
  0x30, 0xC0, 0x0C, 0x10, 0x02, 0x06, 0x00, 0x81, 0x80, 0x60, 0x20, 0x18,
  0x0C, 0x04, 0x03, 0x03, 0x00, 0x40, 0xC0, 0x10, 0x20, 0x06, 0x18, 0x01,
  0x86, 0x00, 0x21, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x48, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x40, 0x30, 0x1C,
  0x07, 0x03, 0x81, 0xE0, 0x50, 0x3C, 0x0A, 0x06, 0x81, 0x40, 0x90, 0x6C,
  0x12, 0x0D, 0x82, 0x41, 0x30, 0xCC, 0x22, 0x19, 0x84, 0x43, 0x31, 0x88,
  0x42, 0x31, 0x88, 0x46, 0x31, 0x08, 0x82, 0x21, 0x10, 0x4C, 0x36, 0x09,
  0x86, 0xC1, 0xB0, 0xD8, 0x34, 0x0A, 0x02, 0x81, 0x40, 0x50, 0x28, 0x0A,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x18, 0x07, 0x01, 0x00, 0x40, 0xE0, 0x00,
  0xC4, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x20, 0x18, 0x0C,
  0x01, 0x03, 0x00, 0x30, 0x60, 0x03, 0x18, 0x00, 0x22, 0x00, 0x06, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x6C, 0x00, 0x09, 0x80,
  0x03, 0x18, 0x00, 0xC1, 0x00, 0x18, 0x30, 0x06, 0x03, 0x00, 0x80, 0x60,
  0x30, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x00, 0xD8, 0x00, 0x0C,
  0xE0, 0x00, 0x6C, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC1, 0x80, 0x18,
  0x10, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x30, 0x06, 0x06, 0x00, 0x41, 0x80,
  0x0C, 0x20, 0x00, 0x8C, 0x00, 0x19, 0x00, 0x01, 0x60, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F,
  0xFF, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0x06, 0x00,
  0x38, 0x03, 0xC0, 0x12, 0x01, 0x98, 0x0C, 0x40, 0x43, 0x06, 0x18, 0x20,
  0x43, 0x03, 0x18, 0x08, 0x80, 0x6C, 0x03, 0x40, 0x0C, 0xFF, 0xFF, 0xC3,
  0x08, 0x61, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x30, 0x0C, 0x60, 0x06, 0x60,
  0x02, 0x40, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xFF, 0x1C,
  0x03, 0x70, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x60, 0x0B, 0x30, 0x73, 0x1F, 0xE3, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x87, 0xC1,
  0x3F, 0xE2, 0xC0, 0x67, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xA0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xE0, 0x02, 0xC0, 0x0D, 0x40, 0x32, 0xE0, 0xC4, 0x7F, 0x00,
  0x03, 0xE0, 0x0F, 0xF8, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x02, 0x40, 0x03,
  0x40, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x60, 0x03, 0x20, 0x02, 0x30, 0x06,
  0x1C, 0x1C, 0x07, 0xF0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x07, 0xC2, 0x3F, 0xE4, 0xE0,
  0x69, 0x80, 0x76, 0x00, 0x68, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x50, 0x00, 0xB0,
  0x01, 0x60, 0x06, 0x60, 0x1C, 0x70, 0xE8, 0x7F, 0x10, 0x03, 0xE0, 0x0F,
  0xF8, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x02, 0x38, 0x03, 0x1C, 0x0C, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xC1, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0xC2, 0x3F,
  0xE4, 0xE0, 0x69, 0x80, 0x76, 0x00, 0x68, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x50,
  0x00, 0xB0, 0x01, 0x60, 0x06, 0x60, 0x1C, 0x70, 0xE8, 0x7F, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x60, 0x0C, 0x60, 0x30, 0x7F, 0xC0,
  0x1E, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x83, 0xE1, 0x1F, 0xF2, 0x60, 0x65, 0x00,
  0x6C, 0x00, 0x58, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x01, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0x00, 0x20, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x0C, 0x01, 0xCF, 0xF8, 0xFE, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0xE0, 0xC1, 0xC0, 0xC3, 0x00,
  0xC6, 0x00, 0xCC, 0x00, 0xDE, 0x00, 0xF7, 0x00, 0xE3, 0x00, 0xC1, 0x80,
  0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0E,
  0xC0, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0x9F, 0x0F,
  0x17, 0xF3, 0xFB, 0x02, 0x83, 0x60, 0x60, 0x28, 0x0C, 0x07, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01,
  0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03,
  0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x83, 0xE1,
  0x1F, 0xF2, 0x60, 0x65, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x18,
  0x00, 0x66, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x26, 0x00, 0x18, 0x80, 0x06,
  0x30, 0x03, 0x06, 0x01, 0x80, 0xE0, 0xC0, 0x1F, 0xE0, 0x87, 0xC1, 0x3F,
  0xE2, 0xC0, 0xE7, 0x00, 0x6C, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x06, 0xC0, 0x0D, 0xC0, 0x32, 0xE0, 0xC4, 0x7F, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xC2, 0x3F, 0xE4, 0xE0, 0x69, 0x80, 0x76, 0x00, 0x68,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x50, 0x00, 0xB0, 0x01, 0x60, 0x06, 0x60, 0x1C,
  0x70, 0xE8, 0x7F, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x81, 0xF8, 0xFF, 0x98, 0x0B,
  0x00, 0xA0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x07, 0xC0, 0x7F, 0xF1, 0x80, 0x72, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0xC0, 0x19, 0xC0,
  0xF0, 0xFF, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x0E, 0xC0, 0x3C, 0xC1, 0xD8, 0xFE, 0x30, 0xC0, 0x00, 0xF0, 0x00, 0x36,
  0x00, 0x09, 0x80, 0x06, 0x20, 0x01, 0x0C, 0x00, 0xC1, 0x00, 0x30, 0x60,
  0x18, 0x18, 0x06, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0x10, 0x20, 0x06, 0x18,
  0x00, 0x86, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x01, 0x20, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x20, 0x1C, 0x06, 0x03, 0x40, 0x60, 0x34,
  0x07, 0x03, 0x60, 0x50, 0x26, 0x0D, 0x02, 0x20, 0x90, 0x62, 0x09, 0x86,
  0x30, 0x98, 0x43, 0x18, 0x84, 0x11, 0x08, 0x41, 0x10, 0xCC, 0x11, 0x04,
  0x81, 0xB0, 0x48, 0x1A, 0x04, 0x80, 0xA0, 0x78, 0x0A, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0x40, 0x30, 0xC0, 0x01, 0xB0, 0x01, 0x98, 0x01,
  0x86, 0x01, 0x81, 0x80, 0xC0, 0x60, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x03,
  0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x68, 0x00, 0x66, 0x00, 0x31, 0x80,
  0x30, 0x60, 0x30, 0x18, 0x30, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xD8, 0x00,
  0x30, 0xC0, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x04, 0x30,
  0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x00,
  0x40, 0x30, 0x06, 0x06, 0x00, 0x20, 0x60, 0x03, 0x04, 0x00, 0x10, 0xC0,
  0x01, 0x88, 0x00, 0x19, 0x80, 0x00, 0xD0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x07, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x07,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x0E, 0x00, 0x70, 0x1C, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x00, 0x80, 0x00, 0x1F, 0x00, 0x13, 0xB8, 0x01, 0x60,
  0xE0, 0x34, 0x07, 0x02, 0xC0, 0x1C, 0xEC, 0x00, 0xF8,
};

const GFXglyph RobotoMono_ExtraLight37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 2, 26, 22, 10, -26 },
  { 8, 6, 8, 22, 8, -28 },
  { 14, 20, 26, 22, 1, -26 },
  { 79, 16, 34, 22, 3, -30 },
  { 147, 20, 27, 22, 1, -27 },
  { 215, 18, 27, 22, 3, -27 },
  { 276, 1, 8, 22, 10, -28 },
  { 277, 8, 37, 22, 7, -29 },
  { 314, 9, 37, 22, 6, -29 },
  { 356, 16, 15, 22, 4, -26 },
  { 386, 18, 19, 22, 2, -22 },
  { 429, 3, 8, 22, 7, -3 },
  { 432, 14, 2, 22, 4, -13 },
  { 436, 3, 3, 22, 10, -3 },
  { 438, 13, 28, 22, 5, -26 },
  { 484, 16, 27, 22, 3, -27 },
  { 538, 9, 26, 22, 4, -26 },
  { 568, 17, 27, 22, 2, -27 },
  { 626, 16, 27, 22, 2, -27 },
  { 680, 18, 26, 22, 2, -26 },
  { 739, 16, 26, 22, 4, -26 },
  { 791, 16, 27, 22, 3, -27 },
  { 845, 17, 26, 22, 2, -26 },
  { 901, 17, 27, 22, 3, -27 },
  { 959, 16, 27, 22, 3, -27 },
  { 1013, 3, 19, 22, 11, -19 },
  { 1021, 4, 24, 22, 10, -19 },
  { 1033, 16, 15, 22, 3, -19 },
  { 1063, 16, 8, 22, 3, -16 },
  { 1079, 16, 16, 22, 3, -20 },
  { 1111, 14, 27, 22, 4, -27 },
  { 1159, 20, 27, 22, 1, -27 },
  { 1227, 19, 26, 22, 2, -26 },
  { 1289, 16, 26, 22, 4, -26 },
  { 1341, 18, 27, 22, 2, -27 },
  { 1402, 17, 26, 22, 3, -26 },
  { 1458, 15, 26, 22, 4, -26 },
  { 1507, 15, 26, 22, 4, -26 },
  { 1556, 18, 27, 22, 2, -27 },
  { 1617, 16, 26, 22, 3, -26 },
  { 1669, 15, 26, 22, 4, -26 },
  { 1718, 16, 26, 22, 2, -26 },
  { 1770, 17, 26, 22, 4, -26 },
  { 1826, 15, 26, 22, 4, -26 },
  { 1875, 16, 26, 22, 3, -26 },
  { 1927, 16, 26, 22, 3, -26 },
  { 1979, 18, 27, 22, 2, -27 },
  { 2040, 16, 26, 22, 4, -26 },
  { 2092, 18, 32, 22, 2, -27 },
  { 2164, 16, 26, 22, 4, -26 },
  { 2216, 17, 27, 22, 3, -27 },
  { 2274, 18, 26, 22, 2, -26 },
  { 2333, 16, 26, 22, 3, -26 },
  { 2385, 18, 26, 22, 2, -26 },
  { 2444, 19, 26, 22, 2, -26 },
  { 2506, 19, 26, 22, 2, -26 },
  { 2568, 19, 26, 22, 1, -26 },
  { 2630, 17, 26, 22, 2, -26 },
  { 2686, 6, 36, 22, 8, -30 },
  { 2713, 12, 28, 22, 5, -26 },
  { 2755, 6, 36, 22, 8, -30 },
  { 2782, 13, 14, 22, 5, -26 },
  { 2805, 16, 1, 22, 3, 0 },
  { 2807, 5, 5, 22, 9, -27 },
  { 2811, 16, 20, 22, 3, -20 },
  { 2851, 15, 28, 22, 4, -28 },
  { 2904, 16, 20, 22, 3, -20 },
  { 2944, 15, 28, 22, 3, -28 },
  { 2997, 16, 20, 22, 3, -20 },
  { 3037, 16, 28, 22, 4, -28 },
  { 3093, 15, 28, 22, 3, -20 },
  { 3146, 15, 28, 22, 4, -28 },
  { 3199, 16, 27, 22, 4, -27 },
  { 3253, 12, 35, 22, 3, -27 },
  { 3306, 16, 28, 22, 4, -28 },
  { 3362, 16, 28, 22, 4, -28 },
  { 3418, 19, 20, 22, 2, -20 },
  { 3466, 15, 20, 22, 4, -20 },
  { 3504, 18, 20, 22, 2, -20 },
  { 3549, 15, 28, 22, 4, -20 },
  { 3602, 15, 28, 22, 3, -20 },
  { 3655, 12, 20, 22, 7, -20 },
  { 3685, 15, 20, 22, 4, -20 },
  { 3723, 16, 25, 22, 3, -25 },
  { 3773, 15, 20, 22, 4, -20 },
  { 3811, 18, 20, 22, 2, -20 },
  { 3856, 20, 20, 22, 1, -20 },
  { 3906, 17, 20, 22, 3, -20 },
  { 3949, 20, 28, 22, 1, -20 },
  { 4019, 17, 20, 22, 3, -20 },
  { 4062, 12, 37, 22, 6, -29 },
  { 4118, 2, 31, 22, 10, -26 },
  { 4126, 12, 37, 22, 6, -29 },
  { 4182, 20, 6, 22, 1, -14 },
};

const GFXfont RobotoMono_ExtraLight37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight37pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_EXTRALIGHT37PT7B_H_
