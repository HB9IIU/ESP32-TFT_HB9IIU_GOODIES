#ifndef _ROBOTOMONO_EXTRALIGHT47PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight47pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x00, 0x00,
  0x1F, 0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83,
  0x00, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0x01, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x02,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x60, 0x30, 0x0F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x20,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0x80, 0x3C, 0x0F, 0x03, 0x80, 0x18, 0x38, 0x00, 0x61,
  0x80, 0x03, 0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x6C, 0x00, 0x07,
  0x60, 0x00, 0x33, 0x80, 0x01, 0x8E, 0x00, 0x18, 0x38, 0x03, 0xC0, 0xF8,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x10, 0x30, 0x18, 0x06,
  0x0C, 0x02, 0x03, 0x03, 0x00, 0x80, 0x80, 0xC0, 0x20, 0x60, 0x30, 0x18,
  0x30, 0x0C, 0x06, 0x0C, 0x01, 0x01, 0x86, 0x00, 0x60, 0xC1, 0x80, 0x0E,
  0x70, 0xC0, 0x01, 0xF8, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x30,
  0x7F, 0x00, 0x0C, 0x30, 0x60, 0x06, 0x08, 0x08, 0x01, 0x86, 0x03, 0x00,
  0xC1, 0x80, 0xC0, 0x30, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xC1, 0x80, 0x60, 0x30, 0x20, 0x18, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x07,
  0x30, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0C, 0x70, 0x00, 0x18, 0x30, 0x06, 0x38, 0x18, 0x06, 0x30,
  0x0C, 0x06, 0x60, 0x0E, 0x06, 0x60, 0x07, 0x0C, 0x60, 0x03, 0x0C, 0xC0,
  0x01, 0x8C, 0xC0, 0x00, 0xD8, 0x60, 0x00, 0xF8, 0x60, 0x00, 0x70, 0x60,
  0x00, 0x70, 0x30, 0x00, 0xF8, 0x1C, 0x01, 0x8C, 0x0F, 0x9F, 0x0E, 0x07,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x38, 0x02, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x05, 0xC0, 0xC0, 0xFF,
  0x86, 0x3F, 0x0F, 0xB7, 0xC0, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xF0,
  0x00, 0x0C, 0xC0, 0x00, 0xC7, 0x00, 0x0C, 0x1C, 0x00, 0xE0, 0x70, 0x0E,
  0x01, 0x80, 0xE0, 0x06, 0x02, 0x00, 0x20, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x33, 0x33, 0x33, 0x36, 0x6C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x03,
  0x81, 0xE0, 0x30, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x31, 0x80, 0x01,
  0x8C, 0x00, 0x0E, 0xC0, 0x00, 0x36, 0x00, 0x03, 0xB0, 0x00, 0x3D, 0x80,
  0x03, 0xEC, 0x00, 0x3B, 0x60, 0x03, 0x1F, 0x00, 0x30, 0xF8, 0x03, 0x03,
  0xC0, 0x30, 0x1E, 0x03, 0x00, 0xF0, 0x30, 0x07, 0x83, 0x00, 0x3C, 0x30,
  0x01, 0xE3, 0x00, 0x0F, 0x30, 0x00, 0xDB, 0x00, 0x06, 0xF0, 0x00, 0x37,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00,
  0x70, 0xE0, 0x07, 0x03, 0x80, 0x70, 0x0F, 0x8F, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x70, 0x1F, 0x0F, 0xB3, 0xE3, 0xF0, 0x3C, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0x70, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x86, 0x00, 0x07, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x33, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xC0, 0xF0, 0x38, 0x01, 0xC3, 0x80,
  0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x03, 0x98, 0x00, 0x18, 0xE0, 0x01, 0x83, 0x80, 0x1C,
  0x0F, 0x8F, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x23, 0xFC, 0x06, 0xFF, 0xF0, 0x78, 0x07, 0x87, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x06, 0xE0, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1C,
  0x1E, 0x07, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x07,
  0xF0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC1, 0xF8, 0x0C, 0x7F, 0xE0, 0xCE, 0x07, 0x8F, 0x80, 0x1C,
  0xF0, 0x00, 0xCE, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00, 0x0C, 0x38,
  0x01, 0xC1, 0xC0, 0x38, 0x0F, 0x8F, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xC0, 0xF0,
  0x38, 0x01, 0x83, 0x80, 0x06, 0x18, 0x00, 0x39, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x63,
  0x00, 0x07, 0x1C, 0x00, 0x30, 0x70, 0x03, 0x01, 0xE0, 0x70, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0x80, 0xF0, 0x70, 0x01, 0xC3, 0x00, 0x07, 0x30,
  0x00, 0x1B, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x18, 0xC0,
  0x01, 0xC3, 0x80, 0x1C, 0x0F, 0xCF, 0xC0, 0x1F, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0xE0, 0x1E, 0x07, 0x03, 0x80, 0x38, 0x30, 0x01, 0xC6, 0x00,
  0x0C, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0xF3, 0x80, 0x1B,
  0x1C, 0x07, 0x30, 0xFF, 0xE3, 0x03, 0xF8, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x70, 0x7B,
  0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63,
  0x18, 0xC6, 0x63, 0x19, 0x8C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0, 0x0E, 0x70, 0x01, 0x98, 0x00, 0x36,
  0x00, 0x0F, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x60, 0x1C, 0x06, 0x10, 0x1F, 0xC1, 0x8C, 0x0C, 0x38, 0x22,
  0x06, 0x06, 0x09, 0x81, 0x01, 0x83, 0x60, 0xC0, 0x40, 0xD8, 0x20, 0x10,
  0x34, 0x18, 0x04, 0x0D, 0x06, 0x01, 0x03, 0xC1, 0x80, 0x40, 0xF0, 0x60,
  0x30, 0x3C, 0x10, 0x0C, 0x0F, 0x04, 0x03, 0x03, 0xC1, 0x00, 0xC0, 0xB0,
  0x60, 0x70, 0x2C, 0x18, 0x1C, 0x19, 0x06, 0x0F, 0x04, 0x60, 0x82, 0xC3,
  0x18, 0x3B, 0x99, 0x86, 0x07, 0xC3, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x03,
  0xF1, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x09, 0x80, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x63,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0xFF, 0xF8, 0x0C, 0x07, 0xE0, 0xC0, 0x07,
  0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0,
  0x01, 0xCC, 0x00, 0x38, 0xC0, 0x0F, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0C,
  0x00, 0x38, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x03, 0x8F, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x70, 0x3C,
  0x03, 0x00, 0x38, 0x18, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x00, 0x01, 0x9C,
  0x00, 0x06, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x36, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18,
  0x60, 0x00, 0xC1, 0xC0, 0x06, 0x03, 0x80, 0x38, 0x07, 0xC7, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0x01, 0xF8, 0x0C, 0x00, 0x70, 0x30, 0x00,
  0x70, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x38, 0xC0, 0x01, 0xC3, 0x00, 0x0E,
  0x0C, 0x00, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFC, 0xFF,
  0xFF, 0x98, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x98, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x70, 0x3C, 0x03, 0x80, 0x38, 0x18, 0x00,
  0x70, 0xE0, 0x00, 0xE3, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x31, 0xC0, 0x01,
  0xC3, 0x80, 0x1E, 0x03, 0xC3, 0xE0, 0x07, 0xFE, 0x00, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xE0, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x76, 0x00,
  0x06, 0x60, 0x00, 0xE3, 0x00, 0x1C, 0x3C, 0x03, 0x80, 0xF1, 0xF0, 0x07,
  0xFC, 0x00, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0x70, 0xC0, 0x03, 0x83, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x30, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x00, 0xC1,
  0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0x33, 0xE0, 0x00, 0xDD, 0x80,
  0x03, 0xE3, 0x00, 0x0F, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xC0, 0x07, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xBD, 0x80, 0x0D, 0xEC, 0x00, 0x6F,
  0x60, 0x06, 0x79, 0x80, 0x33, 0xCC, 0x03, 0x1E, 0x60, 0x18, 0xF1, 0x80,
  0xC7, 0x8C, 0x0C, 0x3C, 0x30, 0x61, 0xE1, 0x86, 0x0F, 0x0C, 0x30, 0x78,
  0x31, 0x83, 0xC1, 0x98, 0x1E, 0x0C, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x30, 0x0F, 0x01, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xD8, 0x00, 0x3D,
  0x80, 0x03, 0xCC, 0x00, 0x3C, 0xC0, 0x03, 0xC6, 0x00, 0x3C, 0x60, 0x03,
  0xC3, 0x00, 0x3C, 0x38, 0x03, 0xC1, 0x80, 0x3C, 0x0C, 0x03, 0xC0, 0xC0,
  0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x03, 0x03, 0xC0, 0x30, 0x3C, 0x01,
  0x83, 0xC0, 0x1C, 0x3C, 0x00, 0xC3, 0xC0, 0x06, 0x3C, 0x00, 0x63, 0xC0,
  0x03, 0x3C, 0x00, 0x33, 0xC0, 0x01, 0xBC, 0x00, 0x1B, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x70, 0x38, 0x03, 0x80, 0x30, 0x18, 0x00, 0x60,
  0xE0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0x60, 0x01, 0xC1, 0xC0, 0x0E, 0x03,
  0x80, 0x70, 0x07, 0xCF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFE, 0x06, 0x00,
  0x7C, 0x30, 0x00, 0x71, 0x80, 0x01, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x01, 0xD8,
  0x00, 0x1C, 0xC0, 0x03, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1C, 0x0F, 0x00, 0x60, 0x07, 0x01, 0x80,
  0x07, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x73, 0x00, 0x00, 0xC3, 0x00, 0x03, 0x87, 0x00,
  0x06, 0x07, 0x00, 0x18, 0x07, 0x00, 0xE0, 0x07, 0xCF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFC, 0x06, 0x01, 0xF8, 0x30,
  0x00, 0xE1, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x73, 0x00, 0x03, 0x18, 0x00, 0x30,
  0xC0, 0x07, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0x80, 0x30, 0x0C, 0x00,
  0xC0, 0x60, 0x07, 0x03, 0x00, 0x18, 0x18, 0x00, 0xE0, 0xC0, 0x03, 0x06,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00,
  0x33, 0x00, 0x01, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x38, 0x00, 0x7E, 0x00,
  0x0F, 0xFE, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x80, 0x03, 0x87, 0x80,
  0x1C, 0x07, 0xE7, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x70, 0x00, 0xE3, 0x80,
  0x1C, 0x1C, 0x03, 0x80, 0xF9, 0xF0, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x1C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xD0, 0x07, 0x00, 0x6C, 0x03, 0x80,
  0x26, 0x01, 0x40, 0x33, 0x00, 0xB0, 0x19, 0x80, 0xD8, 0x0C, 0xC0, 0x6C,
  0x06, 0x60, 0x36, 0x03, 0x10, 0x19, 0x01, 0x0C, 0x08, 0xC0, 0x86, 0x0C,
  0x60, 0xC3, 0x06, 0x30, 0x61, 0x83, 0x18, 0x30, 0xC1, 0x84, 0x18, 0x60,
  0x83, 0x0C, 0x10, 0xC1, 0x84, 0x0C, 0x60, 0xC2, 0x06, 0x30, 0x63, 0x03,
  0x18, 0x31, 0x81, 0x88, 0x0C, 0xC0, 0xCC, 0x06, 0x60, 0x26, 0x03, 0x30,
  0x1B, 0x01, 0x90, 0x0D, 0x80, 0xD8, 0x06, 0x80, 0x2C, 0x03, 0x40, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x38, 0xC0, 0x00, 0x61, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x01, 0x80,
  0x0C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x60, 0x03, 0x01, 0x80, 0x07, 0x07,
  0x00, 0x06, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x30, 0x60, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0xC0, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x30,
  0x01, 0x80, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x86, 0x00, 0x03, 0x1C, 0x00,
  0x07, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0x60, 0x00,
  0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x18, 0x00,
  0x38, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01, 0x83,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x07, 0xFF, 0xE0, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0x87, 0x0C, 0x18, 0x30,
  0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1C, 0x01, 0xC3, 0x00, 0x0C, 0x70,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xC0, 0x03,
  0x70, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0xF6, 0x00, 0x1B, 0x70, 0x07, 0x33, 0xE3,
  0xE3, 0x0F, 0xF8, 0x30, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x0F, 0xE0, 0x67, 0xFF, 0x0D, 0xC0, 0x71, 0xE0,
  0x07, 0x38, 0x00, 0x77, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0D, 0x80, 0x01, 0xB8, 0x00, 0x77, 0x80, 0x0C, 0xD8, 0x07, 0x19, 0xE7,
  0xC3, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x1C, 0x03, 0xC1,
  0x80, 0x0C, 0x30, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x63, 0x80, 0x0E, 0x1C,
  0x01, 0xC0, 0xF8, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x0F, 0xE1, 0x87, 0xFF, 0x31,
  0xC0, 0x36, 0x70, 0x03, 0xCC, 0x00, 0x3B, 0x00, 0x03, 0x60, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x39, 0xC0, 0x07, 0x1C,
  0x03, 0xE1, 0xF3, 0xEC, 0x0F, 0xF1, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0x80, 0xF0, 0x30, 0x01, 0x83, 0x00, 0x06, 0x30, 0x00, 0x39, 0x80,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x02, 0x0C, 0x00, 0x38, 0x78, 0x03, 0x80, 0xF0, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0xF8, 0x61, 0xFF, 0xCC, 0x70, 0x0D, 0x9C,
  0x00, 0xF3, 0x00, 0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0D, 0x80,
  0x01, 0xB0, 0x00, 0x33, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0xF8, 0x7C,
  0xFB, 0x03, 0xFC, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x40, 0x01, 0x98, 0x00, 0x31, 0xC0, 0x0C, 0x1C, 0x07, 0x01, 0xFF,
  0xC0, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x07, 0xF0, 0x63, 0xFF, 0x8C, 0xC0, 0x39, 0xB0,
  0x03, 0xBC, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xE3,
  0xFF, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x03,
  0x8C, 0x00, 0x70, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x70, 0x0C, 0x0E,
  0x00, 0xC1, 0xC0, 0x0C, 0x38, 0x00, 0xC7, 0x00, 0x0C, 0xF0, 0x00, 0xDD,
  0x80, 0x0F, 0x1C, 0x00, 0xE0, 0xE0, 0x0C, 0x07, 0x00, 0xC0, 0x38, 0x0C,
  0x01, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x38,
  0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x70, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xCF, 0xE1, 0xFC, 0xDF, 0xF3, 0xFE, 0xF0, 0x36, 0x06, 0xE0, 0x1C, 0x03,
  0xE0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC1, 0xFC, 0x18, 0xFF, 0xE3, 0x30, 0x0E, 0x6C, 0x00,
  0xEF, 0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0x38, 0x38, 0x00, 0x70, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x38, 0x00,
  0x30, 0x70, 0x01, 0x80, 0xE0, 0x1C, 0x01, 0xF1, 0xE0, 0x01, 0xFF, 0x00,
  0xC3, 0xF8, 0x19, 0xFF, 0xC3, 0x60, 0x1C, 0x78, 0x01, 0xCE, 0x00, 0x1D,
  0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0x6E,
  0x00, 0x1D, 0xE0, 0x07, 0x3E, 0x01, 0xC6, 0x78, 0xF0, 0xC7, 0xFC, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x61, 0xFF, 0xCC, 0x70, 0x0D, 0x9C, 0x00, 0xF3, 0x00, 0x0E,
  0xC0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x33,
  0x00, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0xF8, 0x7C, 0xFB, 0x07, 0xFC, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0xC1, 0xFF, 0xC7, 0xFF, 0xCE, 0x00, 0xD8, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xE0, 0x0E, 0x38, 0x00, 0x66,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00, 0x71, 0xF8, 0xFC, 0x0F,
  0xFE, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xC6, 0x00, 0x3F, 0xF0, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x76, 0x00, 0x1E, 0xC0, 0x06,
  0xCC, 0x01, 0x98, 0xF3, 0xE3, 0x0F, 0xF8, 0x60, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x19, 0x80, 0x00, 0x73, 0x00, 0x00, 0xC7, 0x00, 0x01, 0x86, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x18, 0x01,
  0xC0, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x01, 0xE0,
  0x0C, 0x00, 0xF0, 0x07, 0x00, 0x58, 0x03, 0x80, 0x64, 0x03, 0x40, 0x33,
  0x01, 0xA0, 0x19, 0x80, 0xD8, 0x0C, 0xC0, 0x4C, 0x0C, 0x60, 0x66, 0x06,
  0x18, 0x31, 0x03, 0x0C, 0x18, 0xC1, 0x86, 0x08, 0x60, 0x83, 0x0C, 0x30,
  0xC0, 0x86, 0x08, 0x60, 0x63, 0x06, 0x30, 0x31, 0x03, 0x18, 0x19, 0x81,
  0x98, 0x04, 0xC0, 0x4C, 0x03, 0x60, 0x36, 0x01, 0xA0, 0x1B, 0x00, 0xF0,
  0x0D, 0x00, 0x78, 0x02, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xE0, 0x00, 0xC0,
  0xE0, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x60, 0x01,
  0xC1, 0x80, 0x01, 0xC7, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x63,
  0x00, 0x01, 0x87, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x06, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x0C,
  0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06,
  0x70, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x1C, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xE3, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x76, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x3E, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x3E, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x33,
  0x87, 0x80, 0x09, 0x80, 0x70, 0x06, 0x60, 0x0E, 0x01, 0x90, 0x01, 0xE0,
  0xC4, 0x00, 0x1F, 0xE2, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_ExtraLight47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 3, 33, 28, 12, -33 },
  { 14, 8, 10, 28, 10, -35 },
  { 24, 26, 33, 28, 1, -33 },
  { 132, 21, 43, 28, 4, -38 },
  { 245, 26, 34, 28, 1, -34 },
  { 356, 24, 34, 28, 3, -34 },
  { 458, 2, 10, 28, 12, -35 },
  { 461, 11, 48, 28, 9, -37 },
  { 527, 11, 48, 28, 8, -37 },
  { 593, 21, 19, 28, 4, -33 },
  { 643, 23, 25, 28, 3, -28 },
  { 715, 4, 10, 28, 9, -4 },
  { 720, 16, 2, 28, 6, -16 },
  { 724, 4, 3, 28, 13, -3 },
  { 726, 16, 36, 28, 7, -33 },
  { 798, 21, 34, 28, 4, -34 },
  { 888, 12, 33, 28, 5, -33 },
  { 938, 22, 34, 28, 2, -34 },
  { 1032, 21, 34, 28, 2, -34 },
  { 1122, 24, 33, 28, 2, -33 },
  { 1221, 20, 33, 28, 5, -33 },
  { 1304, 20, 34, 28, 4, -34 },
  { 1389, 22, 33, 28, 3, -33 },
  { 1480, 21, 34, 28, 4, -34 },
  { 1570, 20, 34, 28, 4, -34 },
  { 1655, 4, 23, 28, 14, -23 },
  { 1667, 5, 29, 28, 13, -23 },
  { 1686, 20, 19, 28, 4, -25 },
  { 1734, 20, 11, 28, 4, -21 },
  { 1762, 20, 19, 28, 4, -25 },
  { 1810, 18, 34, 28, 5, -34 },
  { 1887, 26, 34, 28, 1, -34 },
  { 1998, 23, 33, 28, 3, -33 },
  { 2093, 20, 33, 28, 5, -33 },
  { 2176, 22, 34, 28, 3, -34 },
  { 2270, 22, 33, 28, 4, -33 },
  { 2361, 19, 33, 28, 5, -33 },
  { 2440, 19, 33, 28, 5, -33 },
  { 2519, 22, 34, 28, 3, -34 },
  { 2613, 20, 33, 28, 4, -33 },
  { 2696, 19, 33, 28, 5, -33 },
  { 2775, 20, 33, 28, 3, -33 },
  { 2858, 22, 33, 28, 5, -33 },
  { 2949, 20, 33, 28, 5, -33 },
  { 3032, 21, 33, 28, 4, -33 },
  { 3119, 20, 33, 28, 4, -33 },
  { 3202, 22, 34, 28, 3, -34 },
  { 3296, 21, 33, 28, 5, -33 },
  { 3383, 23, 40, 28, 3, -34 },
  { 3498, 21, 33, 28, 5, -33 },
  { 3585, 22, 34, 28, 3, -34 },
  { 3679, 24, 33, 28, 2, -33 },
  { 3778, 20, 33, 28, 4, -33 },
  { 3861, 24, 33, 28, 2, -33 },
  { 3960, 25, 33, 28, 2, -33 },
  { 4064, 23, 33, 28, 3, -33 },
  { 4159, 24, 33, 28, 2, -33 },
  { 4258, 21, 33, 28, 3, -33 },
  { 4345, 7, 45, 28, 11, -38 },
  { 4385, 16, 36, 28, 6, -33 },
  { 4457, 8, 45, 28, 10, -38 },
  { 4502, 16, 18, 28, 6, -33 },
  { 4538, 20, 2, 28, 4, 0 },
  { 4543, 6, 7, 28, 11, -35 },
  { 4549, 20, 25, 28, 4, -25 },
  { 4612, 19, 35, 28, 5, -35 },
  { 4696, 20, 25, 28, 4, -25 },
  { 4759, 19, 35, 28, 4, -35 },
  { 4843, 21, 25, 28, 4, -25 },
  { 4909, 22, 36, 28, 4, -36 },
  { 5008, 19, 35, 28, 4, -25 },
  { 5092, 19, 35, 28, 5, -35 },
  { 5176, 20, 34, 28, 5, -34 },
  { 5261, 15, 44, 28, 4, -34 },
  { 5344, 20, 35, 28, 5, -35 },
  { 5432, 20, 35, 28, 5, -35 },
  { 5520, 24, 25, 28, 2, -25 },
  { 5595, 19, 25, 28, 5, -25 },
  { 5655, 22, 25, 28, 3, -25 },
  { 5724, 19, 35, 28, 5, -25 },
  { 5808, 19, 35, 28, 4, -25 },
  { 5892, 16, 25, 28, 9, -25 },
  { 5942, 19, 25, 28, 5, -25 },
  { 6002, 20, 31, 28, 4, -31 },
  { 6080, 19, 25, 28, 5, -25 },
  { 6140, 23, 25, 28, 3, -25 },
  { 6212, 25, 25, 28, 2, -25 },
  { 6291, 23, 25, 28, 3, -25 },
  { 6363, 24, 35, 28, 2, -25 },
  { 6468, 22, 25, 28, 3, -25 },
  { 6537, 15, 47, 28, 8, -37 },
  { 6626, 2, 40, 28, 13, -33 },
  { 6636, 15, 47, 28, 8, -37 },
  { 6725, 26, 8, 28, 1, -18 },
};

const GFXfont RobotoMono_ExtraLight47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight47pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_EXTRALIGHT47PT7B_H_
