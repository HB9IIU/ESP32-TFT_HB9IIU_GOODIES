#ifndef _ROBOTOMONO_EXTRALIGHT20PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight20pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA0, 0x30, 0x99, 0x99, 0x08, 0x81, 0x10, 0x44, 0x08,
  0x8F, 0xFE, 0x22, 0x04, 0x40, 0x88, 0x22, 0x1F, 0xF8, 0x88, 0x11, 0x02,
  0x20, 0x88, 0x00, 0x08, 0x04, 0x0D, 0x88, 0x28, 0x14, 0x0A, 0x00, 0x80,
  0x38, 0x03, 0x00, 0x40, 0x28, 0x0C, 0x09, 0x04, 0x7C, 0x08, 0x04, 0x00,
  0x78, 0x08, 0x88, 0x88, 0x88, 0x90, 0x49, 0x07, 0x20, 0x02, 0x00, 0x40,
  0x05, 0xE0, 0x92, 0x09, 0x11, 0x11, 0x11, 0x20, 0x0E, 0x1E, 0x04, 0x40,
  0x88, 0x11, 0x02, 0x40, 0x30, 0x04, 0x01, 0x40, 0x44, 0x48, 0x4A, 0x05,
  0x20, 0xC4, 0x18, 0x7C, 0xC0, 0xF0, 0x12, 0x24, 0x48, 0x88, 0x88, 0x88,
  0x88, 0x84, 0x44, 0x21, 0x10, 0x82, 0x08, 0x21, 0x08, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x22, 0x11, 0x08, 0x88, 0x00, 0x08, 0x04, 0x22, 0x2F, 0xE0,
  0x80, 0xA0, 0x88, 0x86, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x56, 0x80, 0xFF, 0x80, 0x06, 0x08,
  0x10, 0x40, 0x81, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x00,
  0x7E, 0x42, 0x81, 0x81, 0x83, 0x85, 0x89, 0x91, 0xA1, 0xC1, 0x81, 0x81,
  0x42, 0x3C, 0x1B, 0x62, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3E,
  0x20, 0xA0, 0x50, 0x20, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x07, 0xFC, 0x3E, 0x20, 0xA0, 0x30, 0x10, 0x10, 0x08, 0x78, 0x06,
  0x01, 0x00, 0x60, 0x30, 0x14, 0x11, 0xF0, 0x03, 0x01, 0x40, 0x50, 0x24,
  0x11, 0x04, 0x42, 0x11, 0x04, 0x41, 0x3F, 0xF0, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x03, 0xE1, 0x0C, 0x02, 0x01, 0x00,
  0x60, 0x50, 0x24, 0x31, 0xF0, 0x0E, 0x08, 0x08, 0x08, 0x04, 0x03, 0xF9,
  0x04, 0x81, 0x80, 0xC0, 0x50, 0x28, 0x12, 0x10, 0xF0, 0xFF, 0xC0, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x0C, 0x00, 0x7E, 0x20, 0xA0, 0x50, 0x28, 0x12, 0x08, 0xF8, 0x84,
  0x81, 0x40, 0x60, 0x30, 0x1C, 0x11, 0xF0, 0x7E, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x83, 0x7D, 0x01, 0x01, 0x02, 0x04, 0x78, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x49, 0x28, 0x01, 0x03, 0x1C, 0x60, 0x80, 0x60, 0x18,
  0x07, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x38, 0x06, 0x01,
  0x06, 0x38, 0xC0, 0x80, 0x3E, 0x41, 0x81, 0x01, 0x01, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x00, 0x00, 0x00, 0x18, 0x1F, 0x08, 0x24, 0x46, 0x29, 0x92,
  0x64, 0x9A, 0x26, 0x89, 0xA2, 0x68, 0x99, 0xDA, 0x00, 0x40, 0x0F, 0xC0,
  0x0C, 0x03, 0x00, 0xA0, 0x48, 0x12, 0x04, 0x42, 0x10, 0x84, 0x21, 0x0F,
  0xE4, 0x09, 0x02, 0x40, 0x60, 0x10, 0xFE, 0x40, 0xA0, 0x50, 0x28, 0x14,
  0x13, 0xF1, 0x06, 0x81, 0x40, 0x60, 0x30, 0x18, 0x17, 0xF0, 0x3F, 0x08,
  0x24, 0x09, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x05,
  0x02, 0x20, 0x87, 0xC0, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x27, 0xE0, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x3F, 0x18, 0x24, 0x0A, 0x01, 0x80, 0x20, 0x08, 0x02, 0x1F, 0x80, 0x60,
  0x14, 0x05, 0x01, 0x20, 0xC7, 0xC0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x14,
  0x11, 0xF0, 0x81, 0xA0, 0xC8, 0x22, 0x10, 0x88, 0x24, 0x0B, 0x03, 0x60,
  0x88, 0x21, 0x08, 0x22, 0x04, 0x81, 0x20, 0x30, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x81, 0xC0,
  0xF0, 0xB8, 0x5A, 0x4D, 0x26, 0x93, 0x31, 0x98, 0xC8, 0x60, 0x30, 0x18,
  0x0C, 0x04, 0x81, 0x81, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85,
  0x83, 0x83, 0x81, 0x81, 0x3F, 0x08, 0x44, 0x09, 0x02, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x14, 0x09, 0x02, 0x21, 0x07, 0x80, 0xFE, 0x40,
  0xA0, 0x30, 0x18, 0x0C, 0x06, 0x05, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x00, 0x3F, 0x10, 0x24, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x05, 0x02, 0x21, 0x87, 0x80, 0x10, 0x02, 0x00, 0x40,
  0xFE, 0x40, 0xA0, 0x50, 0x18, 0x14, 0x0A, 0x09, 0xF8, 0x84, 0x41, 0x20,
  0x90, 0x28, 0x14, 0x04, 0x3F, 0x10, 0x24, 0x05, 0x01, 0x40, 0x08, 0x01,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x05, 0x01, 0x40, 0x8F, 0xC0, 0xFF, 0xC1,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x80, 0x60, 0x24, 0x09, 0x02, 0x40,
  0x88, 0x42, 0x10, 0x84, 0x12, 0x04, 0x81, 0x20, 0x30, 0x0C, 0x03, 0x00,
  0x84, 0x63, 0x18, 0xC6, 0x31, 0x8A, 0x52, 0x95, 0x25, 0x4A, 0x52, 0x94,
  0x65, 0x18, 0x86, 0x21, 0x88, 0x40, 0xC0, 0x50, 0x22, 0x10, 0x44, 0x12,
  0x03, 0x00, 0x40, 0x30, 0x0A, 0x04, 0x82, 0x10, 0x82, 0x40, 0xA0, 0x10,
  0x80, 0x50, 0x24, 0x08, 0x84, 0x22, 0x04, 0x81, 0x40, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x7F, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x07, 0xFC, 0xF2, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x93, 0x80, 0x82, 0x04, 0x10, 0x40, 0x82, 0x04,
  0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x27, 0x80, 0x18, 0x18, 0x24, 0x24, 0x24, 0x42, 0x42, 0x81, 0xFF, 0xA4,
  0x3C, 0x42, 0x81, 0x01, 0x01, 0x3F, 0xC1, 0x81, 0x81, 0x83, 0x7D, 0x80,
  0x80, 0x80, 0x80, 0x9C, 0xE2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC2, 0xBC, 0x3C, 0x42, 0x81, 0x81, 0x80, 0x80, 0x80, 0x80, 0x81, 0x41,
  0x3E, 0x01, 0x01, 0x01, 0x01, 0x39, 0x47, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x3D, 0x1C, 0x62, 0x81, 0x81, 0x81, 0xFF, 0x80, 0x80,
  0x80, 0x41, 0x3E, 0x0F, 0x88, 0x04, 0x02, 0x0F, 0xF0, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x39, 0x47, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x82, 0x7C, 0x80,
  0x80, 0x80, 0x80, 0x9C, 0xA2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x08, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x0C, 0x00, 0x1F, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0B, 0xC0, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x14, 0x12, 0x11, 0x10, 0x90, 0x58, 0x32, 0x10, 0x88, 0x64, 0x12,
  0x06, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0xB3, 0xB3, 0x18, 0x46, 0x21, 0x88,
  0x62, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x84, 0x9C, 0xA2, 0xC1, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x08, 0x44, 0x09, 0x02,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x98, 0x61, 0xE0, 0xBC, 0xC2, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x39, 0x47, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01,
  0x01, 0x01, 0x01, 0x9F, 0xC2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x00, 0x3C, 0x43, 0x81, 0x80, 0x40, 0x3C, 0x03, 0x01, 0x81, 0x81, 0x7E,
  0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x0F, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x7D,
  0x80, 0x60, 0x24, 0x09, 0x02, 0x21, 0x08, 0x41, 0x20, 0x48, 0x14, 0x03,
  0x00, 0xC0, 0x84, 0x63, 0x18, 0xC6, 0x31, 0x8A, 0x54, 0xA5, 0x29, 0x4A,
  0x51, 0x88, 0x42, 0x10, 0x40, 0x50, 0x22, 0x10, 0x48, 0x0C, 0x01, 0x00,
  0xC0, 0x48, 0x21, 0x08, 0x2C, 0x0C, 0x80, 0x60, 0x14, 0x09, 0x02, 0x21,
  0x08, 0x41, 0x20, 0x48, 0x0A, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x0E,
  0x00, 0x7F, 0x80, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x0F, 0xFC, 0x02, 0x18, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x43,
  0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x30, 0xFF, 0xFF, 0x80,
  0x80, 0xC0, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x18, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x86, 0x00, 0x60, 0x26, 0x18, 0x46, 0x0E,
};

const GFXglyph RobotoMono_ExtraLight20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 14, 12, 5, -14 },
  { 5, 4, 4, 12, 4, -15 },
  { 7, 11, 14, 12, 1, -14 },
  { 27, 9, 18, 12, 2, -16 },
  { 48, 12, 14, 12, 0, -14 },
  { 69, 11, 14, 12, 1, -14 },
  { 89, 1, 4, 12, 5, -15 },
  { 90, 4, 21, 12, 4, -16 },
  { 101, 5, 21, 12, 3, -16 },
  { 115, 9, 8, 12, 2, -14 },
  { 124, 10, 11, 12, 1, -12 },
  { 138, 2, 5, 12, 4, -2 },
  { 140, 8, 1, 12, 2, -7 },
  { 141, 1, 1, 12, 6, -1 },
  { 142, 7, 15, 12, 3, -14 },
  { 156, 8, 14, 12, 2, -14 },
  { 170, 5, 14, 12, 2, -14 },
  { 179, 9, 14, 12, 1, -14 },
  { 195, 9, 14, 12, 1, -14 },
  { 211, 10, 14, 12, 1, -14 },
  { 229, 9, 14, 12, 2, -14 },
  { 245, 9, 14, 12, 1, -14 },
  { 261, 10, 14, 12, 1, -14 },
  { 279, 9, 14, 12, 2, -14 },
  { 295, 8, 14, 12, 2, -14 },
  { 309, 2, 10, 12, 6, -10 },
  { 312, 3, 13, 12, 5, -10 },
  { 317, 8, 9, 12, 2, -11 },
  { 326, 8, 5, 12, 2, -9 },
  { 331, 8, 9, 12, 2, -11 },
  { 340, 8, 14, 12, 2, -14 },
  { 354, 10, 14, 12, 1, -14 },
  { 372, 10, 14, 12, 1, -14 },
  { 390, 9, 14, 12, 2, -14 },
  { 406, 10, 14, 12, 1, -14 },
  { 424, 9, 14, 12, 2, -14 },
  { 440, 8, 14, 12, 2, -14 },
  { 454, 8, 14, 12, 2, -14 },
  { 468, 10, 14, 12, 1, -14 },
  { 486, 8, 14, 12, 2, -14 },
  { 500, 8, 14, 12, 2, -14 },
  { 514, 9, 14, 12, 1, -14 },
  { 530, 10, 14, 12, 2, -14 },
  { 548, 8, 14, 12, 2, -14 },
  { 562, 9, 14, 12, 2, -14 },
  { 578, 8, 14, 12, 2, -14 },
  { 592, 10, 14, 12, 1, -14 },
  { 610, 9, 14, 12, 2, -14 },
  { 626, 10, 17, 12, 1, -14 },
  { 648, 9, 14, 12, 2, -14 },
  { 664, 10, 14, 12, 1, -14 },
  { 682, 10, 14, 12, 1, -14 },
  { 700, 8, 14, 12, 2, -14 },
  { 714, 10, 14, 12, 1, -14 },
  { 732, 10, 14, 12, 1, -14 },
  { 750, 10, 14, 12, 1, -14 },
  { 768, 10, 14, 12, 1, -14 },
  { 786, 9, 14, 12, 1, -14 },
  { 802, 3, 19, 12, 5, -16 },
  { 810, 6, 15, 12, 3, -14 },
  { 822, 3, 19, 12, 4, -16 },
  { 830, 8, 8, 12, 2, -14 },
  { 838, 8, 1, 12, 2, 0 },
  { 839, 2, 3, 12, 5, -15 },
  { 840, 8, 11, 12, 2, -11 },
  { 851, 8, 15, 12, 2, -15 },
  { 866, 8, 11, 12, 2, -11 },
  { 877, 8, 15, 12, 2, -15 },
  { 892, 8, 11, 12, 2, -11 },
  { 903, 9, 15, 12, 2, -15 },
  { 920, 8, 15, 12, 2, -11 },
  { 935, 8, 15, 12, 2, -15 },
  { 950, 9, 14, 12, 2, -14 },
  { 966, 6, 18, 12, 2, -14 },
  { 980, 9, 15, 12, 2, -15 },
  { 997, 9, 15, 12, 2, -15 },
  { 1014, 10, 11, 12, 1, -11 },
  { 1028, 8, 11, 12, 2, -11 },
  { 1039, 10, 11, 12, 1, -11 },
  { 1053, 8, 15, 12, 2, -11 },
  { 1068, 8, 15, 12, 2, -11 },
  { 1083, 7, 11, 12, 4, -11 },
  { 1093, 8, 11, 12, 2, -11 },
  { 1104, 8, 13, 12, 2, -13 },
  { 1117, 8, 11, 12, 2, -11 },
  { 1128, 10, 11, 12, 1, -11 },
  { 1142, 10, 11, 12, 1, -11 },
  { 1156, 10, 11, 12, 1, -11 },
  { 1170, 10, 15, 12, 1, -11 },
  { 1189, 10, 11, 12, 1, -11 },
  { 1203, 7, 20, 12, 3, -16 },
  { 1221, 1, 17, 12, 6, -14 },
  { 1224, 7, 20, 12, 3, -16 },
  { 1242, 10, 4, 12, 1, -8 },
};

const GFXfont RobotoMono_ExtraLight20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight20pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_EXTRALIGHT20PT7B_H_
