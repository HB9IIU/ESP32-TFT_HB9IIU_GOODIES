#ifndef _ROBOTOMONO_EXTRALIGHT36PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight36pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00, 0x00, 0xFC, 0x46,
  0x8D, 0x1A, 0x34, 0x68, 0xD1, 0xE3, 0x00, 0x81, 0x80, 0x08, 0x18, 0x00,
  0x81, 0x00, 0x08, 0x10, 0x01, 0x81, 0x00, 0x18, 0x30, 0x01, 0x03, 0x00,
  0x10, 0x20, 0x7F, 0xFF, 0xF0, 0x30, 0x20, 0x03, 0x02, 0x00, 0x20, 0x60,
  0x02, 0x06, 0x00, 0x20, 0x40, 0x06, 0x04, 0x00, 0x60, 0x40, 0x04, 0x0C,
  0x00, 0x40, 0xC0, 0xFF, 0xFF, 0xC0, 0x40, 0x80, 0x0C, 0x08, 0x00, 0xC0,
  0x80, 0x08, 0x18, 0x00, 0x81, 0x80, 0x08, 0x10, 0x01, 0x81, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x03, 0xE0, 0x0F, 0x78, 0x18, 0x0C, 0x30,
  0x06, 0x60, 0x06, 0x60, 0x02, 0x60, 0x03, 0x60, 0x03, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40,
  0x03, 0x60, 0x02, 0x30, 0x06, 0x1C, 0x1C, 0x0F, 0xF0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x3C, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x00,
  0x08, 0x10, 0x30, 0x81, 0x02, 0x08, 0x10, 0x60, 0x81, 0x04, 0x08, 0x10,
  0xC0, 0x81, 0x08, 0x0C, 0x31, 0x80, 0x7E, 0x10, 0x01, 0x82, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x7C, 0x01, 0x8C, 0x60,
  0x10, 0x82, 0x03, 0x18, 0x30, 0x21, 0x03, 0x06, 0x10, 0x30, 0x41, 0x03,
  0x08, 0x18, 0x30, 0x00, 0x82, 0x00, 0x0C, 0x60, 0x00, 0x7C, 0x07, 0x80,
  0x03, 0xB8, 0x01, 0x82, 0x00, 0xC0, 0xC0, 0x30, 0x10, 0x08, 0x04, 0x03,
  0x03, 0x00, 0xC0, 0x80, 0x10, 0x60, 0x06, 0x30, 0x00, 0xB0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x06, 0xC0, 0x03, 0x10, 0x01, 0x86, 0x06, 0xC0, 0xC1,
  0xB0, 0x18, 0x68, 0x03, 0x12, 0x00, 0x6C, 0x80, 0x1B, 0x20, 0x03, 0x8C,
  0x00, 0xE1, 0x80, 0x6C, 0x30, 0x31, 0x87, 0xF8, 0x30, 0xFF, 0xFF, 0x01,
  0x03, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0xC0,
  0x40, 0x40, 0x60, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x04, 0x06, 0x03,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02,
  0x03, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03,
  0x03, 0x03, 0x02, 0x02, 0x06, 0x04, 0x04, 0x08, 0x08, 0x10, 0x30, 0x60,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x40,
  0x83, 0xF8, 0x9F, 0x0F, 0xF8, 0x01, 0xC0, 0x01, 0xC0, 0x02, 0x60, 0x06,
  0x30, 0x0C, 0x18, 0x18, 0x0C, 0x10, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x24, 0x96, 0xF4, 0xFF, 0xF8, 0x5F, 0x80, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x07, 0xE0, 0x1E, 0xF0, 0x30, 0x18, 0x20, 0x0C, 0x60, 0x06, 0x40,
  0x06, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x0F, 0x80, 0x1B, 0x80, 0x33, 0x80,
  0x63, 0x80, 0xC3, 0x81, 0x83, 0x83, 0x03, 0x84, 0x03, 0xC8, 0x03, 0xD0,
  0x03, 0xE0, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x60, 0x06, 0x60, 0x04, 0x30,
  0x0C, 0x18, 0x38, 0x0F, 0xE0, 0x00, 0x81, 0xC3, 0xEF, 0x3C, 0x1C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x07,
  0xC0, 0x1E, 0xF0, 0x30, 0x18, 0x60, 0x0C, 0x40, 0x04, 0xC0, 0x06, 0xC0,
  0x06, 0x80, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0x07, 0xE0, 0x1E, 0xF8, 0x30, 0x1C, 0x60, 0x04, 0x40,
  0x06, 0xC0, 0x06, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x02, 0x40,
  0x06, 0x60, 0x0C, 0x38, 0x18, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x80, 0x04,
  0x20, 0x03, 0x08, 0x00, 0x82, 0x00, 0x40, 0x80, 0x30, 0x20, 0x08, 0x08,
  0x04, 0x02, 0x03, 0x00, 0x81, 0x80, 0x20, 0x40, 0x08, 0x30, 0x02, 0x0F,
  0xFF, 0xFC, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x3F, 0x83, 0xC7, 0x86, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x98,
  0x03, 0x38, 0x0C, 0x3C, 0x78, 0x1F, 0xC0, 0x00, 0x70, 0x07, 0xE0, 0x18,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x87, 0x83, 0x3F, 0xC5, 0x80, 0xCE, 0x00, 0xD8, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x68, 0x00,
  0xD8, 0x03, 0x18, 0x06, 0x1C, 0x38, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x78, 0x38, 0x0C, 0x30, 0x06,
  0x60, 0x02, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x02, 0x60, 0x06,
  0x30, 0x06, 0x18, 0x1C, 0x0F, 0xF0, 0x0F, 0xF8, 0x38, 0x0C, 0x60, 0x06,
  0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x60, 0x03, 0x70, 0x06, 0x18, 0x1C, 0x0F, 0xF0, 0x07, 0xC0, 0x1E, 0xF0,
  0x30, 0x18, 0x60, 0x0C, 0x60, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x60, 0x07,
  0x60, 0x0A, 0x30, 0x3A, 0x1F, 0xE2, 0x07, 0x82, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x1F, 0x80,
  0x5F, 0x80, 0x00, 0x00, 0x00, 0x02, 0xFC, 0x27, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x66, 0x66, 0x4C, 0x80, 0x00, 0x02, 0x00, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x80,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x0F, 0xC0, 0x7F, 0xC3, 0x03, 0x18, 0x06, 0xC0, 0x0B, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xF0, 0x06, 0x01, 0x80, 0xC0, 0x0C, 0x18, 0x00, 0x43, 0x00,
  0x06, 0x20, 0xF8, 0x26, 0x18, 0x42, 0x43, 0x04, 0x24, 0x20, 0x42, 0xC2,
  0x04, 0x38, 0x60, 0x43, 0x86, 0x0C, 0x38, 0x40, 0xC2, 0x84, 0x08, 0x28,
  0x40, 0x82, 0x84, 0x08, 0x28, 0x41, 0x86, 0xC6, 0x3C, 0x44, 0x36, 0x6C,
  0x41, 0xC3, 0x86, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x06,
  0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0x20, 0x00, 0x48, 0x00, 0x33, 0x00, 0x0C, 0x40, 0x02, 0x10, 0x01,
  0x86, 0x00, 0x60, 0x80, 0x10, 0x20, 0x0C, 0x0C, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x18, 0x18, 0x02, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xC0, 0x0C,
  0x20, 0x01, 0x18, 0x00, 0x66, 0x00, 0x19, 0x00, 0x02, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0xFE, 0x01, 0xFF, 0xC2, 0x00, 0xC4, 0x00, 0xC8, 0x00, 0xD0,
  0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x64, 0x01,
  0x8F, 0xFC, 0x1F, 0xFE, 0x20, 0x06, 0x40, 0x06, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x40, 0x0E, 0x80,
  0xF9, 0xFF, 0xC0, 0x03, 0xF0, 0x07, 0x9E, 0x06, 0x01, 0x82, 0x00, 0x63,
  0x00, 0x33, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x01, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x2C, 0x00, 0x36, 0x00, 0x19,
  0x00, 0x08, 0xC0, 0x0C, 0x30, 0x0C, 0x0C, 0x1C, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x30, 0x0E, 0x18, 0x03, 0x8C, 0x00, 0x46, 0x00, 0x33,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0x60,
  0x00, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x26, 0x00, 0x33, 0x00, 0x31,
  0x80, 0x30, 0xC1, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFD, 0xFF, 0xFA, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x06, 0x01, 0x86, 0x00, 0x63, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x06,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x50,
  0x00, 0x2C, 0x00, 0x16, 0x00, 0x09, 0x00, 0x04, 0xC0, 0x02, 0x30, 0x03,
  0x0E, 0x07, 0x01, 0xFE, 0x00, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x02, 0x40, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x18, 0x38, 0x0F, 0xF0, 0x80,
  0x03, 0x40, 0x03, 0x20, 0x03, 0x10, 0x03, 0x08, 0x03, 0x04, 0x03, 0x02,
  0x01, 0x81, 0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x21, 0x80, 0x11, 0x80,
  0x09, 0xC0, 0x05, 0xB0, 0x03, 0x8C, 0x01, 0x83, 0x00, 0x80, 0x80, 0x40,
  0x60, 0x20, 0x18, 0x10, 0x06, 0x08, 0x01, 0x04, 0x00, 0xC2, 0x00, 0x31,
  0x00, 0x0C, 0x80, 0x03, 0x40, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xD0, 0x0B, 0xD0, 0x1B, 0xD8, 0x1B,
  0xC8, 0x13, 0xCC, 0x33, 0xCC, 0x23, 0xC4, 0x63, 0xC6, 0x63, 0xC2, 0x43,
  0xC2, 0xC3, 0xC3, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xD0, 0x03,
  0xD8, 0x03, 0xC8, 0x03, 0xCC, 0x03, 0xC6, 0x03, 0xC2, 0x03, 0xC3, 0x03,
  0xC1, 0x03, 0xC1, 0x83, 0xC0, 0x83, 0xC0, 0xC3, 0xC0, 0x43, 0xC0, 0x63,
  0xC0, 0x33, 0xC0, 0x13, 0xC0, 0x1B, 0xC0, 0x0B, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0x03, 0xE0, 0x07, 0xFC, 0x06, 0x03, 0x02, 0x00,
  0xC3, 0x00, 0x33, 0x00, 0x09, 0x80, 0x04, 0x80, 0x03, 0x40, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x11, 0x00, 0x18, 0xC0, 0x08, 0x30, 0x0C, 0x0E, 0x1C, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x02,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x38, 0xFF, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFE, 0x01, 0x80, 0xE0, 0xC0,
  0x08, 0x20, 0x03, 0x18, 0x00, 0x64, 0x00, 0x19, 0x00, 0x02, 0xC0, 0x00,
  0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x09, 0x00,
  0x02, 0x60, 0x01, 0x98, 0x00, 0x43, 0x00, 0x30, 0x60, 0x18, 0x0E, 0x1C,
  0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0xFF, 0x00, 0xFF, 0xE0, 0x80, 0x38, 0x80, 0x18, 0x80, 0x0C,
  0x80, 0x04, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x04,
  0x80, 0x0C, 0x80, 0x18, 0x80, 0x70, 0xFF, 0xC0, 0x80, 0xC0, 0x80, 0x60,
  0x80, 0x60, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80, 0x08, 0x80, 0x0C,
  0x80, 0x04, 0x80, 0x06, 0x80, 0x03, 0x07, 0xE0, 0x1F, 0xF8, 0x30, 0x0C,
  0x60, 0x06, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0x60, 0x03, 0x70, 0x06, 0x3C, 0x1C, 0x0F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x04, 0x30, 0x0C, 0x1C, 0x38, 0x0F,
  0xE0, 0x80, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x19, 0x00, 0x06, 0x60, 0x01,
  0x18, 0x00, 0x42, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x02, 0x04, 0x01, 0x81,
  0x80, 0x60, 0x60, 0x10, 0x08, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x80, 0x10,
  0x60, 0x04, 0x18, 0x01, 0x84, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x03, 0x20,
  0x00, 0x58, 0x00, 0x16, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0x60, 0x60, 0x2C, 0x0E, 0x05,
  0x83, 0xC0, 0xB0, 0x68, 0x32, 0x09, 0x06, 0x41, 0x20, 0x88, 0x26, 0x11,
  0x84, 0xC2, 0x31, 0x88, 0x46, 0x31, 0x18, 0x44, 0x23, 0x08, 0x86, 0x61,
  0x10, 0xC8, 0x26, 0x09, 0x06, 0xC1, 0x20, 0xD0, 0x24, 0x1A, 0x07, 0x81,
  0x40, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0xC0, 0x00, 0xD8, 0x00, 0x62, 0x00, 0x18, 0xC0, 0x0C, 0x18,
  0x02, 0x02, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x20, 0x06, 0x18, 0x00, 0xCC,
  0x00, 0x13, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0x04, 0xC0, 0x03, 0x10, 0x01, 0x86, 0x00, 0x40, 0x80, 0x30, 0x30, 0x18,
  0x06, 0x06, 0x00, 0x83, 0x00, 0x30, 0x80, 0x06, 0x60, 0x01, 0xB0, 0x00,
  0x30, 0xC0, 0x00, 0x6C, 0x00, 0x18, 0x80, 0x03, 0x18, 0x00, 0xC1, 0x00,
  0x10, 0x30, 0x06, 0x02, 0x00, 0x80, 0x60, 0x30, 0x04, 0x04, 0x00, 0xC1,
  0x80, 0x08, 0x20, 0x01, 0x8C, 0x00, 0x11, 0x00, 0x03, 0x60, 0x00, 0x28,
  0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xF0, 0x80, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x03, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F,
  0xC0, 0x02, 0x00, 0x18, 0x01, 0xC0, 0x0B, 0x00, 0x48, 0x06, 0x60, 0x23,
  0x03, 0x08, 0x10, 0x61, 0x81, 0x0C, 0x0C, 0x40, 0x66, 0x01, 0x60, 0x0C,
  0xFF, 0xFE, 0xE1, 0x04, 0x30, 0x0F, 0xF0, 0x38, 0x18, 0x20, 0x0C, 0x60,
  0x06, 0x40, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x03, 0xFE, 0x1F,
  0x82, 0x30, 0x02, 0x60, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0,
  0x0E, 0x60, 0x1A, 0x70, 0x72, 0x1F, 0xC3, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x8F, 0xE1,
  0x70, 0xE2, 0x80, 0x66, 0x00, 0x4C, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x50, 0x00,
  0xA0, 0x03, 0x60, 0x04, 0xE0, 0x19, 0x70, 0xE2, 0x3F, 0x80, 0x0F, 0xF0,
  0x38, 0x30, 0xC0, 0x33, 0x00, 0x36, 0x00, 0x68, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x58, 0x00, 0xB0, 0x03, 0x30, 0x0C, 0x38, 0x30, 0x3F, 0xC0, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x0F, 0xE6, 0x30, 0x6C, 0xC0, 0x3B, 0x00, 0x74, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xD0, 0x01, 0xB0, 0x03, 0x30, 0x0E, 0x30, 0x6C, 0x3F,
  0x98, 0x07, 0xF0, 0x1C, 0x18, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x02, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x02, 0x30, 0x06, 0x1C,
  0x1C, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0xFF, 0xFE, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0xE6, 0x30, 0x6C, 0xC0, 0x3B, 0x00, 0x74, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xD0, 0x01, 0xB0, 0x03, 0x30, 0x0E, 0x30, 0x6C, 0x3F,
  0x98, 0x00, 0x30, 0x00, 0x60, 0x00, 0x90, 0x03, 0x30, 0x06, 0x30, 0x38,
  0x3F, 0xE0, 0x06, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x8F, 0xE2, 0x60, 0xEB, 0x01, 0xB8,
  0x03, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x01, 0xFF, 0xFC, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30,
  0x0C, 0xFF, 0x0F, 0x80, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x0F, 0x80, 0x33, 0x00,
  0xC6, 0x03, 0x0C, 0x1C, 0x18, 0x60, 0x31, 0x80, 0x66, 0x00, 0xDC, 0x01,
  0xEC, 0x03, 0x8C, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x18, 0x60,
  0x18, 0xC0, 0x19, 0x80, 0x1B, 0x00, 0x18, 0xFF, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xFF, 0xF8, 0xBF, 0x1F,
  0xB8, 0x6C, 0x6C, 0x0C, 0x0E, 0x03, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x04, 0x8F, 0xE2, 0x60, 0xEB, 0x01, 0xB8, 0x03,
  0xC0, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x07, 0xF8, 0x06, 0x0E, 0x06, 0x01, 0x86, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x0D, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x14, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0C, 0x60,
  0x06, 0x18, 0x06, 0x06, 0x0E, 0x01, 0xFE, 0x00, 0x8F, 0xE1, 0x70, 0xE3,
  0x80, 0x66, 0x00, 0x48, 0x00, 0xD0, 0x01, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x50, 0x01, 0xA0, 0x03,
  0x60, 0x04, 0xE0, 0x19, 0x60, 0xE2, 0x3F, 0x84, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x0F, 0xE6, 0x30,
  0x6C, 0xC0, 0x3B, 0x00, 0x74, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xD0,
  0x01, 0xB0, 0x03, 0x30, 0x0E, 0x30, 0x6C, 0x3F, 0x98, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x87, 0xF9,
  0xC0, 0xB0, 0x0A, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x00, 0x0F, 0xF0, 0x18, 0x1C, 0x30, 0x06, 0x60, 0x02, 0x60,
  0x03, 0x60, 0x00, 0x20, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x03, 0x40, 0x02, 0x60,
  0x06, 0x38, 0x1C, 0x0F, 0xF8, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x1F, 0xFF, 0x80, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x7F, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x15, 0xC1, 0x91, 0xFC, 0x40,
  0xC0, 0x00, 0xD0, 0x00, 0x66, 0x00, 0x11, 0x80, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0x81, 0x00, 0x60, 0x60, 0x10, 0x08, 0x0C, 0x03, 0x02, 0x00, 0xC1,
  0x80, 0x10, 0x60, 0x06, 0x10, 0x00, 0x8C, 0x00, 0x32, 0x00, 0x05, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xC0, 0x60, 0x34, 0x06, 0x02,
  0x40, 0x60, 0x24, 0x0E, 0x06, 0x60, 0xB0, 0x66, 0x09, 0x04, 0x20, 0x90,
  0x42, 0x19, 0x04, 0x31, 0x18, 0xC3, 0x10, 0x8C, 0x11, 0x08, 0x81, 0x30,
  0x88, 0x12, 0x0D, 0x81, 0xA0, 0x58, 0x1A, 0x05, 0x00, 0xE0, 0x50, 0x0C,
  0x07, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x60, 0x01, 0x8C, 0x00, 0xC1,
  0x80, 0x60, 0x20, 0x10, 0x0C, 0x0C, 0x01, 0x86, 0x00, 0x33, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x0C, 0xC0, 0x02, 0x10,
  0x01, 0x86, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x4E,
  0x00, 0x1C, 0xC0, 0x00, 0x6C, 0x00, 0x08, 0x80, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x18, 0x30, 0x03, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x02, 0x00,
  0xC0, 0xC0, 0x18, 0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x02, 0x30, 0x00,
  0x66, 0x00, 0x04, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x30, 0x1C, 0x03, 0xC0, 0x0C,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x38, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x0E, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x07, 0x81, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x18, 0x06, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x05,
  0x83, 0x00, 0xA0, 0x30, 0x3C, 0x03, 0x8D, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoMono_ExtraLight36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 3, 26, 22, 9, -26 },
  { 11, 7, 8, 22, 7, -27 },
  { 18, 20, 26, 22, 1, -26 },
  { 83, 16, 33, 22, 3, -29 },
  { 149, 20, 26, 22, 1, -26 },
  { 214, 18, 26, 22, 3, -26 },
  { 273, 2, 8, 22, 9, -27 },
  { 275, 8, 37, 22, 7, -29 },
  { 312, 8, 37, 22, 6, -29 },
  { 349, 16, 15, 22, 3, -26 },
  { 379, 18, 18, 22, 2, -21 },
  { 420, 3, 8, 22, 7, -3 },
  { 423, 13, 1, 22, 4, -12 },
  { 425, 3, 3, 22, 10, -3 },
  { 427, 12, 28, 22, 5, -26 },
  { 469, 16, 26, 22, 3, -26 },
  { 521, 9, 26, 22, 4, -26 },
  { 551, 16, 26, 22, 2, -26 },
  { 603, 16, 26, 22, 2, -26 },
  { 655, 18, 26, 22, 2, -26 },
  { 714, 15, 26, 22, 4, -26 },
  { 763, 15, 26, 22, 3, -26 },
  { 812, 17, 26, 22, 2, -26 },
  { 868, 16, 26, 22, 3, -26 },
  { 920, 16, 26, 22, 3, -26 },
  { 972, 3, 18, 22, 11, -18 },
  { 979, 4, 23, 22, 10, -18 },
  { 991, 15, 15, 22, 3, -19 },
  { 1020, 16, 9, 22, 3, -16 },
  { 1038, 16, 15, 22, 3, -19 },
  { 1068, 14, 26, 22, 4, -26 },
  { 1114, 20, 26, 22, 1, -26 },
  { 1179, 18, 26, 22, 2, -26 },
  { 1238, 15, 26, 22, 4, -26 },
  { 1287, 17, 26, 22, 2, -26 },
  { 1343, 17, 26, 22, 3, -26 },
  { 1399, 15, 26, 22, 4, -26 },
  { 1448, 15, 26, 22, 4, -26 },
  { 1497, 17, 26, 22, 2, -26 },
  { 1553, 16, 26, 22, 3, -26 },
  { 1605, 14, 26, 22, 4, -26 },
  { 1651, 16, 26, 22, 2, -26 },
  { 1703, 17, 26, 22, 4, -26 },
  { 1759, 15, 26, 22, 4, -26 },
  { 1808, 16, 26, 22, 3, -26 },
  { 1860, 16, 26, 22, 3, -26 },
  { 1912, 17, 26, 22, 2, -26 },
  { 1968, 16, 26, 22, 4, -26 },
  { 2020, 18, 31, 22, 2, -26 },
  { 2090, 16, 26, 22, 4, -26 },
  { 2142, 16, 26, 22, 3, -26 },
  { 2194, 18, 26, 22, 2, -26 },
  { 2253, 16, 26, 22, 3, -26 },
  { 2305, 18, 26, 22, 2, -26 },
  { 2364, 19, 26, 22, 2, -26 },
  { 2426, 18, 26, 22, 2, -26 },
  { 2485, 19, 26, 22, 1, -26 },
  { 2547, 16, 26, 22, 2, -26 },
  { 2599, 6, 34, 22, 8, -29 },
  { 2625, 12, 28, 22, 5, -26 },
  { 2667, 5, 34, 22, 8, -29 },
  { 2689, 13, 14, 22, 4, -26 },
  { 2712, 15, 1, 22, 3, 0 },
  { 2714, 5, 4, 22, 8, -26 },
  { 2717, 16, 19, 22, 3, -19 },
  { 2755, 15, 27, 22, 4, -27 },
  { 2806, 15, 19, 22, 3, -19 },
  { 2842, 15, 27, 22, 3, -27 },
  { 2893, 16, 19, 22, 3, -19 },
  { 2931, 17, 27, 22, 3, -27 },
  { 2989, 15, 27, 22, 3, -19 },
  { 3040, 14, 27, 22, 4, -27 },
  { 3088, 15, 26, 22, 4, -26 },
  { 3137, 11, 34, 22, 3, -26 },
  { 3184, 15, 27, 22, 4, -27 },
  { 3235, 15, 27, 22, 4, -27 },
  { 3286, 18, 19, 22, 2, -19 },
  { 3329, 14, 19, 22, 4, -19 },
  { 3363, 17, 19, 22, 2, -19 },
  { 3404, 15, 26, 22, 4, -19 },
  { 3453, 15, 26, 22, 3, -19 },
  { 3502, 12, 19, 22, 7, -19 },
  { 3531, 16, 19, 22, 3, -19 },
  { 3569, 15, 24, 22, 3, -24 },
  { 3614, 14, 19, 22, 4, -19 },
  { 3648, 18, 19, 22, 2, -19 },
  { 3691, 20, 19, 22, 1, -19 },
  { 3739, 18, 19, 22, 2, -19 },
  { 3782, 19, 27, 22, 1, -19 },
  { 3847, 16, 19, 22, 3, -19 },
  { 3885, 11, 35, 22, 6, -28 },
  { 3934, 2, 31, 22, 10, -26 },
  { 3942, 11, 35, 22, 6, -28 },
  { 3991, 19, 6, 22, 1, -14 },
};

const GFXfont RobotoMono_ExtraLight36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight36pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_EXTRALIGHT36PT7B_H_
