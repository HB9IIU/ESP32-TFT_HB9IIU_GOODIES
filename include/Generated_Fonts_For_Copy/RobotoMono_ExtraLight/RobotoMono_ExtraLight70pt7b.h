#ifndef _ROBOTOMONO_EXTRALIGHT70PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight70pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFB, 0x80, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x01, 0xC0,
  0x0E, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x03, 0x81, 0xC0,
  0x00, 0x70, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x3C, 0x0E, 0x00, 0x00, 0xF0,
  0xF0, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0xFF, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0xFC, 0x00,
  0x00, 0x1C, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x1E, 0x3E, 0x00, 0x00, 0xE0,
  0x78, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x00, 0xE0,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x00,
  0x70, 0x02, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x3C, 0x03, 0xC0, 0x03, 0x8F, 0x00,
  0x3C, 0x00, 0x71, 0xC0, 0x03, 0x80, 0x1C, 0x78, 0x00, 0x38, 0x03, 0x8E,
  0x00, 0x07, 0x80, 0x71, 0xC0, 0x00, 0x78, 0x0E, 0x70, 0x00, 0x07, 0x83,
  0xCE, 0x00, 0x00, 0x70, 0x71, 0xC0, 0x00, 0x07, 0x0E, 0x38, 0x00, 0x00,
  0xF3, 0x87, 0x00, 0x00, 0x0F, 0x70, 0xE0, 0x00, 0x00, 0xFC, 0x0E, 0x00,
  0x00, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x07, 0x9E, 0x07, 0xC0, 0x01, 0xE1,
  0xE0, 0x7F, 0x01, 0xF8, 0x1C, 0x03, 0xFF, 0xFC, 0x01, 0xC0, 0x1F, 0xFE,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x02, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x0C, 0x00, 0x2F, 0x00, 0x30, 0x07, 0xFF, 0x80, 0xC0, 0x7F, 0x7F, 0xC3,
  0x0F, 0xF0, 0x3F, 0xEC, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x70, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x9C, 0x73, 0x8C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x79, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0x7E, 0xE0, 0x00, 0x01,
  0xDD, 0xC0, 0x00, 0x07, 0x3B, 0x80, 0x00, 0x1C, 0x77, 0x00, 0x00, 0xF0,
  0xFE, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x3C, 0x03,
  0xF0, 0x00, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x00, 0x1F,
  0x80, 0x3C, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0xFC,
  0x0F, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x06, 0xE3,
  0x80, 0x00, 0x1D, 0xCE, 0x00, 0x00, 0x3B, 0xB8, 0x00, 0x00, 0x77, 0xE0,
  0x00, 0x00, 0xEF, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x0F,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xB8,
  0x7F, 0x1C, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E,
  0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x71, 0xFF, 0xE0, 0x03,
  0x3F, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0x01, 0xF8, 0x00, 0xFE, 0x0F, 0x80,
  0x01, 0xF8, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x07,
  0x80, 0x01, 0xC0, 0xFF, 0xF0, 0x03, 0x87, 0xFF, 0xF8, 0x07, 0x1F, 0x01,
  0xF8, 0x0E, 0x78, 0x00, 0x78, 0x19, 0xC0, 0x00, 0x78, 0x77, 0x00, 0x00,
  0x78, 0xFC, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7C, 0x70,
  0x00, 0x01, 0xF8, 0xF0, 0x00, 0x07, 0x70, 0xF0, 0x00, 0x1C, 0xE0, 0xF0,
  0x00, 0xF1, 0xC0, 0xF8, 0x07, 0xC3, 0x80, 0xFF, 0xFF, 0x06, 0x00, 0x7F,
  0xF8, 0x1C, 0x00, 0x1F, 0x80, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF,
  0xFF, 0xF7, 0x80, 0x1E, 0x3E, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x83, 0xF0,
  0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x03, 0x03, 0x00, 0x1F, 0xE0, 0x0E,
  0x1C, 0x01, 0xFF, 0xE0, 0x38, 0x60, 0x0F, 0x03, 0x80, 0x63, 0x80, 0x78,
  0x06, 0x01, 0x8C, 0x01, 0xC0, 0x18, 0x06, 0x30, 0x0E, 0x00, 0x60, 0x1D,
  0xC0, 0x30, 0x01, 0x80, 0x77, 0x01, 0xC0, 0x06, 0x01, 0xD8, 0x07, 0x00,
  0x18, 0x03, 0x60, 0x18, 0x00, 0xE0, 0x0F, 0x80, 0xE0, 0x03, 0x80, 0x3E,
  0x03, 0x80, 0x0E, 0x00, 0xF8, 0x0E, 0x00, 0x30, 0x03, 0xE0, 0x30, 0x00,
  0xC0, 0x0F, 0x00, 0xC0, 0x03, 0x00, 0x7C, 0x03, 0x00, 0x0C, 0x01, 0xF0,
  0x0C, 0x00, 0x30, 0x07, 0xC0, 0x30, 0x00, 0xC0, 0x1B, 0x00, 0xC0, 0x07,
  0x00, 0x6C, 0x03, 0x00, 0x1C, 0x01, 0xB8, 0x0C, 0x00, 0xF0, 0x06, 0xE0,
  0x30, 0x03, 0xC0, 0x3B, 0x80, 0xE0, 0x0F, 0x00, 0xCE, 0x03, 0x80, 0x6C,
  0x07, 0x18, 0x06, 0x03, 0xB0, 0x18, 0x60, 0x1C, 0x1C, 0xE0, 0xE1, 0xC0,
  0x3D, 0xE1, 0xC7, 0x07, 0x00, 0xFF, 0x07, 0xF8, 0x0E, 0x00, 0xF8, 0x07,
  0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x20, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x03, 0xF8, 0x0E, 0x00, 0x00, 0xF8, 0x1C,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x3F,
  0x07, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x7C, 0x38, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0xE0, 0x00,
  0x1F, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00,
  0x3E, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x03,
  0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x70, 0x03, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x01, 0xC3, 0xF0, 0x00, 0x00, 0xE3, 0xFC, 0x00, 0x00, 0x73, 0xCE,
  0x00, 0x00, 0x3B, 0xC3, 0x80, 0x00, 0x1D, 0xC1, 0xE0, 0x00, 0x0F, 0xC0,
  0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3B, 0xF7,
  0x00, 0x00, 0x77, 0xEE, 0x00, 0x01, 0xCF, 0xCC, 0x00, 0x03, 0x9F, 0x9C,
  0x00, 0x07, 0x3F, 0x38, 0x00, 0x1C, 0x7E, 0x38, 0x00, 0x38, 0xFC, 0x70,
  0x00, 0xE1, 0xF8, 0xE0, 0x01, 0xC3, 0xF0, 0xE0, 0x03, 0x87, 0xE1, 0xC0,
  0x0E, 0x0F, 0xC1, 0x80, 0x1C, 0x1F, 0x83, 0x80, 0x70, 0x3F, 0x07, 0x00,
  0xE0, 0x7E, 0x07, 0x01, 0xC0, 0xFC, 0x0E, 0x07, 0x01, 0xF8, 0x1C, 0x0E,
  0x03, 0xF0, 0x1C, 0x38, 0x07, 0xE0, 0x38, 0x70, 0x0F, 0xC0, 0x70, 0xE0,
  0x1F, 0x80, 0x73, 0x80, 0x3F, 0x00, 0xE7, 0x00, 0x7E, 0x00, 0xCC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0x80, 0x0F, 0xC0, 0x0E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFB, 0x80, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x1F, 0x9C, 0x00, 0x00, 0x7E,
  0x70, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x1F, 0x87,
  0x00, 0x00, 0x7E, 0x0E, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x07, 0xE0, 0x70,
  0x00, 0x1F, 0x81, 0xC0, 0x00, 0x7E, 0x03, 0x80, 0x01, 0xF8, 0x0E, 0x00,
  0x07, 0xE0, 0x1C, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x7E, 0x00, 0xE0, 0x01,
  0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x7E,
  0x00, 0x38, 0x01, 0xF8, 0x00, 0x70, 0x07, 0xE0, 0x01, 0xC0, 0x1F, 0x80,
  0x03, 0x80, 0x7E, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x1C, 0x07, 0xE0, 0x00,
  0x38, 0x1F, 0x80, 0x00, 0xE0, 0x7E, 0x00, 0x01, 0xC1, 0xF8, 0x00, 0x07,
  0x07, 0xE0, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0x38, 0x7E, 0x00, 0x00, 0x71,
  0xF8, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x03, 0x9F, 0x80, 0x00, 0x07, 0x7E,
  0x00, 0x00, 0x1D, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0xFC, 0x0E, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x83, 0x80,
  0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x01, 0xF8, 0x0E, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3E, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0E,
  0xC0, 0x00, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x80, 0x03, 0xB8, 0x00, 0x7C,
  0x00, 0x19, 0xC0, 0x03, 0xE0, 0x00, 0xCE, 0x00, 0x1F, 0x00, 0x0E, 0x70,
  0x00, 0xDC, 0x00, 0x73, 0x80, 0x06, 0xE0, 0x03, 0x8C, 0x00, 0x77, 0x00,
  0x1C, 0x70, 0x03, 0x98, 0x00, 0xE3, 0x80, 0x1C, 0xC0, 0x06, 0x1C, 0x00,
  0xC7, 0x00, 0x70, 0xE0, 0x06, 0x38, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1C,
  0x18, 0x03, 0x8E, 0x00, 0xE0, 0xC0, 0x1C, 0x30, 0x07, 0x07, 0x00, 0xC1,
  0xC0, 0x30, 0x38, 0x06, 0x0E, 0x01, 0x81, 0xC0, 0x70, 0x70, 0x1C, 0x0E,
  0x03, 0x83, 0x80, 0xE0, 0x70, 0x1C, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x70,
  0x38, 0x0E, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x1C, 0x0C, 0x03, 0x83,
  0x80, 0xE0, 0x60, 0x1C, 0x1C, 0x03, 0x07, 0x00, 0xE0, 0xE0, 0x18, 0x38,
  0x03, 0x06, 0x00, 0xE1, 0xC0, 0x18, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80,
  0x38, 0x60, 0x07, 0x1C, 0x00, 0xC3, 0x00, 0x38, 0xE0, 0x06, 0x18, 0x01,
  0xC6, 0x00, 0x39, 0xC0, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x33, 0x80, 0x0E,
  0x70, 0x01, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x01, 0x98, 0x00, 0x76,
  0x00, 0x0E, 0xC0, 0x03, 0xB0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00,
  0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0x83, 0x80, 0x03, 0x81, 0xC0,
  0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xE0,
  0x0E, 0x0F, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3E, 0x70, 0x00,
  0x03, 0xF9, 0xE0, 0x00, 0x1E, 0xE3, 0xE0, 0x01, 0xF3, 0xC7, 0xE0, 0x3F,
  0x8F, 0x0F, 0xFF, 0xF8, 0x1C, 0x0F, 0xFF, 0x80, 0x70, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xE0,
  0x7F, 0xF0, 0x07, 0x0F, 0xFF, 0xE0, 0x38, 0xF8, 0x1F, 0xC1, 0xCF, 0x00,
  0x1F, 0x0E, 0xE0, 0x00, 0x78, 0x7E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x73,
  0xE0, 0x00, 0x07, 0x9F, 0x80, 0x00, 0x78, 0xEE, 0x00, 0x07, 0x87, 0x78,
  0x00, 0x7C, 0x38, 0xF8, 0x0F, 0xC1, 0xC3, 0xFF, 0xF8, 0x0E, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x3C, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0xF0, 0x38, 0x0F, 0xFF,
  0xE1, 0xC0, 0xF8, 0x0F, 0x8E, 0x0F, 0x00, 0x1E, 0x70, 0xF0, 0x00, 0x3B,
  0x8F, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x3F, 0x0F, 0x00, 0x03, 0xB8, 0x3C, 0x00, 0x3D, 0xC0, 0xF8, 0x0F,
  0x8E, 0x03, 0xFF, 0xF8, 0x70, 0x07, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x07, 0x00, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x38,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x81, 0xC0, 0x7F, 0xFF,
  0x0E, 0x07, 0xC0, 0x7C, 0x70, 0x78, 0x00, 0xF3, 0x87, 0x80, 0x01, 0xDC,
  0x78, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0x1E, 0x00,
  0x01, 0xF8, 0x78, 0x00, 0x1D, 0xC1, 0xE0, 0x01, 0xEE, 0x07, 0xC0, 0x7E,
  0x70, 0x1F, 0xFF, 0xC3, 0x80, 0x3F, 0xF8, 0x1C, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80,
  0x3E, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0xE0, 0x3F, 0xFC, 0x07, 0x03, 0xFF, 0xF8, 0x38, 0x7C, 0x07, 0xE1,
  0xC7, 0x80, 0x0F, 0x8E, 0x70, 0x00, 0x1C, 0x77, 0x00, 0x00, 0x73, 0xB0,
  0x00, 0x03, 0x9F, 0x00, 0x00, 0x0E, 0xF8, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x38, 0x07,
  0x80, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0xE3, 0xF0, 0x00, 0x03, 0x9F, 0xC0, 0x00,
  0x0E, 0xF7, 0x80, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x7C,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x38, 0x0E, 0x3F, 0xF0, 0x1F, 0xF0, 0xE7, 0xFF,
  0x87, 0xFF, 0xCE, 0xF0, 0x7C, 0xF0, 0x3C, 0xFC, 0x01, 0xDC, 0x01, 0xEF,
  0x80, 0x0F, 0x80, 0x0E, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x00,
  0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00,
  0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E,
  0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00,
  0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00,
  0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E,
  0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00,
  0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00,
  0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E,
  0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00,
  0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00,
  0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x7E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x07, 0x01, 0xFF, 0xE0, 0x38,
  0x1F, 0xFF, 0xC1, 0xC3, 0xE0, 0x3F, 0x0E, 0x3C, 0x00, 0x7C, 0x73, 0x80,
  0x00, 0xE3, 0xB8, 0x00, 0x07, 0x9D, 0x80, 0x00, 0x1C, 0xF8, 0x00, 0x00,
  0x77, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x07, 0x03, 0xFF, 0x80, 0x38, 0x7F, 0xFF, 0x01, 0xC7, 0xC0, 0xFC,
  0x0E, 0x78, 0x00, 0xF0, 0x77, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x03, 0xC7, 0xF0, 0x00,
  0x3C, 0x3B, 0xC0, 0x03, 0xC1, 0xCF, 0xC0, 0x7C, 0x0E, 0x1F, 0xFF, 0xC0,
  0x70, 0x3F, 0xF8, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xFF, 0x81, 0xC0, 0x7F, 0xFF, 0x0E, 0x0F, 0xC0, 0x7C, 0x70, 0xF8, 0x00,
  0xF3, 0x87, 0x80, 0x01, 0xDC, 0x78, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x1F,
  0x38, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x1F, 0xC1, 0xE0,
  0x01, 0xEE, 0x07, 0xC0, 0x7E, 0x70, 0x1F, 0xFF, 0xC3, 0x80, 0x3F, 0xF8,
  0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFE, 0x06, 0xE3, 0xE0, 0x00, 0xE7, 0x80, 0x00, 0xEF, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F,
  0x01, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xF8, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xF3, 0x80, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0x71, 0xE0, 0x01,
  0xE7, 0x0F, 0x80, 0x7C, 0x70, 0x7F, 0xFF, 0x87, 0x01, 0xFF, 0xE0, 0x70,
  0x01, 0xD0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1D, 0xC0, 0x00,
  0xE0, 0x00, 0x77, 0x00, 0x07, 0x80, 0x01, 0xDC, 0x00, 0x1E, 0x00, 0x06,
  0x70, 0x00, 0x7C, 0x00, 0x38, 0xC0, 0x01, 0xF0, 0x00, 0xE3, 0x80, 0x0E,
  0xC0, 0x03, 0x8E, 0x00, 0x3B, 0x00, 0x0C, 0x38, 0x00, 0xCE, 0x00, 0x70,
  0x60, 0x03, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0xE0, 0x07, 0x07, 0x00, 0x71,
  0x80, 0x1C, 0x1C, 0x01, 0xC7, 0x00, 0x60, 0x70, 0x06, 0x1C, 0x03, 0x80,
  0xC0, 0x38, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0xC0, 0x38, 0x0E, 0x03, 0x83,
  0x80, 0xC0, 0x38, 0x0C, 0x0E, 0x03, 0x00, 0x60, 0x70, 0x38, 0x1C, 0x01,
  0xC1, 0xC0, 0x60, 0x70, 0x07, 0x06, 0x01, 0xC1, 0xC0, 0x1C, 0x18, 0x07,
  0x06, 0x00, 0x70, 0xE0, 0x0C, 0x38, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x03,
  0x8C, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0x39, 0xC0, 0x06,
  0x30, 0x00, 0x67, 0x00, 0x19, 0xC0, 0x01, 0x98, 0x00, 0x77, 0x00, 0x07,
  0x60, 0x01, 0xD8, 0x00, 0x1D, 0x80, 0x03, 0x60, 0x00, 0x7E, 0x00, 0x0D,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x70, 0xFF, 0xF0, 0x00, 0x01, 0xC7, 0x83, 0xF0, 0x00,
  0x07, 0x3C, 0x03, 0xE0, 0x00, 0x19, 0xE0, 0x03, 0xC0, 0x00, 0xE7, 0x00,
  0x07, 0x80, 0x03, 0x98, 0x00, 0x0F, 0x80, 0x1C, 0xE0, 0x00, 0x1F, 0x00,
  0xF3, 0x80, 0x00, 0x1F, 0xFF, 0x8E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0,
};

const GFXglyph RobotoMono_ExtraLight70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 5, 50, 42, 18, -50 },
  { 33, 12, 15, 42, 15, -53 },
  { 56, 38, 50, 42, 2, -50 },
  { 294, 31, 64, 42, 6, -57 },
  { 542, 39, 51, 42, 1, -50 },
  { 791, 35, 51, 42, 5, -50 },
  { 1015, 3, 15, 42, 18, -53 },
  { 1021, 16, 72, 42, 13, -56 },
  { 1165, 16, 72, 42, 12, -56 },
  { 1309, 30, 29, 42, 7, -50 },
  { 1418, 34, 36, 42, 4, -41 },
  { 1571, 6, 15, 42, 14, -6 },
  { 1583, 25, 3, 42, 8, -24 },
  { 1593, 6, 5, 42, 19, -5 },
  { 1597, 24, 54, 42, 10, -50 },
  { 1759, 31, 51, 42, 6, -50 },
  { 1957, 17, 50, 42, 8, -50 },
  { 2064, 31, 50, 42, 4, -50 },
  { 2258, 31, 51, 42, 3, -50 },
  { 2456, 35, 50, 42, 3, -50 },
  { 2675, 29, 51, 42, 8, -50 },
  { 2860, 31, 51, 42, 5, -50 },
  { 3058, 32, 50, 42, 5, -50 },
  { 3258, 32, 51, 42, 6, -50 },
  { 3462, 31, 51, 42, 5, -50 },
  { 3660, 6, 35, 42, 21, -35 },
  { 3687, 8, 44, 42, 19, -35 },
  { 3731, 29, 29, 42, 6, -37 },
  { 3837, 30, 17, 42, 6, -31 },
  { 3901, 30, 29, 42, 6, -37 },
  { 4010, 27, 50, 42, 8, -50 },
  { 4179, 38, 50, 42, 2, -50 },
  { 4417, 35, 50, 42, 4, -50 },
  { 4636, 31, 50, 42, 7, -50 },
  { 4830, 32, 51, 42, 5, -50 },
  { 5034, 32, 50, 42, 6, -50 },
  { 5234, 29, 50, 42, 7, -50 },
  { 5416, 28, 50, 42, 8, -50 },
  { 5591, 33, 51, 42, 4, -50 },
  { 5802, 30, 50, 42, 6, -50 },
  { 5990, 28, 50, 42, 7, -50 },
  { 6165, 31, 51, 42, 4, -50 },
  { 6363, 33, 50, 42, 7, -50 },
  { 6570, 29, 50, 42, 8, -50 },
  { 6752, 31, 50, 42, 6, -50 },
  { 6946, 30, 50, 42, 6, -50 },
  { 7134, 32, 51, 42, 5, -50 },
  { 7338, 31, 50, 42, 8, -50 },
  { 7532, 34, 59, 42, 4, -50 },
  { 7783, 31, 50, 42, 7, -50 },
  { 7977, 33, 51, 42, 5, -50 },
  { 8188, 35, 50, 42, 4, -50 },
  { 8407, 30, 51, 42, 6, -50 },
  { 8599, 35, 50, 42, 3, -50 },
  { 8818, 37, 50, 42, 3, -50 },
  { 9050, 35, 50, 42, 4, -50 },
  { 9269, 35, 50, 42, 3, -50 },
  { 9488, 31, 50, 42, 5, -50 },
  { 9682, 11, 68, 42, 16, -57 },
  { 9776, 24, 54, 42, 9, -50 },
  { 9938, 11, 68, 42, 15, -57 },
  { 10032, 24, 27, 42, 9, -50 },
  { 10113, 30, 3, 42, 6, 0 },
  { 10125, 10, 10, 42, 16, -52 },
  { 10138, 30, 39, 42, 6, -38 },
  { 10285, 29, 54, 42, 7, -53 },
  { 10481, 30, 39, 42, 6, -38 },
  { 10628, 29, 54, 42, 6, -53 },
  { 10824, 32, 39, 42, 5, -38 },
  { 10980, 31, 53, 42, 7, -53 },
  { 11186, 29, 53, 42, 6, -38 },
  { 11379, 29, 53, 42, 7, -53 },
  { 11572, 29, 50, 42, 8, -50 },
  { 11754, 22, 65, 42, 6, -50 },
  { 11933, 30, 53, 42, 8, -53 },
  { 12132, 29, 53, 42, 8, -53 },
  { 12325, 36, 38, 42, 3, -38 },
  { 12496, 29, 38, 42, 7, -38 },
  { 12634, 32, 39, 42, 5, -38 },
  { 12790, 29, 52, 42, 7, -38 },
  { 12979, 29, 52, 42, 6, -38 },
  { 13168, 24, 38, 42, 13, -38 },
  { 13282, 29, 39, 42, 7, -38 },
  { 13424, 29, 48, 42, 6, -47 },
  { 13598, 28, 38, 42, 7, -37 },
  { 13731, 34, 37, 42, 4, -37 },
  { 13889, 38, 37, 42, 2, -37 },
  { 14065, 33, 37, 42, 5, -37 },
  { 14218, 36, 52, 42, 3, -37 },
  { 14452, 33, 37, 42, 5, -37 },
  { 14605, 23, 69, 42, 11, -55 },
  { 14804, 2, 60, 42, 20, -50 },
  { 14819, 23, 69, 42, 11, -55 },
  { 15018, 38, 12, 42, 2, -27 },
};

const GFXfont RobotoMono_ExtraLight70pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight70pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _ROBOTOMONO_EXTRALIGHT70PT7B_H_
