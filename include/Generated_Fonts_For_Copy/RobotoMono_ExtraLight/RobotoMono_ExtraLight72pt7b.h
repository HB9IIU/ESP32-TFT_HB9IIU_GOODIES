#ifndef _ROBOTOMONO_EXTRALIGHT72PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight72pt7bBitmaps[] PROGMEM = {
  0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x9E, 0xFF, 0xFC, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xB8, 0x0D, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x80, 0xC0, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xF8, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x04, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x01, 0xC0,
  0x00, 0x70, 0x07, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x00, 0x3C,
  0x1E, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0x00, 0x00, 0x0F, 0xF0, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xC0, 0x7F, 0xF0, 0x00,
  0x01, 0xC0, 0xF0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x03, 0x81,
  0xC0, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x0E,
  0x00, 0x0E, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x03, 0x80, 0x07, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x70, 0x03, 0x80, 0x06, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x40, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x0E,
  0x01, 0xE0, 0x00, 0xE1, 0xC0, 0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0x00,
  0xE3, 0x80, 0x03, 0xC0, 0x1C, 0x78, 0x00, 0x1C, 0x01, 0xC7, 0x00, 0x01,
  0xE0, 0x1C, 0x70, 0x00, 0x0F, 0x01, 0xCF, 0x00, 0x00, 0x78, 0x3C, 0xE0,
  0x00, 0x03, 0xC3, 0x8E, 0x00, 0x00, 0x1C, 0x38, 0xE0, 0x00, 0x00, 0xE7,
  0x0E, 0x00, 0x00, 0x0F, 0xF0, 0x70, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x3C,
  0x00, 0x00, 0xFF, 0x01, 0xE0, 0x00, 0x1E, 0x78, 0x0F, 0x80, 0x07, 0xC3,
  0xC0, 0x7E, 0x03, 0xF8, 0x1C, 0x03, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0xFF,
  0x80, 0x0F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDB, 0x6D,
  0xB0, 0x00, 0x02, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x02, 0x00, 0x01, 0x40, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x80, 0x07, 0x00, 0x0B, 0xE0, 0x0E,
  0x00, 0xFF, 0xF8, 0x1C, 0x0F, 0xF7, 0xFE, 0x38, 0x7F, 0x80, 0xFF, 0x77,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x70, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0xF3, 0x8E, 0x71, 0xCE, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x00, 0x7E, 0xE0, 0x00, 0x01, 0xEE,
  0xE0, 0x00, 0x03, 0xCE, 0xE0, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x0F, 0x0F,
  0xE0, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x78, 0x07,
  0xE0, 0x00, 0xF0, 0x07, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0x80, 0x07, 0xE0, 0x0F, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x07,
  0xE0, 0x3C, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x07,
  0xE1, 0xC0, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0x0E, 0xE7, 0x00, 0x00, 0x0E,
  0xEE, 0x00, 0x00, 0x0E, 0xFC, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFB, 0xC3, 0xF8, 0xF7, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x20, 0x00, 0x0E, 0x1F, 0xFE, 0x00, 0x3B, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x38,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x70, 0x1F, 0xFE, 0x00, 0x70, 0x7F, 0xFF, 0x80, 0x71, 0xFC, 0x0F, 0xC0,
  0x73, 0xE0, 0x03, 0xE0, 0x77, 0x80, 0x00, 0xF0, 0x7E, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x00, 0x38, 0xFC, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF9, 0xC0,
  0x00, 0x03, 0xF3, 0xC0, 0x00, 0x0E, 0xE3, 0xC0, 0x00, 0x3D, 0xC3, 0xC0,
  0x00, 0xF3, 0x83, 0xE0, 0x07, 0xC7, 0x03, 0xFC, 0xFE, 0x0C, 0x03, 0xFF,
  0xF8, 0x38, 0x01, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0xFB, 0xFF, 0x9E, 0x0F, 0x0F, 0x87, 0xE3, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0xF8, 0x00, 0xC0, 0xE0, 0x07, 0xFC, 0x01,
  0xC3, 0x80, 0x1F, 0xFE, 0x03, 0x87, 0x00, 0x70, 0x1C, 0x03, 0x1C, 0x01,
  0xC0, 0x18, 0x06, 0x38, 0x07, 0x00, 0x30, 0x0E, 0x60, 0x0C, 0x00, 0x60,
  0x1D, 0xC0, 0x38, 0x00, 0xC0, 0x3B, 0x80, 0x60, 0x03, 0x80, 0x36, 0x01,
  0xC0, 0x07, 0x00, 0x6C, 0x03, 0x80, 0x0E, 0x00, 0xD8, 0x06, 0x00, 0x18,
  0x01, 0xF0, 0x0C, 0x00, 0x30, 0x03, 0xE0, 0x38, 0x00, 0x60, 0x07, 0xC0,
  0x70, 0x00, 0xC0, 0x0F, 0x80, 0xE0, 0x01, 0x80, 0x1F, 0x01, 0xC0, 0x03,
  0x00, 0x3E, 0x03, 0x00, 0x0E, 0x00, 0xFC, 0x06, 0x00, 0x1C, 0x01, 0xF8,
  0x0C, 0x00, 0x38, 0x03, 0xF0, 0x1C, 0x00, 0x70, 0x06, 0xE0, 0x38, 0x01,
  0xC0, 0x0D, 0xC0, 0x70, 0x03, 0x80, 0x1B, 0x80, 0xE0, 0x0F, 0x80, 0x77,
  0x00, 0xC0, 0x1F, 0x00, 0xC6, 0x01, 0x80, 0x7E, 0x03, 0x8C, 0x03, 0x81,
  0xCC, 0x06, 0x1C, 0x03, 0x87, 0x1C, 0x1C, 0x38, 0x07, 0xFC, 0x1F, 0xF0,
  0x30, 0x07, 0xF0, 0x3F, 0xC0, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0F,
  0xC0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0xE0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x1F, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x01,
  0xC0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x07, 0x80, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xC3, 0xE0, 0x00,
  0x00, 0xE3, 0xF8, 0x00, 0x00, 0x73, 0xDE, 0x00, 0x00, 0x3B, 0xC7, 0x80,
  0x00, 0x1F, 0xC1, 0xC0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00,
  0x77, 0xE7, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x01,
  0xC7, 0xE3, 0x80, 0x01, 0xC7, 0xE3, 0x80, 0x01, 0xC7, 0xE3, 0x80, 0x03,
  0x87, 0xE1, 0xC0, 0x03, 0x87, 0xE1, 0xC0, 0x07, 0x07, 0xE0, 0xC0, 0x07,
  0x07, 0xE0, 0xE0, 0x07, 0x07, 0xE0, 0xE0, 0x0E, 0x07, 0xE0, 0x70, 0x0E,
  0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x38, 0x1C,
  0x07, 0xE0, 0x38, 0x38, 0x07, 0xE0, 0x38, 0x38, 0x07, 0xE0, 0x1C, 0x70,
  0x07, 0xE0, 0x1C, 0x70, 0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0xE0,
  0x07, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x03, 0xF7, 0x00, 0x00, 0x07,
  0xE7, 0x00, 0x00, 0x0F, 0xCE, 0x00, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0x3F,
  0x1E, 0x00, 0x00, 0x7E, 0x1C, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x01, 0xF8,
  0x38, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x0F, 0xC0,
  0x70, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0x7E, 0x01,
  0xE0, 0x00, 0xFC, 0x01, 0xC0, 0x01, 0xF8, 0x03, 0xC0, 0x03, 0xF0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x07,
  0x00, 0x3F, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0x1E,
  0x01, 0xF8, 0x00, 0x1C, 0x03, 0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x38,
  0x0F, 0xC0, 0x00, 0x38, 0x1F, 0x80, 0x00, 0x70, 0x3F, 0x00, 0x00, 0x70,
  0x7E, 0x00, 0x00, 0xE0, 0xFC, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0x01, 0xE3,
  0xF0, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x03, 0x9F,
  0x80, 0x00, 0x03, 0xBF, 0x00, 0x00, 0x07, 0x7E, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x07,
  0xE0, 0xE0, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0xFC, 0x0E,
  0x00, 0x00, 0x7C, 0x1C, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1F,
  0x03, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x00, 0x78, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1F, 0x80, 0x00, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x80, 0x01, 0xDC, 0x00,
  0x1E, 0x00, 0x07, 0x70, 0x00, 0x7C, 0x00, 0x1D, 0xC0, 0x01, 0xF0, 0x00,
  0x67, 0x00, 0x07, 0xC0, 0x01, 0x9C, 0x00, 0x3F, 0x00, 0x0E, 0x30, 0x00,
  0xEC, 0x00, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0xE3, 0x80, 0x0E, 0xE0, 0x03,
  0x8E, 0x00, 0x33, 0x80, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x30, 0xE0, 0x07,
  0x18, 0x00, 0xC3, 0x80, 0x1C, 0x70, 0x07, 0x06, 0x00, 0x71, 0xC0, 0x1C,
  0x1C, 0x01, 0x87, 0x00, 0x70, 0x70, 0x06, 0x1C, 0x01, 0xC1, 0xC0, 0x38,
  0x30, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x18, 0x1C, 0x03, 0x83, 0x80, 0xE0,
  0x70, 0x0C, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0xE0, 0x38, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x00,
  0xE0, 0x70, 0x1C, 0x0C, 0x03, 0x81, 0x80, 0x70, 0x70, 0x06, 0x0E, 0x01,
  0xC1, 0xC0, 0x18, 0x38, 0x03, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0x70, 0x07, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x70, 0x03,
  0x86, 0x00, 0x71, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x1C, 0xE0, 0x03,
  0x9C, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x07,
  0x38, 0x00, 0xEE, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00, 0x33, 0x00, 0x0E,
  0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x3E, 0x70, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x03, 0xB8, 0xF0, 0x00, 0x0F,
  0x71, 0xF0, 0x00, 0x7C, 0xF1, 0xFC, 0x07, 0xE1, 0xE0, 0xFF, 0xFF, 0x83,
  0xC0, 0x7F, 0xF8, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x7F, 0xF8, 0x03,
  0xC3, 0xFF, 0xF8, 0x0F, 0x3F, 0x03, 0xF0, 0x3D, 0xE0, 0x01, 0xE0, 0xFF,
  0x00, 0x03, 0xC3, 0xF8, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01,
  0xCF, 0x80, 0x00, 0x07, 0x3E, 0x00, 0x00, 0x38, 0xFC, 0x00, 0x01, 0xE3,
  0xB8, 0x00, 0x0F, 0x0E, 0x78, 0x00, 0x78, 0x38, 0xFC, 0x0F, 0xC0, 0xE1,
  0xFF, 0xFE, 0x03, 0x81, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x07, 0x00, 0x7F,
  0xF8, 0x1C, 0x07, 0xFF, 0xF0, 0x70, 0x3F, 0x01, 0xF1, 0xC1, 0xF0, 0x01,
  0xE7, 0x0F, 0x00, 0x01, 0xDC, 0x78, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0xFC, 0x3C, 0x00, 0x07, 0x70, 0x7C, 0x00, 0x79, 0xC0, 0xFC, 0x0F,
  0xC7, 0x01, 0xFF, 0xFE, 0x1C, 0x01, 0xFF, 0xE0, 0x70, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x70, 0x1F, 0xFF, 0xE1, 0xC0, 0xFC, 0x0F, 0xC7,
  0x07, 0xC0, 0x07, 0x9C, 0x3C, 0x00, 0x07, 0x71, 0xE0, 0x00, 0x0F, 0xC7,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1D, 0xC1, 0xF0, 0x01, 0xE7,
  0x03, 0xF0, 0x3F, 0x1C, 0x07, 0xFF, 0xF8, 0x70, 0x07, 0xFF, 0x81, 0xC0,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFC, 0x00, 0xE0, 0x1F, 0xFE, 0x03,
  0x81, 0xFF, 0xFE, 0x0E, 0x0F, 0x80, 0xFC, 0x38, 0x78, 0x00, 0xF8, 0xE3,
  0x80, 0x01, 0xE3, 0x9C, 0x00, 0x03, 0xCE, 0xE0, 0x00, 0x07, 0x3B, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0xE0, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x1F, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x01, 0xCF,
  0xF0, 0x00, 0x03, 0xBF, 0xE0, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x0F, 0xC1,
  0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03,
  0xE0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x07, 0x0F, 0xF8, 0x0F, 0xFC, 0x39, 0xFF, 0xF0, 0xFF, 0xF9, 0xDE, 0x07,
  0x8F, 0x03, 0xCE, 0xC0, 0x1E, 0xE0, 0x0F, 0x7C, 0x00, 0x76, 0x00, 0x3B,
  0xC0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00,
  0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00,
  0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F,
  0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x38,
  0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00,
  0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00,
  0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0,
  0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x03, 0x80, 0x7F, 0xF8, 0x0E, 0x07, 0xFF, 0xF8, 0x38, 0x3E, 0x03, 0xF0,
  0xE3, 0xC0, 0x03, 0xE3, 0x8E, 0x00, 0x07, 0x8E, 0x70, 0x00, 0x0F, 0x3B,
  0x80, 0x00, 0x1C, 0xFC, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0x81, 0xFF, 0xE0, 0x0E, 0x1F, 0xFF, 0xE0, 0x38, 0xFC, 0x0F, 0xC0,
  0xE7, 0x80, 0x0F, 0x83, 0xBC, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x38, 0xF8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0xE3, 0xF0, 0x00, 0x07, 0x8E, 0xE0, 0x00, 0x3C, 0x39, 0xE0, 0x03, 0xE0,
  0xE3, 0xE0, 0x3F, 0x03, 0x87, 0xFF, 0xF8, 0x0E, 0x07, 0xFF, 0x80, 0x38,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x70, 0x1F, 0xFF, 0xE1, 0xC0, 0xFC, 0x07, 0xC7, 0x07,
  0xC0, 0x07, 0x9C, 0x3C, 0x00, 0x07, 0x71, 0xE0, 0x00, 0x0F, 0xC7, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x7C,
  0x78, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1D, 0xC1, 0xF0, 0x01, 0xE7, 0x03,
  0xF0, 0x1F, 0x1C, 0x07, 0xFF, 0xF8, 0x70, 0x07, 0xFF, 0x81, 0xC0, 0x01,
  0xF0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x70, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xE0, 0x6E, 0x1F, 0x00, 0x07, 0x1E,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x10, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xE7,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x1D, 0xC7, 0xC0,
  0x03, 0xCE, 0x1F, 0x80, 0xFC, 0x70, 0x3F, 0xFF, 0xC3, 0x80, 0xFF, 0xF8,
  0x1C, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0xE0, 0x00, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0xF0, 0x00, 0x3B, 0x80, 0x01, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x80, 0x03, 0x8E, 0x00, 0x1F,
  0x80, 0x07, 0x1C, 0x00, 0x37, 0x00, 0x0E, 0x38, 0x00, 0x66, 0x00, 0x18,
  0x38, 0x01, 0xCC, 0x00, 0x70, 0x70, 0x03, 0x9C, 0x00, 0xE0, 0xE0, 0x06,
  0x38, 0x01, 0xC1, 0xC0, 0x0C, 0x70, 0x03, 0x01, 0x80, 0x38, 0x60, 0x0E,
  0x03, 0x80, 0x70, 0xE0, 0x1C, 0x07, 0x00, 0xC1, 0xC0, 0x38, 0x0E, 0x01,
  0x81, 0x80, 0x70, 0x1C, 0x07, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x07, 0x03,
  0x80, 0x38, 0x18, 0x0E, 0x07, 0x00, 0x70, 0x30, 0x0C, 0x0E, 0x00, 0xE0,
  0xE0, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x70,
  0xE0, 0x03, 0x86, 0x00, 0x61, 0xC0, 0x07, 0x1C, 0x00, 0xC3, 0x80, 0x0E,
  0x38, 0x01, 0xC6, 0x00, 0x0C, 0x60, 0x03, 0x9C, 0x00, 0x1C, 0xC0, 0x03,
  0x38, 0x00, 0x3B, 0x80, 0x06, 0x70, 0x00, 0x77, 0x00, 0x0E, 0xC0, 0x00,
  0x6C, 0x00, 0x1D, 0x80, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x08, 0x1F,
  0xFF, 0x00, 0x00, 0x1C, 0x7E, 0x7F, 0x00, 0x00, 0x39, 0xE0, 0x1F, 0x00,
  0x00, 0x73, 0x80, 0x0F, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x80, 0x03, 0x9C,
  0x00, 0x0F, 0x80, 0x0E, 0x30, 0x00, 0x07, 0x80, 0x3C, 0xE0, 0x00, 0x07,
  0xC0, 0xF1, 0xC0, 0x00, 0x07, 0xFF, 0xC3, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoMono_ExtraLight72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 5, 51, 43, 19, -51 },
  { 33, 13, 15, 43, 15, -54 },
  { 58, 39, 51, 43, 2, -51 },
  { 307, 32, 66, 43, 6, -59 },
  { 571, 40, 53, 43, 2, -52 },
  { 836, 36, 53, 43, 5, -52 },
  { 1075, 3, 15, 43, 19, -54 },
  { 1081, 16, 74, 43, 14, -57 },
  { 1229, 17, 74, 43, 12, -57 },
  { 1387, 31, 29, 43, 7, -51 },
  { 1500, 35, 37, 43, 4, -42 },
  { 1662, 6, 16, 43, 14, -6 },
  { 1674, 25, 3, 43, 9, -25 },
  { 1684, 6, 5, 43, 20, -5 },
  { 1688, 25, 55, 43, 10, -51 },
  { 1860, 32, 53, 43, 6, -52 },
  { 2072, 18, 51, 43, 8, -51 },
  { 2187, 32, 52, 43, 4, -52 },
  { 2395, 32, 53, 43, 3, -52 },
  { 2607, 36, 51, 43, 3, -51 },
  { 2837, 30, 52, 43, 8, -51 },
  { 3032, 32, 53, 43, 5, -52 },
  { 3244, 33, 51, 43, 5, -51 },
  { 3455, 33, 53, 43, 6, -52 },
  { 3674, 31, 53, 43, 6, -52 },
  { 3880, 6, 36, 43, 22, -36 },
  { 3907, 9, 46, 43, 19, -36 },
  { 3959, 30, 29, 43, 6, -38 },
  { 4068, 31, 17, 43, 6, -32 },
  { 4134, 30, 29, 43, 7, -38 },
  { 4243, 28, 52, 43, 8, -52 },
  { 4425, 39, 52, 43, 2, -52 },
  { 4679, 36, 51, 43, 4, -51 },
  { 4909, 32, 51, 43, 7, -51 },
  { 5113, 33, 53, 43, 5, -52 },
  { 5332, 32, 51, 43, 7, -51 },
  { 5536, 30, 51, 43, 7, -51 },
  { 5728, 29, 51, 43, 8, -51 },
  { 5913, 34, 53, 43, 4, -52 },
  { 6139, 31, 51, 43, 6, -51 },
  { 6337, 29, 51, 43, 7, -51 },
  { 6522, 32, 52, 43, 4, -51 },
  { 6730, 33, 51, 43, 8, -51 },
  { 6941, 30, 51, 43, 8, -51 },
  { 7133, 32, 51, 43, 6, -51 },
  { 7337, 31, 51, 43, 6, -51 },
  { 7535, 34, 53, 43, 5, -52 },
  { 7761, 32, 51, 43, 8, -51 },
  { 7965, 36, 61, 43, 4, -52 },
  { 8240, 31, 51, 43, 8, -51 },
  { 8438, 34, 53, 43, 5, -52 },
  { 8664, 36, 51, 43, 4, -51 },
  { 8894, 31, 52, 43, 6, -51 },
  { 9096, 37, 51, 43, 3, -51 },
  { 9332, 38, 51, 43, 3, -51 },
  { 9575, 36, 51, 43, 4, -51 },
  { 9805, 36, 51, 43, 3, -51 },
  { 10035, 32, 51, 43, 5, -51 },
  { 10239, 12, 70, 43, 16, -59 },
  { 10344, 25, 55, 43, 9, -51 },
  { 10516, 11, 70, 43, 16, -59 },
  { 10613, 25, 28, 43, 9, -51 },
  { 10701, 31, 3, 43, 6, 0 },
  { 10713, 10, 9, 43, 17, -53 },
  { 10725, 31, 40, 43, 6, -39 },
  { 10880, 30, 55, 43, 7, -54 },
  { 11087, 31, 40, 43, 6, -39 },
  { 11242, 30, 55, 43, 6, -54 },
  { 11449, 32, 40, 43, 6, -39 },
  { 11609, 32, 55, 43, 7, -55 },
  { 11829, 30, 54, 43, 6, -39 },
  { 12032, 30, 54, 43, 7, -54 },
  { 12235, 30, 52, 43, 8, -52 },
  { 12430, 22, 67, 43, 7, -52 },
  { 12615, 31, 54, 43, 8, -54 },
  { 12825, 30, 54, 43, 8, -54 },
  { 13028, 37, 39, 43, 3, -39 },
  { 13209, 30, 39, 43, 7, -39 },
  { 13356, 33, 40, 43, 5, -39 },
  { 13521, 30, 54, 43, 7, -39 },
  { 13724, 30, 54, 43, 6, -39 },
  { 13927, 25, 39, 43, 13, -39 },
  { 14049, 30, 40, 43, 7, -39 },
  { 14199, 30, 49, 43, 6, -48 },
  { 14383, 29, 39, 43, 7, -38 },
  { 14525, 35, 38, 43, 4, -38 },
  { 14692, 39, 38, 43, 2, -38 },
  { 14878, 34, 38, 43, 5, -38 },
  { 15040, 37, 53, 43, 3, -38 },
  { 15286, 34, 38, 43, 5, -38 },
  { 15448, 23, 71, 43, 12, -56 },
  { 15653, 3, 62, 43, 20, -51 },
  { 15677, 23, 71, 43, 12, -56 },
  { 15882, 39, 12, 43, 2, -27 },
};

const GFXfont RobotoMono_ExtraLight72pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight72pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _ROBOTOMONO_EXTRALIGHT72PT7B_H_
