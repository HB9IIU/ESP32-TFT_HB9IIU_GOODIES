#ifndef _ROBOTOMONO_EXTRALIGHT52PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight52pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x70, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x07,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xFC, 0x03, 0x80, 0x78, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x00,
  0x01, 0x9C, 0x00, 0x06, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x60, 0x00,
  0x1D, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x87, 0x80, 0x3C, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x18, 0x02, 0x03, 0x00, 0x60, 0x18, 0x18, 0x03, 0x01, 0x80, 0xC0, 0x18,
  0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x06, 0x0E, 0x01, 0x80, 0x30, 0x60,
  0x0C, 0x03, 0x06, 0x00, 0x30, 0x18, 0x30, 0x01, 0xC1, 0x83, 0x00, 0x07,
  0xBC, 0x18, 0x00, 0x1F, 0xC1, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x3F, 0x00, 0x03, 0x07, 0x9C, 0x00, 0x18, 0x30, 0x70,
  0x01, 0x83, 0x01, 0x80, 0x0C, 0x18, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x06,
  0x0C, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x30, 0x18,
  0x03, 0x03, 0x80, 0x60, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x70, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01,
  0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x61, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x81, 0x80, 0x19, 0xC0, 0x30, 0x0E, 0x60, 0x0E, 0x03,
  0x38, 0x01, 0xC0, 0xCC, 0x00, 0x38, 0x33, 0x00, 0x07, 0x0C, 0xC0, 0x00,
  0xC6, 0x30, 0x00, 0x39, 0x8C, 0x00, 0x07, 0xE3, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x03, 0x00, 0x06, 0xE0, 0xF0, 0x07, 0x1C,
  0x0F, 0xDF, 0x83, 0x81, 0xFF, 0x80, 0x70, 0x06, 0x00, 0x00, 0x6D, 0xB6,
  0xD6, 0xDB, 0x00, 0x00, 0x20, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x20, 0xC0,
  0x0E, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x0E, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x70, 0x18, 0x0E, 0xFC, 0x30, 0x7E, 0x7F, 0x67, 0xE0,
  0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0D, 0x80, 0x00,
  0x31, 0x80, 0x00, 0xC3, 0x80, 0x03, 0x83, 0x80, 0x0E, 0x03, 0x80, 0x38,
  0x03, 0x00, 0xE0, 0x07, 0x80, 0xC0, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x39, 0xCE, 0x73,
  0x98, 0xC6, 0x67, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x67, 0xF7, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x78, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x00, 0x07, 0x0E, 0x00,
  0x06, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x3B, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0C, 0xF0, 0x00, 0x31,
  0xE0, 0x00, 0xC3, 0xC0, 0x03, 0x07, 0x80, 0x0C, 0x0F, 0x00, 0x30, 0x1E,
  0x00, 0xC0, 0x3C, 0x03, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x70, 0x01, 0xE1,
  0xC0, 0x03, 0xE7, 0x00, 0x07, 0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x1B, 0xC0,
  0x00, 0x37, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x18, 0x00,
  0x0E, 0x38, 0x00, 0x18, 0x30, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x78, 0x07,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x07, 0x03, 0xF0, 0xFB, 0x3E, 0x3F, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x78, 0x07, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x38,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x78,
  0x03, 0x81, 0xC0, 0x03, 0x83, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x70, 0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x30, 0x00,
  0x0E, 0x70, 0x00, 0x18, 0x70, 0x00, 0x60, 0x78, 0x03, 0xC0, 0x7F, 0x7E,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x07, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x70, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCE, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x9F, 0xF8, 0x0D,
  0xFF, 0xF0, 0x7C, 0x07, 0xC3, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEC, 0x00, 0x0E, 0x70, 0x00, 0x71, 0xC0,
  0x07, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x1F, 0xE0, 0x38, 0xFF, 0xF0, 0x67, 0x80, 0xF0, 0xDC, 0x00,
  0x71, 0xF0, 0x00, 0x73, 0xC0, 0x00, 0x67, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0x9C, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0x3C, 0x03, 0x80, 0x3F, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0x00, 0xF0, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30,
  0x00, 0x0E, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x1C,
  0x00, 0x18, 0x0E, 0x00, 0x38, 0x07, 0x80, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x07, 0x81, 0xF0, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x30,
  0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x07, 0x70, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x78, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x38, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80,
  0x03, 0x06, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x60, 0x00,
  0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0E,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x79, 0x80, 0x01, 0xB3, 0x80, 0x07, 0x63,
  0x80, 0x1D, 0xC3, 0xC0, 0xF3, 0x03, 0xFF, 0x86, 0x00, 0xFC, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x6F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFE, 0x18,
  0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x8E, 0x38, 0xE3, 0x0C, 0x31, 0xC6, 0x38, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0,
  0x3C, 0x03, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xE6, 0x00, 0x06, 0xE0, 0x00,
  0x6C, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3C, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x01, 0x81, 0x80, 0x10, 0x0C, 0x18, 0x07, 0xE0,
  0x30, 0xC0, 0xF3, 0xC1, 0x8C, 0x06, 0x06, 0x0C, 0x60, 0x60, 0x30, 0x22,
  0x06, 0x01, 0x81, 0x30, 0x30, 0x08, 0x0D, 0x81, 0x00, 0x40, 0x6C, 0x18,
  0x02, 0x03, 0x60, 0xC0, 0x30, 0x1A, 0x06, 0x01, 0x80, 0xD0, 0x30, 0x0C,
  0x07, 0x81, 0x00, 0x60, 0x3C, 0x08, 0x03, 0x01, 0x60, 0x40, 0x18, 0x0B,
  0x02, 0x00, 0xC0, 0xC8, 0x18, 0x0E, 0x06, 0x60, 0xC0, 0x70, 0x33, 0x06,
  0x07, 0x83, 0x18, 0x38, 0x6C, 0x18, 0xC0, 0xC6, 0x31, 0x83, 0x03, 0xE1,
  0xF8, 0x18, 0x0C, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0xE0, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0x00, 0x1F, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x18, 0x00,
  0x07, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x07,
  0x30, 0x00, 0x1C, 0x60, 0x00, 0x70, 0xC0, 0x03, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x06, 0x00, 0x0F, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x03, 0x30,
  0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x39, 0x80, 0x00, 0xE3, 0x00, 0x07,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x60,
  0x00, 0x60, 0x60, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x18,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x18,
  0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0x3F, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x03, 0x00, 0x3E, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x18,
  0x00, 0x0E, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x1D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x30,
  0x00, 0x0E, 0x60, 0x00, 0x38, 0xC0, 0x00, 0xE1, 0x80, 0x07, 0x83, 0x00,
  0x3E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x60, 0x00, 0x06, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x87,
  0x00, 0x03, 0x81, 0xE0, 0x07, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xDC, 0x00, 0x01, 0x98, 0x00, 0x07, 0x38, 0x00, 0x0C,
  0x30, 0x00, 0x38, 0x70, 0x00, 0xE0, 0x78, 0x07, 0x80, 0x7F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x03, 0x83, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x73,
  0xE0, 0x00, 0x3B, 0xB8, 0x00, 0x1D, 0x8E, 0x00, 0x0F, 0x83, 0x00, 0x07,
  0x81, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0C,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x18, 0x70, 0x00, 0x06, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x06, 0xFB, 0x00, 0x0D,
  0xF6, 0x00, 0x3B, 0xEE, 0x00, 0x67, 0xCC, 0x00, 0xCF, 0x98, 0x03, 0x1F,
  0x18, 0x06, 0x3E, 0x30, 0x1C, 0x7C, 0x60, 0x30, 0xF8, 0x60, 0x61, 0xF0,
  0xC1, 0x83, 0xE1, 0xC3, 0x07, 0xC1, 0x8E, 0x0F, 0x83, 0x18, 0x1F, 0x03,
  0x30, 0x3E, 0x06, 0xC0, 0x7C, 0x0D, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1C,
  0x03, 0xE0, 0x38, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3D, 0x80, 0x00, 0x7B, 0x80, 0x00, 0xF3, 0x00, 0x01, 0xE7,
  0x00, 0x03, 0xC6, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x0C,
  0x00, 0x3C, 0x18, 0x00, 0x78, 0x18, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x30,
  0x03, 0xC0, 0x70, 0x07, 0x80, 0x60, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xC0,
  0x3E, 0x00, 0xC0, 0x7C, 0x01, 0x80, 0xF8, 0x01, 0x81, 0xF0, 0x03, 0x83,
  0xE0, 0x03, 0x07, 0xC0, 0x07, 0x0F, 0x80, 0x06, 0x1F, 0x00, 0x0E, 0x3E,
  0x00, 0x0C, 0x7C, 0x00, 0x0C, 0xF8, 0x00, 0x19, 0xF0, 0x00, 0x1B, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x01,
  0xC0, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x38,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x30,
  0xE0, 0x00, 0x38, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x1C,
  0x01, 0xE0, 0x1C, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x0F, 0x86, 0x00, 0x07,
  0x8C, 0x00, 0x03, 0x98, 0x00, 0x03, 0x30, 0x00, 0x07, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0xC0,
  0x00, 0x39, 0x80, 0x00, 0xE3, 0x00, 0x03, 0xC6, 0x00, 0x7E, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x78, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x1C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x60, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x02, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x03, 0x80, 0x0F, 0x07, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x0D, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xDC, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x31,
  0xC0, 0x00, 0xE3, 0x80, 0x07, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1C,
  0x00, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x81, 0xC0,
  0x03, 0x03, 0x80, 0x07, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x19, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00,
  0x0E, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x38, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x3F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x1C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x06, 0x00, 0x36, 0x00, 0x60, 0x03, 0x60, 0x07, 0x00, 0x66, 0x00,
  0xF0, 0x06, 0x60, 0x0F, 0x00, 0x66, 0x00, 0xF0, 0x06, 0x60, 0x0F, 0x00,
  0x67, 0x00, 0xD8, 0x06, 0x30, 0x19, 0x80, 0x63, 0x01, 0x98, 0x0C, 0x30,
  0x19, 0x80, 0xC3, 0x01, 0x98, 0x0C, 0x30, 0x18, 0xC0, 0xC3, 0x01, 0x0C,
  0x0C, 0x38, 0x30, 0xC0, 0xC1, 0x83, 0x0C, 0x0C, 0x18, 0x30, 0xC1, 0x81,
  0x83, 0x0C, 0x18, 0x18, 0x30, 0x61, 0x81, 0x86, 0x06, 0x18, 0x18, 0x60,
  0x61, 0x80, 0xC6, 0x06, 0x18, 0x0C, 0x60, 0x61, 0x00, 0xC6, 0x03, 0x30,
  0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC,
  0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x07, 0x38, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x18,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x18,
  0x07, 0x00, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00,
  0xE0, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x80, 0x0C,
  0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x03, 0x38,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x07, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xE0, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x70, 0x30, 0x06, 0x06, 0x00, 0xC1, 0xC0, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x39, 0x80, 0x03, 0x70, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC1, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x86, 0x00,
  0x03, 0x1C, 0x00, 0x07, 0x30, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x7F, 0xFF,
  0x83, 0xF0, 0x03, 0x0E, 0x00, 0x06, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x98,
  0x00, 0x07, 0x30, 0x00, 0x1E, 0x70, 0x00, 0xEC, 0x78, 0x03, 0x98, 0x7F,
  0xFE, 0x38, 0x3F, 0xF0, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x3F, 0x00, 0xE3, 0xFF, 0x83, 0x9C, 0x0F, 0x0E, 0xC0,
  0x0E, 0x3E, 0x00, 0x18, 0xF0, 0x00, 0x33, 0x80, 0x00, 0xEE, 0x00, 0x01,
  0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x06,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xCF, 0x00, 0x07, 0x3E, 0x00, 0x38, 0xEE,
  0x01, 0xC3, 0x9F, 0xFE, 0x0E, 0x1F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x80, 0x1E, 0x07, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x03,
  0x87, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x17, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x8E, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x1E, 0x01,
  0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x3F, 0x03, 0x03, 0xFF, 0x0C, 0x3E, 0x0F,
  0x31, 0xE0, 0x0E, 0xC7, 0x00, 0x1B, 0x38, 0x00, 0x3C, 0xC0, 0x00, 0x77,
  0x00, 0x01, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x80, 0x03, 0xC7, 0x00,
  0x1B, 0x0E, 0x01, 0xEC, 0x1F, 0xFE, 0x30, 0x1F, 0xF0, 0xC0, 0x0C, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x1E, 0x07, 0x80, 0x70, 0x03, 0x81,
  0xC0, 0x03, 0x87, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x1C,
  0x0E, 0x00, 0x70, 0x0F, 0xCF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x18, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC,
  0x30, 0xF8, 0x3C, 0xC3, 0x80, 0x3B, 0x1C, 0x00, 0x7C, 0xE0, 0x00, 0xF3,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x73, 0x00, 0x01, 0xCE, 0x00,
  0x0F, 0x1C, 0x00, 0x6C, 0x38, 0x03, 0xB0, 0x7F, 0xF8, 0xC0, 0x7F, 0xC3,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x40, 0x00, 0xE3, 0x80, 0x07, 0x07, 0x00, 0x38, 0x0F, 0x03,
  0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0xFE, 0x0C, 0x1F, 0xFC, 0x63, 0xC0, 0xF3, 0x38, 0x01, 0xD9, 0x80,
  0x06, 0xD8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x02, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x8C, 0x00,
  0x1C, 0x30, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0x70, 0x0C, 0x03, 0x80,
  0x30, 0x1C, 0x00, 0xC0, 0xE0, 0x03, 0x07, 0x00, 0x0C, 0x38, 0x00, 0x33,
  0xC0, 0x00, 0xDF, 0x80, 0x03, 0xE7, 0x00, 0x0F, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x80,
  0xC0, 0x07, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x38, 0xC0,
  0x00, 0x73, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xC0, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x3E, 0x19,
  0xFF, 0x1F, 0xF3, 0x70, 0xF7, 0x07, 0x78, 0x07, 0x80, 0x6E, 0x00, 0xF0,
  0x0F, 0xC0, 0x1C, 0x00, 0xF8, 0x03, 0x80, 0x1E, 0x00, 0x30, 0x03, 0xC0,
  0x06, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0x00, 0x18, 0x01, 0xE0, 0x03, 0x00,
  0x3C, 0x00, 0x60, 0x07, 0x80, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x1E, 0x00,
  0x30, 0x03, 0xC0, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0x00, 0x18, 0x01,
  0xE0, 0x03, 0x00, 0x3C, 0x00, 0x60, 0x07, 0x80, 0x0C, 0x00, 0xF0, 0x01,
  0x80, 0x1E, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x0F,
  0x00, 0x18, 0x01, 0xE0, 0x03, 0x00, 0x30, 0x00, 0x7E, 0x06, 0x0F, 0xFE,
  0x31, 0xE0, 0x79, 0x9C, 0x00, 0xED, 0xC0, 0x03, 0x6C, 0x00, 0x1F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0x0F, 0xFC, 0x0C, 0xF0, 0x3C,
  0x37, 0x00, 0x78, 0xD8, 0x00, 0x63, 0xC0, 0x01, 0xCE, 0x00, 0x03, 0x38,
  0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x1B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0x3C, 0x00, 0x1C, 0xD8, 0x00,
  0xE3, 0x70, 0x07, 0x0C, 0x7F, 0xF8, 0x30, 0xFF, 0xC0, 0xC0, 0x30, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x30, 0xF8, 0x3C,
  0xC7, 0x80, 0x3B, 0x1C, 0x00, 0x7C, 0xE0, 0x00, 0xF3, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60,
  0x00, 0x0D, 0xC0, 0x00, 0x33, 0x00, 0x01, 0xCE, 0x00, 0x0F, 0x1C, 0x00,
  0x7C, 0x38, 0x03, 0xB0, 0x7E, 0xF8, 0xC0, 0x7F, 0xC3, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xF1, 0xF8, 0x39, 0xC0,
  0x0D, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xF0, 0x3E,
  0x0E, 0x00, 0x1C, 0x30, 0x00, 0x39, 0x80, 0x00, 0x66, 0x00, 0x01, 0xD8,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x70, 0x00,
  0x38, 0xF0, 0x03, 0xC0, 0xFE, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x36, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0xC0, 0x01, 0xE7,
  0x00, 0x1B, 0x1C, 0x03, 0x98, 0x7F, 0xF8, 0xC1, 0xFF, 0x86, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x38,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x60,
  0x00, 0x1C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0xE0, 0x06, 0xE0, 0x0E, 0x00,
  0x66, 0x00, 0xF0, 0x06, 0x60, 0x0B, 0x00, 0x66, 0x01, 0xB0, 0x0C, 0x60,
  0x1B, 0x00, 0xC3, 0x01, 0x98, 0x0C, 0x30, 0x19, 0x80, 0xC3, 0x03, 0x18,
  0x0C, 0x30, 0x31, 0x81, 0x83, 0x83, 0x0C, 0x18, 0x18, 0x30, 0xC1, 0x81,
  0x86, 0x0C, 0x18, 0x18, 0x60, 0xC3, 0x01, 0x86, 0x06, 0x30, 0x0C, 0x60,
  0x63, 0x00, 0xCC, 0x06, 0x30, 0x0C, 0xC0, 0x23, 0x00, 0xCC, 0x03, 0x60,
  0x0C, 0x80, 0x36, 0x00, 0x78, 0x03, 0x60, 0x07, 0x80, 0x16, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0xF0, 0x00, 0x0F, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x81,
  0xC0, 0x01, 0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x00,
  0xC0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x38, 0x30, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x38, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x70, 0x00, 0x70, 0x0C,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x38, 0x60, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0x38, 0xF8, 0x00, 0x66, 0x01, 0xC0, 0x06,
  0xE0, 0x0E, 0x00, 0x6C, 0x00, 0x70, 0x0C, 0xC0, 0x03, 0xC1, 0xCC, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoMono_ExtraLight52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 4, 37, 31, 13, -37 },
  { 20, 9, 11, 31, 11, -39 },
  { 33, 28, 37, 31, 2, -37 },
  { 163, 22, 47, 31, 5, -42 },
  { 293, 29, 39, 31, 1, -38 },
  { 435, 26, 39, 31, 4, -38 },
  { 562, 3, 11, 31, 13, -39 },
  { 567, 12, 53, 31, 10, -41 },
  { 647, 12, 53, 31, 9, -41 },
  { 727, 23, 21, 31, 5, -37 },
  { 788, 25, 27, 31, 3, -31 },
  { 873, 5, 11, 31, 10, -4 },
  { 880, 19, 2, 31, 6, -18 },
  { 885, 4, 4, 31, 14, -4 },
  { 887, 18, 40, 31, 7, -37 },
  { 977, 23, 39, 31, 4, -38 },
  { 1090, 12, 37, 31, 6, -37 },
  { 1146, 23, 37, 31, 3, -37 },
  { 1253, 23, 38, 31, 3, -37 },
  { 1363, 26, 37, 31, 2, -37 },
  { 1484, 21, 38, 31, 6, -37 },
  { 1584, 23, 38, 31, 4, -37 },
  { 1694, 24, 37, 31, 3, -37 },
  { 1805, 24, 38, 31, 4, -37 },
  { 1919, 23, 37, 31, 4, -37 },
  { 2026, 4, 26, 31, 16, -26 },
  { 2039, 6, 33, 31, 14, -26 },
  { 2064, 22, 21, 31, 4, -27 },
  { 2122, 23, 12, 31, 4, -23 },
  { 2157, 22, 21, 31, 5, -27 },
  { 2215, 20, 37, 31, 6, -37 },
  { 2308, 29, 37, 31, 1, -37 },
  { 2443, 26, 37, 31, 3, -37 },
  { 2564, 23, 37, 31, 5, -37 },
  { 2671, 25, 39, 31, 3, -38 },
  { 2793, 23, 37, 31, 5, -37 },
  { 2900, 22, 37, 31, 5, -37 },
  { 3002, 21, 37, 31, 6, -37 },
  { 3100, 25, 38, 31, 3, -37 },
  { 3219, 23, 37, 31, 4, -37 },
  { 3326, 21, 37, 31, 5, -37 },
  { 3424, 23, 38, 31, 3, -37 },
  { 3534, 25, 37, 31, 5, -37 },
  { 3650, 21, 37, 31, 6, -37 },
  { 3748, 23, 37, 31, 4, -37 },
  { 3855, 23, 37, 31, 4, -37 },
  { 3962, 25, 38, 31, 3, -37 },
  { 4081, 23, 37, 31, 6, -37 },
  { 4188, 26, 44, 31, 3, -37 },
  { 4331, 23, 37, 31, 5, -37 },
  { 4438, 24, 38, 31, 4, -37 },
  { 4552, 26, 37, 31, 3, -37 },
  { 4673, 23, 38, 31, 4, -37 },
  { 4783, 27, 37, 31, 2, -37 },
  { 4908, 28, 37, 31, 2, -37 },
  { 5038, 26, 37, 31, 3, -37 },
  { 5159, 26, 37, 31, 2, -37 },
  { 5280, 24, 37, 31, 3, -37 },
  { 5391, 8, 50, 31, 12, -42 },
  { 5441, 17, 40, 31, 7, -37 },
  { 5526, 8, 50, 31, 11, -42 },
  { 5576, 19, 20, 31, 6, -37 },
  { 5624, 22, 2, 31, 5, 0 },
  { 5630, 7, 6, 31, 12, -38 },
  { 5636, 23, 29, 31, 4, -28 },
  { 5720, 22, 40, 31, 5, -39 },
  { 5830, 23, 29, 31, 4, -28 },
  { 5914, 22, 40, 31, 4, -39 },
  { 6024, 23, 29, 31, 4, -28 },
  { 6108, 23, 40, 31, 5, -40 },
  { 6223, 22, 39, 31, 4, -28 },
  { 6331, 21, 39, 31, 5, -39 },
  { 6434, 22, 37, 31, 6, -37 },
  { 6536, 16, 48, 31, 5, -37 },
  { 6632, 22, 39, 31, 6, -39 },
  { 6740, 22, 39, 31, 6, -39 },
  { 6848, 27, 28, 31, 2, -28 },
  { 6943, 21, 28, 31, 5, -28 },
  { 7017, 25, 29, 31, 3, -28 },
  { 7108, 22, 39, 31, 5, -28 },
  { 7216, 22, 39, 31, 4, -28 },
  { 7324, 17, 28, 31, 10, -28 },
  { 7384, 22, 29, 31, 5, -28 },
  { 7464, 21, 36, 31, 5, -35 },
  { 7559, 21, 28, 31, 5, -27 },
  { 7633, 25, 27, 31, 3, -27 },
  { 7718, 28, 27, 31, 2, -27 },
  { 7813, 24, 27, 31, 4, -27 },
  { 7894, 27, 38, 31, 2, -27 },
  { 8023, 24, 27, 31, 4, -27 },
  { 8104, 17, 52, 31, 8, -41 },
  { 8215, 2, 45, 31, 15, -37 },
  { 8227, 17, 52, 31, 8, -41 },
  { 8338, 28, 9, 31, 2, -20 },
};

const GFXfont RobotoMono_ExtraLight52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight52pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_EXTRALIGHT52PT7B_H_
