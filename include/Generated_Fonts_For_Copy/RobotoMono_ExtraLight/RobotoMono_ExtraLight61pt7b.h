#ifndef _ROBOTOMONO_EXTRALIGHT61PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight61pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8,
  0x1B, 0x03, 0x60, 0x6C, 0x0C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x38, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xF3, 0xF8, 0x03, 0xC0, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0xF0,
  0x3E, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x10, 0x06, 0x00, 0xE0, 0x06, 0x03, 0x80,
  0x18, 0x03, 0x80, 0xE0, 0x06, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x70, 0x0E,
  0x00, 0x60, 0x18, 0x03, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0x06, 0x07, 0x00,
  0x18, 0x03, 0x81, 0x80, 0x06, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0x30, 0x30,
  0x00, 0x38, 0x1C, 0x1C, 0x00, 0x07, 0x1E, 0x06, 0x00, 0x00, 0xFF, 0x03,
  0x80, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x3F, 0x00, 0x00, 0x30, 0x3F, 0xE0,
  0x00, 0x1C, 0x1C, 0x1C, 0x00, 0x06, 0x06, 0x03, 0x80, 0x03, 0x83, 0x80,
  0x60, 0x00, 0xC0, 0xC0, 0x1C, 0x00, 0x70, 0x30, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x0C, 0x01, 0x80,
  0x70, 0x03, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x1C,
  0x00, 0xC0, 0x0C, 0x02, 0x00, 0x38, 0x07, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x70, 0x0E,
  0x00, 0x71, 0xC0, 0x0E, 0x00, 0xE3, 0x00, 0x0E, 0x01, 0x8E, 0x00, 0x1C,
  0x03, 0x1C, 0x00, 0x1C, 0x0E, 0x30, 0x00, 0x1C, 0x1C, 0xE0, 0x00, 0x1C,
  0x31, 0xC0, 0x00, 0x1C, 0xE3, 0x80, 0x00, 0x39, 0xC3, 0x00, 0x00, 0x3F,
  0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x1E, 0x70, 0x1F, 0x00, 0xF8, 0x70,
  0x1F, 0xFF, 0xC0, 0x70, 0x0F, 0xFE, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x0C, 0x00,
  0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x02, 0x00, 0x30, 0x01, 0xF0, 0x0C, 0x03, 0xFF, 0x03, 0x03, 0xF3, 0xF8,
  0xC7, 0xF0, 0x1F, 0xF7, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x30, 0x04, 0x00, 0x08, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x18, 0xC6, 0x31, 0x9C,
  0xE7, 0x33, 0x9D, 0xC4, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF7, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC7,
  0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x0F, 0xB8, 0x00, 0x03, 0xBF, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x38,
  0xFC, 0x00, 0x0E, 0x1F, 0x80, 0x03, 0x83, 0xF0, 0x00, 0xE0, 0x7E, 0x00,
  0x38, 0x0F, 0xC0, 0x0E, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0xE0, 0x07,
  0xE0, 0x38, 0x00, 0xFC, 0x0E, 0x00, 0x1F, 0x83, 0x80, 0x03, 0xF0, 0xE0,
  0x00, 0x7E, 0x38, 0x00, 0x0F, 0xCE, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x06, 0xF8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x7C, 0x03, 0xF8, 0x3F, 0x71, 0xF8, 0xEF, 0x81, 0xFC, 0x03,
  0xE0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xC7, 0xF0, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x0F,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC6, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x10, 0x00, 0x71, 0xFF,
  0xC0, 0x3B, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0x00, 0x0F, 0x87, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0xE0, 0xFF, 0xE0, 0x38, 0xFF, 0xFC,
  0x0E, 0x7C, 0x07, 0xC3, 0x38, 0x00, 0x78, 0xDC, 0x00, 0x0F, 0x3E, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0x70,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x78,
  0x01, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x80,
  0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x3F, 0x80,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x98, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x1B, 0x3C, 0x00, 0x0E, 0xC7,
  0x80, 0x07, 0x30, 0xF0, 0x07, 0x8C, 0x1F, 0xDF, 0xC7, 0x01, 0xFF, 0xC1,
  0xC0, 0x1F, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x1E, 0x7C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE3, 0x8E,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0x9F, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x03,
  0x8F, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x30, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x38, 0x03, 0x06, 0x00,
  0xFF, 0x01, 0xC7, 0x00, 0xFB, 0xC0, 0x63, 0x00, 0xE0, 0x70, 0x31, 0x80,
  0xE0, 0x10, 0x19, 0x80, 0x60, 0x18, 0x0C, 0xC0, 0x60, 0x0C, 0x03, 0x60,
  0x30, 0x06, 0x01, 0xF0, 0x30, 0x03, 0x00, 0xF0, 0x18, 0x01, 0x80, 0x78,
  0x0C, 0x00, 0xC0, 0x3C, 0x06, 0x00, 0x60, 0x1E, 0x07, 0x00, 0x30, 0x0F,
  0x03, 0x00, 0x18, 0x07, 0x81, 0x80, 0x08, 0x03, 0xC0, 0xC0, 0x0C, 0x03,
  0xE0, 0x60, 0x06, 0x01, 0xB0, 0x30, 0x03, 0x00, 0xD8, 0x18, 0x03, 0x80,
  0x6C, 0x0C, 0x01, 0xC0, 0x36, 0x07, 0x00, 0xE0, 0x33, 0x01, 0x80, 0xF0,
  0x19, 0xC0, 0xC0, 0xCC, 0x1C, 0x60, 0x70, 0xE6, 0x1C, 0x30, 0x1F, 0xE3,
  0xFC, 0x18, 0x07, 0xE0, 0xFC, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x01, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x03, 0x80, 0x07, 0xE0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF0, 0xE0, 0x01, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x70,
  0x00, 0x78, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0x00,
  0x0F, 0x80, 0x60, 0x00, 0x7C, 0x0C, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x3C,
  0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38,
  0x30, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x80, 0xC0, 0x0F, 0xE0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0,
  0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x70, 0x0F, 0x80, 0x78, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x3F, 0x00, 0x00, 0x73, 0xBC,
  0x00, 0x03, 0xB8, 0xE0, 0x00, 0x1F, 0x83, 0x80, 0x00, 0xF8, 0x0E, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x37, 0xF8, 0x00, 0x0E, 0xFB, 0x00, 0x01, 0x9F, 0x70, 0x00, 0x73,
  0xEE, 0x00, 0x0E, 0x7C, 0xC0, 0x01, 0x8F, 0x9C, 0x00, 0x71, 0xF1, 0x80,
  0x0C, 0x3E, 0x38, 0x03, 0x87, 0xC7, 0x00, 0x70, 0xF8, 0x60, 0x0C, 0x1F,
  0x0E, 0x03, 0x83, 0xE1, 0xC0, 0x60, 0x7C, 0x18, 0x1C, 0x0F, 0x83, 0x83,
  0x81, 0xF0, 0x30, 0x60, 0x3E, 0x06, 0x1C, 0x07, 0xC0, 0xE3, 0x01, 0xF8,
  0x0C, 0xE0, 0x3F, 0x01, 0xDC, 0x07, 0xE0, 0x3B, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x78, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFB, 0x00, 0x00, 0x3F, 0x70,
  0x00, 0x07, 0xE7, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0x1F, 0x8E, 0x00, 0x03,
  0xF0, 0xC0, 0x00, 0x7E, 0x1C, 0x00, 0x0F, 0xC1, 0x80, 0x01, 0xF8, 0x38,
  0x00, 0x3F, 0x03, 0x00, 0x07, 0xE0, 0x70, 0x00, 0xFC, 0x07, 0x00, 0x1F,
  0x80, 0xE0, 0x03, 0xF0, 0x0E, 0x00, 0x7E, 0x00, 0xC0, 0x0F, 0xC0, 0x1C,
  0x01, 0xF8, 0x01, 0x80, 0x3F, 0x00, 0x38, 0x07, 0xE0, 0x03, 0x00, 0xFC,
  0x00, 0x70, 0x1F, 0x80, 0x07, 0x03, 0xF0, 0x00, 0xE0, 0x7E, 0x00, 0x0E,
  0x0F, 0xC0, 0x00, 0xC1, 0xF8, 0x00, 0x1C, 0x3F, 0x00, 0x01, 0x87, 0xE0,
  0x00, 0x38, 0xFC, 0x00, 0x03, 0x1F, 0x80, 0x00, 0x73, 0xF0, 0x00, 0x07,
  0x7E, 0x00, 0x00, 0xEF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0x00, 0x01, 0xF0, 0x60, 0x00, 0x0F, 0x0C, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x03, 0xCC, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x7C, 0x30,
  0x00, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xF8,
  0x03, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x02, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0xE0,
  0x70, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0x3F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0,
  0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xC0, 0x06, 0xE0, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x07,
  0xC0, 0x06, 0x60, 0x07, 0xE0, 0x0E, 0x60, 0x06, 0xE0, 0x0E, 0x70, 0x06,
  0x60, 0x0E, 0x70, 0x06, 0x60, 0x0C, 0x70, 0x0E, 0x60, 0x0C, 0x30, 0x0E,
  0x70, 0x0C, 0x30, 0x0C, 0x70, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x38, 0x0C,
  0x30, 0x1C, 0x38, 0x1C, 0x30, 0x18, 0x38, 0x1C, 0x38, 0x18, 0x18, 0x18,
  0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x18, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x1C, 0x30, 0x1C, 0x30,
  0x1C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70,
  0x0C, 0x30, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0x70, 0x0E, 0x60,
  0x06, 0x60, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0x60, 0x06, 0xE0,
  0x07, 0x60, 0x06, 0xC0, 0x07, 0xE0, 0x06, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x38, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x7F, 0xFF, 0xE0, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0x80, 0x00,
  0xCE, 0x00, 0x0E, 0x30, 0x00, 0x71, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x30,
  0x01, 0x81, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70,
  0x07, 0x03, 0x00, 0x38, 0x38, 0x00, 0xC1, 0x80, 0x07, 0x1C, 0x00, 0x18,
  0xE0, 0x00, 0xE6, 0x00, 0x07, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x07, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC1, 0xF8, 0x00, 0x38, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x38, 0x00,
  0x03, 0xE7, 0x00, 0x01, 0xDC, 0x70, 0x00, 0x73, 0x87, 0x80, 0x3C, 0x70,
  0x7F, 0xFF, 0x0E, 0x03, 0xFF, 0x80, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x0F, 0xC0, 0x0E, 0x1F, 0xFE, 0x03, 0x8F,
  0xFF, 0xC0, 0xE7, 0x00, 0x78, 0x3B, 0x80, 0x07, 0x0F, 0x80, 0x00, 0xE3,
  0xE0, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0x3E,
  0x00, 0x07, 0x8E, 0xE0, 0x03, 0xC3, 0x9E, 0x03, 0xE0, 0xE3, 0xFF, 0xF0,
  0x38, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x18, 0x70,
  0x00, 0x0E, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x03, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x01, 0xF8, 0x0C, 0x07, 0xFF, 0x06, 0x07, 0xFF, 0xE3,
  0x0F, 0x80, 0x79, 0x87, 0x00, 0x0E, 0xC7, 0x00, 0x03, 0xE7, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xC3, 0x80, 0x07,
  0x60, 0xF0, 0x0F, 0x30, 0x3F, 0xFF, 0x18, 0x07, 0xFE, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xC0, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x40,
  0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xE0, 0xC0, 0xFF, 0xFC, 0x60, 0xF0, 0x0F, 0x30,
  0xE0, 0x01, 0xD8, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x03, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0xF8, 0x70, 0x00, 0xEC, 0x1E, 0x01, 0xE6,
  0x07, 0xFF, 0xE3, 0x00, 0xFF, 0xC1, 0x80, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x20, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x03, 0xC0,
  0x0F, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0xFC, 0x03, 0x81, 0xFF, 0xC1, 0xC3, 0xFF,
  0xF0, 0xE3, 0x80, 0x3C, 0x73, 0x80, 0x07, 0x3B, 0x00, 0x01, 0xDF, 0x00,
  0x00, 0xEF, 0x80, 0x00, 0x37, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x30, 0x7E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x78, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80,
  0x07, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x03,
  0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x3F, 0xB8, 0x00, 0x0F, 0xC7,
  0x00, 0x03, 0xE0, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x0E,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00,
  0x0F, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC1, 0x8F, 0xF8, 0x3F, 0xE3, 0x7F,
  0xF8, 0xFF, 0xE6, 0xC0, 0x7B, 0x80, 0xEF, 0x00, 0x7C, 0x01, 0xDC, 0x00,
  0x78, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x1E,
  0x00, 0x18, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x78, 0x00, 0x60, 0x00, 0xF0,
  0x00, 0xC0, 0x01, 0xE0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1F, 0x80, 0x70, 0x3F, 0xF8, 0x38, 0x7F, 0xFE, 0x1C, 0x70, 0x07, 0x8E,
  0x70, 0x00, 0xE7, 0x60, 0x00, 0x7B, 0xE0, 0x00, 0x1D, 0xF0, 0x00, 0x06,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x38, 0x7F, 0xF0, 0x0E, 0x3F, 0xFF, 0x03, 0xBC, 0x01, 0xE0,
  0xEC, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x38, 0xF8, 0x00, 0x1C, 0x3F, 0x00, 0x0F,
  0x0E, 0xF0, 0x0F, 0x83, 0x8F, 0xFF, 0xC0, 0xE0, 0xFF, 0xC0, 0x38, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0xC1, 0xFF, 0xFC, 0x61,
  0xF0, 0x0F, 0x30, 0xE0, 0x01, 0xD8, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x1E,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0xF8, 0x70, 0x00, 0xEC,
  0x1E, 0x01, 0xE6, 0x07, 0xFF, 0xE3, 0x00, 0xFF, 0xC1, 0x80, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x07, 0xF7, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xC0, 0x0E, 0x78, 0x00,
  0x77, 0x00, 0x03, 0xB0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xE7, 0x00,
  0x03, 0xF3, 0xC0, 0x03, 0xB8, 0xF8, 0x07, 0x9C, 0x3F, 0xFF, 0x8E, 0x07,
  0xFF, 0x07, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x70, 0x01, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00,
  0xE0, 0x01, 0xD8, 0x00, 0x70, 0x00, 0xCC, 0x00, 0x3C, 0x00, 0x67, 0x00,
  0x36, 0x00, 0x73, 0x80, 0x1B, 0x00, 0x38, 0xC0, 0x0D, 0x80, 0x18, 0x60,
  0x06, 0xE0, 0x0C, 0x38, 0x07, 0x70, 0x06, 0x1C, 0x03, 0x18, 0x07, 0x0E,
  0x01, 0x8C, 0x03, 0x83, 0x00, 0xC7, 0x01, 0x81, 0x80, 0xE3, 0x80, 0xC0,
  0xE0, 0x60, 0xC0, 0x60, 0x70, 0x30, 0x60, 0x70, 0x18, 0x18, 0x38, 0x30,
  0x0C, 0x1C, 0x1C, 0x18, 0x06, 0x0C, 0x06, 0x0C, 0x03, 0x86, 0x03, 0x0E,
  0x00, 0xC3, 0x01, 0xC7, 0x00, 0x63, 0x00, 0x63, 0x00, 0x31, 0x80, 0x31,
  0x80, 0x1C, 0xC0, 0x18, 0xC0, 0x0E, 0x60, 0x0C, 0xE0, 0x03, 0x60, 0x03,
  0x60, 0x01, 0xB0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0x6C, 0x00,
  0x6C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x78, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x38,
  0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x11, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x20, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xCF, 0x0F, 0x80, 0x00, 0xCE, 0x01, 0xF0, 0x00, 0x67, 0x00, 0x3C,
  0x00, 0x73, 0x00, 0x0F, 0x00, 0x3B, 0x80, 0x03, 0xC0, 0x39, 0x80, 0x00,
  0xFC, 0x78, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph RobotoMono_ExtraLight61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 4, 43, 37, 16, -43 },
  { 23, 11, 13, 37, 13, -46 },
  { 41, 33, 43, 37, 2, -43 },
  { 219, 26, 56, 37, 6, -50 },
  { 401, 34, 45, 37, 1, -44 },
  { 593, 31, 45, 37, 4, -44 },
  { 768, 2, 13, 37, 16, -46 },
  { 772, 13, 62, 37, 12, -48 },
  { 873, 13, 62, 37, 11, -48 },
  { 974, 26, 25, 37, 6, -43 },
  { 1056, 29, 32, 37, 4, -36 },
  { 1172, 5, 13, 37, 12, -5 },
  { 1181, 22, 3, 37, 7, -21 },
  { 1190, 5, 4, 37, 17, -4 },
  { 1193, 20, 47, 37, 9, -43 },
  { 1311, 27, 45, 37, 5, -44 },
  { 1463, 15, 43, 37, 7, -43 },
  { 1544, 28, 44, 37, 3, -44 },
  { 1698, 27, 45, 37, 3, -44 },
  { 1850, 30, 43, 37, 3, -43 },
  { 2012, 25, 44, 37, 7, -43 },
  { 2150, 26, 45, 37, 5, -44 },
  { 2297, 28, 43, 37, 4, -43 },
  { 2448, 28, 45, 37, 5, -44 },
  { 2606, 26, 44, 37, 5, -44 },
  { 2749, 4, 30, 37, 19, -30 },
  { 2764, 7, 38, 37, 16, -30 },
  { 2798, 26, 25, 37, 5, -32 },
  { 2880, 27, 15, 37, 5, -27 },
  { 2931, 25, 25, 37, 6, -32 },
  { 3010, 23, 44, 37, 7, -44 },
  { 3137, 33, 44, 37, 2, -44 },
  { 3319, 31, 43, 37, 3, -43 },
  { 3486, 27, 43, 37, 6, -43 },
  { 3632, 29, 45, 37, 4, -44 },
  { 3796, 27, 43, 37, 6, -43 },
  { 3942, 25, 43, 37, 6, -43 },
  { 4077, 25, 43, 37, 7, -43 },
  { 4212, 28, 45, 37, 4, -44 },
  { 4370, 27, 43, 37, 5, -43 },
  { 4516, 25, 43, 37, 6, -43 },
  { 4651, 26, 44, 37, 4, -43 },
  { 4794, 29, 43, 37, 6, -43 },
  { 4950, 25, 43, 37, 7, -43 },
  { 5085, 27, 43, 37, 5, -43 },
  { 5231, 27, 43, 37, 5, -43 },
  { 5377, 29, 45, 37, 4, -44 },
  { 5541, 27, 43, 37, 7, -43 },
  { 5687, 30, 52, 37, 3, -44 },
  { 5882, 27, 43, 37, 6, -43 },
  { 6028, 29, 45, 37, 4, -44 },
  { 6192, 31, 43, 37, 3, -43 },
  { 6359, 27, 44, 37, 5, -43 },
  { 6508, 30, 43, 37, 3, -43 },
  { 6670, 32, 43, 37, 3, -43 },
  { 6842, 30, 43, 37, 4, -43 },
  { 7004, 31, 43, 37, 2, -43 },
  { 7171, 27, 43, 37, 4, -43 },
  { 7317, 9, 59, 37, 14, -50 },
  { 7384, 21, 47, 37, 8, -43 },
  { 7508, 10, 59, 37, 13, -50 },
  { 7582, 21, 23, 37, 8, -43 },
  { 7643, 26, 2, 37, 5, 0 },
  { 7650, 9, 8, 37, 14, -45 },
  { 7659, 27, 34, 37, 5, -33 },
  { 7774, 26, 47, 37, 6, -46 },
  { 7927, 26, 34, 37, 5, -33 },
  { 8038, 25, 47, 37, 5, -46 },
  { 8185, 27, 34, 37, 5, -33 },
  { 8300, 27, 47, 37, 6, -47 },
  { 8459, 25, 46, 37, 5, -33 },
  { 8603, 25, 46, 37, 6, -46 },
  { 8747, 25, 44, 37, 7, -44 },
  { 8885, 19, 57, 37, 6, -44 },
  { 9021, 26, 46, 37, 7, -46 },
  { 9171, 25, 46, 37, 7, -46 },
  { 9315, 31, 33, 37, 3, -33 },
  { 9443, 25, 33, 37, 6, -33 },
  { 9547, 29, 34, 37, 4, -33 },
  { 9671, 26, 45, 37, 6, -33 },
  { 9818, 25, 45, 37, 5, -33 },
  { 9959, 21, 33, 37, 11, -33 },
  { 10046, 26, 34, 37, 6, -33 },
  { 10157, 26, 42, 37, 5, -41 },
  { 10294, 25, 33, 37, 6, -32 },
  { 10398, 30, 32, 37, 3, -32 },
  { 10518, 33, 32, 37, 2, -32 },
  { 10650, 29, 32, 37, 4, -32 },
  { 10766, 32, 45, 37, 2, -32 },
  { 10946, 29, 32, 37, 4, -32 },
  { 11062, 20, 61, 37, 10, -48 },
  { 11215, 2, 52, 37, 17, -43 },
  { 11228, 20, 61, 37, 10, -48 },
  { 11381, 33, 10, 37, 2, -23 },
};

const GFXfont RobotoMono_ExtraLight61pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight61pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight61pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOMONO_EXTRALIGHT61PT7B_H_
