#ifndef _ROBOTOMONO_EXTRALIGHT60PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight60pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x7F, 0xDC, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0,
  0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x3E, 0x06, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x38, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0x1C, 0x00,
  0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x10, 0x0E, 0x00, 0xE0,
  0x0E, 0x03, 0x80, 0x38, 0x03, 0x00, 0xE0, 0x06, 0x01, 0x80, 0x38, 0x01,
  0x80, 0xE0, 0x0E, 0x00, 0x60, 0x30, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0,
  0x0E, 0x06, 0x00, 0x18, 0x03, 0x03, 0x80, 0x06, 0x00, 0xC0, 0xC0, 0x01,
  0xC0, 0x70, 0x70, 0x00, 0x38, 0x38, 0x18, 0x00, 0x07, 0xFC, 0x0C, 0x00,
  0x00, 0xFE, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x00, 0xC0, 0xFF, 0x80, 0x00,
  0x70, 0x78, 0xF0, 0x00, 0x18, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x03, 0x80,
  0x03, 0x03, 0x00, 0x60, 0x01, 0x81, 0xC0, 0x18, 0x00, 0xE0, 0x60, 0x07,
  0x00, 0x30, 0x18, 0x01, 0xC0, 0x1C, 0x06, 0x00, 0x70, 0x06, 0x01, 0x80,
  0x1C, 0x03, 0x80, 0x60, 0x07, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x07,
  0x00, 0x60, 0x08, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x03, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x18, 0x38, 0x0E, 0x00, 0x30, 0xE0, 0x0E, 0x00, 0xE1,
  0x80, 0x0E, 0x01, 0xC7, 0x00, 0x0E, 0x03, 0x8C, 0x00, 0x0E, 0x07, 0x18,
  0x00, 0x1E, 0x0C, 0x70, 0x00, 0x1C, 0x38, 0xE0, 0x00, 0x1C, 0x71, 0xC0,
  0x00, 0x1D, 0xC1, 0x80, 0x00, 0x1F, 0x83, 0x00, 0x00, 0x3E, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x03, 0xF8, 0x0E, 0x00,
  0x0F, 0x38, 0x0F, 0x00, 0x78, 0x78, 0x0F, 0xFF, 0xE0, 0x70, 0x07, 0xFF,
  0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x6F, 0xFE, 0x00,
  0x08, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x04, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x01, 0xBE, 0x03,
  0x01, 0xFF, 0xE0, 0xC3, 0xF8, 0x7F, 0x33, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x38, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x04,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x33, 0x99, 0xC4, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xDF, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x70, 0xF0, 0x00,
  0x38, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x00, 0xF0,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00,
  0xF0, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x8E, 0x00, 0x03, 0xE7, 0x00,
  0x00, 0xFB, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x0F, 0xCC, 0xFC,
  0x3F, 0x80, 0xF8, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0x03, 0xE0, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x0F,
  0x80, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x7F, 0x80, 0x0E, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0x80, 0xF8, 0x01, 0xF0,
  0x38, 0x00, 0x3E, 0x04, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x03, 0x98, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0xE1, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0xFE, 0x00, 0xE1, 0xFF,
  0xE0, 0x39, 0xF8, 0x7E, 0x0C, 0xF0, 0x03, 0xC3, 0x70, 0x00, 0x78, 0xF8,
  0x00, 0x0E, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x70, 0x07, 0x80, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x81, 0xF0, 0x07, 0x80,
  0x0F, 0x01, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x38, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x60, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x3F, 0x1C,
  0x00, 0x1D, 0xC3, 0x80, 0x1E, 0x70, 0x7C, 0x1F, 0x18, 0x0F, 0xFF, 0x06,
  0x00, 0xFF, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xB8, 0x1C, 0x7C, 0xF8, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1C,
  0x38, 0x71, 0xC3, 0x8E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3E, 0x0F, 0x81, 0xE0, 0x03, 0x83,
  0x80, 0x03, 0x8E, 0x00, 0x03, 0x98, 0x00, 0x07, 0x70, 0x00, 0x06, 0xE0,
  0x00, 0x0D, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x01, 0xF8, 0x06, 0x38, 0x07, 0xFC, 0x06,
  0x30, 0x0F, 0x0E, 0x07, 0x30, 0x1C, 0x06, 0x03, 0x70, 0x18, 0x06, 0x03,
  0x60, 0x30, 0x06, 0x03, 0x60, 0x30, 0x06, 0x03, 0x60, 0x60, 0x06, 0x03,
  0xC0, 0x60, 0x06, 0x03, 0xC0, 0x60, 0x06, 0x03, 0xC0, 0xE0, 0x0C, 0x03,
  0xC0, 0xC0, 0x0C, 0x03, 0xC0, 0xC0, 0x0C, 0x03, 0xC0, 0xC0, 0x0C, 0x03,
  0xC0, 0xC0, 0x0C, 0x03, 0xC0, 0xC0, 0x0C, 0x03, 0xC0, 0xC0, 0x0C, 0x03,
  0xC0, 0xC0, 0x1C, 0x03, 0xC0, 0xC0, 0x1C, 0x06, 0xC0, 0xC0, 0x3C, 0x06,
  0xC0, 0xE0, 0x3C, 0x06, 0xC0, 0x60, 0x6C, 0x0C, 0xE0, 0x70, 0xCE, 0x1C,
  0x60, 0x3F, 0xC7, 0xF8, 0x60, 0x1F, 0x03, 0xF0, 0x70, 0x04, 0x00, 0x80,
  0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x38, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x38, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0x3C, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x38, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0x38, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x07, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0E, 0x00, 0x0F, 0x83, 0x80, 0x00,
  0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0xF8, 0xE0, 0x01, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x03,
  0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x60,
  0x00, 0xF0, 0x0C, 0x00, 0x07, 0x81, 0x80, 0x00, 0x78, 0x30, 0x00, 0x07,
  0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x1E,
  0x06, 0x00, 0x0F, 0x80, 0xC0, 0x0F, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0x73, 0xB8, 0x00,
  0x03, 0xB8, 0xE0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0xFC, 0x1C, 0x00, 0x07,
  0xC0, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xBF, 0x60, 0x00, 0x77, 0xEE, 0x00, 0x0C, 0xFD, 0xC0, 0x03, 0x9F,
  0x98, 0x00, 0x73, 0xF3, 0x80, 0x0C, 0x7E, 0x30, 0x03, 0x8F, 0xC6, 0x00,
  0x61, 0xF8, 0xE0, 0x1C, 0x3F, 0x0C, 0x03, 0x87, 0xE1, 0xC0, 0x60, 0xFC,
  0x38, 0x1C, 0x1F, 0x83, 0x03, 0x03, 0xF0, 0x70, 0xE0, 0x7E, 0x06, 0x1C,
  0x0F, 0xC0, 0xC3, 0x01, 0xF8, 0x1C, 0xE0, 0x3F, 0x01, 0x98, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x78, 0x03, 0xF0, 0x0F, 0x00,
  0x7E, 0x00, 0xC0, 0x0F, 0xC0, 0x18, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x0F, 0x30, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x3C, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC1, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x3C, 0x0C, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0x60, 0x00, 0xF0,
  0x1C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00,
  0xF0, 0x03, 0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x18, 0x03, 0xE0, 0x07,
  0x00, 0xF8, 0x00, 0xC0, 0x3E, 0x00, 0x38, 0x0F, 0x80, 0x07, 0x03, 0xE0,
  0x01, 0xC0, 0xF8, 0x00, 0x38, 0x3E, 0x00, 0x06, 0x0F, 0x80, 0x01, 0xC3,
  0xE0, 0x00, 0x30, 0xF8, 0x00, 0x0E, 0x3E, 0x00, 0x01, 0xCF, 0x80, 0x00,
  0x73, 0xE0, 0x00, 0x0E, 0xF8, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0x00, 0x01, 0xF0, 0xC0,
  0x00, 0x1E, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x8C, 0x00, 0x0F,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x07,
  0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x30, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x06, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x70, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0xB0, 0x03, 0x60, 0x06,
  0x60, 0x06, 0xC0, 0x0C, 0xC0, 0x0D, 0xC0, 0x19, 0xC0, 0x3B, 0x80, 0x33,
  0x80, 0x73, 0x00, 0xE7, 0x00, 0xC6, 0x01, 0xC6, 0x01, 0x8C, 0x03, 0x0C,
  0x03, 0x18, 0x06, 0x18, 0x06, 0x38, 0x0C, 0x30, 0x1C, 0x30, 0x18, 0x70,
  0x30, 0x60, 0x30, 0xE0, 0x60, 0xC0, 0xE0, 0xC0, 0xC1, 0x81, 0xC1, 0x81,
  0x83, 0x83, 0x03, 0x07, 0x07, 0x06, 0x06, 0x0C, 0x06, 0x0C, 0x0E, 0x18,
  0x0C, 0x18, 0x1C, 0x30, 0x18, 0x30, 0x38, 0x60, 0x38, 0xE0, 0x31, 0xC0,
  0x71, 0xC0, 0x63, 0x80, 0x63, 0x00, 0xC6, 0x00, 0xC6, 0x01, 0x8C, 0x01,
  0x8C, 0x03, 0x98, 0x03, 0x98, 0x07, 0x70, 0x07, 0x30, 0x0E, 0xE0, 0x06,
  0xE0, 0x0D, 0x80, 0x0D, 0x80, 0x1B, 0x00, 0x1B, 0x00, 0x36, 0x00, 0x36,
  0x00, 0x6C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF0,
  0x01, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x01,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80,
  0x01, 0x86, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x30, 0x01, 0xC0, 0xE0, 0x06,
  0x01, 0x80, 0x18, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x30, 0x1C, 0x00,
  0xE0, 0x60, 0x01, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x31,
  0xC0, 0x00, 0xE6, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x78, 0x00, 0x78,
  0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0x01, 0x87, 0x80, 0x00, 0x63, 0x80, 0x00,
  0x19, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xE6,
  0x00, 0x00, 0xF9, 0xC0, 0x00, 0x76, 0x38, 0x00, 0x39, 0x8F, 0x80, 0x7C,
  0x70, 0xFF, 0xFC, 0x1C, 0x1F, 0xFC, 0x07, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x07, 0xFC, 0x03, 0x8F, 0xFF, 0x81, 0xCF, 0x03,
  0xE0, 0xEE, 0x00, 0x78, 0x7E, 0x00, 0x0E, 0x3E, 0x00, 0x03, 0x9E, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0D, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x39, 0xE0, 0x00, 0x1C, 0xF8, 0x00, 0x1C, 0x7E, 0x00, 0x1C, 0x3B, 0xC0,
  0x3E, 0x1C, 0x7F, 0xFC, 0x0E, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0x98, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x0F,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x07, 0xFC, 0x1C, 0x0F, 0xFF, 0x8E, 0x0F, 0x81,
  0xE7, 0x0F, 0x00, 0x3B, 0x8E, 0x00, 0x0F, 0xCE, 0x00, 0x03, 0xE7, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x87, 0x00, 0x0F, 0xC1, 0xE0,
  0x1E, 0xE0, 0x7F, 0xFC, 0x70, 0x1F, 0xFC, 0x38, 0x00, 0x40, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3C, 0x07, 0xC0, 0x3C, 0x00, 0x78,
  0x0E, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x01, 0xF0, 0x07,
  0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x83, 0x81, 0xFF, 0xF1, 0xC1, 0xF0, 0x3C, 0xE1, 0xE0, 0x07, 0x71,
  0xC0, 0x01, 0xF9, 0xC0, 0x00, 0x7C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xE3,
  0x80, 0x01, 0xF0, 0xE0, 0x01, 0xF8, 0x3C, 0x03, 0xDC, 0x0F, 0xFF, 0x8E,
  0x03, 0xFF, 0x87, 0x00, 0x08, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x40, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x01, 0xFE, 0x03, 0x87, 0xFF, 0xC1, 0xC7, 0x80, 0xF0, 0xE7, 0x00,
  0x1C, 0x77, 0x00, 0x07, 0x3F, 0x00, 0x03, 0x9F, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x05, 0xFC, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x78, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0xF0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0xF0, 0x00,
  0xE0, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xF8, 0x00,
  0x0E, 0xFE, 0x00, 0x07, 0xE7, 0x80, 0x03, 0xE1, 0xC0, 0x01, 0xE0, 0x70,
  0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xF0, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x78, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC7, 0xF8, 0x0F, 0xE3, 0x3F, 0xF0, 0xFF, 0xCD, 0xC1,
  0xE7, 0x07, 0xBC, 0x03, 0xB0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1E,
  0x00, 0x3E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x7F, 0xC0, 0xC1, 0xFF, 0xF0, 0xC3, 0xC0, 0xF8,
  0xC7, 0x00, 0x1C, 0xCE, 0x00, 0x0E, 0xDC, 0x00, 0x0E, 0xD8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0xFF, 0x80, 0x71, 0xFF, 0xF0, 0x39, 0xE0, 0x7C, 0x1D, 0xC0, 0x0F, 0x0F,
  0xC0, 0x03, 0xC7, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9F,
  0x00, 0x03, 0x8F, 0xC0, 0x03, 0x87, 0x78, 0x07, 0x83, 0x9F, 0xFF, 0x81,
  0xC3, 0xFF, 0x80, 0xE0, 0x08, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x83, 0x81, 0xFF, 0xF1, 0xC1,
  0xF0, 0x3C, 0xE1, 0xE0, 0x07, 0x71, 0xC0, 0x01, 0xF9, 0xE0, 0x00, 0x7C,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x01, 0xE3, 0x80, 0x01, 0xF0, 0xE0, 0x01, 0xF8,
  0x3C, 0x03, 0xDC, 0x0F, 0xFF, 0x8E, 0x03, 0xFF, 0x87, 0x00, 0x08, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0xC0,
  0x1F, 0xFF, 0x07, 0xFF, 0xB8, 0x7E, 0x05, 0xCF, 0x00, 0x0E, 0xE0, 0x00,
  0x76, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xE0, 0x3F, 0x03, 0x80, 0x03, 0xC3,
  0x80, 0x00, 0xF3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x38, 0x00, 0x1B, 0x3C, 0x00, 0x33, 0x1E, 0x01, 0xE3, 0x0F, 0xFF,
  0xC3, 0x03, 0xFF, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0xE0,
  0x01, 0xC0, 0x03, 0x60, 0x01, 0xC0, 0x07, 0x60, 0x03, 0xC0, 0x07, 0x60,
  0x03, 0xC0, 0x06, 0x70, 0x03, 0xE0, 0x06, 0x70, 0x03, 0x60, 0x06, 0x30,
  0x07, 0x60, 0x0E, 0x30, 0x06, 0x60, 0x0E, 0x38, 0x06, 0x70, 0x0C, 0x38,
  0x06, 0x70, 0x0C, 0x18, 0x0E, 0x30, 0x0C, 0x18, 0x0C, 0x30, 0x1C, 0x18,
  0x0C, 0x38, 0x18, 0x1C, 0x0C, 0x18, 0x18, 0x1C, 0x1C, 0x18, 0x18, 0x0C,
  0x18, 0x18, 0x38, 0x0C, 0x18, 0x1C, 0x38, 0x0C, 0x18, 0x0C, 0x30, 0x0E,
  0x38, 0x0C, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x06,
  0x30, 0x06, 0x60, 0x07, 0x70, 0x06, 0x60, 0x07, 0x60, 0x06, 0x60, 0x03,
  0x60, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0x40, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x78, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x3F, 0xFE, 0x00, 0x03, 0x38, 0x0F,
  0x00, 0x07, 0x70, 0x07, 0x80, 0x06, 0x60, 0x03, 0xC0, 0x06, 0xE0, 0x00,
  0xF0, 0x0E, 0xC0, 0x00, 0x78, 0x3C, 0xC0, 0x00, 0x3F, 0xF8, 0x20, 0x00,
  0x0F, 0xE0,
};

const GFXglyph RobotoMono_ExtraLight60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 5, 43, 36, 15, -43 },
  { 28, 11, 13, 36, 12, -45 },
  { 46, 32, 43, 36, 2, -43 },
  { 218, 27, 55, 36, 5, -49 },
  { 404, 34, 44, 36, 1, -43 },
  { 591, 31, 44, 36, 4, -43 },
  { 762, 3, 13, 36, 15, -45 },
  { 767, 13, 62, 36, 12, -48 },
  { 868, 14, 62, 36, 10, -48 },
  { 977, 26, 25, 36, 6, -43 },
  { 1059, 30, 31, 36, 3, -35 },
  { 1176, 5, 13, 36, 12, -5 },
  { 1185, 22, 2, 36, 7, -20 },
  { 1191, 4, 4, 36, 17, -4 },
  { 1193, 20, 47, 36, 9, -43 },
  { 1311, 26, 44, 36, 5, -43 },
  { 1454, 14, 43, 36, 7, -43 },
  { 1530, 27, 43, 36, 3, -43 },
  { 1676, 27, 44, 36, 3, -43 },
  { 1825, 30, 43, 36, 3, -43 },
  { 1987, 26, 44, 36, 6, -43 },
  { 2130, 26, 44, 36, 5, -43 },
  { 2273, 28, 43, 36, 4, -43 },
  { 2424, 27, 44, 36, 5, -43 },
  { 2573, 26, 43, 36, 5, -43 },
  { 2713, 5, 30, 36, 18, -30 },
  { 2732, 7, 38, 36, 16, -30 },
  { 2766, 25, 25, 36, 5, -32 },
  { 2845, 26, 15, 36, 5, -27 },
  { 2894, 26, 25, 36, 5, -32 },
  { 2976, 23, 43, 36, 7, -43 },
  { 3100, 32, 43, 36, 2, -43 },
  { 3272, 31, 43, 36, 3, -43 },
  { 3439, 26, 43, 36, 6, -43 },
  { 3579, 28, 44, 36, 4, -43 },
  { 3733, 27, 43, 36, 6, -43 },
  { 3879, 25, 43, 36, 6, -43 },
  { 4014, 25, 43, 36, 6, -43 },
  { 4149, 28, 44, 36, 4, -43 },
  { 4303, 26, 43, 36, 5, -43 },
  { 4443, 24, 43, 36, 6, -43 },
  { 4572, 27, 44, 36, 3, -43 },
  { 4721, 29, 43, 36, 6, -43 },
  { 4877, 24, 43, 36, 7, -43 },
  { 5006, 27, 43, 36, 5, -43 },
  { 5152, 26, 43, 36, 5, -43 },
  { 5292, 28, 44, 36, 4, -43 },
  { 5446, 26, 43, 36, 7, -43 },
  { 5586, 30, 51, 36, 3, -43 },
  { 5778, 27, 43, 36, 6, -43 },
  { 5924, 28, 44, 36, 4, -43 },
  { 6078, 30, 43, 36, 3, -43 },
  { 6240, 26, 44, 36, 5, -43 },
  { 6383, 30, 43, 36, 3, -43 },
  { 6545, 31, 43, 36, 3, -43 },
  { 6712, 31, 43, 36, 3, -43 },
  { 6879, 31, 43, 36, 2, -43 },
  { 7046, 27, 43, 36, 4, -43 },
  { 7192, 9, 58, 36, 14, -49 },
  { 7258, 20, 47, 36, 8, -43 },
  { 7376, 9, 58, 36, 13, -49 },
  { 7442, 22, 24, 36, 7, -43 },
  { 7508, 26, 2, 36, 5, 0 },
  { 7515, 8, 8, 36, 14, -44 },
  { 7523, 26, 33, 36, 5, -32 },
  { 7631, 25, 46, 36, 6, -45 },
  { 7775, 26, 33, 36, 5, -32 },
  { 7883, 25, 46, 36, 5, -45 },
  { 8027, 26, 33, 36, 5, -32 },
  { 8135, 27, 46, 36, 6, -46 },
  { 8291, 25, 45, 36, 5, -32 },
  { 8432, 25, 45, 36, 6, -45 },
  { 8573, 25, 43, 36, 7, -43 },
  { 8708, 19, 56, 36, 5, -43 },
  { 8841, 25, 45, 36, 7, -45 },
  { 8982, 25, 45, 36, 7, -45 },
  { 9123, 30, 32, 36, 3, -32 },
  { 9243, 24, 32, 36, 6, -32 },
  { 9339, 28, 33, 36, 4, -32 },
  { 9455, 25, 44, 36, 6, -32 },
  { 9593, 25, 44, 36, 5, -32 },
  { 9731, 21, 32, 36, 11, -32 },
  { 9815, 25, 33, 36, 6, -32 },
  { 9919, 25, 41, 36, 5, -40 },
  { 10048, 24, 33, 36, 6, -32 },
  { 10147, 30, 32, 36, 3, -32 },
  { 10267, 32, 32, 36, 2, -32 },
  { 10395, 29, 32, 36, 4, -32 },
  { 10511, 32, 45, 36, 2, -32 },
  { 10691, 28, 32, 36, 4, -32 },
  { 10803, 19, 59, 36, 10, -47 },
  { 10944, 2, 52, 36, 17, -43 },
  { 10957, 19, 59, 36, 10, -47 },
  { 11098, 32, 10, 36, 2, -23 },
};

const GFXfont RobotoMono_ExtraLight60pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight60pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOMONO_EXTRALIGHT60PT7B_H_
