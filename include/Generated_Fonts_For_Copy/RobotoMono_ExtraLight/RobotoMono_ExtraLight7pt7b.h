#ifndef _ROBOTOMONO_EXTRALIGHT7PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x5F, 0x6F, 0x60, 0x56, 0x23, 0x50, 0xCE, 0x27, 0x70,
  0xDA, 0x7E, 0x80, 0x5A, 0xA5, 0x95, 0x56, 0x5F, 0x00, 0x2F, 0x22, 0xC0,
  0xC0, 0x80, 0x56, 0x80, 0xF7, 0xDE, 0xF8, 0xE1, 0x24, 0xF0, 0xE5, 0x9E,
  0x26, 0x6F, 0x20, 0xF3, 0x9E, 0xDA, 0xDE, 0xF2, 0x22, 0x40, 0xF7, 0x5E,
  0xD6, 0xBC, 0x90, 0x98, 0x71, 0x80, 0xFC, 0x8F, 0x00, 0xD5, 0x00, 0x7F,
  0xBF, 0xE0, 0x42, 0x66, 0x90, 0xF7, 0x5E, 0x79, 0x89, 0x70, 0xD6, 0xDC,
  0xF3, 0x4E, 0xF3, 0x48, 0x78, 0xA9, 0x70, 0xB7, 0xDA, 0xE9, 0x2E, 0x24,
  0x9E, 0xBA, 0x6A, 0x92, 0x4E, 0xB7, 0xDA, 0xB6, 0xFA, 0x79, 0x99, 0x70,
  0xF7, 0xC8, 0x79, 0x99, 0x71, 0xF7, 0x6A, 0x78, 0x69, 0x70, 0xF2, 0x22,
  0x20, 0xB6, 0xDE, 0x99, 0x66, 0x40, 0xBB, 0xD6, 0x50, 0x96, 0x26, 0x90,
  0x96, 0x22, 0x20, 0x72, 0x44, 0xF0, 0xFE, 0xA5, 0x40, 0xFE, 0xBC, 0xE0,
  0x80, 0xC7, 0xF0, 0x9A, 0xDE, 0xD6, 0x70, 0x7F, 0xC0, 0xDE, 0x70, 0xFA,
  0x48, 0xFF, 0xC0, 0x9A, 0xDA, 0x51, 0x2E, 0x75, 0x58, 0x97, 0x6A, 0xC9,
  0x2E, 0xFB, 0xBB, 0xD6, 0xD0, 0x69, 0x97, 0xD6, 0xF8, 0xFF, 0x40, 0xF2,
  0x40, 0xD5, 0xF0, 0x9A, 0x4E, 0xB6, 0xF0, 0x95, 0x64, 0xBB, 0x56, 0x96,
  0x2D, 0x99, 0x64, 0x48, 0x72, 0x4F, 0x57, 0x50, 0xFC, 0xD5, 0x70, 0xD3,
};

const GFXglyph RobotoMono_ExtraLight7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 1, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 7, 4, 1, -6 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 3, 5, 4, 1, -5 },
  { 14, 1, 1, 4, 1, -5 },
  { 15, 2, 8, 4, 1, -6 },
  { 17, 2, 8, 4, 1, -6 },
  { 19, 3, 3, 4, 1, -5 },
  { 21, 4, 4, 4, 0, -4 },
  { 23, 1, 2, 4, 1, -1 },
  { 24, 2, 1, 4, 1, -3 },
  { 25, 1, 1, 4, 2, -1 },
  { 26, 2, 5, 4, 1, -5 },
  { 28, 3, 5, 4, 1, -5 },
  { 30, 1, 5, 4, 1, -5 },
  { 31, 4, 5, 4, 0, -5 },
  { 34, 3, 5, 4, 0, -5 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 3, 5, 4, 1, -5 },
  { 41, 3, 5, 4, 1, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 3, 5, 4, 1, -5 },
  { 48, 3, 5, 4, 1, -5 },
  { 50, 1, 4, 4, 2, -4 },
  { 51, 1, 5, 4, 2, -4 },
  { 52, 3, 3, 4, 1, -4 },
  { 54, 3, 2, 4, 1, -3 },
  { 55, 3, 3, 4, 1, -4 },
  { 57, 2, 5, 4, 1, -5 },
  { 59, 4, 5, 4, 0, -5 },
  { 62, 4, 5, 4, 0, -5 },
  { 65, 3, 5, 4, 1, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 3, 5, 4, 1, -5 },
  { 72, 3, 5, 4, 1, -5 },
  { 74, 3, 5, 4, 1, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 3, 5, 4, 1, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 3, 5, 4, 0, -5 },
  { 85, 3, 5, 4, 1, -5 },
  { 87, 3, 5, 4, 1, -5 },
  { 89, 3, 5, 4, 1, -5 },
  { 91, 3, 5, 4, 1, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 3, 5, 4, 1, -5 },
  { 98, 4, 6, 4, 0, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 3, 5, 4, 1, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 1, 7, 4, 2, -6 },
  { 127, 2, 5, 4, 1, -5 },
  { 129, 1, 7, 4, 2, -6 },
  { 130, 2, 3, 4, 1, -5 },
  { 131, 3, 1, 4, 1, 0 },
  { 132, 1, 1, 4, 2, -5 },
  { 133, 3, 4, 4, 1, -4 },
  { 135, 3, 5, 4, 1, -5 },
  { 137, 3, 4, 4, 1, -4 },
  { 139, 2, 5, 4, 1, -5 },
  { 141, 3, 4, 4, 1, -4 },
  { 143, 3, 5, 4, 1, -5 },
  { 145, 2, 5, 4, 1, -4 },
  { 147, 3, 5, 4, 1, -5 },
  { 149, 3, 5, 4, 1, -5 },
  { 151, 2, 7, 4, 1, -5 },
  { 153, 3, 5, 4, 1, -5 },
  { 155, 3, 5, 4, 1, -5 },
  { 157, 4, 4, 4, 0, -4 },
  { 159, 3, 4, 4, 1, -4 },
  { 161, 4, 4, 4, 0, -4 },
  { 163, 3, 5, 4, 1, -4 },
  { 165, 2, 5, 4, 1, -4 },
  { 167, 3, 4, 4, 1, -4 },
  { 169, 3, 4, 4, 1, -4 },
  { 171, 3, 5, 4, 1, -5 },
  { 173, 3, 4, 4, 1, -4 },
  { 175, 4, 4, 4, 0, -4 },
  { 177, 4, 4, 4, 0, -4 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 4, 6, 4, 0, -4 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 2, 6, 4, 1, -5 },
  { 188, 1, 6, 4, 2, -5 },
  { 189, 2, 6, 4, 1, -5 },
  { 191, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoMono_ExtraLight7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight7pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_EXTRALIGHT7PT7B_H_
