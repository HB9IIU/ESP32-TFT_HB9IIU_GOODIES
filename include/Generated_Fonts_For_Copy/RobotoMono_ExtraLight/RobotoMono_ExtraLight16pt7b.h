#ifndef _ROBOTOMONO_EXTRALIGHT16PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0x80, 0x09, 0x08, 0x84, 0x4F, 0xD1, 0x20, 0x90,
  0x49, 0xFF, 0x24, 0x12, 0x09, 0x00, 0x08, 0x30, 0x9A, 0x14, 0x28, 0x08,
  0x0E, 0x02, 0x06, 0x0A, 0x13, 0xC1, 0x02, 0x00, 0x60, 0x48, 0x24, 0x92,
  0x49, 0x43, 0x20, 0x20, 0x17, 0x14, 0x8A, 0x49, 0x20, 0x70, 0x10, 0x2C,
  0x44, 0x44, 0x48, 0x30, 0x50, 0x49, 0x89, 0x86, 0x82, 0x7D, 0xE0, 0x12,
  0x44, 0x88, 0x88, 0x88, 0x88, 0x84, 0x42, 0x10, 0x91, 0x12, 0x49, 0x24,
  0x92, 0x54, 0x80, 0x10, 0x23, 0x79, 0x84, 0x89, 0x80, 0x10, 0x10, 0x10,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x58, 0xFC, 0xC0, 0x04, 0x20, 0x84, 0x10,
  0x42, 0x08, 0x41, 0x04, 0x20, 0x18, 0xC9, 0x0C, 0x18, 0x71, 0x64, 0xD1,
  0xC3, 0x05, 0x09, 0xE0, 0x79, 0x11, 0x11, 0x11, 0x11, 0x10, 0x30, 0x9A,
  0x14, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0x07, 0xF0, 0x38, 0x8A, 0x0C,
  0x10, 0x20, 0x8F, 0x01, 0x03, 0x06, 0x0B, 0xE0, 0x0C, 0x0C, 0x14, 0x24,
  0x24, 0x44, 0x84, 0xFF, 0x04, 0x04, 0x04, 0xFE, 0x08, 0x20, 0xF8, 0x10,
  0x41, 0x86, 0x17, 0x80, 0x0C, 0x61, 0x02, 0x09, 0x9C, 0xA0, 0xC1, 0x83,
  0x05, 0x09, 0xE0, 0xFE, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40,
  0x80, 0x18, 0x66, 0x42, 0x42, 0x42, 0x24, 0x3C, 0x42, 0x81, 0x81, 0x42,
  0x3C, 0x18, 0xC9, 0x0C, 0x18, 0x30, 0x50, 0xBF, 0x02, 0x04, 0x11, 0xC0,
  0x81, 0x40, 0x01, 0x60, 0x06, 0x73, 0x03, 0x01, 0x80, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0xE0, 0x30, 0x18, 0x63, 0x18, 0x00, 0x33, 0x28, 0x41, 0x04,
  0x21, 0x08, 0x20, 0x00, 0x08, 0x1F, 0x10, 0x53, 0xAA, 0x59, 0x2D, 0x16,
  0x8B, 0x29, 0x5B, 0x20, 0x0F, 0x80, 0x18, 0x18, 0x28, 0x24, 0x24, 0x44,
  0x42, 0x7E, 0x42, 0x81, 0x81, 0xF9, 0x0A, 0x14, 0x28, 0x9F, 0x21, 0x41,
  0x83, 0x0B, 0xE0, 0x18, 0x64, 0x42, 0x81, 0x80, 0x80, 0x80, 0x80, 0x81,
  0x82, 0x42, 0x3C, 0xFC, 0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x86, 0xF8, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x0F, 0xC0, 0xFE,
  0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x00, 0x18, 0x64, 0x42, 0x81,
  0x80, 0x80, 0x80, 0x8F, 0x81, 0x81, 0x41, 0x3E, 0x83, 0x06, 0x0C, 0x18,
  0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x8F, 0xC0, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x83, 0x09,
  0xE0, 0x87, 0x12, 0x45, 0x0A, 0x1C, 0x24, 0x44, 0x89, 0x0A, 0x08, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC3, 0x86, 0x9D, 0x3A,
  0xB3, 0x64, 0xC1, 0x83, 0x06, 0x08, 0x83, 0x86, 0x8D, 0x19, 0x32, 0x62,
  0xC3, 0x87, 0x06, 0x08, 0x18, 0x64, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x82, 0x42, 0x3C, 0xFD, 0x06, 0x0C, 0x18, 0x3F, 0xA0, 0x40, 0x81,
  0x02, 0x00, 0x18, 0x64, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x42, 0x3C, 0x02, 0x01, 0xF9, 0x0A, 0x14, 0x28, 0x5D, 0x24, 0x44, 0x85,
  0x0A, 0x08, 0x10, 0x66, 0x82, 0x81, 0x40, 0x20, 0x1C, 0x02, 0x01, 0x81,
  0x42, 0x3C, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x84, 0xF0, 0x81,
  0x82, 0x42, 0x42, 0x44, 0x44, 0x24, 0x28, 0x28, 0x18, 0x10, 0x91, 0x99,
  0x99, 0x99, 0x99, 0xA6, 0x66, 0x66, 0x66, 0x42, 0x42, 0x83, 0x42, 0x24,
  0x24, 0x18, 0x18, 0x18, 0x24, 0x42, 0x42, 0x81, 0x83, 0x42, 0x44, 0x24,
  0x28, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x08, 0x10, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x83, 0xF8, 0xEA, 0xAA, 0xAA, 0xAC, 0x81, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x78,
  0x20, 0xC5, 0x12, 0x8A, 0x10, 0xFE, 0x90, 0x38, 0x8E, 0x08, 0x13, 0xE8,
  0x60, 0xC1, 0x7E, 0x82, 0x08, 0x2C, 0xCA, 0x18, 0x61, 0x86, 0x18, 0x7E,
  0x18, 0xCD, 0x0C, 0x08, 0x10, 0x20, 0xA1, 0x3C, 0x02, 0x04, 0x09, 0xD4,
  0x68, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xF0, 0x18, 0xC9, 0x0C, 0x1F, 0xF0,
  0x20, 0x21, 0x3C, 0x1E, 0x40, 0x87, 0xE2, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x00, 0x38, 0x8D, 0x0C, 0x18, 0x30, 0x60, 0xA1, 0x3E, 0x04, 0x0B,
  0xE0, 0x82, 0x08, 0x2E, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x61, 0x10, 0x0E,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x4F, 0xC0, 0x08, 0x1C, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0xF8, 0x81, 0x02, 0x04, 0x28, 0x92, 0x28, 0x70, 0x91,
  0x22, 0x24, 0x30, 0xF0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x3F,
  0x66, 0x99, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0x3B, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x84, 0x38, 0x44, 0x82, 0x81, 0x81, 0x81, 0x82, 0x42,
  0x3C, 0x33, 0x28, 0x61, 0x86, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x38, 0x8D,
  0x0C, 0x18, 0x30, 0x60, 0xA1, 0x3E, 0x04, 0x08, 0x10, 0x1F, 0x21, 0x08,
  0x42, 0x10, 0x80, 0x7A, 0x18, 0x60, 0x70, 0x30, 0x61, 0x78, 0x10, 0x23,
  0xF8, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x78, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x5F, 0x83, 0x42, 0x42, 0x44, 0x24, 0x28, 0x18, 0x10, 0x91, 0x99,
  0x99, 0xAA, 0xA6, 0x66, 0x46, 0x44, 0xC3, 0x24, 0x28, 0x10, 0x18, 0x24,
  0x42, 0x83, 0x81, 0x82, 0x42, 0x44, 0x24, 0x28, 0x18, 0x10, 0x10, 0x10,
  0xE0, 0xFE, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0xFF, 0x19, 0x08, 0x42,
  0x11, 0x10, 0x41, 0x08, 0x42, 0x10, 0x60, 0xFF, 0xF8, 0xC2, 0x08, 0x42,
  0x10, 0x83, 0x21, 0x08, 0x42, 0x22, 0x00, 0xE1, 0x99, 0x06,
};

const GFXglyph RobotoMono_ExtraLight16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 1, 11, 10, 4, -11 },
  { 3, 3, 3, 10, 3, -12 },
  { 5, 9, 11, 10, 0, -11 },
  { 18, 7, 15, 10, 1, -13 },
  { 32, 9, 12, 10, 0, -12 },
  { 46, 8, 12, 10, 1, -12 },
  { 58, 1, 3, 10, 4, -12 },
  { 59, 4, 17, 10, 3, -13 },
  { 68, 3, 17, 10, 3, -13 },
  { 75, 7, 6, 10, 2, -11 },
  { 81, 8, 8, 10, 1, -9 },
  { 89, 2, 3, 10, 3, -1 },
  { 90, 6, 1, 10, 2, -6 },
  { 91, 2, 1, 10, 4, -1 },
  { 92, 6, 12, 10, 2, -11 },
  { 101, 7, 12, 10, 1, -12 },
  { 112, 4, 11, 10, 2, -11 },
  { 118, 7, 12, 10, 1, -12 },
  { 129, 7, 12, 10, 1, -12 },
  { 140, 8, 11, 10, 1, -11 },
  { 151, 6, 11, 10, 2, -11 },
  { 160, 7, 12, 10, 1, -12 },
  { 171, 7, 11, 10, 1, -11 },
  { 181, 8, 12, 10, 1, -12 },
  { 193, 7, 12, 10, 1, -12 },
  { 204, 1, 8, 10, 5, -8 },
  { 205, 2, 10, 10, 4, -8 },
  { 208, 7, 6, 10, 1, -8 },
  { 214, 7, 4, 10, 1, -7 },
  { 218, 7, 6, 10, 1, -8 },
  { 224, 6, 12, 10, 2, -12 },
  { 233, 9, 11, 10, 0, -11 },
  { 246, 8, 11, 10, 1, -11 },
  { 257, 7, 11, 10, 2, -11 },
  { 267, 8, 12, 10, 1, -12 },
  { 279, 8, 11, 10, 1, -11 },
  { 290, 6, 11, 10, 2, -11 },
  { 299, 6, 11, 10, 2, -11 },
  { 308, 8, 12, 10, 1, -12 },
  { 320, 7, 11, 10, 1, -11 },
  { 330, 6, 11, 10, 2, -11 },
  { 339, 7, 11, 10, 1, -11 },
  { 349, 7, 11, 10, 2, -11 },
  { 359, 6, 11, 10, 2, -11 },
  { 368, 7, 11, 10, 1, -11 },
  { 378, 7, 11, 10, 1, -11 },
  { 388, 8, 12, 10, 1, -12 },
  { 400, 7, 11, 10, 2, -11 },
  { 410, 8, 14, 10, 1, -12 },
  { 424, 7, 11, 10, 2, -11 },
  { 434, 8, 12, 10, 1, -12 },
  { 446, 8, 11, 10, 1, -11 },
  { 457, 7, 11, 10, 1, -11 },
  { 467, 8, 11, 10, 1, -11 },
  { 478, 8, 11, 10, 1, -11 },
  { 489, 8, 11, 10, 1, -11 },
  { 500, 8, 11, 10, 1, -11 },
  { 511, 7, 11, 10, 1, -11 },
  { 521, 2, 15, 10, 4, -13 },
  { 525, 6, 12, 10, 2, -11 },
  { 534, 3, 15, 10, 3, -13 },
  { 540, 6, 6, 10, 2, -11 },
  { 545, 7, 1, 10, 1, 0 },
  { 546, 2, 2, 10, 4, -12 },
  { 547, 7, 9, 10, 1, -9 },
  { 555, 6, 12, 10, 2, -12 },
  { 564, 7, 9, 10, 1, -9 },
  { 572, 7, 12, 10, 1, -12 },
  { 583, 7, 9, 10, 1, -9 },
  { 591, 7, 12, 10, 2, -12 },
  { 602, 7, 12, 10, 1, -9 },
  { 613, 6, 12, 10, 2, -12 },
  { 622, 6, 11, 10, 2, -11 },
  { 631, 5, 14, 10, 1, -11 },
  { 640, 7, 12, 10, 2, -12 },
  { 651, 6, 12, 10, 2, -12 },
  { 660, 8, 9, 10, 1, -9 },
  { 669, 6, 9, 10, 2, -9 },
  { 676, 8, 9, 10, 1, -9 },
  { 685, 6, 12, 10, 2, -9 },
  { 694, 7, 12, 10, 1, -9 },
  { 705, 5, 9, 10, 3, -9 },
  { 711, 6, 9, 10, 2, -9 },
  { 718, 7, 11, 10, 1, -11 },
  { 728, 6, 8, 10, 2, -8 },
  { 734, 8, 8, 10, 1, -8 },
  { 742, 8, 8, 10, 1, -8 },
  { 750, 8, 8, 10, 1, -8 },
  { 758, 8, 11, 10, 1, -8 },
  { 769, 8, 8, 10, 1, -8 },
  { 777, 5, 15, 10, 3, -12 },
  { 787, 1, 13, 10, 4, -11 },
  { 789, 5, 15, 10, 3, -12 },
  { 799, 8, 3, 10, 1, -6 },
};

const GFXfont RobotoMono_ExtraLight16pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight16pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOMONO_EXTRALIGHT16PT7B_H_
