#ifndef _ROBOTOMONO_EXTRALIGHT6PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight6pt7bBitmaps[] PROGMEM = {
  0x00, 0xE0, 0xC0, 0x7D, 0x50, 0xB9, 0xE0, 0xF9, 0xD0, 0xEA, 0xF0, 0xC0,
  0x6A, 0xB0, 0xFC, 0xF0, 0x4B, 0xA0, 0xC0, 0xC0, 0x00, 0x5A, 0xF7, 0xF0,
  0xF0, 0xE5, 0x70, 0xEC, 0xF0, 0x2F, 0x90, 0xF7, 0x76, 0xF0, 0xE5, 0x20,
  0xFF, 0xF5, 0xB0, 0x00, 0x30, 0x7C, 0xF0, 0xB0, 0xD8, 0xF6, 0xF0, 0x4F,
  0xD0, 0xFF, 0xF2, 0x70, 0xFF, 0xFB, 0xFA, 0xF2, 0xF0, 0xBE, 0xD0, 0xEB,
  0x24, 0xF0, 0xEB, 0xAB, 0xFF, 0xBE, 0xD0, 0xF6, 0xF0, 0xFA, 0xF6, 0xF2,
  0xFB, 0xE8, 0xF0, 0xE9, 0x20, 0xB6, 0xF0, 0xB5, 0x20, 0xEE, 0xB0, 0xE9,
  0x50, 0xA9, 0x20, 0xE9, 0x70, 0xFC, 0xA9, 0xFC, 0xB0, 0xC0, 0x80, 0xFC,
  0xAF, 0xC0, 0xF3, 0x80, 0x2E, 0xDE, 0xFB, 0x80, 0x7A, 0x80, 0xF6, 0xB0,
  0xAF, 0xC0, 0x2B, 0x78, 0xAE, 0xC0, 0xAA, 0xC0, 0xFF, 0x80, 0xFC, 0xF7,
  0x80, 0xFE, 0xF7, 0x90, 0xE8, 0xDC, 0xEB, 0xFC, 0xAD, 0x00, 0xEE, 0x80,
  0xEA, 0x80, 0xAD, 0x60, 0xEB, 0x80, 0x6A, 0x90, 0xF8, 0xA9, 0xA0, 0xE0,
};

const GFXglyph RobotoMono_ExtraLight6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 1, 2, 4, 1, -5 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 2, 6, 4, 1, -5 },
  { 7, 3, 4, 4, 0, -4 },
  { 9, 3, 4, 4, 0, -4 },
  { 11, 1, 2, 4, 1, -5 },
  { 12, 2, 6, 4, 1, -5 },
  { 14, 1, 6, 4, 1, -5 },
  { 15, 2, 2, 4, 1, -4 },
  { 16, 3, 4, 4, 0, -4 },
  { 18, 1, 2, 4, 1, -1 },
  { 19, 2, 1, 4, 1, -2 },
  { 20, 1, 1, 4, 1, -1 },
  { 21, 2, 4, 4, 1, -4 },
  { 22, 3, 4, 4, 0, -4 },
  { 24, 1, 4, 4, 1, -4 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 2, 4, 4, 1, -4 },
  { 32, 3, 4, 4, 0, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 2, 4, 4, 1, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 1, 3, 4, 2, -3 },
  { 40, 1, 4, 4, 1, -3 },
  { 41, 3, 2, 4, 0, -3 },
  { 42, 2, 2, 4, 1, -3 },
  { 43, 2, 2, 4, 1, -3 },
  { 44, 2, 4, 4, 1, -4 },
  { 45, 3, 4, 4, 0, -4 },
  { 47, 3, 4, 4, 0, -4 },
  { 49, 2, 4, 4, 1, -4 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 2, 4, 4, 1, -4 },
  { 54, 2, 4, 4, 1, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 2, 4, 4, 1, -4 },
  { 70, 3, 5, 4, 0, -4 },
  { 72, 2, 4, 4, 1, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 3, 4, 4, 0, -4 },
  { 87, 3, 4, 4, 0, -4 },
  { 89, 1, 6, 4, 1, -5 },
  { 90, 2, 4, 4, 1, -4 },
  { 91, 1, 6, 4, 1, -5 },
  { 92, 2, 2, 4, 1, -4 },
  { 93, 2, 1, 4, 1, 0 },
  { 94, 1, 1, 4, 1, -5 },
  { 95, 2, 3, 4, 1, -3 },
  { 96, 2, 5, 4, 1, -5 },
  { 98, 3, 3, 4, 0, -3 },
  { 100, 3, 5, 4, 0, -5 },
  { 102, 3, 3, 4, 0, -3 },
  { 104, 2, 5, 4, 1, -5 },
  { 106, 3, 4, 4, 0, -3 },
  { 108, 2, 5, 4, 1, -5 },
  { 110, 2, 4, 4, 1, -4 },
  { 111, 1, 5, 4, 1, -4 },
  { 112, 2, 5, 4, 1, -5 },
  { 114, 2, 5, 4, 1, -5 },
  { 116, 3, 3, 4, 0, -3 },
  { 118, 2, 3, 4, 1, -3 },
  { 119, 3, 3, 4, 0, -3 },
  { 121, 2, 4, 4, 1, -3 },
  { 122, 3, 4, 4, 0, -3 },
  { 124, 2, 3, 4, 1, -3 },
  { 125, 2, 3, 4, 1, -3 },
  { 126, 2, 4, 4, 1, -4 },
  { 127, 2, 3, 4, 1, -3 },
  { 128, 3, 3, 4, 0, -3 },
  { 130, 3, 3, 4, 0, -3 },
  { 132, 3, 3, 4, 0, -3 },
  { 134, 3, 4, 4, 0, -3 },
  { 136, 3, 3, 4, 0, -3 },
  { 138, 2, 6, 4, 1, -5 },
  { 140, 1, 5, 4, 1, -4 },
  { 141, 2, 6, 4, 1, -5 },
  { 143, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoMono_ExtraLight6pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight6pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOMONO_EXTRALIGHT6PT7B_H_
