#ifndef _ROBOTOMONO_EXTRALIGHT39PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight39pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x00, 0x0B, 0xF0,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x00, 0x40, 0x40, 0x02, 0x02,
  0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x40, 0x40, 0x02,
  0x02, 0x00, 0x10, 0x30, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x40, 0x40,
  0x02, 0x02, 0x00, 0x10, 0x10, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x01, 0x81, 0x81, 0xFF, 0xFF, 0xE0,
  0x60, 0x60, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x81, 0x80, 0x0C, 0x0C,
  0x00, 0x60, 0x60, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x07, 0xF0, 0x1F, 0x38, 0x38, 0x0C, 0x60,
  0x06, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x01, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x60, 0x03, 0x70, 0x06, 0x3C, 0x1C, 0x0F,
  0xF8, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x3E, 0x00, 0x01,
  0xCC, 0x00, 0x04, 0x18, 0x00, 0x30, 0x60, 0x40, 0x80, 0x81, 0x82, 0x02,
  0x04, 0x08, 0x08, 0x30, 0x20, 0x20, 0x80, 0x80, 0x86, 0x03, 0x06, 0x30,
  0x06, 0x30, 0x80, 0x0F, 0x86, 0x00, 0x08, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x43, 0xE0, 0x03, 0x18, 0xC0, 0x08,
  0x41, 0x80, 0x63, 0x02, 0x03, 0x0C, 0x08, 0x08, 0x30, 0x30, 0x60, 0xC0,
  0xC1, 0x03, 0x02, 0x0C, 0x0C, 0x08, 0x00, 0x10, 0x60, 0x00, 0x61, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x01, 0xEE, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x30, 0x03,
  0x0C, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0x60, 0x01, 0x8C, 0x01, 0x30, 0xC0, 0x4C, 0x0C, 0x0B, 0x00, 0xC1, 0x60,
  0x0C, 0x6C, 0x01, 0x8D, 0x80, 0x19, 0x30, 0x01, 0xE6, 0x00, 0x18, 0x60,
  0x07, 0x8E, 0x01, 0xB0, 0xE0, 0xE3, 0x07, 0xF8, 0x30, 0xFF, 0xFE, 0x00,
  0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x01,
  0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x02, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC0, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x04, 0x04,
  0x0B, 0xC2, 0x1E, 0x7D, 0x7C, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0xD0, 0x00,
  0xCC, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x60, 0x30, 0x60, 0x0C, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x6D, 0xB6,
  0xB4, 0xFF, 0xFC, 0xDF, 0x80, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x07, 0xF0, 0x07, 0x9E, 0x06, 0x03,
  0x86, 0x00, 0xC2, 0x00, 0x33, 0x00, 0x09, 0x00, 0x06, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0x38, 0x03, 0x1C, 0x03, 0x0E, 0x03, 0x07,
  0x03, 0x03, 0x86, 0x01, 0xC6, 0x00, 0xE6, 0x00, 0x76, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1A, 0x00, 0x0D, 0x80, 0x04, 0xC0, 0x06, 0x30, 0x03, 0x0C,
  0x03, 0x03, 0x07, 0x00, 0xFE, 0x00, 0x00, 0x40, 0x70, 0xFC, 0xF3, 0xF0,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x07, 0xF0, 0x07, 0x9E, 0x03, 0x80, 0xE1,
  0x80, 0x18, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xBE,
  0x0E, 0x01, 0x86, 0x00, 0x66, 0x00, 0x32, 0x00, 0x0B, 0x00, 0x07, 0x80,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x06, 0x80, 0x03, 0x60,
  0x03, 0x18, 0x03, 0x87, 0x07, 0x80, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x11,
  0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x03, 0x03,
  0x00, 0x40, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0x80, 0x30, 0x30, 0x06,
  0x0C, 0x00, 0xC1, 0x00, 0x18, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x30, 0x0D, 0xFF, 0x07, 0x83, 0xC3, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x19, 0x00, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0x1C, 0x07, 0x07, 0xDF,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x31, 0xFC, 0x19, 0xC7, 0x8D, 0x80, 0xE7, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x02, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0D, 0x00, 0x04, 0xC0, 0x06, 0x30, 0x03, 0x1C, 0x03, 0x07, 0x87,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xCF, 0x01, 0x80, 0x60, 0xC0, 0x0C,
  0x20, 0x01, 0x98, 0x00, 0x66, 0x00, 0x09, 0x80, 0x02, 0x60, 0x01, 0x98,
  0x00, 0x63, 0x00, 0x10, 0x60, 0x0C, 0x0C, 0x0E, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x60, 0x1C, 0x30, 0x03, 0x98, 0x00, 0x64, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0x8C,
  0x00, 0xC1, 0xE0, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xBC, 0x06, 0x03,
  0x06, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x0D,
  0x80, 0x0E, 0x60, 0x0F, 0x38, 0x0D, 0x8F, 0xFC, 0xC1, 0xF8, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x5F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0B, 0xF0, 0x31, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x8C, 0x63, 0x18, 0x8C, 0xC0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xF0,
  0xC0, 0x33, 0x00, 0x26, 0x00, 0x68, 0x00, 0xF0, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xC0, 0x30, 0x18, 0x00, 0xC1,
  0x80, 0x03, 0x08, 0x00, 0x08, 0xC1, 0xF0, 0x64, 0x1C, 0xC3, 0x61, 0x82,
  0x0A, 0x08, 0x10, 0x50, 0xC0, 0x83, 0x84, 0x04, 0x1C, 0x20, 0x20, 0xE1,
  0x01, 0x06, 0x08, 0x18, 0x30, 0xC0, 0xC1, 0x86, 0x06, 0x0E, 0x10, 0x20,
  0xF0, 0x83, 0x05, 0x84, 0x1C, 0x24, 0x31, 0x23, 0x20, 0xF1, 0xF1, 0x81,
  0x02, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x08, 0x03, 0xC1, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x90, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x10, 0x80, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x02, 0x04, 0x00, 0x20, 0x40, 0x06, 0x06, 0x00,
  0x40, 0x60, 0x04, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x10,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x10, 0x00, 0x83, 0x00, 0x0C, 0x30, 0x00,
  0xC2, 0x00, 0x04, 0x60, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00, 0x2C, 0x00,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x30, 0x07, 0x18, 0x01, 0xCC, 0x00, 0x66,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01,
  0x98, 0x01, 0x8C, 0x03, 0x87, 0xFF, 0x03, 0x01, 0xF1, 0x80, 0x1C, 0xC0,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x07, 0x3F, 0xFF, 0x1F, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xCF, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x60, 0x01,
  0x98, 0x00, 0x64, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x26, 0x00, 0x19, 0x80, 0x06, 0x30, 0x03, 0x06, 0x01, 0x80,
  0xE1, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xF0, 0x20, 0x0E, 0x10, 0x01,
  0x88, 0x00, 0x64, 0x00, 0x32, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x14, 0x00, 0x1A, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x0C, 0x40, 0x1C, 0x20,
  0x7C, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xF7,
  0xC0, 0x30, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00,
  0x13, 0x00, 0x03, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x61, 0x80, 0x18, 0x1C, 0x1E,
  0x01, 0xFF, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0D, 0x00, 0x06,
  0xC0, 0x02, 0x60, 0x03, 0x18, 0x03, 0x07, 0x07, 0x00, 0xFF, 0x00, 0xC0,
  0x01, 0xF0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x06,
  0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x38, 0x03,
  0x0C, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0D, 0xB0, 0x03, 0xC6, 0x00, 0xE0,
  0xC0, 0x30, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x06,
  0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x1B,
  0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7D, 0x00, 0x2E, 0xC0, 0x37, 0x60,
  0x13, 0x90, 0x19, 0xCC, 0x0C, 0xE6, 0x04, 0x71, 0x06, 0x38, 0xC2, 0x1C,
  0x63, 0x0E, 0x11, 0x87, 0x0C, 0x83, 0x82, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0,
  0x70, 0x30, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x10, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0xC0, 0x07, 0x20,
  0x03, 0x98, 0x01, 0xC4, 0x00, 0xE3, 0x00, 0x70, 0xC0, 0x38, 0x60, 0x1C,
  0x18, 0x0E, 0x0C, 0x07, 0x03, 0x03, 0x80, 0x81, 0xC0, 0x60, 0xE0, 0x10,
  0x70, 0x0C, 0x38, 0x03, 0x1C, 0x01, 0x8E, 0x00, 0x67, 0x00, 0x33, 0x80,
  0x0D, 0xC0, 0x02, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x30, 0x03, 0xF0,
  0x03, 0xDF, 0x01, 0x80, 0xE0, 0xC0, 0x18, 0x60, 0x03, 0x18, 0x00, 0x44,
  0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x66,
  0x00, 0x19, 0x80, 0x0C, 0x30, 0x03, 0x06, 0x01, 0x80, 0xE1, 0xC0, 0x1F,
  0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x2C,
  0x00, 0x0B, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x01, 0xE3, 0xFF,
  0xE0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x30, 0x1C, 0x0C,
  0x00, 0xC3, 0x00, 0x08, 0x40, 0x01, 0x98, 0x00, 0x13, 0x00, 0x03, 0x40,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xA0, 0x00, 0x34, 0x00, 0x06, 0xC0, 0x00, 0x98, 0x00, 0x31, 0x80,
  0x06, 0x18, 0x01, 0x83, 0x80, 0x60, 0x3C, 0x38, 0x01, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF,
  0xC0, 0x7F, 0xF8, 0x30, 0x07, 0x18, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x66, 0x00, 0x63, 0x00, 0xE1, 0xFF, 0xE0, 0xC0, 0x60, 0x60,
  0x18, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0x86, 0x00, 0x63, 0x00, 0x11,
  0x80, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x30, 0x03,
  0xF8, 0x03, 0xEF, 0x03, 0x80, 0x70, 0xC0, 0x0C, 0x60, 0x01, 0x90, 0x00,
  0x24, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x01, 0x8C, 0x00, 0xE1, 0xE0, 0xE0,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0D, 0x00,
  0x06, 0xC0, 0x06, 0x30, 0x03, 0x1C, 0x03, 0x07, 0x87, 0x00, 0xFF, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x26, 0x00, 0x0C,
  0x40, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x0C, 0x30, 0x01, 0x83, 0x00, 0x20,
  0x60, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x20, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x08, 0x30, 0x01, 0x84, 0x00,
  0x31, 0x80, 0x02, 0x30, 0x00, 0x64, 0x00, 0x0D, 0x80, 0x00, 0xB0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x60, 0x1C, 0x06, 0x03, 0xC0, 0x70, 0x34, 0x0F, 0x03, 0x40, 0xD0,
  0x24, 0x09, 0x02, 0x60, 0x90, 0x26, 0x09, 0x82, 0x61, 0x98, 0x66, 0x19,
  0x86, 0x21, 0x08, 0x62, 0x10, 0x84, 0x21, 0x0C, 0x43, 0x30, 0xC4, 0x33,
  0x0C, 0xC3, 0x30, 0x4C, 0x32, 0x04, 0xC1, 0x20, 0x6C, 0x16, 0x06, 0x81,
  0x60, 0x68, 0x1E, 0x02, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0xC0, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x60, 0x00, 0x76, 0x00, 0x06, 0x30, 0x00,
  0xC1, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x60, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x01, 0x98, 0x00, 0x09, 0x80, 0x00,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x01, 0x98, 0x00,
  0x19, 0x80, 0x03, 0x0C, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00,
  0x6C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00,
  0x63, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x10, 0x0C, 0x06,
  0x01, 0x80, 0x80, 0x18, 0x30, 0x03, 0x04, 0x00, 0x31, 0x80, 0x06, 0x20,
  0x00, 0x6C, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0xFF, 0xF0, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F,
  0xFF, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x60, 0x0D, 0x80, 0x33,
  0x01, 0x8C, 0x06, 0x10, 0x10, 0x60, 0xC0, 0x82, 0x03, 0x18, 0x0C, 0x60,
  0x11, 0x00, 0x6C, 0x00, 0xC0, 0xFF, 0xFF, 0x80, 0xC3, 0x08, 0x61, 0x80,
  0x03, 0xF0, 0x07, 0xFE, 0x0E, 0x01, 0x86, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xC3, 0xFF, 0xE7,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xB0, 0x03, 0xD8, 0x03, 0x67, 0x07, 0x31, 0xFE, 0x18, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC7, 0xE0, 0xCF, 0xF8, 0xF8, 0x1C, 0xE0, 0x0C, 0xC0, 0x06, 0xC0,
  0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xE0,
  0x06, 0xF0, 0x0C, 0xDC, 0x38, 0xCF, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x06,
  0x01, 0x86, 0x00, 0x62, 0x00, 0x33, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x03, 0x60, 0x01, 0x98, 0x01, 0x86, 0x01, 0x81,
  0xC3, 0x80, 0x7F, 0x80, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x03, 0xE1, 0x0F, 0xF9,
  0x18, 0x0D, 0x30, 0x07, 0x60, 0x03, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x40, 0x01, 0x60, 0x01, 0x60, 0x03, 0x30, 0x03, 0x38, 0x07, 0x1C, 0x1D,
  0x07, 0xF1, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x01, 0x86, 0x00, 0x62, 0x00,
  0x13, 0x00, 0x0D, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0xC6, 0x00, 0xC1, 0xC1, 0xC0, 0x7F, 0xC0, 0x00,
  0x1F, 0x00, 0x7F, 0xC0, 0x70, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x03, 0xE1, 0x0F, 0xF9, 0x18, 0x0D, 0x30, 0x07, 0x60,
  0x03, 0x60, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x60, 0x01, 0x60,
  0x03, 0x30, 0x03, 0x38, 0x07, 0x1C, 0x1D, 0x07, 0xF1, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x60, 0x06, 0x30, 0x0E, 0x1C, 0x3C, 0x07,
  0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xF0, 0xCF, 0xF8, 0xD8, 0x0C, 0xF0,
  0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x60, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x1C, 0x07, 0x8F, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x06, 0x80,
  0x0C, 0x80, 0x38, 0x80, 0x70, 0x80, 0xE0, 0x81, 0x80, 0x83, 0x00, 0x86,
  0x00, 0x8C, 0x00, 0x9C, 0x00, 0xB6, 0x00, 0xE7, 0x00, 0xC3, 0x00, 0x81,
  0x80, 0x80, 0xC0, 0x80, 0x60, 0x80, 0x30, 0x80, 0x18, 0x80, 0x0C, 0x80,
  0x0E, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x8F, 0x07, 0x8B, 0xF9, 0xFE, 0xE0, 0xF0,
  0x6C, 0x06, 0x03, 0xC0, 0x60, 0x38, 0x04, 0x03, 0x80, 0x40, 0x38, 0x04,
  0x03, 0x80, 0x40, 0x38, 0x04, 0x03, 0x80, 0x40, 0x38, 0x04, 0x03, 0x80,
  0x40, 0x38, 0x04, 0x03, 0x80, 0x40, 0x38, 0x04, 0x03, 0x80, 0x40, 0x38,
  0x04, 0x03, 0x80, 0x40, 0x38, 0x04, 0x03, 0x80, 0x40, 0x30, 0x83, 0xF0,
  0x8F, 0xF8, 0x98, 0x0C, 0xB0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0x80, 0xE0, 0xC0,
  0x0C, 0x60, 0x03, 0x10, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x02, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0B, 0x00, 0x06, 0x60, 0x01, 0x98, 0x00, 0xC3, 0x80, 0x60, 0x70,
  0x70, 0x07, 0xF8, 0x00, 0xC7, 0xE0, 0xDF, 0xF8, 0xF0, 0x1C, 0xE0, 0x0C,
  0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02,
  0xC0, 0x06, 0xE0, 0x06, 0xF0, 0x0C, 0xD8, 0x38, 0xCF, 0xF0, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x07, 0xE1, 0x0F, 0xF9, 0x18, 0x0D, 0x30, 0x07, 0x60, 0x03,
  0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x60, 0x01, 0x60, 0x01,
  0x30, 0x03, 0x38, 0x07, 0x1C, 0x1D, 0x07, 0xF1, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0xC1, 0xFE, 0x3F, 0xF3, 0x01, 0xA0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xFC, 0x30, 0x0E, 0x60, 0x06, 0x40, 0x03, 0xC0, 0x03, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x60,
  0x06, 0x38, 0x1C, 0x0F, 0xF8, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x07, 0xFF, 0xFB, 0xFF, 0xFC, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x3F,
  0xC0, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x60,
  0x07, 0x60, 0x0B, 0x38, 0x33, 0x1F, 0xE3, 0xC0, 0x00, 0x68, 0x00, 0x0D,
  0x80, 0x01, 0x30, 0x00, 0x63, 0x00, 0x08, 0x60, 0x03, 0x04, 0x00, 0x60,
  0xC0, 0x18, 0x08, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x03, 0x02, 0x00,
  0x60, 0xC0, 0x04, 0x18, 0x00, 0xC6, 0x00, 0x08, 0xC0, 0x01, 0x90, 0x00,
  0x36, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x30, 0x0A,
  0x01, 0x80, 0x50, 0x0C, 0x06, 0xC0, 0xE0, 0x36, 0x07, 0x81, 0x30, 0x2C,
  0x08, 0x81, 0x20, 0xC4, 0x19, 0x06, 0x30, 0xCC, 0x31, 0x84, 0x61, 0x04,
  0x21, 0x08, 0x23, 0x08, 0xC1, 0x98, 0x66, 0x0C, 0x83, 0x20, 0x24, 0x09,
  0x01, 0x60, 0x48, 0x0B, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x63, 0x00, 0x30,
  0xE0, 0x18, 0x18, 0x06, 0x03, 0x03, 0x00, 0x61, 0x80, 0x0C, 0xC0, 0x03,
  0x60, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0x70, 0x00, 0xCC,
  0x00, 0x61, 0x80, 0x30, 0x30, 0x18, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x31,
  0x80, 0x06, 0xC0, 0x00, 0xC0, 0x80, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00,
  0x66, 0x00, 0x04, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x81, 0x80,
  0x18, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x06,
  0x04, 0x00, 0x20, 0xC0, 0x03, 0x08, 0x00, 0x11, 0x80, 0x01, 0x98, 0x00,
  0x1B, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3C,
  0x01, 0xE0, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1E, 0x00, 0xF0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x58, 0x38, 0x06, 0x80,
  0x60, 0x3C, 0x01, 0x83, 0x60, 0x07, 0xF0, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoMono_ExtraLight39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 3, 28, 23, 10, -28 },
  { 12, 7, 8, 23, 8, -29 },
  { 19, 21, 28, 23, 1, -28 },
  { 93, 16, 36, 23, 4, -32 },
  { 165, 22, 28, 23, 1, -28 },
  { 242, 19, 28, 23, 3, -28 },
  { 309, 2, 8, 23, 10, -29 },
  { 311, 9, 40, 23, 7, -31 },
  { 356, 8, 40, 23, 7, -31 },
  { 396, 17, 16, 23, 4, -28 },
  { 430, 19, 20, 23, 2, -23 },
  { 478, 3, 8, 23, 8, -3 },
  { 481, 14, 1, 23, 5, -13 },
  { 483, 3, 3, 23, 11, -3 },
  { 485, 13, 30, 23, 6, -28 },
  { 534, 17, 28, 23, 3, -28 },
  { 594, 10, 28, 23, 4, -28 },
  { 629, 18, 28, 23, 2, -28 },
  { 692, 17, 28, 23, 2, -28 },
  { 752, 19, 28, 23, 2, -28 },
  { 819, 17, 28, 23, 4, -28 },
  { 879, 17, 28, 23, 3, -28 },
  { 939, 17, 28, 23, 3, -28 },
  { 999, 18, 28, 23, 3, -28 },
  { 1062, 17, 28, 23, 3, -28 },
  { 1122, 3, 20, 23, 12, -20 },
  { 1130, 5, 25, 23, 10, -20 },
  { 1146, 17, 16, 23, 3, -21 },
  { 1180, 17, 9, 23, 3, -17 },
  { 1200, 16, 16, 23, 4, -21 },
  { 1232, 15, 28, 23, 4, -28 },
  { 1285, 21, 28, 23, 1, -28 },
  { 1359, 20, 28, 23, 2, -28 },
  { 1429, 17, 28, 23, 4, -28 },
  { 1489, 18, 28, 23, 3, -28 },
  { 1552, 17, 28, 23, 4, -28 },
  { 1612, 16, 28, 23, 4, -28 },
  { 1668, 16, 28, 23, 4, -28 },
  { 1724, 19, 28, 23, 2, -28 },
  { 1791, 17, 28, 23, 3, -28 },
  { 1851, 16, 28, 23, 4, -28 },
  { 1907, 17, 28, 23, 2, -28 },
  { 1967, 18, 28, 23, 4, -28 },
  { 2030, 16, 28, 23, 4, -28 },
  { 2086, 17, 28, 23, 3, -28 },
  { 2146, 17, 28, 23, 3, -28 },
  { 2206, 18, 28, 23, 3, -28 },
  { 2269, 18, 28, 23, 4, -28 },
  { 2332, 19, 33, 23, 2, -28 },
  { 2411, 17, 28, 23, 4, -28 },
  { 2471, 18, 28, 23, 3, -28 },
  { 2534, 20, 28, 23, 2, -28 },
  { 2604, 17, 28, 23, 3, -28 },
  { 2664, 19, 28, 23, 2, -28 },
  { 2731, 20, 28, 23, 2, -28 },
  { 2801, 20, 28, 23, 2, -28 },
  { 2871, 19, 28, 23, 2, -28 },
  { 2938, 17, 28, 23, 3, -28 },
  { 2998, 6, 38, 23, 9, -32 },
  { 3027, 13, 30, 23, 5, -28 },
  { 3076, 7, 38, 23, 8, -32 },
  { 3110, 14, 15, 23, 5, -28 },
  { 3137, 17, 1, 23, 3, 0 },
  { 3140, 5, 5, 23, 9, -29 },
  { 3144, 17, 21, 23, 3, -21 },
  { 3189, 16, 29, 23, 4, -29 },
  { 3247, 17, 21, 23, 3, -21 },
  { 3292, 16, 29, 23, 3, -29 },
  { 3350, 17, 21, 23, 3, -21 },
  { 3395, 17, 30, 23, 4, -30 },
  { 3459, 16, 29, 23, 3, -21 },
  { 3517, 16, 29, 23, 4, -29 },
  { 3575, 17, 28, 23, 4, -28 },
  { 3635, 12, 36, 23, 4, -28 },
  { 3689, 16, 29, 23, 5, -29 },
  { 3747, 17, 29, 23, 4, -29 },
  { 3809, 20, 21, 23, 2, -21 },
  { 3862, 16, 21, 23, 4, -21 },
  { 3904, 18, 21, 23, 3, -21 },
  { 3952, 16, 29, 23, 4, -21 },
  { 4010, 16, 29, 23, 3, -21 },
  { 4068, 13, 21, 23, 7, -21 },
  { 4103, 16, 21, 23, 4, -21 },
  { 4145, 17, 26, 23, 3, -26 },
  { 4201, 16, 21, 23, 4, -21 },
  { 4243, 19, 21, 23, 2, -21 },
  { 4293, 21, 21, 23, 1, -21 },
  { 4349, 18, 21, 23, 3, -21 },
  { 4397, 20, 29, 23, 2, -21 },
  { 4470, 18, 21, 23, 3, -21 },
  { 4518, 13, 38, 23, 6, -30 },
  { 4580, 1, 34, 23, 11, -28 },
  { 4585, 13, 38, 23, 6, -30 },
  { 4647, 21, 7, 23, 1, -15 },
};

const GFXfont RobotoMono_ExtraLight39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight39pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_EXTRALIGHT39PT7B_H_
