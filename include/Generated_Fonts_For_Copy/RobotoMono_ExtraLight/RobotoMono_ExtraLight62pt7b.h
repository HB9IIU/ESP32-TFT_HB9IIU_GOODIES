#ifndef _ROBOTOMONO_EXTRALIGHT62PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight62pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0D, 0x81, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0x70, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x07, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x30,
  0x03, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x18, 0x07, 0x00, 0x70, 0x03, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x38, 0x01,
  0xC0, 0x0C, 0x06, 0x00, 0x18, 0x03, 0x81, 0x80, 0x03, 0x80, 0x70, 0x70,
  0x00, 0x30, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x03, 0x80, 0x00, 0x7F, 0xE0,
  0x60, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0E, 0x03,
  0xF8, 0x00, 0x01, 0x81, 0xFF, 0x80, 0x00, 0x70, 0x30, 0x38, 0x00, 0x0C,
  0x0C, 0x03, 0x80, 0x03, 0x81, 0x80, 0x30, 0x00, 0x60, 0x70, 0x06, 0x00,
  0x1C, 0x0C, 0x00, 0xE0, 0x03, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x30, 0x03,
  0x80, 0x18, 0x06, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x18,
  0x01, 0xC0, 0x30, 0x03, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x40,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xC0, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x61, 0xC0, 0x3C,
  0x00, 0xC7, 0x00, 0x38, 0x03, 0x8C, 0x00, 0x38, 0x07, 0x38, 0x00, 0x38,
  0x0E, 0x70, 0x00, 0x38, 0x18, 0xC0, 0x00, 0x78, 0x71, 0x80, 0x00, 0x70,
  0xE3, 0x00, 0x00, 0x71, 0x86, 0x00, 0x00, 0x77, 0x0C, 0x00, 0x00, 0x7C,
  0x1C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x0E, 0xE0, 0x78, 0x00, 0x78, 0xE0, 0x7C, 0x03, 0xE0, 0xE0,
  0x7F, 0xFF, 0x81, 0xE0, 0x3F, 0xF8, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xDB, 0x6D, 0x80, 0x00, 0x08, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x80, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0xDF, 0x01, 0xC0, 0xFF, 0xFC, 0x38,
  0x7F, 0x07, 0xF7, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x07,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0x78, 0x06, 0x00, 0x04,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38,
  0xC7, 0x38, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x23, 0xFF, 0xF7,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0xE0,
  0x3C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x77, 0xE0, 0x00, 0x1C, 0x7C, 0x00, 0x07, 0x0F, 0x80, 0x01, 0xC1, 0xF0,
  0x00, 0x70, 0x3E, 0x00, 0x1C, 0x07, 0xC0, 0x07, 0x00, 0xF8, 0x01, 0xC0,
  0x1F, 0x00, 0x70, 0x03, 0xE0, 0x1C, 0x00, 0x7C, 0x07, 0x00, 0x0F, 0x81,
  0xC0, 0x01, 0xF0, 0x70, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0xC7, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03,
  0xF8, 0x1F, 0xF0, 0xFC, 0xE7, 0xC1, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00,
  0xF0, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x0C, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x81, 0xF8, 0x03, 0xF0, 0x78, 0x00, 0x3E, 0x0C, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x9C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x3E,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x3F, 0xC0, 0x1C,
  0x1F, 0xFE, 0x03, 0x8F, 0xEF, 0xE0, 0x73, 0xC0, 0x1F, 0x0C, 0xE0, 0x00,
  0xF1, 0xB0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0,
  0x1F, 0x00, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x80, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0xE0, 0x00,
  0x78, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x1F,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x3E,
  0x00, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x07, 0xE3,
  0x80, 0x01, 0xDC, 0x78, 0x00, 0x73, 0x87, 0xC0, 0x3C, 0x70, 0x3F, 0xFF,
  0x0C, 0x03, 0xFF, 0x81, 0x80, 0x07, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x27, 0xBF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x4F, 0x7F, 0xFE, 0x08, 0x78, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0C,
  0x38, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x00,
  0xF8, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0xFE, 0x01, 0x86, 0x00, 0xFF,
  0x80, 0xC7, 0x00, 0xE0, 0xE0, 0x73, 0x00, 0xE0, 0x30, 0x1B, 0x80, 0xE0,
  0x18, 0x0D, 0x80, 0x60, 0x0C, 0x06, 0xC0, 0x60, 0x06, 0x03, 0x60, 0x30,
  0x03, 0x01, 0xF0, 0x38, 0x03, 0x00, 0xF0, 0x18, 0x01, 0x80, 0x78, 0x0C,
  0x00, 0xC0, 0x3C, 0x06, 0x00, 0x60, 0x1E, 0x03, 0x00, 0x30, 0x0F, 0x03,
  0x80, 0x18, 0x07, 0x81, 0x80, 0x0C, 0x03, 0xC0, 0xC0, 0x06, 0x01, 0xE0,
  0x60, 0x03, 0x00, 0xF0, 0x30, 0x03, 0x80, 0x78, 0x1C, 0x01, 0xC0, 0x6C,
  0x06, 0x01, 0xE0, 0x36, 0x03, 0x00, 0xF0, 0x1B, 0x01, 0x80, 0xD8, 0x19,
  0xC0, 0xE0, 0xEC, 0x0C, 0x60, 0x38, 0xE7, 0x0C, 0x30, 0x1F, 0xE1, 0xFE,
  0x1C, 0x07, 0xE0, 0x7C, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0x80, 0x0F, 0xE0,
  0x70, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x7C, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x1F, 0x1C, 0x00, 0x3F, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x00,
  0x78, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xC0, 0x07, 0xE0, 0x0C, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x3C, 0x0C,
  0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x1E, 0x0C, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0xF8, 0x0C, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xC0, 0x3E, 0x00,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xE6, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0xF0, 0x06,
  0x00, 0x0F, 0x00, 0x30, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x07, 0x80,
  0x00, 0xC0, 0x78, 0x00, 0x06, 0x07, 0x80, 0x00, 0x30, 0x78, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x0C, 0x3E, 0x00, 0x00, 0x63, 0xF0, 0x00, 0x03, 0x39,
  0xC0, 0x00, 0x1B, 0x87, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x38, 0x03, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x70, 0x06, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x83, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x3D, 0x80, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x37, 0xEC, 0x00, 0x07, 0x7E, 0xE0, 0x00, 0x77, 0xEE, 0x00,
  0x06, 0x7E, 0x60, 0x00, 0xE7, 0xE7, 0x00, 0x0C, 0x7E, 0x30, 0x01, 0xC7,
  0xE3, 0x80, 0x1C, 0x7E, 0x38, 0x01, 0x87, 0xE1, 0x80, 0x38, 0x7E, 0x1C,
  0x03, 0x07, 0xE1, 0xC0, 0x70, 0x7E, 0x0C, 0x07, 0x07, 0xE0, 0xE0, 0x60,
  0x7E, 0x06, 0x0E, 0x07, 0xE0, 0x60, 0xC0, 0x7E, 0x07, 0x1C, 0x07, 0xE0,
  0x31, 0xC0, 0x7E, 0x03, 0x98, 0x07, 0xE0, 0x3B, 0x80, 0x7E, 0x01, 0xB0,
  0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0E, 0x00, 0x7E,
  0x00, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFB, 0x00, 0x00, 0x3F, 0x70, 0x00, 0x07, 0xE7, 0x00, 0x00, 0xFC, 0xE0,
  0x00, 0x1F, 0x8E, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x7E, 0x1C, 0x00, 0x0F,
  0xC1, 0x80, 0x01, 0xF8, 0x38, 0x00, 0x3F, 0x03, 0x00, 0x07, 0xE0, 0x70,
  0x00, 0xFC, 0x07, 0x00, 0x1F, 0x80, 0xE0, 0x03, 0xF0, 0x0E, 0x00, 0x7E,
  0x01, 0xC0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x01, 0x80, 0x3F, 0x00, 0x38,
  0x07, 0xE0, 0x03, 0x00, 0xFC, 0x00, 0x70, 0x1F, 0x80, 0x07, 0x03, 0xF0,
  0x00, 0xE0, 0x7E, 0x00, 0x0E, 0x0F, 0xC0, 0x01, 0xC1, 0xF8, 0x00, 0x1C,
  0x3F, 0x00, 0x01, 0x87, 0xE0, 0x00, 0x38, 0xFC, 0x00, 0x03, 0x1F, 0x80,
  0x00, 0x73, 0xF0, 0x00, 0x07, 0x7E, 0x00, 0x00, 0xEF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x78, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x38, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0x80, 0x03, 0xF0, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0x38, 0x00,
  0x0F, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x70,
  0x07, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0x00, 0x0F,
  0xC0, 0x60, 0x00, 0x3C, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x30,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03,
  0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x0C, 0x00,
  0x01, 0xE1, 0x80, 0x00, 0x78, 0x30, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x18, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00,
  0xE0, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x06,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x30,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0x7E, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xB8,
  0x00, 0x70, 0x00, 0xDC, 0x00, 0x78, 0x00, 0x6E, 0x00, 0x3C, 0x00, 0x33,
  0x00, 0x1E, 0x00, 0x39, 0x80, 0x0F, 0x80, 0x1C, 0xC0, 0x06, 0xC0, 0x0C,
  0x70, 0x07, 0x60, 0x06, 0x38, 0x03, 0xB0, 0x03, 0x1C, 0x01, 0x98, 0x01,
  0x8E, 0x00, 0xCE, 0x01, 0xC3, 0x00, 0x67, 0x00, 0xE1, 0x80, 0x71, 0x80,
  0x70, 0xC0, 0x38, 0xC0, 0x30, 0x70, 0x18, 0x60, 0x18, 0x38, 0x0C, 0x38,
  0x0C, 0x1C, 0x06, 0x1C, 0x06, 0x06, 0x07, 0x06, 0x07, 0x03, 0x03, 0x83,
  0x03, 0x81, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xE0, 0xC0, 0x70, 0x60,
  0x70, 0x60, 0x38, 0x70, 0x18, 0x30, 0x1C, 0x38, 0x0C, 0x18, 0x06, 0x18,
  0x06, 0x1C, 0x03, 0x0C, 0x03, 0x8E, 0x01, 0x86, 0x01, 0xC6, 0x00, 0xC7,
  0x00, 0xE3, 0x00, 0x73, 0x80, 0x31, 0x80, 0x39, 0xC0, 0x18, 0xC0, 0x1C,
  0xC0, 0x0E, 0x60, 0x06, 0x60, 0x07, 0x70, 0x03, 0x30, 0x03, 0xB8, 0x01,
  0xB8, 0x00, 0xD8, 0x00, 0xFC, 0x00, 0x6C, 0x00, 0x7C, 0x00, 0x36, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x01, 0xE0,
  0x07, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x18, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0x70,
  0x70, 0x01, 0x80, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x06, 0x00, 0xC0, 0x1C,
  0x07, 0x00, 0x70, 0x18, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x06, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x38, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0x01, 0xF8, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0F,
  0x38, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xFC, 0x78, 0x00, 0x79, 0x87, 0x80,
  0x3E, 0x38, 0x7F, 0xFF, 0x07, 0x03, 0xFF, 0x80, 0xE0, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x07, 0xFC,
  0x03, 0x87, 0xFF, 0xC0, 0xE7, 0xC0, 0xF8, 0x3B, 0xC0, 0x0F, 0x0E, 0xC0,
  0x01, 0xE3, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xF0, 0x00,
  0x07, 0x3E, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0xE3, 0xB8, 0x00, 0xF0, 0xE7,
  0x80, 0x78, 0x38, 0xFF, 0xFC, 0x0E, 0x0F, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0x81, 0xF8, 0x03, 0x80,
  0x07, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x38, 0x1E, 0x00, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x0F, 0xFC, 0x1C, 0x0F, 0xFF, 0x87, 0x07,
  0xC0, 0xF9, 0xC3, 0xC0, 0x07, 0x71, 0xE0, 0x00, 0xFC, 0x70, 0x00, 0x1F,
  0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x77, 0x07, 0x80, 0x79, 0xC0, 0xFF, 0xFC,
  0x70, 0x0F, 0xFC, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0x81, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0,
  0x20, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0xC1, 0xC0, 0x7F, 0xF8, 0x70, 0x7C, 0x0F, 0x9C, 0x3C, 0x00, 0x77,
  0x1E, 0x00, 0x0F, 0xC7, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x07,
  0x70, 0x7C, 0x07, 0x9C, 0x0F, 0xFF, 0xC7, 0x00, 0xFF, 0xC1, 0xC0, 0x03,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x40, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x1F, 0x83, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x03, 0xFE, 0x03, 0x83, 0xFF, 0xE0, 0xE1, 0xE0, 0x7C,
  0x39, 0xE0, 0x07, 0x8E, 0x60, 0x00, 0x73, 0xB0, 0x00, 0x1C, 0xF8, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x20, 0x3F, 0x07,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x03,
  0xC0, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x00, 0xE0,
  0x3C, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x3B, 0xF8, 0x00, 0x0F, 0xEF, 0x00, 0x03, 0xF1, 0xE0,
  0x00, 0xF8, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x03,
  0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x3C, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC3,
  0xF8, 0x0F, 0xF0, 0xCF, 0xFE, 0x1F, 0xF8, 0xDC, 0x1F, 0x38, 0x3C, 0xF8,
  0x07, 0x60, 0x0E, 0xF0, 0x03, 0xC0, 0x0E, 0xE0, 0x03, 0xC0, 0x06, 0xE0,
  0x03, 0x80, 0x06, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xE0,
  0x3F, 0xE0, 0x70, 0x7F, 0xFC, 0x38, 0xF8, 0x1F, 0x1C, 0xF0, 0x03, 0xCE,
  0xE0, 0x00, 0x77, 0x60, 0x00, 0x3B, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x7F, 0xC0, 0x38, 0x7F, 0xFC, 0x0E, 0x7C, 0x0F, 0x83, 0xB8, 0x00, 0xF0,
  0xFC, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xCF,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x0E, 0x3B, 0x80, 0x0F,
  0x0E, 0x78, 0x07, 0x83, 0x8F, 0xFF, 0xC0, 0xE0, 0xFF, 0xC0, 0x38, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xC0, 0xFF, 0xFC, 0x70,
  0x7C, 0x0F, 0x9C, 0x3C, 0x00, 0x77, 0x1E, 0x00, 0x0F, 0xC7, 0x00, 0x01,
  0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x07, 0xF0, 0x78, 0x07, 0xDC, 0x0F, 0xFF,
  0xC7, 0x00, 0xFF, 0xC1, 0xC0, 0x03, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0xE0,
  0x1F, 0xFF, 0x81, 0xFF, 0xEE, 0x1F, 0xC0, 0xB8, 0xF0, 0x00, 0xE7, 0x00,
  0x03, 0xB8, 0x00, 0x0E, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0xF8, 0x07, 0xE0, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC1, 0xF0, 0x03, 0xE0, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xE6, 0x00, 0x01,
  0xF3, 0x80, 0x01, 0xD8, 0xE0, 0x01, 0xCC, 0x7C, 0x03, 0xC6, 0x0F, 0xFF,
  0xC3, 0x03, 0xFF, 0x81, 0x80, 0x3A, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0,
  0x07, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x30, 0x00,
  0x66, 0x00, 0x1C, 0x00, 0x19, 0x80, 0x07, 0x80, 0x0E, 0x70, 0x01, 0xE0,
  0x03, 0x9C, 0x00, 0x78, 0x00, 0xC3, 0x00, 0x36, 0x00, 0x30, 0xC0, 0x0D,
  0xC0, 0x1C, 0x30, 0x03, 0x30, 0x07, 0x0E, 0x00, 0xCC, 0x01, 0x83, 0x80,
  0x73, 0x00, 0x60, 0x60, 0x18, 0xE0, 0x18, 0x18, 0x06, 0x18, 0x0E, 0x07,
  0x01, 0x86, 0x03, 0x81, 0xC0, 0xC1, 0x80, 0xC0, 0x30, 0x30, 0x70, 0x30,
  0x0C, 0x0C, 0x0C, 0x0C, 0x03, 0x07, 0x03, 0x07, 0x00, 0xE1, 0x80, 0xC1,
  0x80, 0x38, 0x60, 0x38, 0x60, 0x06, 0x18, 0x06, 0x18, 0x01, 0x8E, 0x01,
  0x8E, 0x00, 0x73, 0x00, 0x63, 0x80, 0x1C, 0xC0, 0x1C, 0xC0, 0x03, 0x30,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x37, 0x00, 0x0D,
  0x80, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xC7, 0xFF, 0x80, 0x00, 0x67, 0x83, 0xE0, 0x00, 0x37, 0x00, 0x78,
  0x00, 0x3B, 0x00, 0x1E, 0x00, 0x19, 0x80, 0x03, 0xC0, 0x1D, 0xC0, 0x00,
  0xF0, 0x1C, 0xC0, 0x00, 0x3F, 0xFE, 0x60, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00,
};

const GFXglyph RobotoMono_ExtraLight62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 4, 44, 37, 16, -44 },
  { 23, 11, 14, 37, 13, -47 },
  { 43, 34, 44, 37, 2, -44 },
  { 230, 27, 57, 37, 6, -51 },
  { 423, 35, 46, 37, 1, -45 },
  { 625, 31, 46, 37, 5, -45 },
  { 804, 3, 14, 37, 16, -47 },
  { 810, 14, 63, 37, 12, -49 },
  { 921, 14, 63, 37, 11, -49 },
  { 1032, 27, 25, 37, 6, -44 },
  { 1117, 30, 33, 37, 4, -37 },
  { 1241, 6, 13, 37, 12, -5 },
  { 1251, 23, 2, 37, 7, -21 },
  { 1257, 5, 5, 37, 17, -5 },
  { 1261, 21, 48, 37, 9, -44 },
  { 1387, 27, 46, 37, 5, -45 },
  { 1543, 15, 44, 37, 7, -44 },
  { 1626, 28, 45, 37, 3, -45 },
  { 1784, 27, 46, 37, 3, -45 },
  { 1940, 31, 44, 37, 3, -44 },
  { 2111, 26, 45, 37, 7, -44 },
  { 2258, 27, 46, 37, 5, -45 },
  { 2414, 29, 44, 37, 4, -44 },
  { 2574, 28, 46, 37, 5, -45 },
  { 2735, 27, 45, 37, 5, -45 },
  { 2887, 5, 32, 37, 19, -32 },
  { 2907, 7, 40, 37, 17, -32 },
  { 2942, 26, 26, 37, 5, -33 },
  { 3027, 27, 14, 37, 5, -27 },
  { 3075, 26, 25, 37, 6, -33 },
  { 3157, 24, 45, 37, 7, -45 },
  { 3292, 33, 44, 37, 2, -44 },
  { 3474, 32, 44, 37, 3, -44 },
  { 3650, 27, 44, 37, 6, -44 },
  { 3799, 29, 46, 37, 4, -45 },
  { 3966, 28, 44, 37, 6, -44 },
  { 4120, 26, 44, 37, 6, -44 },
  { 4263, 25, 44, 37, 7, -44 },
  { 4401, 29, 46, 37, 4, -45 },
  { 4568, 27, 44, 37, 5, -44 },
  { 4717, 25, 44, 37, 6, -44 },
  { 4855, 27, 45, 37, 4, -44 },
  { 5007, 29, 44, 37, 7, -44 },
  { 5167, 26, 44, 37, 7, -44 },
  { 5310, 28, 44, 37, 5, -44 },
  { 5464, 27, 44, 37, 5, -44 },
  { 5613, 29, 46, 37, 4, -45 },
  { 5780, 27, 44, 37, 7, -44 },
  { 5929, 31, 53, 37, 3, -45 },
  { 6135, 27, 44, 37, 7, -44 },
  { 6284, 30, 46, 37, 4, -45 },
  { 6457, 31, 44, 37, 3, -44 },
  { 6628, 27, 45, 37, 5, -44 },
  { 6780, 31, 44, 37, 3, -44 },
  { 6951, 33, 44, 37, 3, -44 },
  { 7133, 31, 44, 37, 4, -44 },
  { 7304, 31, 44, 37, 3, -44 },
  { 7475, 28, 44, 37, 4, -44 },
  { 7629, 10, 59, 37, 14, -50 },
  { 7703, 21, 48, 37, 8, -44 },
  { 7829, 10, 59, 37, 13, -50 },
  { 7903, 22, 24, 37, 8, -44 },
  { 7969, 26, 2, 37, 6, 0 },
  { 7976, 9, 8, 37, 14, -46 },
  { 7985, 27, 34, 37, 5, -33 },
  { 8100, 26, 48, 37, 6, -47 },
  { 8256, 27, 34, 37, 5, -33 },
  { 8371, 26, 48, 37, 5, -47 },
  { 8527, 27, 34, 37, 5, -33 },
  { 8642, 28, 47, 37, 6, -47 },
  { 8807, 26, 46, 37, 5, -33 },
  { 8957, 26, 47, 37, 6, -47 },
  { 9110, 26, 44, 37, 7, -44 },
  { 9253, 19, 57, 37, 6, -44 },
  { 9389, 26, 47, 37, 7, -47 },
  { 9542, 26, 47, 37, 7, -47 },
  { 9695, 32, 33, 37, 3, -33 },
  { 9827, 25, 33, 37, 6, -33 },
  { 9931, 29, 34, 37, 4, -33 },
  { 10055, 26, 46, 37, 6, -33 },
  { 10205, 26, 46, 37, 5, -33 },
  { 10355, 22, 33, 37, 11, -33 },
  { 10446, 26, 34, 37, 6, -33 },
  { 10557, 25, 42, 37, 6, -41 },
  { 10689, 25, 34, 37, 6, -33 },
  { 10796, 31, 33, 37, 3, -33 },
  { 10924, 34, 33, 37, 2, -33 },
  { 11065, 30, 33, 37, 4, -33 },
  { 11189, 33, 46, 37, 2, -33 },
  { 11379, 29, 33, 37, 4, -33 },
  { 11499, 20, 61, 37, 10, -48 },
  { 11652, 3, 53, 37, 17, -44 },
  { 11672, 20, 61, 37, 10, -48 },
  { 11825, 33, 11, 37, 2, -24 },
};

const GFXfont RobotoMono_ExtraLight62pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight62pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOMONO_EXTRALIGHT62PT7B_H_
