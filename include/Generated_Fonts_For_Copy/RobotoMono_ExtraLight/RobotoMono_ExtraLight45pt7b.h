#ifndef _ROBOTOMONO_EXTRALIGHT45PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight45pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x00, 0x01,
  0xBE, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC3, 0xC3, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x03, 0x00,
  0x02, 0x01, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x30, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x20,
  0x18, 0x00, 0x10, 0x08, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x06,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x10, 0x0C, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0xE0, 0x0F, 0x8F, 0x01, 0xC0, 0x38, 0x38,
  0x01, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x06, 0x60,
  0x00, 0x63, 0x00, 0x0C, 0x18, 0x01, 0xC0, 0xF0, 0xF8, 0x07, 0xFE, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x3F, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x18, 0x08, 0x04,
  0x0C, 0x06, 0x03, 0x06, 0x03, 0x03, 0x03, 0x01, 0x81, 0x81, 0x80, 0xC1,
  0x80, 0xC0, 0x60, 0xC0, 0x60, 0x30, 0xC0, 0x30, 0x10, 0x40, 0x0C, 0x18,
  0x60, 0x03, 0xB8, 0x20, 0x00, 0xF8, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x1F, 0x00,
  0x06, 0x1D, 0xC0, 0x06, 0x18, 0x30, 0x02, 0x08, 0x08, 0x03, 0x0C, 0x06,
  0x01, 0x06, 0x03, 0x01, 0x83, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0xC0,
  0x60, 0xC0, 0x60, 0x30, 0x20, 0x10, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0x38, 0x00, 0x38, 0x18,
  0x00, 0x60, 0x38, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x70, 0x00,
  0x31, 0xC0, 0x00, 0x66, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0xE0, 0xC0, 0x31, 0x80,
  0xC0, 0x66, 0x01, 0xC0, 0xCC, 0x01, 0x83, 0x30, 0x01, 0x86, 0x60, 0x01,
  0x8C, 0xC0, 0x01, 0xB1, 0x80, 0x03, 0xE1, 0x80, 0x03, 0x83, 0x00, 0x07,
  0x07, 0x00, 0x1F, 0x07, 0x00, 0x73, 0x07, 0xC7, 0x87, 0x03, 0xFE, 0x07,
  0xFF, 0xAA, 0xA0, 0x00, 0x40, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x60, 0x7F, 0xC6, 0x1F, 0x1F, 0xEF, 0x80, 0x1F, 0xC0,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0x98, 0x00, 0x30, 0xC0, 0x07, 0x06,
  0x00, 0x60, 0x70, 0x0C, 0x03, 0x81, 0x80, 0x18, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x33, 0x33, 0x32, 0x66, 0xCC, 0xFF, 0xFF, 0x7F, 0x70, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x01,
  0xE3, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC7, 0x00, 0x0C, 0xC0, 0x01, 0x90,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xBC, 0x00, 0xE3, 0x80, 0x30, 0x70, 0x0C, 0x0E, 0x03, 0x01, 0xC0,
  0xC0, 0x38, 0x30, 0x07, 0x0C, 0x00, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0xB0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x0D, 0x80,
  0x03, 0x38, 0x00, 0x63, 0x00, 0x18, 0x30, 0x06, 0x03, 0xC7, 0x80, 0x3F,
  0xE0, 0x00, 0x60, 0x3C, 0x1F, 0x9F, 0x3F, 0x87, 0x80, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x03, 0xFC, 0x00,
  0x78, 0x78, 0x07, 0x00, 0xE0, 0x60, 0x03, 0x87, 0x00, 0x0C, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x03, 0xFE, 0x00,
  0xF0, 0xF0, 0x1C, 0x01, 0x83, 0x80, 0x0C, 0x30, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x60, 0x00, 0x37, 0x00, 0x06, 0x30, 0x00, 0xE1, 0xC0, 0x1C,
  0x0F, 0x0F, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60,
  0x60, 0x01, 0x81, 0x80, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x7F, 0x80, 0xFF, 0xFC, 0x1E, 0x03, 0xC3, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x19, 0x80,
  0x03, 0x30, 0x00, 0xE3, 0x00, 0x38, 0x78, 0x0E, 0x07, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x0F, 0xC0, 0x67, 0xFF, 0x06, 0xE0, 0x38,
  0x58, 0x01, 0xCF, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x18,
  0x00, 0xC0, 0xC0, 0x18, 0x07, 0x8F, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0xF8, 0xF0, 0x1C, 0x03, 0x83, 0x00, 0x0C, 0x70, 0x00, 0xE6, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x67, 0x00, 0x0E, 0x30, 0x00, 0xC1, 0xC0, 0x38, 0x0F, 0x8F, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0x01, 0xC0, 0x38, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x60,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x06, 0x70, 0x00, 0xE3, 0x80, 0x1C,
  0x1F, 0x8F, 0x80, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0xF0, 0x1C, 0x03,
  0x81, 0x80, 0x1C, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x30, 0x00, 0x73,
  0x80, 0x0F, 0x1C, 0x03, 0xB0, 0xF0, 0xF3, 0x07, 0xFC, 0x30, 0x06, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x39, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x63, 0x18,
  0xC6, 0x23, 0x19, 0x80, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0x9F, 0x0E, 0x01, 0xCE, 0x00, 0x66,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x01, 0x80,
  0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x18, 0x0C, 0x60, 0x3F, 0x06,
  0x30, 0x70, 0xC1, 0x10, 0x30, 0x60, 0x98, 0x30, 0x30, 0x4C, 0x10, 0x18,
  0x34, 0x18, 0x0C, 0x1A, 0x0C, 0x04, 0x0F, 0x04, 0x02, 0x07, 0x82, 0x01,
  0x03, 0xC1, 0x00, 0x81, 0xE1, 0x80, 0x40, 0xB0, 0xC0, 0x60, 0x58, 0x20,
  0x30, 0x2C, 0x10, 0x18, 0x36, 0x08, 0x1C, 0x19, 0x06, 0x1A, 0x08, 0xC3,
  0x19, 0x8C, 0x60, 0xF8, 0xFC, 0x30, 0x10, 0x18, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0x00, 0x1F, 0x8F, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x63, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x60, 0x02, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x20, 0x03,
  0x00, 0xC0, 0x02, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x63,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x82, 0x00, 0x38, 0x40, 0x01, 0x88, 0x00, 0x19, 0x00,
  0x03, 0x20, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00,
  0x03, 0x40, 0x00, 0xC8, 0x00, 0x39, 0x00, 0x0E, 0x20, 0x1F, 0x07, 0xFF,
  0xC0, 0x80, 0x1E, 0x10, 0x00, 0x72, 0x00, 0x07, 0x40, 0x00, 0x68, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x00, 0x0E, 0x3F, 0xFF,
  0x87, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3C, 0x3C, 0x03, 0x00, 0x70, 0x30,
  0x01, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x07,
  0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0xC1, 0x80, 0x0E, 0x06, 0x00, 0xE0, 0x1E, 0x1E,
  0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x30, 0x03, 0x81, 0x80,
  0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x03, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x07, 0x30,
  0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x07, 0x03, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0xFC, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3C, 0x7C, 0x03, 0x80, 0x70, 0x30,
  0x01, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xCC,
  0x00, 0x06, 0x70, 0x00, 0x31, 0xC0, 0x03, 0x87, 0x00, 0x38, 0x1E, 0x0F,
  0x00, 0x3F, 0xE0, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0x30, 0x00, 0x67, 0x00, 0x18, 0x70, 0x06, 0x07, 0xC7,
  0x80, 0x3F, 0xE0, 0xC0, 0x00, 0x76, 0x00, 0x07, 0x30, 0x00, 0x71, 0x80,
  0x07, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00,
  0xC0, 0x30, 0x06, 0x03, 0x80, 0x30, 0x38, 0x01, 0x83, 0x80, 0x0C, 0x38,
  0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x19, 0xE0, 0x00, 0xD9, 0x80, 0x07,
  0x8E, 0x00, 0x38, 0x38, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0x70, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xE1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01,
  0xD8, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xBD, 0x00, 0x1B, 0xD8, 0x03,
  0x3D, 0x80, 0x33, 0xCC, 0x03, 0x3C, 0xC0, 0x63, 0xCC, 0x06, 0x3C, 0x60,
  0xC3, 0xC6, 0x0C, 0x3C, 0x20, 0xC3, 0xC3, 0x18, 0x3C, 0x31, 0x83, 0xC1,
  0xB0, 0x3C, 0x1B, 0x03, 0xC1, 0xB0, 0x3C, 0x0E, 0x03, 0xC0, 0xE0, 0x3C,
  0x04, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xB0, 0x00, 0xF6, 0x00, 0x1E, 0x60, 0x03, 0xCC, 0x00,
  0x78, 0xC0, 0x0F, 0x18, 0x01, 0xE1, 0x80, 0x3C, 0x18, 0x07, 0x83, 0x00,
  0xF0, 0x30, 0x1E, 0x06, 0x03, 0xC0, 0x60, 0x78, 0x0C, 0x0F, 0x00, 0xC1,
  0xE0, 0x18, 0x3C, 0x01, 0x87, 0x80, 0x18, 0xF0, 0x03, 0x1E, 0x00, 0x33,
  0xC0, 0x06, 0x78, 0x00, 0x6F, 0x00, 0x0D, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x03, 0xFE, 0x00, 0x3C, 0x78,
  0x03, 0x80, 0xE0, 0x30, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x31, 0x80,
  0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x80, 0x0C, 0x07,
  0x00, 0xC0, 0x1E, 0x3C, 0x00, 0x7F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xC0, 0x07, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0,
  0x07, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x8F, 0x00, 0x18, 0x03, 0x80,
  0x60, 0x03, 0x01, 0x80, 0x03, 0x07, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0x80,
  0xC0, 0x06, 0x00, 0xC0, 0x1C, 0x00, 0xF1, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xC0, 0x0F,
  0x0C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0x4C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x70, 0xC0, 0x1E, 0x0F,
  0xFF, 0x80, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00, 0xC0,
  0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00,
  0x07, 0x03, 0xFE, 0x00, 0x7E, 0x3C, 0x07, 0x00, 0x70, 0x70, 0x00, 0xC3,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xE0, 0x00, 0x73, 0x80, 0x03, 0x0E, 0x00, 0x70, 0x3F, 0x1F, 0x00, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x80,
  0x03, 0x30, 0x00, 0x63, 0x00, 0x18, 0x30, 0x06, 0x03, 0xC7, 0x80, 0x3F,
  0xE0, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x63, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00,
  0xC0, 0x06, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x88, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x02, 0x40, 0x3C, 0x02, 0x40, 0x3C, 0x06,
  0x60, 0x3C, 0x06, 0x60, 0x3C, 0x06, 0x60, 0x24, 0x06, 0x60, 0x64, 0x06,
  0x60, 0x66, 0x04, 0x20, 0x66, 0x04, 0x30, 0x66, 0x0C, 0x30, 0x46, 0x0C,
  0x30, 0xC2, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x08,
  0x10, 0x83, 0x18, 0x19, 0x81, 0x18, 0x19, 0x81, 0x98, 0x19, 0x81, 0x98,
  0x19, 0x81, 0x98, 0x19, 0x01, 0x90, 0x09, 0x00, 0x90, 0x0B, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE0, 0x00, 0x1D,
  0x80, 0x00, 0x67, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x70,
  0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x03, 0x80, 0x0C, 0x0C,
  0x00, 0x38, 0x60, 0x00, 0x61, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00,
  0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0C,
  0xC0, 0x00, 0x73, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x30,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x06, 0x0E,
  0x00, 0x18, 0x30, 0x00, 0x31, 0x80, 0x00, 0xE6, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x61, 0x80, 0x00,
  0xC3, 0x00, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x66, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0F, 0xFF, 0xF0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x36,
  0x00, 0x6C, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x18, 0x30, 0x30, 0x60,
  0xC0, 0x61, 0x80, 0xC2, 0x00, 0x8C, 0x01, 0x98, 0x03, 0x60, 0x03, 0xC0,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xE0, 0x0E, 0x18, 0x00, 0xC6, 0x00, 0x0C,
  0xC0, 0x01, 0xB0, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0xFF, 0x83, 0xFF, 0xF1, 0xE0, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFE,
  0x00, 0x36, 0xE0, 0x0C, 0xCF, 0x0F, 0x18, 0xFF, 0x83, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x7F, 0x83, 0x3F, 0xF0,
  0xD8, 0x0E, 0x3C, 0x00, 0xCE, 0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xB0, 0x00, 0x6E, 0x00, 0x33, 0xC0, 0x18, 0x9E, 0x3C, 0x21,
  0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x70, 0x0E, 0x1C, 0x00, 0xC3,
  0x00, 0x0C, 0xC0, 0x01, 0xD8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x0D, 0x80, 0x01, 0xB8,
  0x00, 0x63, 0x00, 0x1C, 0x38, 0x07, 0x03, 0xC7, 0xC0, 0x1F, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x7F, 0x8C,
  0x3F, 0xF3, 0x1C, 0x06, 0xCC, 0x00, 0xF7, 0x00, 0x1D, 0x80, 0x03, 0x60,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x1C, 0x60, 0x0F, 0x0F,
  0x1E, 0xC1, 0xFE, 0x30, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0x70,
  0x38, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x19, 0xC0, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x13, 0x00, 0x00, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x41, 0xC0, 0x03, 0x07,
  0x00, 0x70, 0x1E, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xF1,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xF8, 0x43, 0xFF, 0x11, 0xC0, 0x64, 0xC0, 0x0D, 0x70, 0x01,
  0xD8, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x01,
  0xC6, 0x00, 0xF0, 0xF1, 0xEC, 0x1F, 0xE3, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x20, 0x01, 0x98, 0x00, 0x63, 0x80, 0x70, 0x78,
  0x78, 0x07, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x07, 0xF8, 0x61, 0xFF, 0x8C, 0xE0,
  0x39, 0x90, 0x03, 0xB4, 0x00, 0x37, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x78, 0xFF, 0x80, 0xF0, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x07, 0x60,
  0x01, 0xCC, 0x00, 0x71, 0x80, 0x1C, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x18, 0x38, 0x03, 0x0E, 0x00, 0x63, 0x80, 0x0C, 0xE0, 0x01, 0xBE,
  0x00, 0x3E, 0x60, 0x07, 0x0E, 0x00, 0xC0, 0xE0, 0x18, 0x0E, 0x03, 0x00,
  0xE0, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC6, 0x00,
  0x1C, 0xC0, 0x01, 0xD8, 0x00, 0x1C, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xCF, 0xC1, 0xF9, 0xBF, 0xCF, 0xFB, 0xC1, 0xF0, 0x37,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x02, 0x00, 0xF0, 0x04, 0x01, 0xE0,
  0x08, 0x03, 0xC0, 0x10, 0x07, 0x80, 0x20, 0x0F, 0x00, 0x40, 0x1E, 0x00,
  0x80, 0x3C, 0x01, 0x00, 0x78, 0x02, 0x00, 0xF0, 0x04, 0x01, 0xE0, 0x08,
  0x03, 0xC0, 0x10, 0x07, 0x80, 0x20, 0x0F, 0x00, 0x40, 0x1E, 0x00, 0x80,
  0x3C, 0x01, 0x00, 0x78, 0x02, 0x00, 0xF0, 0x04, 0x01, 0xE0, 0x08, 0x03,
  0xC1, 0xFE, 0x18, 0x7F, 0xE3, 0x38, 0x0E, 0x6C, 0x00, 0xED, 0x00, 0x0D,
  0xE0, 0x01, 0xB8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0x80, 0xE0, 0x30, 0x01, 0x83, 0x00, 0x06, 0x38, 0x00,
  0x39, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60,
  0x00, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0xE0, 0x3E, 0x3E, 0x00, 0x7F, 0xC0,
  0x87, 0xF8, 0x23, 0xFF, 0x0B, 0x80, 0xE2, 0xC0, 0x1C, 0xE0, 0x03, 0xB0,
  0x00, 0x6C, 0x00, 0x1A, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xE0, 0x03, 0x2C,
  0x01, 0x89, 0xE3, 0xC2, 0x1F, 0xE0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x43, 0xFF, 0x11, 0xC0, 0x64, 0xC0, 0x0D,
  0x70, 0x01, 0xD8, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03,
  0x30, 0x01, 0xC6, 0x00, 0xF0, 0xE1, 0xEC, 0x1F, 0xE3, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0xFF, 0xC3, 0xFE, 0xCE, 0x00,
  0xDC, 0x00, 0xD0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x60,
  0x0E, 0x18, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0x00, 0x01, 0xB0, 0x00, 0x37, 0x00, 0x0E, 0x70, 0x03, 0x87, 0xC3,
  0xE0, 0x3F, 0xF0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x84,
  0x00, 0x7F, 0xC0, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x60, 0x02, 0xDC, 0x03, 0xB3, 0xC7, 0xCC, 0x3F, 0xC3, 0xE0, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x60,
  0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x80, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x38, 0x06,
  0xC0, 0x38, 0x06, 0xC0, 0x2C, 0x06, 0x60, 0x2C, 0x06, 0x60, 0x6C, 0x04,
  0x60, 0x64, 0x0C, 0x60, 0x46, 0x0C, 0x20, 0x46, 0x0C, 0x30, 0xC6, 0x08,
  0x30, 0xC2, 0x08, 0x30, 0x83, 0x18, 0x10, 0x83, 0x18, 0x19, 0x83, 0x18,
  0x19, 0x81, 0x10, 0x19, 0x01, 0xB0, 0x19, 0x01, 0xB0, 0x0B, 0x01, 0xB0,
  0x0F, 0x00, 0xA0, 0x0E, 0x00, 0xA0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0x8E, 0x00, 0x18, 0x30,
  0x01, 0x80, 0xC0, 0x1C, 0x03, 0x00, 0xC0, 0x1C, 0x0C, 0x00, 0x70, 0xC0,
  0x01, 0x8E, 0x00, 0x06, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0x30, 0x00, 0x31, 0xC0, 0x03, 0x07, 0x00,
  0x38, 0x18, 0x03, 0x80, 0x60, 0x18, 0x01, 0x81, 0x80, 0x0E, 0x18, 0x00,
  0x39, 0xC0, 0x00, 0xDC, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1D,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x03, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xE0,
  0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x60, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x38,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0x9F, 0xF0, 0x00, 0x8C, 0x1E, 0x00, 0x4C,
  0x03, 0x80, 0x64, 0x00, 0xE0, 0x72, 0x00, 0x3C, 0xF3, 0x00, 0x07, 0xF0,
};

const GFXglyph RobotoMono_ExtraLight45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 3, 32, 27, 12, -32 },
  { 13, 8, 10, 27, 9, -34 },
  { 23, 25, 32, 27, 1, -32 },
  { 123, 20, 42, 27, 4, -37 },
  { 228, 25, 32, 27, 1, -32 },
  { 328, 23, 32, 27, 3, -32 },
  { 420, 2, 10, 27, 12, -34 },
  { 423, 10, 46, 27, 9, -36 },
  { 481, 10, 46, 27, 8, -36 },
  { 539, 20, 18, 27, 4, -32 },
  { 584, 22, 24, 27, 3, -27 },
  { 650, 4, 10, 27, 9, -4 },
  { 655, 16, 1, 27, 5, -15 },
  { 657, 4, 3, 27, 12, -3 },
  { 659, 16, 35, 27, 6, -32 },
  { 729, 19, 32, 27, 4, -32 },
  { 805, 11, 32, 27, 5, -32 },
  { 849, 21, 32, 27, 2, -32 },
  { 933, 20, 32, 27, 2, -32 },
  { 1013, 22, 32, 27, 2, -32 },
  { 1101, 19, 32, 27, 5, -32 },
  { 1177, 20, 32, 27, 3, -32 },
  { 1257, 21, 32, 27, 3, -32 },
  { 1341, 20, 32, 27, 4, -32 },
  { 1421, 20, 32, 27, 3, -32 },
  { 1501, 3, 22, 27, 14, -22 },
  { 1510, 5, 28, 27, 12, -22 },
  { 1528, 19, 19, 27, 4, -24 },
  { 1574, 19, 11, 27, 4, -20 },
  { 1601, 19, 19, 27, 4, -24 },
  { 1647, 17, 32, 27, 5, -32 },
  { 1715, 25, 32, 27, 1, -32 },
  { 1815, 23, 32, 27, 2, -32 },
  { 1907, 19, 32, 27, 5, -32 },
  { 1983, 21, 32, 27, 3, -32 },
  { 2067, 21, 32, 27, 4, -32 },
  { 2151, 18, 32, 27, 5, -32 },
  { 2223, 18, 32, 27, 5, -32 },
  { 2295, 21, 32, 27, 3, -32 },
  { 2379, 19, 32, 27, 4, -32 },
  { 2455, 19, 32, 27, 4, -32 },
  { 2531, 19, 32, 27, 3, -32 },
  { 2607, 21, 32, 27, 5, -32 },
  { 2691, 19, 32, 27, 5, -32 },
  { 2767, 20, 32, 27, 4, -32 },
  { 2847, 19, 32, 27, 4, -32 },
  { 2923, 21, 32, 27, 3, -32 },
  { 3007, 20, 32, 27, 5, -32 },
  { 3087, 23, 38, 27, 2, -32 },
  { 3197, 20, 32, 27, 5, -32 },
  { 3277, 21, 32, 27, 3, -32 },
  { 3361, 23, 32, 27, 2, -32 },
  { 3453, 19, 32, 27, 4, -32 },
  { 3529, 23, 32, 27, 2, -32 },
  { 3621, 24, 32, 27, 2, -32 },
  { 3717, 22, 32, 27, 3, -32 },
  { 3805, 23, 32, 27, 2, -32 },
  { 3897, 20, 32, 27, 3, -32 },
  { 3977, 7, 44, 27, 10, -37 },
  { 4016, 15, 35, 27, 6, -32 },
  { 4082, 7, 44, 27, 10, -37 },
  { 4121, 15, 17, 27, 6, -32 },
  { 4153, 19, 2, 27, 4, 0 },
  { 4158, 7, 6, 27, 10, -33 },
  { 4164, 19, 24, 27, 4, -24 },
  { 4221, 18, 34, 27, 5, -34 },
  { 4298, 19, 24, 27, 4, -24 },
  { 4355, 18, 34, 27, 4, -34 },
  { 4432, 21, 24, 27, 3, -24 },
  { 4495, 21, 34, 27, 4, -34 },
  { 4585, 18, 34, 27, 4, -24 },
  { 4662, 19, 34, 27, 4, -34 },
  { 4743, 19, 32, 27, 5, -32 },
  { 4819, 14, 42, 27, 4, -32 },
  { 4893, 19, 34, 27, 5, -34 },
  { 4974, 19, 34, 27, 5, -34 },
  { 5055, 23, 24, 27, 2, -24 },
  { 5124, 19, 24, 27, 4, -24 },
  { 5181, 21, 24, 27, 3, -24 },
  { 5244, 18, 33, 27, 5, -24 },
  { 5319, 18, 33, 27, 4, -24 },
  { 5394, 16, 24, 27, 8, -24 },
  { 5442, 19, 24, 27, 4, -24 },
  { 5499, 19, 30, 27, 4, -30 },
  { 5571, 18, 24, 27, 5, -24 },
  { 5625, 22, 24, 27, 2, -24 },
  { 5691, 24, 24, 27, 2, -24 },
  { 5763, 21, 24, 27, 3, -24 },
  { 5826, 23, 34, 27, 2, -24 },
  { 5924, 21, 24, 27, 3, -24 },
  { 5987, 15, 44, 27, 7, -35 },
  { 6070, 1, 39, 27, 13, -32 },
  { 6075, 15, 44, 27, 7, -35 },
  { 6158, 25, 7, 27, 1, -17 },
};

const GFXfont RobotoMono_ExtraLight45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight45pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_EXTRALIGHT45PT7B_H_
