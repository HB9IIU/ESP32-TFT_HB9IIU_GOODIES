#ifndef _ROBOTOMONO_EXTRALIGHT19PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC4, 0xB6, 0xD0, 0x08, 0x84, 0x41, 0x10, 0x44, 0xFF, 0xC4,
  0x41, 0x20, 0x88, 0x22, 0x3F, 0xE2, 0x20, 0x90, 0x44, 0x11, 0x00, 0x08,
  0x08, 0x3C, 0x42, 0x81, 0x81, 0x80, 0x40, 0x20, 0x1C, 0x02, 0x01, 0x81,
  0x81, 0x82, 0x7E, 0x08, 0x08, 0x30, 0x09, 0x02, 0x22, 0x44, 0x88, 0x90,
  0xB4, 0x08, 0x80, 0x20, 0x05, 0xC1, 0x44, 0x48, 0x89, 0x11, 0x22, 0x03,
  0x80, 0x1C, 0x08, 0x82, 0x20, 0x88, 0x24, 0x0A, 0x01, 0x00, 0xA0, 0x44,
  0x51, 0x28, 0x2A, 0x06, 0x41, 0x8F, 0x90, 0xF0, 0x12, 0x44, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x84, 0x42, 0x10, 0x82, 0x08, 0x41, 0x08, 0x42, 0x08,
  0x42, 0x11, 0x08, 0x42, 0x22, 0x30, 0x08, 0x08, 0x08, 0xD3, 0x3C, 0x18,
  0x24, 0x42, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x00, 0xF8, 0xFE, 0xC0, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20,
  0x84, 0x10, 0x42, 0x08, 0x00, 0x38, 0x46, 0x82, 0x81, 0x83, 0x85, 0x89,
  0x91, 0xA1, 0xC1, 0x81, 0x81, 0x42, 0x7C, 0x09, 0xF2, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x3C, 0x21, 0x20, 0x50, 0x20, 0x10, 0x08, 0x08,
  0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x07, 0xFC, 0x1C, 0x62, 0x81, 0x81,
  0x01, 0x01, 0x06, 0x1E, 0x01, 0x01, 0x81, 0x81, 0x41, 0x3E, 0x02, 0x03,
  0x01, 0x81, 0x41, 0x20, 0x90, 0x88, 0x84, 0x42, 0x41, 0x1F, 0xE0, 0x40,
  0x20, 0x10, 0x7F, 0x40, 0x40, 0x40, 0x40, 0x58, 0x66, 0x03, 0x01, 0x01,
  0x81, 0x81, 0x42, 0x3C, 0x06, 0x0C, 0x08, 0x08, 0x04, 0x02, 0xF2, 0x85,
  0x82, 0x80, 0xC0, 0x60, 0x28, 0x24, 0x11, 0xF0, 0xFF, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x38, 0x46, 0x81, 0x81, 0x81, 0x81, 0x66, 0x7E, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x7E, 0x1C, 0x11, 0x10, 0x48, 0x18, 0x0C, 0x05, 0x02, 0x83, 0x22,
  0x8E, 0x40, 0x40, 0x20, 0x21, 0xE0, 0x80, 0x80, 0x40, 0x01, 0x5A, 0x03,
  0x0C, 0x30, 0xC0, 0xC0, 0x38, 0x06, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x60, 0x1C, 0x03, 0x06, 0x18, 0x60, 0x80, 0x38, 0x8E, 0x0C, 0x10, 0x20,
  0x41, 0x04, 0x10, 0x20, 0x00, 0x00, 0x02, 0x00, 0x07, 0x03, 0x10, 0x81,
  0x23, 0x14, 0x92, 0xA2, 0x64, 0x4C, 0x89, 0x91, 0x32, 0x65, 0x37, 0x20,
  0x02, 0x00, 0x3E, 0x00, 0x08, 0x03, 0x00, 0xC0, 0x50, 0x12, 0x04, 0x82,
  0x20, 0x84, 0x21, 0x0F, 0xC4, 0x09, 0x02, 0x80, 0xA0, 0x10, 0xF8, 0x86,
  0x82, 0x81, 0x81, 0x82, 0x84, 0xFE, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC,
  0x1C, 0x11, 0x90, 0x28, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x28, 0x14, 0x11, 0xF0, 0xF0, 0x8C, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x86, 0xF8, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1C, 0x11,
  0x90, 0x28, 0x18, 0x04, 0x02, 0x01, 0x00, 0x87, 0xC0, 0x60, 0x28, 0x12,
  0x08, 0xF8, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x81, 0x81, 0x41, 0x3E, 0x81, 0xC0, 0xA0, 0x90,
  0x88, 0x84, 0x82, 0x81, 0xA0, 0x88, 0x44, 0x21, 0x10, 0x48, 0x14, 0x04,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0x81, 0x83, 0x83, 0xC3, 0xC5, 0xA5, 0xA9, 0xA9, 0x91, 0x91,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0xA1, 0xA1, 0x91, 0x91,
  0x89, 0x89, 0x85, 0x83, 0x83, 0x81, 0x1C, 0x11, 0x90, 0x48, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x14, 0x11, 0xF0, 0xF8, 0x86,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x86, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x1C, 0x11, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x28, 0x14, 0x11, 0xF0, 0x04, 0x01, 0xF8, 0x86, 0x82, 0x81, 0x81, 0x81,
  0x82, 0xF4, 0x88, 0x84, 0x82, 0x82, 0x81, 0x81, 0x1E, 0x10, 0x90, 0x28,
  0x14, 0x02, 0x00, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x28, 0x14, 0x09, 0xF8,
  0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x7C, 0x80, 0xC0, 0x60, 0x28,
  0x14, 0x12, 0x08, 0x84, 0x44, 0x22, 0x09, 0x05, 0x02, 0x80, 0xC0, 0x40,
  0x88, 0x62, 0x18, 0xC6, 0x31, 0x8C, 0xA5, 0x25, 0x29, 0x4A, 0x52, 0x94,
  0xA6, 0x29, 0x8C, 0x21, 0x08, 0x40, 0x80, 0xD0, 0x24, 0x10, 0x84, 0x12,
  0x05, 0x00, 0xC0, 0x30, 0x14, 0x04, 0x82, 0x20, 0x84, 0x40, 0xA0, 0x30,
  0x80, 0xC0, 0x50, 0x48, 0x22, 0x21, 0x10, 0x50, 0x28, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x7F, 0x00, 0xC0, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x07, 0xFC, 0xF2, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x9C, 0x80, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x40, 0x80, 0x80, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x3C,
  0x10, 0x20, 0xA1, 0x42, 0x48, 0x90, 0xC1, 0xFF, 0xCC, 0x7C, 0x82, 0x81,
  0x01, 0x3F, 0xC1, 0x81, 0x81, 0x83, 0x7D, 0x80, 0x80, 0x80, 0x80, 0xBC,
  0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x7C, 0x82, 0x81,
  0x80, 0x80, 0x80, 0x80, 0x81, 0x42, 0x3C, 0x02, 0x04, 0x08, 0x17, 0xF0,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x2F, 0xC0, 0x1E, 0x10, 0x90, 0x28,
  0x1F, 0xFC, 0x01, 0x00, 0x80, 0x20, 0x8F, 0x80, 0x07, 0x18, 0x10, 0x20,
  0x20, 0xFE, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x7F,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x08, 0x18, 0x2F, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xBE, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x08, 0x18, 0x00, 0x00, 0xF8, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0xFF, 0x08, 0x30, 0x00, 0x78, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x0B, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x83, 0x84,
  0x88, 0x90, 0xA0, 0xD0, 0x88, 0x84, 0x82, 0x81, 0xF8, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0xFF, 0xA2,
  0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0x62, 0x10, 0xBC,
  0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x3E, 0x20, 0x90,
  0x30, 0x18, 0x0C, 0x06, 0x02, 0x81, 0x41, 0x1F, 0x00, 0xBC, 0xC2, 0x82,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x7F,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x08, 0x10, 0x20, 0x40,
  0x9F, 0x43, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x7E, 0x81, 0x81,
  0x80, 0x78, 0x06, 0x01, 0x81, 0x81, 0x7E, 0x20, 0x20, 0x20, 0xFE, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x1F, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0xA0, 0x50, 0x48, 0x22, 0x21,
  0x10, 0x48, 0x28, 0x0C, 0x04, 0x00, 0x88, 0x62, 0x18, 0xCA, 0x52, 0x54,
  0x94, 0xA5, 0x29, 0x8C, 0x21, 0x08, 0x40, 0xC0, 0x90, 0x88, 0x82, 0x80,
  0xC0, 0x60, 0x48, 0x44, 0x41, 0x60, 0x40, 0x80, 0xE0, 0x24, 0x09, 0x04,
  0x21, 0x08, 0x81, 0x20, 0x50, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x10, 0x38,
  0x00, 0x7F, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x7F,
  0xC0, 0x04, 0x21, 0x04, 0x10, 0x41, 0x08, 0x23, 0x02, 0x08, 0x10, 0x41,
  0x04, 0x10, 0x20, 0x40, 0xFF, 0xFF, 0x80, 0x81, 0x82, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x31, 0x84, 0x10, 0x41, 0x04, 0x20, 0x8C, 0x00, 0xF0, 0x62,
  0x18, 0x78,
};

const GFXglyph RobotoMono_ExtraLight19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 1, 14, 11, 5, -14 },
  { 3, 3, 4, 11, 4, -14 },
  { 5, 10, 14, 11, 1, -14 },
  { 23, 8, 18, 11, 2, -16 },
  { 41, 11, 14, 11, 0, -14 },
  { 61, 10, 14, 11, 1, -14 },
  { 79, 1, 4, 11, 5, -14 },
  { 80, 4, 19, 11, 4, -15 },
  { 90, 5, 19, 11, 3, -15 },
  { 102, 8, 8, 11, 2, -14 },
  { 110, 9, 10, 11, 1, -11 },
  { 122, 1, 5, 11, 4, -2 },
  { 123, 7, 1, 11, 2, -7 },
  { 124, 2, 1, 11, 5, -1 },
  { 125, 6, 15, 11, 3, -14 },
  { 137, 8, 14, 11, 2, -14 },
  { 151, 5, 14, 11, 2, -14 },
  { 160, 9, 14, 11, 1, -14 },
  { 176, 8, 14, 11, 1, -14 },
  { 190, 9, 14, 11, 1, -14 },
  { 206, 8, 14, 11, 2, -14 },
  { 220, 9, 14, 11, 1, -14 },
  { 236, 9, 14, 11, 1, -14 },
  { 252, 8, 14, 11, 2, -14 },
  { 266, 9, 14, 11, 1, -14 },
  { 282, 1, 9, 11, 6, -9 },
  { 284, 2, 12, 11, 5, -9 },
  { 287, 8, 8, 11, 2, -10 },
  { 295, 8, 4, 11, 2, -8 },
  { 299, 8, 8, 11, 2, -10 },
  { 307, 7, 14, 11, 2, -14 },
  { 320, 11, 14, 11, 0, -14 },
  { 340, 10, 14, 11, 1, -14 },
  { 358, 8, 14, 11, 2, -14 },
  { 372, 9, 14, 11, 1, -14 },
  { 388, 8, 14, 11, 2, -14 },
  { 402, 8, 14, 11, 2, -14 },
  { 416, 8, 14, 11, 2, -14 },
  { 430, 9, 14, 11, 1, -14 },
  { 446, 8, 14, 11, 2, -14 },
  { 460, 8, 14, 11, 2, -14 },
  { 474, 8, 14, 11, 1, -14 },
  { 488, 9, 14, 11, 2, -14 },
  { 504, 8, 14, 11, 2, -14 },
  { 518, 8, 14, 11, 2, -14 },
  { 532, 8, 14, 11, 2, -14 },
  { 546, 9, 14, 11, 1, -14 },
  { 562, 8, 14, 11, 2, -14 },
  { 576, 9, 16, 11, 1, -14 },
  { 594, 8, 14, 11, 2, -14 },
  { 608, 9, 14, 11, 1, -14 },
  { 624, 10, 14, 11, 1, -14 },
  { 642, 8, 14, 11, 2, -14 },
  { 656, 9, 14, 11, 1, -14 },
  { 672, 10, 14, 11, 1, -14 },
  { 690, 10, 14, 11, 1, -14 },
  { 708, 9, 14, 11, 1, -14 },
  { 724, 9, 14, 11, 1, -14 },
  { 740, 3, 18, 11, 4, -15 },
  { 747, 7, 15, 11, 2, -14 },
  { 761, 3, 18, 11, 4, -15 },
  { 768, 7, 8, 11, 2, -14 },
  { 775, 8, 1, 11, 2, 0 },
  { 776, 3, 2, 11, 4, -14 },
  { 777, 8, 10, 11, 2, -10 },
  { 787, 8, 14, 11, 2, -14 },
  { 801, 8, 10, 11, 2, -10 },
  { 811, 7, 14, 11, 2, -14 },
  { 824, 9, 10, 11, 1, -10 },
  { 836, 8, 15, 11, 2, -15 },
  { 851, 7, 14, 11, 2, -10 },
  { 864, 8, 14, 11, 2, -14 },
  { 878, 8, 14, 11, 2, -14 },
  { 892, 6, 18, 11, 2, -14 },
  { 906, 8, 14, 11, 2, -14 },
  { 920, 8, 14, 11, 2, -14 },
  { 934, 10, 10, 11, 1, -10 },
  { 947, 8, 10, 11, 2, -10 },
  { 957, 9, 10, 11, 1, -10 },
  { 969, 8, 14, 11, 2, -10 },
  { 983, 7, 14, 11, 2, -10 },
  { 996, 7, 10, 11, 3, -10 },
  { 1005, 8, 10, 11, 2, -10 },
  { 1015, 8, 13, 11, 2, -13 },
  { 1028, 8, 10, 11, 2, -10 },
  { 1038, 9, 10, 11, 1, -10 },
  { 1050, 10, 10, 11, 1, -10 },
  { 1063, 9, 10, 11, 1, -10 },
  { 1075, 10, 14, 11, 1, -10 },
  { 1093, 9, 10, 11, 1, -10 },
  { 1105, 6, 19, 11, 3, -15 },
  { 1120, 1, 17, 11, 5, -14 },
  { 1123, 6, 19, 11, 3, -15 },
  { 1138, 10, 3, 11, 1, -7 },
};

const GFXfont RobotoMono_ExtraLight19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight19pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_EXTRALIGHT19PT7B_H_
