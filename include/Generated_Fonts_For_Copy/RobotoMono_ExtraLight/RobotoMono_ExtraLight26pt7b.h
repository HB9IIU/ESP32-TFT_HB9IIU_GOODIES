#ifndef _ROBOTOMONO_EXTRALIGHT26PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight26pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x80, 0xB0, 0xCE, 0x63, 0x18, 0xC4, 0x06, 0x10,
  0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x21, 0xFF, 0xF0, 0x82, 0x02, 0x10,
  0x08, 0x40, 0x21, 0x00, 0x84, 0x04, 0x10, 0xFF, 0xF8, 0x42, 0x01, 0x08,
  0x04, 0x20, 0x20, 0x80, 0x86, 0x00, 0x02, 0x00, 0x20, 0x07, 0x01, 0x9C,
  0x20, 0x64, 0x02, 0x40, 0x24, 0x03, 0x40, 0x02, 0x00, 0x18, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x20, 0x03, 0xC0, 0x14, 0x03, 0x40, 0x22, 0x06,
  0x1F, 0x80, 0x20, 0x02, 0x00, 0x20, 0x70, 0x03, 0x20, 0x08, 0x40, 0x21,
  0x08, 0x84, 0x42, 0x11, 0x08, 0x48, 0x32, 0x20, 0x31, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x1E, 0x04, 0x8C, 0x22, 0x10, 0x88, 0x44, 0x21, 0x10, 0x84,
  0x02, 0x30, 0x07, 0x80, 0x0E, 0x00, 0x98, 0x08, 0x60, 0x41, 0x02, 0x08,
  0x10, 0x80, 0x8C, 0x02, 0xC0, 0x18, 0x00, 0xC0, 0x09, 0x00, 0x84, 0x2C,
  0x31, 0x40, 0xCA, 0x02, 0xD0, 0x0C, 0xC0, 0x63, 0x05, 0x8F, 0xC6, 0xFC,
  0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x04, 0x10, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43,
  0x08, 0x21, 0x04, 0x21, 0x8C, 0x00, 0x02, 0x00, 0x20, 0x02, 0x0E, 0x23,
  0x3B, 0xC0, 0x60, 0x05, 0x00, 0x98, 0x10, 0xC3, 0x04, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x55, 0xC0, 0xFF, 0x80, 0xF0, 0x01, 0x80,
  0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x00, 0x0E, 0x03, 0x18,
  0x20, 0x44, 0x02, 0x40, 0x28, 0x02, 0x80, 0x68, 0x0B, 0x81, 0x38, 0x23,
  0x8C, 0x39, 0x83, 0xB0, 0x3E, 0x02, 0xC0, 0x24, 0x02, 0x40, 0x42, 0x0C,
  0x1F, 0x80, 0x0D, 0xDC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x06, 0x03, 0x9C, 0x60, 0x44, 0x02, 0xC0, 0x28,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x7F, 0xF0, 0x07, 0x03, 0x8C,
  0x60, 0x64, 0x02, 0x40, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xC0, 0xF0,
  0x00, 0xC0, 0x02, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x03, 0x40, 0x22, 0x06,
  0x1F, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x50, 0x04, 0x80, 0x64, 0x02, 0x20,
  0x21, 0x03, 0x08, 0x10, 0x41, 0x02, 0x18, 0x10, 0x80, 0x8F, 0xFF, 0x80,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x7F, 0xC8, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x13, 0x83, 0x9C, 0xC0, 0xC0, 0x08, 0x01, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x12, 0x06, 0x61, 0x87, 0xE0, 0x01, 0x81, 0xC0,
  0x60, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04, 0xFC, 0xA0, 0xD8, 0x0A, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x01, 0x40, 0x44, 0x18, 0x7E, 0x00,
  0xFF, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x07, 0x03, 0x9C, 0x20, 0x64, 0x02, 0x40, 0x24, 0x03,
  0x40, 0x26, 0x02, 0x30, 0xC0, 0xF0, 0x30, 0xC4, 0x02, 0x40, 0x18, 0x01,
  0x80, 0x1C, 0x01, 0x40, 0x22, 0x06, 0x1F, 0x80, 0x0E, 0x06, 0x31, 0x81,
  0x20, 0x3C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x05, 0x01, 0x98,
  0x51, 0xF2, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x60, 0x78, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x24, 0x94, 0x00, 0x20, 0x1C,
  0x0E, 0x06, 0x07, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x40, 0x30, 0x38, 0x1C,
  0x0C, 0x02, 0x00, 0x00, 0x0C, 0x1C, 0xC4, 0x0A, 0x03, 0x80, 0x40, 0x10,
  0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0xC0, 0x03, 0x80, 0x31, 0x81, 0x01, 0x08, 0x02, 0x43,
  0x89, 0x11, 0x18, 0x84, 0x62, 0x11, 0x88, 0x46, 0x41, 0x19, 0x08, 0x64,
  0x21, 0x90, 0x8A, 0x25, 0x28, 0xE7, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x81,
  0xFC, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x01, 0x20, 0x04, 0x80, 0x33,
  0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x3F,
  0xF0, 0x80, 0x42, 0x01, 0x10, 0x02, 0x40, 0x0B, 0x00, 0x30, 0xFF, 0x10,
  0x12, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x34, 0x0C, 0xFF, 0x10, 0x12,
  0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x9F, 0xE0, 0x07,
  0x03, 0x9C, 0x60, 0x44, 0x02, 0xC0, 0x28, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x34, 0x02, 0x40,
  0x22, 0x0C, 0x1F, 0x80, 0xFF, 0x08, 0x0C, 0x80, 0x68, 0x02, 0x80, 0x38,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x02, 0x80, 0x28, 0x04, 0x81, 0x8F, 0xF0, 0xFF, 0xE0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0x90, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x0E, 0x03, 0x9C, 0x60, 0x64,
  0x02, 0x80, 0x38, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x83, 0xF8,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x13, 0x02, 0x1F, 0xC0,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF,
  0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x14, 0x01, 0x40, 0x26, 0x02,
  0x30, 0x41, 0xF8, 0x80, 0x68, 0x0C, 0x81, 0x88, 0x30, 0x82, 0x08, 0x40,
  0x88, 0x09, 0x00, 0xB8, 0x0C, 0x80, 0x84, 0x08, 0x20, 0x83, 0x08, 0x18,
  0x80, 0x88, 0x04, 0x80, 0x68, 0x03, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFC, 0xC0, 0x3C, 0x05, 0xA0, 0x5A,
  0x05, 0xB0, 0x99, 0x09, 0x91, 0x18, 0x91, 0x89, 0x18, 0xA1, 0x86, 0x18,
  0x41, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x38,
  0x06, 0x80, 0xD0, 0x19, 0x03, 0x30, 0x62, 0x0C, 0x21, 0x84, 0x30, 0x46,
  0x08, 0xC0, 0x98, 0x13, 0x01, 0x60, 0x3C, 0x03, 0x80, 0x30, 0x04, 0x0E,
  0x03, 0x98, 0x60, 0x44, 0x02, 0xC0, 0x28, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x40,
  0x62, 0x0C, 0x1F, 0x80, 0xFF, 0x90, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0xDF, 0xF2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x00, 0x07, 0x00, 0xE6, 0x0C, 0x08, 0x40, 0x24,
  0x01, 0xA0, 0x05, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x14, 0x00, 0xA0, 0x05, 0x00, 0x2C, 0x02, 0x20, 0x30, 0x83, 0x03, 0xF0,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x07,
  0x00, 0xE0, 0x14, 0x02, 0x80, 0x9F, 0xE2, 0x08, 0x40, 0x88, 0x11, 0x01,
  0x20, 0x24, 0x02, 0x80, 0x70, 0x04, 0x0F, 0x03, 0x9C, 0x60, 0x64, 0x02,
  0xC0, 0x1C, 0x01, 0x40, 0x06, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x40, 0x36, 0x06, 0x1F, 0xC0, 0xFF,
  0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x28, 0x02, 0x40, 0x24, 0x06, 0x20, 0xC1, 0xF8, 0xC0, 0x0A, 0x00, 0xD0,
  0x04, 0xC0, 0x22, 0x01, 0x10, 0x10, 0xC0, 0x82, 0x04, 0x10, 0x40, 0xC2,
  0x02, 0x10, 0x11, 0x00, 0xC8, 0x02, 0x40, 0x14, 0x00, 0xA0, 0x03, 0x00,
  0x10, 0x00, 0x83, 0x07, 0x0C, 0x14, 0x30, 0x90, 0xC2, 0x42, 0x89, 0x12,
  0x24, 0x48, 0x91, 0x22, 0x64, 0x88, 0x93, 0x42, 0x85, 0x0A, 0x14, 0x28,
  0x50, 0xA1, 0x42, 0x85, 0x04, 0x0C, 0x10, 0x20, 0x40, 0x80, 0x60, 0x18,
  0x80, 0x41, 0x03, 0x04, 0x08, 0x08, 0x40, 0x33, 0x00, 0x48, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x48, 0x01, 0x30, 0x08, 0x40, 0x61, 0x81, 0x02,
  0x08, 0x04, 0x60, 0x1B, 0x00, 0x30, 0xC0, 0x1A, 0x00, 0x88, 0x0C, 0x40,
  0x41, 0x06, 0x08, 0x20, 0x23, 0x01, 0x10, 0x05, 0x00, 0x28, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0xFF, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x1F,
  0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0xF0, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x30, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x0C, 0x06, 0x05, 0x02, 0x42, 0x21, 0x09, 0x84, 0x83, 0x40,
  0xC0, 0x40, 0xFF, 0xE0, 0xC4, 0x30, 0x1F, 0x06, 0x19, 0x01, 0xA0, 0x10,
  0x02, 0x00, 0x43, 0xF9, 0x81, 0x40, 0x30, 0x06, 0x00, 0xE0, 0x34, 0x0A,
  0x7E, 0x40, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x27, 0x87,
  0x0C, 0xC0, 0x90, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xE0, 0x14, 0x02,
  0x80, 0x50, 0x1B, 0x06, 0x5F, 0x80, 0x0F, 0x06, 0x19, 0x81, 0xA0, 0x1C,
  0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0xA0, 0x12, 0x04,
  0x3F, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x47, 0xC9,
  0x85, 0x60, 0x68, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01,
  0x40, 0x28, 0x0C, 0x83, 0x8F, 0x90, 0x0F, 0x03, 0x0C, 0x60, 0x64, 0x02,
  0xC0, 0x28, 0x03, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x02,
  0x30, 0x61, 0xF8, 0x01, 0xF0, 0x30, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0xFF, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x1F, 0x26, 0x15,
  0x81, 0xA0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x05, 0x00,
  0xA0, 0x32, 0x0E, 0x3E, 0x40, 0x08, 0x01, 0x40, 0x4C, 0x18, 0xEE, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xF2, 0x86, 0xC0,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x04, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x83, 0xFF, 0x80, 0x01, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x03, 0x02, 0xDC, 0x20, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x14, 0x04, 0x83, 0x10, 0xC2, 0x30, 0x4C, 0x0B, 0x01,
  0x90, 0x21, 0x04, 0x10, 0x83, 0x10, 0x32, 0x03, 0x40, 0x30, 0xFC, 0x1F,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x7F, 0xF0, 0xBC, 0x73, 0x0E, 0x2C, 0x30, 0xA0, 0x83, 0x82, 0x0E, 0x08,
  0x38, 0x20, 0xE0, 0x83, 0x82, 0x0E, 0x08, 0x38, 0x20, 0xE0, 0x83, 0x82,
  0x0E, 0x08, 0x30, 0x9F, 0x28, 0x6C, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x1F, 0x03, 0x0C,
  0x40, 0x6C, 0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0xC0, 0x24, 0x06, 0x20, 0xC1, 0xF8, 0x9E, 0x38, 0x6C, 0x0A, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0xC1, 0xAF, 0xC8,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1F, 0x26, 0x15, 0x81, 0xA0, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x05, 0x00, 0xA0, 0x32, 0x0E,
  0x3E, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x8F, 0xD8, 0x30,
  0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x00, 0x1F, 0x86, 0x19, 0x00, 0xA0, 0x14, 0x00, 0x40, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x07, 0x00, 0xA0, 0x16, 0x06, 0x3F, 0x80, 0x08, 0x01, 0x00,
  0x20, 0x7F, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x03, 0xE0, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x41, 0x4F, 0x90, 0xC0, 0x0A, 0x00, 0xD8, 0x04, 0x40, 0x22, 0x02, 0x08,
  0x10, 0x41, 0x03, 0x08, 0x08, 0xC0, 0x64, 0x01, 0x20, 0x0A, 0x00, 0x30,
  0x01, 0x00, 0x82, 0x06, 0x0C, 0x18, 0x30, 0x90, 0xC2, 0x45, 0x09, 0x12,
  0x24, 0x49, 0x99, 0x24, 0x28, 0x90, 0xA1, 0x42, 0x85, 0x0A, 0x18, 0x10,
  0x60, 0x40, 0x80, 0xC0, 0x34, 0x02, 0x20, 0x41, 0x08, 0x19, 0x80, 0xB0,
  0x06, 0x00, 0x60, 0x0B, 0x01, 0x98, 0x10, 0x82, 0x04, 0x40, 0x2C, 0x03,
  0x80, 0x0D, 0x00, 0x24, 0x01, 0x88, 0x04, 0x20, 0x30, 0xC0, 0x81, 0x02,
  0x06, 0x10, 0x08, 0x40, 0x32, 0x00, 0x48, 0x01, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x07, 0x80, 0x10, 0x00, 0xFF,
  0xE0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0x03, 0x83, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x06, 0x0C, 0x01, 0x80,
  0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x0C, 0x03,
  0x80, 0xFF, 0xFF, 0xFC, 0xC0, 0x18, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0x00, 0xC0, 0x18, 0x30, 0x30, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x60, 0xE0, 0x00, 0x38, 0x05, 0x18,
  0x18, 0x30, 0xA0, 0x7E, 0x00, 0x20,
};

const GFXglyph RobotoMono_ExtraLight26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 2, 18, 16, 7, -18 },
  { 6, 5, 6, 16, 5, -20 },
  { 10, 14, 18, 16, 1, -18 },
  { 42, 12, 24, 16, 2, -21 },
  { 78, 14, 19, 16, 1, -19 },
  { 112, 13, 19, 16, 2, -19 },
  { 143, 1, 6, 16, 7, -20 },
  { 144, 6, 27, 16, 5, -21 },
  { 165, 6, 27, 16, 4, -21 },
  { 186, 12, 10, 16, 2, -18 },
  { 201, 12, 13, 16, 2, -15 },
  { 221, 2, 5, 16, 5, -2 },
  { 223, 9, 1, 16, 3, -9 },
  { 225, 2, 2, 16, 7, -2 },
  { 226, 9, 20, 16, 4, -18 },
  { 249, 12, 19, 16, 2, -19 },
  { 278, 6, 18, 16, 3, -18 },
  { 292, 12, 19, 16, 1, -19 },
  { 321, 12, 19, 16, 1, -19 },
  { 350, 13, 18, 16, 1, -18 },
  { 380, 11, 18, 16, 3, -18 },
  { 405, 11, 19, 16, 2, -19 },
  { 432, 12, 18, 16, 2, -18 },
  { 459, 12, 19, 16, 2, -19 },
  { 488, 11, 19, 16, 2, -19 },
  { 515, 2, 13, 16, 8, -13 },
  { 519, 3, 16, 16, 7, -13 },
  { 525, 11, 11, 16, 2, -14 },
  { 541, 12, 7, 16, 2, -12 },
  { 552, 11, 11, 16, 2, -14 },
  { 568, 10, 19, 16, 3, -19 },
  { 592, 14, 19, 16, 1, -19 },
  { 626, 14, 18, 16, 1, -18 },
  { 658, 11, 18, 16, 3, -18 },
  { 683, 12, 19, 16, 2, -19 },
  { 712, 12, 18, 16, 2, -18 },
  { 739, 10, 18, 16, 3, -18 },
  { 762, 11, 18, 16, 3, -18 },
  { 787, 12, 19, 16, 2, -19 },
  { 816, 11, 18, 16, 2, -18 },
  { 841, 10, 18, 16, 3, -18 },
  { 864, 12, 18, 16, 1, -18 },
  { 891, 12, 18, 16, 3, -18 },
  { 918, 11, 18, 16, 3, -18 },
  { 943, 12, 18, 16, 2, -18 },
  { 970, 11, 18, 16, 2, -18 },
  { 995, 12, 19, 16, 2, -19 },
  { 1024, 11, 18, 16, 3, -18 },
  { 1049, 13, 22, 16, 1, -19 },
  { 1085, 11, 18, 16, 3, -18 },
  { 1110, 12, 19, 16, 2, -19 },
  { 1139, 13, 18, 16, 1, -18 },
  { 1169, 12, 18, 16, 2, -18 },
  { 1196, 13, 18, 16, 1, -18 },
  { 1226, 14, 18, 16, 1, -18 },
  { 1258, 14, 18, 16, 1, -18 },
  { 1290, 13, 18, 16, 1, -18 },
  { 1320, 11, 18, 16, 2, -18 },
  { 1345, 4, 25, 16, 6, -21 },
  { 1358, 9, 20, 16, 3, -18 },
  { 1381, 4, 25, 16, 6, -21 },
  { 1394, 9, 10, 16, 3, -18 },
  { 1406, 11, 1, 16, 2, 0 },
  { 1408, 4, 3, 16, 6, -19 },
  { 1410, 11, 14, 16, 2, -14 },
  { 1430, 11, 20, 16, 3, -20 },
  { 1458, 11, 14, 16, 2, -14 },
  { 1478, 11, 20, 16, 2, -20 },
  { 1506, 12, 14, 16, 2, -14 },
  { 1527, 12, 20, 16, 2, -20 },
  { 1557, 11, 20, 16, 2, -14 },
  { 1585, 10, 20, 16, 3, -20 },
  { 1610, 11, 19, 16, 3, -19 },
  { 1637, 8, 25, 16, 2, -19 },
  { 1662, 11, 20, 16, 3, -20 },
  { 1690, 11, 20, 16, 3, -20 },
  { 1718, 14, 14, 16, 1, -14 },
  { 1743, 10, 14, 16, 3, -14 },
  { 1761, 12, 14, 16, 2, -14 },
  { 1782, 10, 19, 16, 3, -14 },
  { 1806, 11, 19, 16, 2, -14 },
  { 1833, 9, 14, 16, 5, -14 },
  { 1849, 11, 14, 16, 2, -14 },
  { 1869, 11, 17, 16, 2, -17 },
  { 1893, 10, 14, 16, 3, -14 },
  { 1911, 13, 14, 16, 1, -14 },
  { 1934, 14, 14, 16, 1, -14 },
  { 1959, 12, 14, 16, 2, -14 },
  { 1980, 14, 20, 16, 1, -14 },
  { 2015, 12, 14, 16, 2, -14 },
  { 2036, 9, 25, 16, 4, -20 },
  { 2065, 1, 22, 16, 7, -18 },
  { 2068, 9, 25, 16, 4, -20 },
  { 2097, 14, 5, 16, 1, -10 },
};

const GFXfont RobotoMono_ExtraLight26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight26pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_EXTRALIGHT26PT7B_H_
