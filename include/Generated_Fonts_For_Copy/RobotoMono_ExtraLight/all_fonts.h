#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoMono_ExtraLight
// Headers: 67

#include "RobotoMono_ExtraLight6pt7b.h"
#include "RobotoMono_ExtraLight7pt7b.h"
#include "RobotoMono_ExtraLight8pt7b.h"
#include "RobotoMono_ExtraLight9pt7b.h"
#include "RobotoMono_ExtraLight10pt7b.h"
#include "RobotoMono_ExtraLight11pt7b.h"
#include "RobotoMono_ExtraLight12pt7b.h"
#include "RobotoMono_ExtraLight13pt7b.h"
#include "RobotoMono_ExtraLight14pt7b.h"
#include "RobotoMono_ExtraLight15pt7b.h"
#include "RobotoMono_ExtraLight16pt7b.h"
#include "RobotoMono_ExtraLight17pt7b.h"
#include "RobotoMono_ExtraLight18pt7b.h"
#include "RobotoMono_ExtraLight19pt7b.h"
#include "RobotoMono_ExtraLight20pt7b.h"
#include "RobotoMono_ExtraLight21pt7b.h"
#include "RobotoMono_ExtraLight22pt7b.h"
#include "RobotoMono_ExtraLight23pt7b.h"
#include "RobotoMono_ExtraLight24pt7b.h"
#include "RobotoMono_ExtraLight25pt7b.h"
#include "RobotoMono_ExtraLight26pt7b.h"
#include "RobotoMono_ExtraLight27pt7b.h"
#include "RobotoMono_ExtraLight28pt7b.h"
#include "RobotoMono_ExtraLight29pt7b.h"
#include "RobotoMono_ExtraLight30pt7b.h"
#include "RobotoMono_ExtraLight31pt7b.h"
#include "RobotoMono_ExtraLight32pt7b.h"
#include "RobotoMono_ExtraLight33pt7b.h"
#include "RobotoMono_ExtraLight34pt7b.h"
#include "RobotoMono_ExtraLight35pt7b.h"
#include "RobotoMono_ExtraLight36pt7b.h"
#include "RobotoMono_ExtraLight37pt7b.h"
#include "RobotoMono_ExtraLight38pt7b.h"
#include "RobotoMono_ExtraLight39pt7b.h"
#include "RobotoMono_ExtraLight40pt7b.h"
#include "RobotoMono_ExtraLight41pt7b.h"
#include "RobotoMono_ExtraLight42pt7b.h"
#include "RobotoMono_ExtraLight43pt7b.h"
#include "RobotoMono_ExtraLight44pt7b.h"
#include "RobotoMono_ExtraLight45pt7b.h"
#include "RobotoMono_ExtraLight46pt7b.h"
#include "RobotoMono_ExtraLight47pt7b.h"
#include "RobotoMono_ExtraLight48pt7b.h"
#include "RobotoMono_ExtraLight49pt7b.h"
#include "RobotoMono_ExtraLight50pt7b.h"
#include "RobotoMono_ExtraLight51pt7b.h"
#include "RobotoMono_ExtraLight52pt7b.h"
#include "RobotoMono_ExtraLight53pt7b.h"
#include "RobotoMono_ExtraLight54pt7b.h"
#include "RobotoMono_ExtraLight55pt7b.h"
#include "RobotoMono_ExtraLight56pt7b.h"
#include "RobotoMono_ExtraLight57pt7b.h"
#include "RobotoMono_ExtraLight58pt7b.h"
#include "RobotoMono_ExtraLight59pt7b.h"
#include "RobotoMono_ExtraLight60pt7b.h"
#include "RobotoMono_ExtraLight61pt7b.h"
#include "RobotoMono_ExtraLight62pt7b.h"
#include "RobotoMono_ExtraLight63pt7b.h"
#include "RobotoMono_ExtraLight64pt7b.h"
#include "RobotoMono_ExtraLight65pt7b.h"
#include "RobotoMono_ExtraLight66pt7b.h"
#include "RobotoMono_ExtraLight67pt7b.h"
#include "RobotoMono_ExtraLight68pt7b.h"
#include "RobotoMono_ExtraLight69pt7b.h"
#include "RobotoMono_ExtraLight70pt7b.h"
#include "RobotoMono_ExtraLight71pt7b.h"
#include "RobotoMono_ExtraLight72pt7b.h"
