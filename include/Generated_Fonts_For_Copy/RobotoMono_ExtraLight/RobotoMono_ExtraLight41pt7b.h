#ifndef _ROBOTOMONO_EXTRALIGHT41PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x86, 0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0, 0x01,
  0x01, 0x80, 0x02, 0x03, 0x00, 0x04, 0x04, 0x00, 0x18, 0x08, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x60, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x06, 0x02,
  0x00, 0x0C, 0x04, 0x00, 0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0x40, 0x60,
  0x01, 0x80, 0x80, 0x03, 0x01, 0x00, 0x06, 0x06, 0x00, 0x08, 0x0C, 0x07,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0xC0, 0x40, 0x01, 0x80, 0x80, 0x03,
  0x03, 0x00, 0x04, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x60,
  0x20, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x07, 0xF8, 0x07, 0x07, 0x83, 0x80, 0x71, 0xC0, 0x0C, 0x60,
  0x01, 0x98, 0x00, 0x64, 0x00, 0x19, 0x00, 0x02, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x01, 0x98, 0x00,
  0xE3, 0x00, 0x70, 0x78, 0x78, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x86,
  0x00, 0x06, 0x04, 0x00, 0x0C, 0x08, 0x08, 0x10, 0x18, 0x18, 0x20, 0x30,
  0x60, 0x40, 0x60, 0x80, 0x80, 0xC3, 0x01, 0x81, 0x84, 0x03, 0x02, 0x18,
  0x03, 0x0C, 0x20, 0x03, 0xF0, 0xC0, 0x03, 0x81, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC1, 0xE0, 0x01, 0x0F, 0xE0,
  0x06, 0x10, 0x60, 0x08, 0x60, 0x40, 0x30, 0x80, 0x80, 0x41, 0x01, 0x81,
  0x82, 0x03, 0x02, 0x04, 0x06, 0x0C, 0x08, 0x0C, 0x10, 0x18, 0x10, 0x00,
  0x30, 0x60, 0x00, 0x31, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x3F,
  0x80, 0x03, 0x86, 0x00, 0x38, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0x40, 0x30, 0x02, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x0C,
  0x00, 0x18, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xB0, 0x00, 0x18, 0xC0, 0x01, 0x87, 0x01, 0x98, 0x18, 0x0C, 0xC0, 0x60,
  0x4C, 0x01, 0x86, 0x60, 0x06, 0x33, 0x00, 0x39, 0x98, 0x00, 0xD8, 0xC0,
  0x03, 0xC6, 0x00, 0x0C, 0x18, 0x00, 0xF0, 0x60, 0x0D, 0xC1, 0xC1, 0xC6,
  0x07, 0xF8, 0x1C, 0xFF, 0x80, 0x00, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x60,
  0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x04, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0x80, 0xC0, 0xC0,
  0x60, 0x60, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x30, 0x2F, 0x0C, 0x7C, 0xFB, 0x78, 0x03,
  0xF0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0C, 0xC0, 0x06, 0x18, 0x03, 0x03,
  0x01, 0xC0, 0xE0, 0xE0, 0x1C, 0x10, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x33, 0x33, 0x26, 0x6C, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x6F, 0x60,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x40, 0x01, 0xFF,
  0x00, 0xE0, 0xE0, 0x60, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x09,
  0x80, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x19, 0xC0,
  0x0C, 0x70, 0x0E, 0x1C, 0x06, 0x07, 0x03, 0x01, 0xC1, 0x80, 0x70, 0xC0,
  0x1C, 0x60, 0x07, 0x30, 0x01, 0xD8, 0x00, 0x5C, 0x00, 0x36, 0x00, 0x0D,
  0x80, 0x03, 0x60, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x30, 0x60, 0x1C, 0x0E,
  0x0E, 0x01, 0xFE, 0x00, 0x00, 0x60, 0x7C, 0x3D, 0x9E, 0x3E, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0xFF,
  0x00, 0x70, 0x78, 0x18, 0x03, 0x86, 0x00, 0x30, 0xC0, 0x03, 0x10, 0x00,
  0x66, 0x00, 0x0C, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x01, 0xFF,
  0x01, 0xC0, 0xE0, 0xE0, 0x0C, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x09,
  0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x37, 0x00, 0x18, 0xE0, 0x0C, 0x1E,
  0x0E, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0A, 0x00,
  0x01, 0xA0, 0x00, 0x32, 0x00, 0x03, 0x20, 0x00, 0x62, 0x00, 0x0C, 0x20,
  0x00, 0xC2, 0x00, 0x18, 0x20, 0x03, 0x02, 0x00, 0x30, 0x20, 0x06, 0x02,
  0x00, 0xC0, 0x20, 0x0C, 0x02, 0x01, 0x80, 0x20, 0x30, 0x02, 0x03, 0x00,
  0x20, 0x60, 0x02, 0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0xBF, 0xE0, 0x3C, 0x3E, 0x1C, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x03, 0x8C, 0x00, 0xC3, 0x80, 0x70, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x3F, 0x83,
  0x3E, 0xF8, 0xD8, 0x07, 0x3C, 0x00, 0xCE, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x34, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x01, 0x8C, 0x00, 0xC1, 0x80, 0x70,
  0x38, 0x78, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x01, 0xC1, 0xE0, 0xC0, 0x1C, 0x60,
  0x03, 0x18, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00,
  0x64, 0x00, 0x19, 0x80, 0x04, 0x30, 0x03, 0x06, 0x03, 0x80, 0xFF, 0x80,
  0x3F, 0xE0, 0x18, 0x0E, 0x1C, 0x00, 0xC6, 0x00, 0x1B, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x26, 0x00, 0x19, 0xC0, 0x0C, 0x1C, 0x1E, 0x03, 0xFE, 0x00, 0x00, 0x80,
  0x01, 0xFE, 0x01, 0xE0, 0xE0, 0x60, 0x1C, 0x30, 0x03, 0x18, 0x00, 0x66,
  0x00, 0x19, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x07, 0x30, 0x03,
  0xCE, 0x01, 0xB1, 0xC1, 0xCC, 0x1F, 0xE3, 0x00, 0x80, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x6F, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x6F, 0x60, 0x33, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x63, 0x18, 0x8C, 0x66, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x3F, 0xE0, 0xE0, 0xE3, 0x00, 0x6C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0x07, 0x80, 0x70, 0x07, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x23, 0x03, 0xE0, 0xC8, 0x18, 0xC3, 0x60, 0xC1, 0x05, 0x86,
  0x04, 0x14, 0x10, 0x10, 0x50, 0x40, 0x41, 0xC3, 0x03, 0x07, 0x08, 0x0C,
  0x1C, 0x20, 0x30, 0x70, 0x80, 0x81, 0xC2, 0x02, 0x07, 0x08, 0x08, 0x1C,
  0x20, 0x60, 0xF0, 0xC1, 0x82, 0x43, 0x0B, 0x19, 0x06, 0x64, 0xC6, 0x0F,
  0x1E, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x08,
  0x01, 0xE0, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x64, 0x00, 0x02, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x84, 0x00, 0x08, 0x30, 0x00, 0xC1, 0x80, 0x06,
  0x04, 0x00, 0x20, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x02, 0x00, 0x30, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x23,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x80, 0xFF,
  0xF0, 0x30, 0x3F, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x33,
  0x00, 0x1C, 0xC0, 0x0C, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0x00, 0x18, 0xC0,
  0x03, 0x30, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x73,
  0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0x80, 0x38, 0x38,
  0x0C, 0x01, 0x83, 0x00, 0x18, 0x40, 0x01, 0x98, 0x00, 0x32, 0x00, 0x02,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x1B,
  0x00, 0x02, 0x60, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x0C, 0x01, 0x80,
  0xE0, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x30, 0x3E, 0x0C, 0x01, 0xC3,
  0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x02, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x03, 0x8C, 0x01, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0x80, 0x38, 0x38, 0x0C, 0x01,
  0x83, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00,
  0x78, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x8E, 0x00, 0xE0, 0xF0, 0x78,
  0x07, 0xFC, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00,
  0x34, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0x8C, 0x00, 0x63, 0x80, 0x70,
  0x38, 0x78, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0xEC, 0x00, 0x18, 0xC0, 0x03,
  0x0C, 0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC7,
  0x00, 0x0C, 0xF0, 0x00, 0xDF, 0x00, 0x0F, 0x98, 0x00, 0xF0, 0xC0, 0x0E,
  0x06, 0x00, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0,
  0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x70, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x3E, 0x80, 0x0B, 0xB0, 0x06, 0xEC, 0x01, 0xB9, 0x00, 0x4E,
  0x60, 0x33, 0x98, 0x08, 0xE2, 0x06, 0x38, 0xC1, 0x8E, 0x30, 0x43, 0x86,
  0x30, 0xE1, 0x88, 0x38, 0x26, 0x0E, 0x0D, 0x83, 0x83, 0x40, 0xE0, 0x70,
  0x38, 0x18, 0x0E, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xD8,
  0x00, 0xF6, 0x00, 0x3C, 0xC0, 0x0F, 0x10, 0x03, 0xC6, 0x00, 0xF0, 0x80,
  0x3C, 0x30, 0x0F, 0x06, 0x03, 0xC1, 0x80, 0xF0, 0x30, 0x3C, 0x0C, 0x0F,
  0x01, 0x83, 0xC0, 0x20, 0xF0, 0x0C, 0x3C, 0x01, 0x8F, 0x00, 0x63, 0xC0,
  0x0C, 0xF0, 0x03, 0x3C, 0x00, 0x6F, 0x00, 0x1B, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0xFF,
  0x00, 0x38, 0x38, 0x0C, 0x03, 0x83, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00,
  0x32, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xB0, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x0C,
  0x0C, 0x03, 0x80, 0xE1, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x20, 0x1F,
  0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x0A,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x06, 0x80,
  0x01, 0xA0, 0x00, 0xC8, 0x00, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x01, 0xC1, 0xC0, 0x18, 0x03,
  0x01, 0x80, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x04, 0x60,
  0x00, 0x32, 0x00, 0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x2C, 0x00, 0x01,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x24, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x06, 0x06, 0x00,
  0x30, 0x18, 0x03, 0x00, 0x78, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0xFF, 0xF0,
  0x30, 0x1F, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0xE3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x0C,
  0x00, 0x63, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x78, 0x3C, 0x1C,
  0x01, 0xC3, 0x00, 0x1C, 0xC0, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x6C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x6C, 0x00, 0x0D, 0xC0, 0x03, 0x1C, 0x00, 0xC1, 0xF0,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x01, 0x8C, 0x00, 0xE1, 0x80, 0x70, 0x38, 0x78,
  0x07, 0xF8, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0xC0, 0x04, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x10, 0x06, 0x01, 0x80, 0x10, 0x0C, 0x00, 0xC0, 0x40, 0x06, 0x06, 0x00,
  0x10, 0x30, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x10, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x60, 0x00, 0x13, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x0F, 0x00,
  0xC0, 0x2C, 0x07, 0x00, 0xB0, 0x1C, 0x06, 0x40, 0x70, 0x19, 0x01, 0x60,
  0x64, 0x05, 0x81, 0x98, 0x36, 0x04, 0x60, 0xC8, 0x11, 0x83, 0x20, 0x46,
  0x08, 0xC3, 0x08, 0x23, 0x0C, 0x21, 0x8C, 0x30, 0x86, 0x10, 0x83, 0x18,
  0x42, 0x0C, 0x41, 0x88, 0x31, 0x06, 0x60, 0xCC, 0x19, 0x81, 0x30, 0x66,
  0x04, 0xC0, 0x98, 0x1B, 0x02, 0x40, 0x68, 0x0D, 0x01, 0xA0, 0x34, 0x07,
  0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x39, 0x80, 0x01, 0x8C, 0x00, 0x18,
  0x30, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0,
  0x60, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x01, 0xB0, 0x00,
  0x05, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xD8,
  0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x03,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03,
  0x0C, 0x00, 0x18, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x36,
  0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x18,
  0x18, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x3F, 0x80, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xFC,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x1F, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x36,
  0x00, 0x4C, 0x01, 0x88, 0x03, 0x18, 0x0C, 0x30, 0x18, 0x30, 0x20, 0x60,
  0xC0, 0x41, 0x80, 0xC6, 0x01, 0x8C, 0x01, 0x90, 0x03, 0x60, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xC3, 0x06, 0x0C, 0x07, 0xF0, 0x0F, 0xFE,
  0x0C, 0x03, 0x8C, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC3, 0xFF, 0xE7, 0x80, 0x37, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xF0, 0x01,
  0xFC, 0x01, 0xB7, 0x87, 0x98, 0xFF, 0x0C, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x61, 0xF8, 0x33, 0xFF, 0x1B, 0x01, 0xCF, 0x00, 0x67, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xB0, 0x00, 0xDC, 0x00, 0xEF, 0x00, 0xE6, 0xE1, 0xE3, 0x1F,
  0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x81, 0xC0, 0x70, 0x60, 0x06, 0x30, 0x01,
  0x98, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x03, 0x60, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x18, 0x60, 0x0C, 0x0E, 0x0E,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x81, 0xF8,
  0x43, 0xFF, 0x23, 0x80, 0xD3, 0x00, 0x39, 0x80, 0x0D, 0x80, 0x06, 0xC0,
  0x01, 0x60, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x4C, 0x00,
  0x66, 0x00, 0x71, 0x80, 0x68, 0x70, 0xE4, 0x1F, 0xE2, 0x01, 0xF8, 0x01,
  0xFF, 0x81, 0xC0, 0x70, 0x60, 0x0E, 0x30, 0x01, 0x98, 0x00, 0x36, 0x00,
  0x0D, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x0C, 0x70, 0x06, 0x0F, 0x07, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x3E, 0x10, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x87,
  0xFE, 0x47, 0x01, 0xA7, 0x00, 0x73, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x02,
  0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0A, 0x00, 0x05, 0x00, 0x02, 0xC0, 0x01, 0x60, 0x00, 0x98, 0x00, 0xCC,
  0x00, 0xE3, 0x00, 0xD0, 0xE1, 0xC8, 0x3F, 0xC4, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC8, 0x00, 0xC6, 0x00, 0xE1, 0xC0, 0xE0, 0x3F,
  0xC0, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0xFC,
  0x31, 0xFF, 0x19, 0x80, 0xCD, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x1C, 0xFF, 0x0F, 0xC0, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x01, 0xB0, 0x03, 0x98, 0x03, 0x8C, 0x03, 0x86,
  0x03, 0x83, 0x03, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x33, 0x00,
  0x1F, 0xC0, 0x0F, 0x70, 0x07, 0x1C, 0x03, 0x07, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x60, 0x18, 0x30, 0x06, 0x18, 0x01, 0x8C, 0x00, 0xE6, 0x00, 0x3B,
  0x00, 0x0E, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x8F, 0x87, 0xC5, 0xFE,
  0x7F, 0xA8, 0x3E, 0x0D, 0x80, 0xE0, 0x3C, 0x06, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0xC1, 0xF8, 0x63, 0xFE, 0x33, 0x01,
  0x9A, 0x00, 0x6E, 0x00, 0x37, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0C, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x70, 0x1C,
  0x18, 0x01, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x02,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x30,
  0xC0, 0x06, 0x0C, 0x01, 0x80, 0xE0, 0xE0, 0x0F, 0xF0, 0x00, 0xC3, 0xF0,
  0x67, 0xFC, 0x36, 0x03, 0x9E, 0x00, 0xCE, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0x60, 0x01,
  0xB8, 0x01, 0x9E, 0x01, 0xCD, 0xC1, 0xC6, 0x3F, 0x83, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xF0, 0x87, 0xFE, 0x47, 0x01, 0xA7, 0x00, 0x73, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x02, 0xC0, 0x01,
  0x60, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x63, 0x00, 0xD0, 0xE1, 0xC8, 0x3F,
  0xC4, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0xC0, 0xFF, 0x87, 0xFB, 0x38, 0x06,
  0xC0, 0x0D, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x07, 0xF0, 0x0F, 0xFF, 0x0C, 0x01, 0xCC, 0x00, 0x66, 0x00, 0x1A, 0x00,
  0x0D, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0xD8, 0x00, 0x6E, 0x00, 0x63, 0xC0, 0xE0, 0x7F, 0xE0, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x07, 0xFF, 0xFB,
  0xFF, 0xFC, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x40, 0x3F, 0xE0, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x01, 0xD8,
  0x01, 0xE6, 0x01, 0xB3, 0xC3, 0x98, 0x7F, 0x8C, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00, 0x0C, 0x18,
  0x00, 0xC1, 0x80, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x10, 0x04, 0x03, 0x00,
  0x60, 0x30, 0x06, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x18, 0xC0,
  0x01, 0x88, 0x00, 0x09, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x80, 0x60, 0x09, 0x80, 0xE0, 0x33,
  0x01, 0x40, 0x66, 0x02, 0x80, 0xC4, 0x0D, 0x01, 0x08, 0x1B, 0x02, 0x18,
  0x26, 0x0C, 0x30, 0x44, 0x18, 0x61, 0x88, 0x20, 0x43, 0x18, 0x40, 0xC4,
  0x31, 0x81, 0x88, 0x23, 0x03, 0x30, 0x46, 0x02, 0x60, 0xC8, 0x04, 0x81,
  0x90, 0x0D, 0x01, 0x60, 0x1A, 0x02, 0xC0, 0x3C, 0x07, 0x00, 0x30, 0x0E,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x18,
  0xC0, 0x06, 0x0C, 0x01, 0x81, 0xC0, 0x70, 0x18, 0x0C, 0x01, 0x83, 0x00,
  0x18, 0xC0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1B, 0x00, 0x07, 0x70, 0x00, 0xC6, 0x00, 0x30, 0x60, 0x0C, 0x06, 0x03,
  0x00, 0x60, 0x60, 0x0E, 0x18, 0x00, 0xC6, 0x00, 0x0D, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00,
  0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x20, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x01, 0xE0, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0xF0, 0x03, 0x80,
  0x70, 0x06, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x13,
  0x0E, 0x00, 0x58, 0x0C, 0x03, 0x40, 0x18, 0x0B, 0x00, 0x38, 0xEC, 0x00,
  0x3F, 0x00,
};

const GFXglyph RobotoMono_ExtraLight41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 2, 29, 25, 11, -29 },
  { 9, 7, 9, 25, 9, -31 },
  { 17, 23, 29, 25, 1, -29 },
  { 101, 18, 37, 25, 4, -33 },
  { 185, 23, 30, 25, 1, -30 },
  { 272, 21, 30, 25, 3, -30 },
  { 351, 1, 9, 25, 11, -31 },
  { 353, 9, 42, 25, 8, -33 },
  { 401, 9, 42, 25, 7, -33 },
  { 449, 18, 17, 25, 4, -29 },
  { 488, 20, 21, 25, 2, -24 },
  { 541, 4, 9, 25, 8, -3 },
  { 546, 15, 2, 25, 5, -14 },
  { 550, 4, 3, 25, 11, -3 },
  { 552, 14, 32, 25, 6, -29 },
  { 608, 18, 30, 25, 3, -30 },
  { 676, 11, 29, 25, 4, -29 },
  { 716, 19, 30, 25, 2, -30 },
  { 788, 18, 30, 25, 2, -30 },
  { 856, 20, 29, 25, 2, -29 },
  { 929, 18, 29, 25, 4, -29 },
  { 995, 18, 29, 25, 3, -29 },
  { 1061, 19, 29, 25, 3, -29 },
  { 1130, 18, 30, 25, 4, -30 },
  { 1198, 18, 30, 25, 3, -30 },
  { 1266, 4, 21, 25, 12, -21 },
  { 1277, 5, 27, 25, 11, -21 },
  { 1294, 18, 17, 25, 3, -22 },
  { 1333, 18, 10, 25, 3, -18 },
  { 1356, 17, 17, 25, 4, -22 },
  { 1393, 15, 30, 25, 5, -30 },
  { 1450, 22, 29, 25, 1, -29 },
  { 1530, 21, 29, 25, 2, -29 },
  { 1607, 18, 29, 25, 4, -29 },
  { 1673, 19, 30, 25, 3, -30 },
  { 1745, 18, 29, 25, 4, -29 },
  { 1811, 17, 29, 25, 4, -29 },
  { 1873, 17, 29, 25, 4, -29 },
  { 1935, 19, 30, 25, 3, -30 },
  { 2007, 18, 29, 25, 3, -29 },
  { 2073, 17, 29, 25, 4, -29 },
  { 2135, 18, 29, 25, 2, -29 },
  { 2201, 20, 29, 25, 4, -29 },
  { 2274, 17, 29, 25, 5, -29 },
  { 2336, 18, 29, 25, 4, -29 },
  { 2402, 18, 29, 25, 3, -29 },
  { 2468, 19, 30, 25, 3, -30 },
  { 2540, 18, 29, 25, 5, -29 },
  { 2606, 21, 35, 25, 2, -30 },
  { 2698, 18, 29, 25, 4, -29 },
  { 2764, 19, 30, 25, 3, -30 },
  { 2836, 21, 29, 25, 2, -29 },
  { 2913, 18, 29, 25, 3, -29 },
  { 2979, 21, 29, 25, 2, -29 },
  { 3056, 22, 29, 25, 2, -29 },
  { 3136, 21, 29, 25, 2, -29 },
  { 3213, 20, 29, 25, 2, -29 },
  { 3286, 18, 29, 25, 3, -29 },
  { 3352, 7, 39, 25, 9, -33 },
  { 3387, 14, 32, 25, 5, -29 },
  { 3443, 6, 39, 25, 9, -33 },
  { 3473, 15, 16, 25, 5, -29 },
  { 3503, 17, 2, 25, 4, 0 },
  { 3508, 6, 5, 25, 9, -30 },
  { 3512, 17, 22, 25, 4, -22 },
  { 3559, 17, 31, 25, 4, -31 },
  { 3625, 18, 22, 25, 3, -22 },
  { 3675, 17, 31, 25, 3, -31 },
  { 3741, 18, 22, 25, 3, -22 },
  { 3791, 18, 31, 25, 4, -31 },
  { 3861, 17, 31, 25, 3, -22 },
  { 3927, 17, 31, 25, 4, -31 },
  { 3993, 17, 29, 25, 5, -29 },
  { 4055, 12, 38, 25, 4, -29 },
  { 4112, 17, 31, 25, 5, -31 },
  { 4178, 17, 31, 25, 5, -31 },
  { 4244, 21, 22, 25, 2, -22 },
  { 4302, 17, 22, 25, 4, -22 },
  { 4349, 19, 22, 25, 3, -22 },
  { 4402, 17, 30, 25, 4, -22 },
  { 4466, 17, 30, 25, 3, -22 },
  { 4530, 15, 22, 25, 7, -22 },
  { 4572, 17, 22, 25, 4, -22 },
  { 4619, 17, 27, 25, 4, -27 },
  { 4677, 17, 22, 25, 4, -22 },
  { 4724, 20, 22, 25, 2, -22 },
  { 4779, 23, 22, 25, 1, -22 },
  { 4843, 19, 22, 25, 3, -22 },
  { 4896, 21, 31, 25, 2, -22 },
  { 4978, 19, 22, 25, 3, -22 },
  { 5031, 13, 40, 25, 7, -32 },
  { 5096, 1, 35, 25, 12, -29 },
  { 5101, 13, 40, 25, 7, -32 },
  { 5166, 22, 7, 25, 1, -16 },
};

const GFXfont RobotoMono_ExtraLight41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight41pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_EXTRALIGHT41PT7B_H_
