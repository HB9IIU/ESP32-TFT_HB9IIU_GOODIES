#ifndef _ROBOTOMONO_EXTRALIGHT28PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x8C, 0x63, 0x18, 0xC4, 0x02, 0x08,
  0x04, 0x10, 0x08, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x1F, 0xFF, 0x82,
  0x10, 0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x86, 0x1F, 0xFF,
  0x84, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x00,
  0x04, 0x00, 0x40, 0x04, 0x01, 0xF8, 0x20, 0xC4, 0x06, 0xC0, 0x28, 0x02,
  0x80, 0x3C, 0x00, 0x40, 0x03, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x28, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x26, 0x04, 0x3F, 0x80, 0x60,
  0x06, 0x00, 0x60, 0x78, 0x01, 0x08, 0x02, 0x10, 0x44, 0x21, 0x88, 0x42,
  0x10, 0x88, 0x21, 0x10, 0x66, 0x40, 0x78, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x11, 0xC0, 0x66, 0x40, 0x88, 0x43, 0x30, 0x84, 0x41, 0x10, 0x82, 0x20,
  0x84, 0x01, 0x18, 0x01, 0xE0, 0x0F, 0x00, 0x42, 0x02, 0x0C, 0x08, 0x10,
  0x20, 0xC0, 0x82, 0x03, 0x10, 0x04, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x40,
  0x18, 0x82, 0x41, 0x0B, 0x06, 0x28, 0x0C, 0xA0, 0x1E, 0x80, 0x31, 0x00,
  0xC6, 0x0D, 0x87, 0xE3, 0xFC, 0x06, 0x18, 0x20, 0x83, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x30, 0x20, 0x30, 0x81, 0x02, 0x0C, 0x10, 0x40, 0x82,
  0x08, 0x30, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x21, 0x84,
  0x10, 0x84, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0xC4, 0x73, 0xDC,
  0x06, 0x00, 0xA0, 0x19, 0x01, 0x08, 0x60, 0xC2, 0x04, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x24, 0xB5, 0x80, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10,
  0x08, 0x0C, 0x04, 0x00, 0x0F, 0x81, 0x83, 0x08, 0x08, 0x80, 0x24, 0x01,
  0x60, 0x0B, 0x00, 0xF0, 0x1B, 0x81, 0x9C, 0x18, 0xE1, 0x87, 0x18, 0x39,
  0x81, 0xF8, 0x0F, 0x80, 0x48, 0x02, 0x40, 0x11, 0x01, 0x0C, 0x18, 0x1F,
  0x00, 0x02, 0x3D, 0xCE, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x0F, 0x81, 0x83, 0x18, 0x08,
  0x80, 0x24, 0x01, 0x60, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80,
  0x18, 0x00, 0xFF, 0xF0, 0x0F, 0xC1, 0x83, 0x08, 0x0C, 0x80, 0x24, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x60, 0x3E, 0x00, 0x70, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x38, 0x01, 0x40, 0x13, 0x00, 0x8C, 0x08, 0x3F,
  0x80, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x68, 0x01, 0x20, 0x08, 0x80,
  0x62, 0x01, 0x08, 0x08, 0x20, 0x60, 0x81, 0x02, 0x08, 0x08, 0x60, 0x21,
  0x00, 0x8F, 0xFF, 0xC0, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x3F, 0xE2, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0xE0,
  0x7F, 0x84, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03,
  0xC0, 0x24, 0x06, 0x30, 0xC1, 0xF8, 0x03, 0xC0, 0xE0, 0x18, 0x03, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x0C, 0xF8, 0xB0, 0x4E, 0x02, 0xC0, 0x38, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x40, 0x36, 0x02, 0x30, 0x60, 0xF8,
  0xFF, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x00, 0x0F, 0xC1, 0x83,
  0x08, 0x0C, 0x80, 0x24, 0x01, 0xA0, 0x0D, 0x00, 0x44, 0x02, 0x30, 0x60,
  0x7E, 0x07, 0x38, 0x40, 0x64, 0x01, 0xA0, 0x07, 0x00, 0x38, 0x01, 0x40,
  0x0B, 0x00, 0x8C, 0x0C, 0x3F, 0x80, 0x1F, 0x83, 0x0C, 0x60, 0x24, 0x03,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x32, 0x05,
  0x1F, 0x90, 0x41, 0x00, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x81, 0xE0,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x04, 0x96,
  0x90, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x80, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x18, 0x1C, 0x0E, 0x0E, 0x03, 0x00, 0x40, 0x00, 0x1F, 0x0C,
  0x19, 0x01, 0x60, 0x38, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x40, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x07, 0xE0, 0x18, 0x30, 0x40, 0x31, 0x00, 0x24, 0x1C, 0x48,
  0xC4, 0x71, 0x08, 0xC4, 0x11, 0x88, 0x43, 0x10, 0x86, 0x21, 0x0C, 0x42,
  0x18, 0x84, 0x31, 0x18, 0xA2, 0x31, 0x43, 0x9C, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x80, 0x7F, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x40, 0x05,
  0x80, 0x22, 0x00, 0x88, 0x02, 0x30, 0x10, 0x40, 0x41, 0x01, 0x06, 0x08,
  0x08, 0x20, 0x20, 0xFF, 0xC6, 0x01, 0x10, 0x04, 0x40, 0x1B, 0x00, 0x28,
  0x00, 0xA0, 0x03, 0xFF, 0x08, 0x1C, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x06, 0x80, 0xCF, 0xF0, 0x81, 0xC8, 0x06, 0x80, 0x38, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0x80, 0xCF, 0xF8, 0x0F, 0x81, 0x83,
  0x08, 0x0C, 0x80, 0x24, 0x01, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x28, 0x03, 0x40,
  0x13, 0x01, 0x8C, 0x18, 0x1F, 0x80, 0xFE, 0x08, 0x38, 0x80, 0xC8, 0x06,
  0x80, 0x28, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0x80, 0x68, 0x0C, 0x81, 0x8F, 0xE0,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x1F, 0xFA, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x7F, 0xF0, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFC, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x81,
  0x83, 0x18, 0x0C, 0x80, 0x2C, 0x01, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x03, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0x40, 0x09, 0x00, 0x4C, 0x0C, 0x1F, 0xC0, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7F, 0xF0, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x03, 0x80, 0x2C, 0x06, 0x60,
  0xC1, 0xF8, 0x80, 0x1C, 0x01, 0x20, 0x11, 0x01, 0x08, 0x18, 0x41, 0x82,
  0x18, 0x11, 0x80, 0x88, 0x04, 0xC0, 0x2B, 0x01, 0x8C, 0x08, 0x20, 0x40,
  0x82, 0x06, 0x10, 0x18, 0x80, 0x44, 0x01, 0x20, 0x0D, 0x00, 0x30, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0x00, 0xF8, 0x0B, 0xC0, 0x5F,
  0x06, 0xE8, 0x27, 0x41, 0x39, 0x11, 0xC8, 0x8E, 0x4C, 0x71, 0x43, 0x8A,
  0x1C, 0x60, 0xE1, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x10, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3D, 0x01, 0xEC, 0x0F,
  0x20, 0x79, 0x83, 0xC4, 0x1E, 0x30, 0xF0, 0x87, 0x82, 0x3C, 0x11, 0xE0,
  0x4F, 0x03, 0x78, 0x0B, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x30, 0x0F,
  0x81, 0x82, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x68,
  0x02, 0x40, 0x13, 0x01, 0x0C, 0x18, 0x1F, 0x00, 0xFF, 0x88, 0x0C, 0x80,
  0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x81,
  0xCF, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x0F, 0x81, 0x83, 0x18, 0x0C, 0x80, 0x2C, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x03, 0x40, 0x13, 0x01, 0x8C, 0x18, 0x3F, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0x08, 0x1C, 0x80, 0x68, 0x02, 0x80,
  0x28, 0x03, 0x80, 0x38, 0x02, 0x80, 0x28, 0x04, 0x83, 0x8F, 0xF0, 0x81,
  0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x68, 0x02, 0x80, 0x38, 0x01, 0x0F,
  0xC1, 0x83, 0x18, 0x0C, 0x80, 0x34, 0x00, 0xA0, 0x05, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x01, 0xC0, 0x0A, 0x00, 0xCC, 0x0C, 0x3F, 0x80, 0xFF, 0xFC, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x58, 0x02, 0x40, 0x13, 0x01,
  0x0C, 0x18, 0x3F, 0x00, 0xC0, 0x05, 0x00, 0x14, 0x00, 0xD8, 0x02, 0x20,
  0x08, 0x80, 0x63, 0x01, 0x04, 0x04, 0x10, 0x30, 0x60, 0x80, 0x82, 0x02,
  0x18, 0x0C, 0x40, 0x11, 0x00, 0x44, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00,
  0x30, 0x00, 0x40, 0x81, 0x03, 0x83, 0x05, 0x06, 0x0A, 0x1C, 0x34, 0x28,
  0x48, 0x50, 0x90, 0xA1, 0x21, 0x22, 0x62, 0x44, 0x48, 0x88, 0x91, 0x31,
  0x22, 0x42, 0x42, 0x84, 0x85, 0x0E, 0x0A, 0x0C, 0x14, 0x18, 0x28, 0x30,
  0x60, 0x60, 0x40, 0xC0, 0x80, 0xC0, 0x09, 0x00, 0x66, 0x01, 0x08, 0x08,
  0x10, 0x60, 0x61, 0x00, 0x88, 0x03, 0x20, 0x05, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x40, 0x0C, 0x80, 0x23, 0x01, 0x04, 0x0C, 0x18, 0x20, 0x31, 0x80,
  0x44, 0x01, 0xA0, 0x03, 0xC0, 0x05, 0x00, 0x36, 0x00, 0x88, 0x04, 0x30,
  0x10, 0x40, 0x81, 0x82, 0x02, 0x10, 0x04, 0x40, 0x12, 0x00, 0x28, 0x00,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0xFF, 0xF0, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0xFE, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x3E, 0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x08, 0x04, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xF0, 0x04, 0x03, 0x00, 0xA0, 0x28, 0x11, 0x04,
  0x42, 0x18, 0x82, 0x60, 0x90, 0x1C, 0x04, 0xFF, 0xF0, 0xC6, 0x21, 0x0F,
  0x83, 0x06, 0x60, 0x34, 0x01, 0x00, 0x10, 0x01, 0x00, 0x11, 0xFF, 0x60,
  0x14, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x36, 0x0D, 0x3F, 0x90, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x9F, 0x0A, 0x0C, 0xC0, 0x48,
  0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x03, 0x80, 0x28, 0x02, 0x80, 0x28,
  0x02, 0xC0, 0x4A, 0x0C, 0x9F, 0x00, 0x0F, 0x81, 0x06, 0x20, 0x34, 0x01,
  0x40, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x14, 0x01,
  0x20, 0x33, 0x06, 0x0F, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x0F, 0x93, 0x0D, 0x20, 0x34, 0x03, 0x40, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14, 0x01, 0x60, 0x33, 0x05, 0x1F,
  0x90, 0x0F, 0x80, 0xC3, 0x08, 0x0C, 0x80, 0x24, 0x01, 0x60, 0x0F, 0xFF,
  0xF0, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x01, 0x18, 0x18,
  0x3F, 0x00, 0x03, 0xF0, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0xFF,
  0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x93,
  0x0D, 0x20, 0x34, 0x03, 0x40, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x40, 0x14, 0x01, 0x60, 0x33, 0x05, 0x1F, 0x90, 0x01, 0x00, 0x10,
  0x02, 0x60, 0x63, 0x0C, 0x0F, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x23, 0xE5, 0x86, 0xE0, 0x78, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0x03, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x0C, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x28, 0x0C, 0x81, 0x88, 0x30, 0x86, 0x08,
  0xC0, 0x98, 0x0A, 0x80, 0xC4, 0x08, 0x20, 0x83, 0x08, 0x18, 0x80, 0xC8,
  0x06, 0x80, 0x30, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x9E,
  0x79, 0x47, 0x0B, 0x04, 0x14, 0x08, 0x38, 0x10, 0x70, 0x20, 0xE0, 0x41,
  0xC0, 0x83, 0x81, 0x07, 0x02, 0x0E, 0x04, 0x1C, 0x08, 0x38, 0x10, 0x70,
  0x20, 0xE0, 0x41, 0x80, 0x8F, 0x96, 0x1B, 0x81, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x0F, 0x81, 0x83, 0x18, 0x08, 0x80, 0x2C, 0x01, 0x40, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xF0, 0x06, 0x80, 0x26, 0x03, 0x18, 0x30,
  0x7E, 0x00, 0x9F, 0x14, 0x33, 0x01, 0x40, 0x38, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x05, 0xC1, 0xA7, 0xE4, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x0F, 0x93, 0x0D, 0x20, 0x34,
  0x03, 0x40, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14,
  0x01, 0x60, 0x33, 0x05, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x8F, 0xE6, 0x0A, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1F, 0x86,
  0x0C, 0xC0, 0x28, 0x02, 0xC0, 0x04, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0,
  0x02, 0x00, 0x28, 0x03, 0x80, 0x26, 0x06, 0x3F, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0xFF, 0xE0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x03, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x06, 0xC1, 0x4F, 0xC8, 0x80,
  0x0C, 0x00, 0xF0, 0x04, 0x80, 0x26, 0x02, 0x10, 0x10, 0x81, 0x82, 0x08,
  0x10, 0xC0, 0xC4, 0x02, 0x20, 0x1A, 0x00, 0x50, 0x03, 0x80, 0x08, 0x00,
  0x81, 0x03, 0x02, 0x07, 0x0A, 0x1A, 0x14, 0x24, 0x28, 0x48, 0x50, 0x91,
  0x31, 0x12, 0x24, 0x24, 0x48, 0x48, 0x90, 0xA0, 0xA1, 0xC1, 0xC1, 0x83,
  0x03, 0x06, 0x04, 0x04, 0x00, 0xC0, 0x1B, 0x01, 0x88, 0x08, 0x20, 0x80,
  0x8C, 0x06, 0xC0, 0x1C, 0x00, 0x40, 0x05, 0x00, 0x6C, 0x06, 0x30, 0x20,
  0x82, 0x02, 0x30, 0x0B, 0x00, 0x60, 0xC0, 0x06, 0x80, 0x09, 0x80, 0x31,
  0x00, 0x42, 0x01, 0x82, 0x02, 0x04, 0x04, 0x0C, 0x10, 0x08, 0x20, 0x18,
  0x80, 0x11, 0x00, 0x36, 0x00, 0x28, 0x00, 0x70, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x07, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0xFF, 0xE0, 0x01,
  0x81, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02,
  0x03, 0x06, 0x03, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x08, 0x02, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0x80, 0x30,
  0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xC0, 0x1C, 0x0E, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x20, 0x10, 0x18, 0x18, 0x10, 0x00, 0x18, 0x00, 0xDC, 0x07, 0x0C, 0x1C,
  0x0C, 0x28, 0x07, 0x80,
};

const GFXglyph RobotoMono_ExtraLight28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 2, 20, 17, 7, -20 },
  { 6, 5, 6, 17, 6, -21 },
  { 10, 15, 20, 17, 1, -20 },
  { 48, 12, 26, 17, 3, -23 },
  { 87, 15, 20, 17, 1, -20 },
  { 125, 14, 20, 17, 2, -20 },
  { 160, 1, 6, 17, 7, -21 },
  { 161, 7, 28, 17, 5, -22 },
  { 186, 6, 28, 17, 5, -22 },
  { 207, 12, 12, 17, 3, -20 },
  { 225, 13, 14, 17, 2, -16 },
  { 248, 3, 6, 17, 5, -2 },
  { 251, 10, 2, 17, 3, -10 },
  { 254, 2, 2, 17, 8, -2 },
  { 255, 9, 22, 17, 4, -20 },
  { 280, 13, 20, 17, 2, -20 },
  { 313, 7, 20, 17, 3, -20 },
  { 331, 13, 20, 17, 1, -20 },
  { 364, 13, 20, 17, 1, -20 },
  { 397, 14, 20, 17, 1, -20 },
  { 432, 12, 20, 17, 3, -20 },
  { 462, 12, 20, 17, 2, -20 },
  { 492, 13, 20, 17, 2, -20 },
  { 525, 13, 20, 17, 2, -20 },
  { 558, 12, 20, 17, 2, -20 },
  { 588, 3, 14, 17, 8, -14 },
  { 594, 3, 18, 17, 8, -14 },
  { 601, 12, 12, 17, 2, -15 },
  { 619, 13, 6, 17, 2, -12 },
  { 629, 11, 12, 17, 3, -15 },
  { 646, 11, 20, 17, 3, -20 },
  { 674, 15, 20, 17, 1, -20 },
  { 712, 14, 20, 17, 2, -20 },
  { 747, 12, 20, 17, 3, -20 },
  { 777, 13, 20, 17, 2, -20 },
  { 810, 12, 20, 17, 3, -20 },
  { 840, 11, 20, 17, 3, -20 },
  { 868, 12, 20, 17, 3, -20 },
  { 898, 13, 20, 17, 2, -20 },
  { 931, 13, 20, 17, 2, -20 },
  { 964, 11, 20, 17, 3, -20 },
  { 992, 12, 20, 17, 2, -20 },
  { 1022, 13, 20, 17, 3, -20 },
  { 1055, 12, 20, 17, 3, -20 },
  { 1085, 13, 20, 17, 2, -20 },
  { 1118, 13, 20, 17, 2, -20 },
  { 1151, 13, 20, 17, 2, -20 },
  { 1184, 12, 20, 17, 3, -20 },
  { 1214, 13, 24, 17, 2, -20 },
  { 1253, 12, 20, 17, 3, -20 },
  { 1283, 13, 20, 17, 2, -20 },
  { 1316, 14, 20, 17, 1, -20 },
  { 1351, 13, 20, 17, 2, -20 },
  { 1384, 14, 20, 17, 1, -20 },
  { 1419, 15, 20, 17, 1, -20 },
  { 1457, 14, 20, 17, 2, -20 },
  { 1492, 14, 20, 17, 1, -20 },
  { 1527, 12, 20, 17, 2, -20 },
  { 1557, 5, 27, 17, 6, -23 },
  { 1574, 9, 22, 17, 4, -20 },
  { 1599, 4, 27, 17, 6, -23 },
  { 1613, 10, 11, 17, 3, -20 },
  { 1627, 12, 1, 17, 2, 0 },
  { 1629, 4, 4, 17, 6, -21 },
  { 1631, 12, 15, 17, 2, -15 },
  { 1654, 12, 21, 17, 3, -21 },
  { 1686, 12, 15, 17, 2, -15 },
  { 1709, 12, 21, 17, 2, -21 },
  { 1741, 13, 15, 17, 2, -15 },
  { 1766, 12, 21, 17, 3, -21 },
  { 1798, 12, 21, 17, 2, -15 },
  { 1830, 11, 21, 17, 3, -21 },
  { 1859, 12, 20, 17, 3, -20 },
  { 1889, 8, 26, 17, 3, -20 },
  { 1915, 12, 21, 17, 3, -21 },
  { 1947, 12, 21, 17, 3, -21 },
  { 1979, 15, 15, 17, 1, -15 },
  { 2008, 11, 15, 17, 3, -15 },
  { 2029, 13, 15, 17, 2, -15 },
  { 2054, 11, 21, 17, 3, -15 },
  { 2083, 12, 21, 17, 2, -15 },
  { 2115, 10, 15, 17, 5, -15 },
  { 2134, 12, 15, 17, 3, -15 },
  { 2157, 12, 19, 17, 2, -19 },
  { 2186, 11, 15, 17, 3, -15 },
  { 2207, 13, 15, 17, 2, -15 },
  { 2232, 15, 15, 17, 1, -15 },
  { 2261, 13, 15, 17, 2, -15 },
  { 2286, 15, 21, 17, 1, -15 },
  { 2326, 13, 15, 17, 2, -15 },
  { 2351, 9, 28, 17, 5, -22 },
  { 2383, 1, 24, 17, 8, -20 },
  { 2386, 9, 28, 17, 5, -22 },
  { 2418, 15, 5, 17, 1, -11 },
};

const GFXfont RobotoMono_ExtraLight28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight28pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_EXTRALIGHT28PT7B_H_
