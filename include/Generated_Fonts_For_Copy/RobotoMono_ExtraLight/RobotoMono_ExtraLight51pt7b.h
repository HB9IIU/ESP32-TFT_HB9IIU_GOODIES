#ifndef _ROBOTOMONO_EXTRALIGHT51PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight51pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x00, 0x00, 0x00, 0x0E, 0xF6, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x05, 0x82, 0x81, 0x41, 0x80, 0x00, 0x18, 0x06, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60,
  0x0C, 0x00, 0x0C, 0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0,
  0x04, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x04, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x08, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xE1, 0xF0, 0x1C, 0x00, 0xE0, 0xE0, 0x01,
  0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x07, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x06,
  0x60, 0x00, 0x19, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x07, 0x00, 0x38, 0x0F,
  0xDF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x60, 0xC0, 0x30, 0x0C, 0x0C, 0x03, 0x01, 0xC0, 0xC0,
  0x30, 0x18, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x0C, 0x03, 0x06,
  0x00, 0x60, 0x30, 0x60, 0x06, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0xC0, 0x01,
  0xFC, 0x18, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xF8,
  0x00, 0x18, 0x3F, 0xC0, 0x01, 0x87, 0x06, 0x00, 0x30, 0x60, 0x30, 0x03,
  0x04, 0x03, 0x00, 0x60, 0xC0, 0x30, 0x06, 0x0C, 0x03, 0x00, 0xC0, 0xC0,
  0x10, 0x1C, 0x0C, 0x01, 0x01, 0x80, 0xC0, 0x10, 0x30, 0x0C, 0x03, 0x03,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xE3, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00,
  0xE0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xC1, 0xC0, 0x18, 0xC0, 0x70, 0x0C, 0xC0, 0x1C, 0x06, 0xE0,
  0x06, 0x03, 0x60, 0x03, 0x83, 0xB0, 0x00, 0xE1, 0x98, 0x00, 0x38, 0xCC,
  0x00, 0x0E, 0xE6, 0x00, 0x03, 0x63, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x70,
  0x60, 0x00, 0x7C, 0x38, 0x00, 0x77, 0x0F, 0x00, 0x71, 0x83, 0xF3, 0xF0,
  0x60, 0x7F, 0xE0, 0x38, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x20,
  0x0C, 0x03, 0x80, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x7C, 0x0C, 0x0F, 0xFE, 0x31,
  0xF8, 0x3F, 0xDF, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x30, 0x00, 0x18, 0x60, 0x00, 0xE1, 0xC0, 0x07, 0x03, 0x80, 0x18,
  0x07, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0x18, 0x08, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x33, 0x33, 0x33, 0x37,
  0x6E, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xF7, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1E, 0x0F, 0x00, 0x70, 0x07,
  0x01, 0xC0, 0x07, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C,
  0x60, 0x00, 0x1C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x77, 0x00, 0x01, 0xEC,
  0x00, 0x06, 0xD8, 0x00, 0x19, 0xF0, 0x00, 0x63, 0xE0, 0x01, 0x87, 0xC0,
  0x06, 0x0F, 0x80, 0x18, 0x1F, 0x00, 0x60, 0x3E, 0x01, 0x80, 0x7C, 0x06,
  0x00, 0xF8, 0x18, 0x01, 0xF0, 0xE0, 0x03, 0xE3, 0x80, 0x07, 0xCE, 0x00,
  0x0F, 0xF8, 0x00, 0x1B, 0xE0, 0x00, 0x33, 0x80, 0x00, 0x66, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x30,
  0x38, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x3F, 0x7E, 0x00, 0x1F, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xF3, 0x78, 0x3E, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x3C, 0x1E, 0x00, 0xE0, 0x0E, 0x03, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0x0F, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x87, 0x00,
  0x03, 0x0C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0xB8, 0x00, 0x06, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0x3F, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x1C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC7, 0xF8, 0x03, 0x7F, 0xF8,
  0x0F, 0xC1, 0xF0, 0x38, 0x01, 0xE0, 0x40, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07,
  0x60, 0x00, 0x19, 0x80, 0x00, 0xE3, 0x00, 0x03, 0x8E, 0x00, 0x1C, 0x1C,
  0x00, 0xF0, 0x3C, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x81, 0xF0, 0x0E, 0x3F, 0xF8, 0x31, 0xE0, 0xF0, 0xDC, 0x00, 0xE3,
  0x60, 0x01, 0xCF, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x8C, 0x00, 0x0E, 0x38, 0x00, 0x30, 0x70, 0x01, 0x80, 0xE0,
  0x1E, 0x01, 0xF3, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0xC3, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00,
  0x0C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x0F, 0x00,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xE7, 0xE0, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x30, 0x00,
  0x0C, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x07, 0xE7, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x7C,
  0x07, 0x80, 0x78, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x38,
  0x00, 0x6C, 0x70, 0x03, 0xB0, 0xE0, 0x3C, 0xC1, 0xFF, 0xC3, 0x01, 0xFE,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x23, 0xBE,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x8E, 0xFB, 0x80, 0x11, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x31, 0x8C, 0x67, 0x31, 0x98, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xC0, 0x7C, 0x3C, 0x1C, 0x01, 0xC7, 0x00, 0x1C, 0xC0, 0x01, 0xB8, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x18, 0x07, 0xC0, 0x61, 0x80, 0xFF, 0x06, 0x30,
  0x18, 0x30, 0x33, 0x03, 0x01, 0x03, 0x30, 0x60, 0x10, 0x36, 0x06, 0x03,
  0x03, 0x60, 0x40, 0x30, 0x36, 0x0C, 0x03, 0x03, 0x60, 0xC0, 0x30, 0x34,
  0x0C, 0x03, 0x03, 0x40, 0x80, 0x30, 0x3C, 0x08, 0x03, 0x03, 0xC1, 0x80,
  0x20, 0x3C, 0x18, 0x02, 0x03, 0xC1, 0x80, 0x60, 0x34, 0x08, 0x06, 0x02,
  0x40, 0x80, 0xE0, 0x66, 0x0C, 0x0A, 0x06, 0x60, 0xC1, 0xB0, 0xC6, 0x06,
  0x33, 0x1C, 0x60, 0x7E, 0x1F, 0x83, 0x01, 0x80, 0xE0, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x07,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x0E,
  0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0x60, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x0C, 0x00, 0x3C, 0x30, 0x00, 0x38, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00, 0x01, 0xCC, 0x00, 0x0E,
  0x30, 0x00, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0C, 0x00, 0x7C, 0x30,
  0x00, 0x3C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0,
  0x00, 0x73, 0x00, 0x07, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xC1, 0xE0, 0x07, 0x00, 0x78, 0x0E, 0x00,
  0x18, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x70, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00,
  0x07, 0x30, 0x00, 0x06, 0x38, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x70, 0x03, 0xF3, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0x00, 0x1E,
  0x06, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x1C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x76, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x30, 0x00, 0x18, 0x60, 0x00, 0x70,
  0xC0, 0x03, 0xC1, 0x80, 0x1E, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xC1, 0xF0, 0x07,
  0x00, 0x78, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x70, 0x00, 0x03, 0x30, 0x00, 0x03, 0x38, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x1C, 0x03,
  0xFB, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x66, 0x00, 0x03, 0x8C,
  0x00, 0x0C, 0x38, 0x00, 0x70, 0x78, 0x07, 0x80, 0xFD, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03,
  0x80, 0xE0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xC0,
  0x00, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0xC0, 0x00, 0xEE, 0xE0,
  0x00, 0xFC, 0x70, 0x00, 0xF8, 0x30, 0x00, 0xF0, 0x18, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0xC0, 0x01, 0xBD, 0x80, 0x03, 0x7B, 0x00, 0x06, 0xF3, 0x00, 0x19, 0xE6,
  0x00, 0x33, 0xCE, 0x00, 0xE7, 0x8C, 0x01, 0x8F, 0x18, 0x03, 0x1E, 0x18,
  0x0C, 0x3E, 0x30, 0x18, 0x7C, 0x60, 0x70, 0xF8, 0x60, 0xC1, 0xF0, 0xC1,
  0x83, 0xE1, 0xC6, 0x07, 0xC1, 0x8C, 0x0F, 0x83, 0x38, 0x1F, 0x03, 0x60,
  0x3E, 0x06, 0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x0E, 0x01, 0xF0, 0x1C, 0x03,
  0xE0, 0x30, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xD8, 0x00,
  0x0F, 0x70, 0x00, 0x3C, 0xC0, 0x00, 0xF3, 0x80, 0x03, 0xC6, 0x00, 0x0F,
  0x0C, 0x00, 0x3C, 0x30, 0x00, 0xF0, 0x60, 0x03, 0xC1, 0x80, 0x0F, 0x03,
  0x00, 0x3C, 0x0E, 0x00, 0xF0, 0x18, 0x03, 0xC0, 0x70, 0x0F, 0x00, 0xC0,
  0x3C, 0x01, 0x80, 0xF0, 0x06, 0x03, 0xC0, 0x0C, 0x0F, 0x00, 0x30, 0x3C,
  0x00, 0x60, 0xF0, 0x01, 0xC3, 0xC0, 0x03, 0x0F, 0x00, 0x0E, 0x3C, 0x00,
  0x18, 0xF0, 0x00, 0x33, 0xC0, 0x00, 0xCF, 0x00, 0x01, 0xBC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xC3, 0xE0, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x18,
  0x00, 0x1C, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x07, 0x00, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0C, 0x00, 0x1E, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x8C, 0x00, 0x3C,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0x0E, 0x00,
  0xC0, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x70, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x70, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x43, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0x80, 0x0F, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x70, 0x00,
  0x0C, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x18,
  0xE0, 0x00, 0x71, 0xC0, 0x03, 0xC3, 0x80, 0x1E, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1C, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xE0,
  0x03, 0x81, 0xC0, 0x03, 0x03, 0x80, 0x07, 0x07, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x19, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xC3, 0xE0, 0x1E, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x0C, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8E, 0x00,
  0x0C, 0x1C, 0x00, 0x70, 0x38, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x10, 0x00, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x07,
  0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x0C, 0x00, 0x38, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0x70, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x18, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x6C, 0x01, 0xC0, 0x0D, 0x80, 0x38, 0x01, 0xB0, 0x07,
  0x80, 0x36, 0x00, 0xF0, 0x06, 0xC0, 0x1E, 0x01, 0x98, 0x02, 0xC0, 0x33,
  0x00, 0xD8, 0x06, 0x30, 0x19, 0x00, 0xC6, 0x03, 0x30, 0x18, 0xC0, 0x66,
  0x03, 0x18, 0x08, 0xC0, 0x63, 0x03, 0x18, 0x18, 0x60, 0x63, 0x03, 0x0E,
  0x0C, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18,
  0x30, 0x61, 0x83, 0x04, 0x0C, 0x30, 0x31, 0x81, 0x86, 0x06, 0x30, 0x18,
  0xC0, 0xC6, 0x03, 0x30, 0x18, 0xC0, 0x66, 0x03, 0x18, 0x0C, 0xC0, 0x33,
  0x01, 0x98, 0x06, 0xC0, 0x33, 0x00, 0xD8, 0x06, 0xC0, 0x1B, 0x00, 0x78,
  0x03, 0x60, 0x0F, 0x00, 0x6C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0xE0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0xE0, 0x18, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x38,
  0x03, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x38, 0x00,
  0x06, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x1C,
  0x18, 0x00, 0x06, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x70, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x06, 0xC0, 0x03, 0xB0, 0x00, 0xCE, 0x00, 0x31, 0x80, 0x18, 0x60, 0x06,
  0x0C, 0x03, 0x83, 0x00, 0xC0, 0xE0, 0x30, 0x18, 0x18, 0x06, 0x06, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x30, 0x01, 0x98, 0x00, 0x7E, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC1, 0xC1, 0x81, 0x81, 0x83,
  0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xE0, 0x0E, 0x06, 0x00, 0x1C,
  0x30, 0x00, 0x39, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xFF,
  0xFC, 0x3F, 0xE0, 0x71, 0xE0, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x1D,
  0x80, 0x00, 0x76, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0x80,
  0x00, 0xF6, 0x00, 0x07, 0xDC, 0x00, 0x3F, 0x38, 0x03, 0xCC, 0x7E, 0xFC,
  0x30, 0x7F, 0xC0, 0xC0, 0x10, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x83,
  0xFC, 0x0C, 0x7F, 0xF8, 0x67, 0x01, 0xE3, 0x60, 0x03, 0x9E, 0x00, 0x0C,
  0xE0, 0x00, 0x77, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x06, 0xE0, 0x00, 0x77, 0x80, 0x03, 0x36,
  0x00, 0x39, 0xB8, 0x03, 0x8C, 0x7F, 0xF8, 0x61, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x1C,
  0x18, 0x00, 0x38, 0xC0, 0x00, 0x67, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0x70, 0x00, 0x0C, 0xC0,
  0x00, 0x63, 0x80, 0x01, 0x87, 0x00, 0x0C, 0x0E, 0x00, 0xE0, 0x1F, 0xBF,
  0x00, 0x1F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x07,
  0xFC, 0x30, 0x7F, 0xF9, 0x87, 0x00, 0xEC, 0x70, 0x03, 0xE7, 0x00, 0x07,
  0x30, 0x00, 0x3B, 0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0x6E, 0x00, 0x03, 0x30, 0x00, 0x19, 0xC0, 0x01, 0xC7,
  0x00, 0x1E, 0x1C, 0x03, 0xB0, 0x7F, 0xF9, 0x81, 0xFF, 0x0C, 0x00, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x03, 0x80, 0xE0, 0x03,
  0x81, 0x80, 0x03, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x02, 0x0E, 0x00, 0x0E, 0x0F, 0x00,
  0x78, 0x07, 0xE7, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xF0, 0x08, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0xFE, 0x18, 0x3F, 0xFC, 0xC3, 0x80, 0x76, 0x38,
  0x00, 0xF3, 0x80, 0x03, 0x98, 0x00, 0x1D, 0xC0, 0x00, 0x6C, 0x00, 0x03,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x37, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0xE0, 0x00, 0xE3, 0x80, 0x0F, 0x0E, 0x01, 0xD8, 0x3F, 0xFC, 0xC0,
  0xFF, 0x86, 0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x31, 0xC0, 0x03, 0x07, 0x00, 0x38, 0x1E,
  0x0F, 0x80, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x81, 0xFE, 0x0C, 0x3F, 0xFC, 0x63, 0x80, 0x73, 0x30, 0x01, 0x9B, 0x00,
  0x06, 0xF0, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x1F,
  0xFE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x70, 0x01, 0xF0, 0xFF, 0xC0, 0xFF,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0xEC, 0x00, 0x0E, 0x60,
  0x00, 0xE3, 0x00, 0x0E, 0x18, 0x01, 0xC0, 0xC0, 0x1C, 0x06, 0x01, 0xC0,
  0x30, 0x1C, 0x01, 0x81, 0xC0, 0x0C, 0x1C, 0x00, 0x61, 0xC0, 0x03, 0x1C,
  0x00, 0x19, 0xF0, 0x00, 0xF9, 0xC0, 0x07, 0x86, 0x00, 0x38, 0x38, 0x01,
  0x80, 0xE0, 0x0C, 0x03, 0x80, 0x60, 0x0E, 0x03, 0x00, 0x38, 0x18, 0x00,
  0xE0, 0xC0, 0x03, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x71, 0x80, 0x01, 0xCC,
  0x00, 0x07, 0x60, 0x00, 0x1C, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC7, 0xF0, 0x7F,
  0x37, 0xFE, 0x7F, 0xED, 0x81, 0xF8, 0x1F, 0xC0, 0x3C, 0x03, 0xE0, 0x0E,
  0x00, 0xF8, 0x03, 0x80, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0,
  0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30,
  0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00,
  0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F,
  0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0,
  0x0C, 0xC0, 0xFF, 0x06, 0x1F, 0xFE, 0x31, 0xC0, 0x39, 0x98, 0x00, 0xCD,
  0x80, 0x07, 0x78, 0x00, 0x1B, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x70, 0x00, 0x06,
  0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x70, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0xC3, 0xFE, 0x06, 0x3F, 0xFC, 0x33, 0x80, 0xF1, 0xB0, 0x01, 0xCF, 0x00,
  0x06, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x70, 0x00, 0x3B, 0xC0, 0x01,
  0x9F, 0x00, 0x1C, 0xDC, 0x03, 0xC6, 0x7E, 0xFC, 0x30, 0xFF, 0x81, 0x80,
  0x40, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x18, 0x3F, 0xFC, 0xC3, 0x80, 0x76, 0x38, 0x00,
  0xF3, 0x80, 0x03, 0x98, 0x00, 0x1D, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x37, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xE0, 0x00, 0xE3, 0x80, 0x0F, 0x0E, 0x01, 0xD8, 0x3F, 0x7C, 0xC0, 0xFF,
  0x86, 0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0xC0, 0x7F, 0xF0, 0x7F, 0xFE, 0x78, 0x03, 0xB8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0x00,
  0x38, 0x60, 0x00, 0xE7, 0x00, 0x03, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0D, 0x80, 0x00, 0x6E, 0x00, 0x06, 0x3C, 0x00, 0xF0, 0xFE,
  0x7F, 0x01, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00,
  0x3D, 0xC0, 0x01, 0xE6, 0x00, 0x1F, 0x3C, 0x03, 0xB8, 0xFF, 0xF9, 0xC1,
  0xFF, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x98,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x1C,
  0x03, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x0C, 0x03, 0x80, 0x07, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x38, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xB0, 0x07, 0x00, 0x66, 0x00, 0xA0, 0x0C, 0xC0,
  0x36, 0x01, 0x98, 0x06, 0xC0, 0x33, 0x00, 0xD8, 0x06, 0x30, 0x11, 0x01,
  0x86, 0x06, 0x30, 0x30, 0xC0, 0xC6, 0x06, 0x18, 0x18, 0xC0, 0xC1, 0x82,
  0x08, 0x30, 0x30, 0xC1, 0x86, 0x06, 0x18, 0x30, 0xC0, 0xC3, 0x06, 0x18,
  0x18, 0x40, 0x43, 0x01, 0x98, 0x0C, 0xC0, 0x33, 0x01, 0x98, 0x06, 0x60,
  0x33, 0x00, 0xC8, 0x02, 0x60, 0x0B, 0x00, 0x68, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x01,
  0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x38, 0x03, 0x80, 0x0E, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x1D, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x30, 0x01, 0x80, 0x38,
  0x00, 0x60, 0x38, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x07,
  0x00, 0x70, 0x00, 0x60, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x67, 0xFE, 0x00, 0x0D, 0xC0, 0xE0, 0x01, 0xF0, 0x0E, 0x00, 0x6C,
  0x00, 0xF0, 0x0D, 0x80, 0x07, 0x03, 0x30, 0x00, 0x7F, 0xC2, 0x00, 0x03,
  0xF0,
};

const GFXglyph RobotoMono_ExtraLight51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 4, 36, 31, 13, -36 },
  { 19, 9, 10, 31, 11, -38 },
  { 31, 27, 36, 31, 2, -36 },
  { 153, 22, 47, 31, 5, -42 },
  { 283, 28, 38, 31, 1, -37 },
  { 416, 25, 38, 31, 4, -37 },
  { 535, 2, 10, 31, 13, -38 },
  { 538, 11, 53, 31, 10, -41 },
  { 611, 11, 53, 31, 9, -41 },
  { 684, 22, 21, 31, 5, -36 },
  { 742, 25, 26, 31, 3, -30 },
  { 824, 4, 11, 31, 10, -4 },
  { 830, 18, 2, 31, 6, -17 },
  { 835, 4, 4, 31, 14, -4 },
  { 837, 18, 39, 31, 7, -36 },
  { 925, 23, 38, 31, 4, -37 },
  { 1035, 12, 36, 31, 6, -36 },
  { 1089, 23, 37, 31, 3, -37 },
  { 1196, 23, 38, 31, 2, -37 },
  { 1306, 26, 36, 31, 2, -36 },
  { 1423, 22, 37, 31, 5, -36 },
  { 1525, 22, 38, 31, 4, -37 },
  { 1630, 24, 36, 31, 3, -36 },
  { 1738, 24, 38, 31, 4, -37 },
  { 1852, 22, 37, 31, 4, -37 },
  { 1954, 5, 26, 31, 15, -26 },
  { 1971, 5, 33, 31, 14, -26 },
  { 1992, 22, 21, 31, 4, -27 },
  { 2050, 23, 13, 31, 4, -23 },
  { 2088, 21, 21, 31, 5, -27 },
  { 2144, 19, 37, 31, 6, -37 },
  { 2232, 28, 37, 31, 1, -37 },
  { 2362, 26, 36, 31, 3, -36 },
  { 2479, 22, 36, 31, 5, -36 },
  { 2578, 24, 38, 31, 3, -37 },
  { 2692, 23, 36, 31, 5, -36 },
  { 2796, 21, 36, 31, 5, -36 },
  { 2891, 22, 36, 31, 5, -36 },
  { 2990, 24, 38, 31, 3, -37 },
  { 3104, 22, 36, 31, 4, -36 },
  { 3203, 21, 36, 31, 5, -36 },
  { 3298, 22, 37, 31, 3, -36 },
  { 3400, 24, 36, 31, 5, -36 },
  { 3508, 21, 36, 31, 6, -36 },
  { 3603, 23, 36, 31, 4, -36 },
  { 3707, 22, 36, 31, 4, -36 },
  { 3806, 24, 38, 31, 3, -37 },
  { 3920, 22, 36, 31, 6, -36 },
  { 4019, 25, 43, 31, 3, -37 },
  { 4154, 23, 36, 31, 5, -36 },
  { 4258, 24, 38, 31, 4, -37 },
  { 4372, 25, 36, 31, 3, -36 },
  { 4485, 22, 37, 31, 4, -36 },
  { 4587, 26, 36, 31, 2, -36 },
  { 4704, 27, 36, 31, 2, -36 },
  { 4826, 26, 36, 31, 3, -36 },
  { 4943, 26, 36, 31, 2, -36 },
  { 5060, 23, 36, 31, 3, -36 },
  { 5164, 8, 49, 31, 12, -41 },
  { 5213, 17, 39, 31, 7, -36 },
  { 5296, 8, 49, 31, 11, -41 },
  { 5345, 18, 19, 31, 6, -36 },
  { 5388, 21, 2, 31, 5, 0 },
  { 5394, 7, 7, 31, 12, -38 },
  { 5401, 22, 28, 31, 4, -27 },
  { 5478, 21, 39, 31, 5, -38 },
  { 5581, 22, 28, 31, 4, -27 },
  { 5658, 21, 39, 31, 4, -38 },
  { 5761, 23, 28, 31, 4, -27 },
  { 5842, 23, 39, 31, 5, -39 },
  { 5955, 21, 38, 31, 4, -27 },
  { 6055, 21, 38, 31, 5, -38 },
  { 6155, 21, 37, 31, 6, -37 },
  { 6253, 16, 48, 31, 5, -37 },
  { 6349, 21, 38, 31, 6, -38 },
  { 6449, 21, 38, 31, 6, -38 },
  { 6549, 26, 27, 31, 2, -27 },
  { 6637, 21, 27, 31, 5, -27 },
  { 6708, 24, 28, 31, 3, -27 },
  { 6792, 21, 37, 31, 5, -27 },
  { 6890, 21, 37, 31, 4, -27 },
  { 6988, 18, 27, 31, 9, -27 },
  { 7049, 21, 28, 31, 5, -27 },
  { 7123, 21, 35, 31, 5, -34 },
  { 7215, 21, 28, 31, 5, -27 },
  { 7289, 25, 27, 31, 3, -27 },
  { 7374, 27, 27, 31, 2, -27 },
  { 7466, 25, 27, 31, 3, -27 },
  { 7551, 27, 38, 31, 2, -27 },
  { 7680, 24, 27, 31, 4, -27 },
  { 7761, 17, 51, 31, 8, -40 },
  { 7870, 2, 44, 31, 14, -36 },
  { 7881, 17, 51, 31, 8, -40 },
  { 7990, 27, 8, 31, 2, -19 },
};

const GFXfont RobotoMono_ExtraLight51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight51pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_EXTRALIGHT51PT7B_H_
