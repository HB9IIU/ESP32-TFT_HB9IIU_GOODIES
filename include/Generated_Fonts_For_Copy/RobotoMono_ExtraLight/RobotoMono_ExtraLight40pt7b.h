#ifndef _ROBOTOMONO_EXTRALIGHT40PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight40pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20, 0x00, 0x0B, 0xB0,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x00, 0x60, 0x60, 0x01, 0x01,
  0x00, 0x04, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x08, 0x08, 0x00, 0x20, 0x20, 0x3F, 0xFF, 0xFC, 0x06, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x40, 0x60, 0x01, 0x01, 0x00, 0x04, 0x04, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x3F,
  0xFF, 0xFE, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x40, 0x60, 0x01, 0x01,
  0x00, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x02, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0x60, 0x38, 0x60, 0x0C, 0x60, 0x03, 0x30, 0x01, 0x90, 0x00, 0x68,
  0x00, 0x34, 0x00, 0x1B, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1B, 0x00, 0x18, 0xC0, 0x1C, 0x38, 0x3C, 0x0F, 0xF8, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00,
  0x06, 0x18, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x82, 0x02, 0x06, 0x08,
  0x08, 0x10, 0x20, 0x20, 0xC0, 0x80, 0x82, 0x03, 0x02, 0x18, 0x04, 0x18,
  0x40, 0x1C, 0xC3, 0x00, 0x3E, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x01, 0x0F, 0xC0, 0x0C, 0x61, 0x80,
  0x21, 0x03, 0x01, 0x84, 0x0C, 0x04, 0x30, 0x10, 0x30, 0xC0, 0x41, 0x83,
  0x01, 0x04, 0x0C, 0x04, 0x30, 0x10, 0x30, 0x00, 0x60, 0x80, 0x00, 0xC6,
  0x00, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x0C, 0x18, 0x01, 0x80,
  0x80, 0x18, 0x0C, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x80, 0x18,
  0x18, 0x01, 0x83, 0x00, 0x08, 0x60, 0x00, 0xCC, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x01, 0x98, 0x00, 0x30, 0xC0, 0x66, 0x06, 0x06,
  0x60, 0x30, 0x6C, 0x03, 0x06, 0xC0, 0x18, 0x6C, 0x00, 0xCC, 0xC0, 0x06,
  0xCC, 0x00, 0x38, 0xC0, 0x03, 0x86, 0x00, 0x38, 0x70, 0x06, 0xC3, 0xC3,
  0xC6, 0x0F, 0xF0, 0x30, 0xFF, 0xFF, 0x01, 0x01, 0xC0, 0x80, 0x80, 0xC0,
  0xC0, 0x40, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x30, 0x18, 0x08, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x81, 0x80,
  0x80, 0x80, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x07, 0x04, 0x1F, 0xE2, 0x3E, 0x1F, 0xF0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xD8, 0x00, 0xC6, 0x00, 0xC1, 0x80, 0x60, 0x60, 0xE0, 0x38,
  0x20, 0x08, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x24, 0xB6, 0xF6, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0,
  0xE0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0x66, 0x00, 0x19, 0x00, 0x02, 0x40,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x6F, 0x00, 0x33, 0xC0, 0x18, 0xF0, 0x0C,
  0x3C, 0x0E, 0x0F, 0x06, 0x03, 0xC3, 0x00, 0xF1, 0x80, 0x3C, 0xC0, 0x0F,
  0x60, 0x03, 0xF0, 0x00, 0xD8, 0x00, 0x26, 0x00, 0x09, 0x80, 0x06, 0x20,
  0x01, 0x8C, 0x00, 0xC1, 0x80, 0x60, 0x38, 0x70, 0x07, 0xF8, 0x00, 0x00,
  0xC1, 0xF1, 0xED, 0xE3, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x03, 0xE0,
  0x03, 0xFE, 0x01, 0x80, 0xE0, 0xC0, 0x18, 0x60, 0x03, 0x10, 0x00, 0x4C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC0, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xC0,
  0x0C, 0x60, 0x01, 0x18, 0x00, 0x64, 0x00, 0x1B, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x02, 0x60, 0x01,
  0x98, 0x00, 0x63, 0x00, 0x30, 0x78, 0x78, 0x07, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x06,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03,
  0x00, 0x60, 0x30, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0x98, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x09, 0xFC, 0x0F, 0xFF, 0x87, 0x01, 0xE1,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x0D, 0x00, 0x06, 0xC0, 0x06, 0x30,
  0x07, 0x1C, 0x07, 0x07, 0xDF, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x38, 0x18, 0xFF, 0x8D, 0xC0, 0xE7,
  0x80, 0x3B, 0x80, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0xC0, 0x03, 0x60,
  0x01, 0x18, 0x01, 0x86, 0x01, 0x81, 0xC3, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x70, 0x1C, 0x1C, 0x01, 0x83, 0x00,
  0x18, 0x40, 0x01, 0x18, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00,
  0x18, 0xC0, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x30, 0x1E, 0x3C, 0x00, 0xFE,
  0x00, 0x78, 0xF0, 0x18, 0x03, 0x06, 0x00, 0x31, 0x80, 0x03, 0x20, 0x00,
  0x64, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x02, 0x60, 0x00,
  0xCE, 0x00, 0x38, 0xE0, 0x0E, 0x0F, 0x07, 0x80, 0x7F, 0xC0, 0x03, 0xE0,
  0x03, 0xFE, 0x01, 0xC0, 0xE0, 0xC0, 0x18, 0x60, 0x03, 0x18, 0x00, 0x44,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x0F, 0x30, 0x06,
  0x87, 0x03, 0x20, 0xFF, 0x88, 0x0F, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x37, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x6C,
  0xC0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x70, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE1,
  0xC0, 0xE3, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0x38, 0x0C, 0x01,
  0x80, 0x18, 0x0C, 0x00, 0x30, 0x60, 0x00, 0x63, 0x01, 0xC1, 0x8C, 0x1F,
  0x82, 0x20, 0xC3, 0x09, 0x86, 0x0C, 0x34, 0x10, 0x30, 0xD0, 0xC0, 0x83,
  0xC3, 0x02, 0x0F, 0x08, 0x08, 0x3C, 0x20, 0x20, 0xF0, 0x80, 0x83, 0xC2,
  0x02, 0x0F, 0x08, 0x18, 0x2C, 0x20, 0x60, 0xB0, 0x83, 0x82, 0xC3, 0x0A,
  0x11, 0x04, 0x4C, 0xC6, 0x1F, 0x1E, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x08, 0x01, 0xC1, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0D, 0x00, 0x00, 0xD8, 0x00,
  0x09, 0x80, 0x01, 0x88, 0x00, 0x18, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0x40,
  0x03, 0x06, 0x00, 0x20, 0x60, 0x06, 0x02, 0x00, 0x60, 0x30, 0x04, 0x03,
  0x00, 0xC0, 0x10, 0x0C, 0x01, 0x80, 0x80, 0x18, 0x1F, 0xFF, 0x81, 0xFF,
  0xFC, 0x10, 0x00, 0xC3, 0x00, 0x04, 0x30, 0x00, 0x62, 0x00, 0x06, 0x60,
  0x00, 0x26, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF0, 0x30,
  0x0F, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x4C, 0x00,
  0x13, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x30,
  0xC0, 0xF8, 0x3F, 0xFE, 0x0C, 0x01, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0x30,
  0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x01, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0,
  0x01, 0xF0, 0x01, 0xFF, 0x01, 0xC0, 0x60, 0xE0, 0x0C, 0x30, 0x01, 0x98,
  0x00, 0x66, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x34, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0x8C, 0x00, 0xE1, 0x80,
  0x70, 0x38, 0x78, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x20, 0x1E, 0x08, 0x01,
  0xC2, 0x00, 0x18, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x1A, 0x00, 0x06,
  0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0A, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x48, 0x00, 0x32, 0x00, 0x18,
  0x80, 0x0C, 0x20, 0x06, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0xFF, 0xF3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0xFF, 0xF3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xC0, 0x38, 0x1C, 0x0E, 0x00, 0xC1, 0x80, 0x0C, 0x60, 0x01, 0x88,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x3F, 0xF8, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x16, 0x00, 0x02, 0xC0,
  0x00, 0x48, 0x00, 0x09, 0x80, 0x01, 0x30, 0x00, 0x23, 0x00, 0x0C, 0x30,
  0x03, 0x83, 0x83, 0xC0, 0x1F, 0xE0, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x19, 0x80, 0x06, 0x30,
  0x03, 0x0E, 0x01, 0xC1, 0xE1, 0xE0, 0x1F, 0xE0, 0xC0, 0x01, 0xD8, 0x00,
  0x63, 0x00, 0x1C, 0x60, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x63, 0x80,
  0x0C, 0xE0, 0x01, 0x9E, 0x00, 0x36, 0x60, 0x07, 0x8C, 0x00, 0xE0, 0xC0,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x1C, 0x0C, 0x01, 0x81, 0x80, 0x18,
  0x30, 0x01, 0x86, 0x00, 0x38, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03,
  0x60, 0x00, 0x30, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x40, 0x0F, 0xD8, 0x02, 0xF6, 0x01,
  0xBC, 0x80, 0x6F, 0x30, 0x13, 0xCC, 0x0C, 0xF1, 0x02, 0x3C, 0x61, 0x8F,
  0x18, 0x63, 0xC3, 0x10, 0xF0, 0xCC, 0x3C, 0x12, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xD8,
  0x00, 0xF2, 0x00, 0x3C, 0xC0, 0x0F, 0x10, 0x03, 0xC6, 0x00, 0xF0, 0xC0,
  0x3C, 0x30, 0x0F, 0x06, 0x03, 0xC1, 0x80, 0xF0, 0x30, 0x3C, 0x04, 0x0F,
  0x01, 0x83, 0xC0, 0x20, 0xF0, 0x0C, 0x3C, 0x01, 0x8F, 0x00, 0x63, 0xC0,
  0x0C, 0xF0, 0x03, 0x3C, 0x00, 0x6F, 0x00, 0x0B, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0xC0, 0xE0,
  0xE0, 0x1C, 0x30, 0x03, 0x18, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x09, 0x80, 0x06, 0x60,
  0x01, 0x8C, 0x00, 0xC1, 0x80, 0x60, 0x38, 0x70, 0x07, 0xF8, 0x00, 0xFF,
  0xF8, 0x30, 0x03, 0x8C, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x06, 0xC0, 0x01, 0xB0, 0x01, 0xCC, 0x03, 0xE3, 0xFF, 0xE0, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x01, 0x80, 0x18,
  0x30, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00,
  0x24, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x62,
  0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x03, 0x80, 0x70, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x02, 0xFF, 0xF0, 0x30, 0x07, 0x0C, 0x00, 0x63, 0x00, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x03, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x0C, 0x30, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x03, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x70,
  0x1C, 0x18, 0x01, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0x90, 0x00, 0x32, 0x00,
  0x02, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x18, 0xE0, 0x0E, 0x0F, 0x07,
  0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xD0, 0x00, 0x26, 0x00, 0x19, 0x80, 0x06, 0x30, 0x03, 0x06, 0x01, 0x80,
  0xE1, 0xC0, 0x1F, 0xE0, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x08,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x04, 0x06, 0x00, 0x60, 0x60, 0x06, 0x04, 0x00, 0x20,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x18, 0x00, 0x19, 0x80, 0x01,
  0x98, 0x00, 0x09, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x60, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0,
  0x24, 0x05, 0x01, 0x20, 0x68, 0x09, 0x03, 0x60, 0xCC, 0x1B, 0x06, 0x60,
  0x98, 0x33, 0x04, 0x41, 0x18, 0x22, 0x08, 0x43, 0x10, 0x42, 0x18, 0xC6,
  0x10, 0x86, 0x30, 0xC4, 0x31, 0x86, 0x20, 0x8C, 0x33, 0x04, 0x41, 0x98,
  0x32, 0x04, 0xC1, 0x90, 0x24, 0x0D, 0x81, 0x20, 0x2C, 0x0F, 0x01, 0x60,
  0x78, 0x0F, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0xC1,
  0x80, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x20, 0x60,
  0x03, 0x06, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x0D, 0x80, 0x01, 0x98, 0x00, 0x18,
  0xC0, 0x03, 0x04, 0x00, 0x30, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x60, 0x00, 0x6E,
  0x00, 0x03, 0xC0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x00, 0x0C,
  0x30, 0x01, 0x81, 0x80, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x19,
  0x00, 0x01, 0xB0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xC0, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x78, 0x01, 0x20, 0x0C, 0xC0, 0x33, 0x01, 0x86, 0x06, 0x18, 0x10, 0x20,
  0xC0, 0xC2, 0x03, 0x18, 0x06, 0x60, 0x19, 0x00, 0x2C, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC3, 0x06, 0x0C, 0x00, 0x40, 0x01, 0xFF, 0x01,
  0xC0, 0xE0, 0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x66, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x3F, 0xF8, 0x7E, 0x06, 0x38, 0x01,
  0x98, 0x00, 0x66, 0x00, 0x19, 0x00, 0x06, 0xC0, 0x01, 0x90, 0x00, 0x66,
  0x00, 0x39, 0xC0, 0x3E, 0x38, 0x39, 0x83, 0xFC, 0x30, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x80, 0x67, 0xF8, 0x37, 0x07, 0x1E, 0x01, 0xCE, 0x00,
  0x66, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x05, 0x80, 0x02,
  0xC0, 0x03, 0x60, 0x01, 0xB8, 0x01, 0x9E, 0x01, 0x8D, 0xC3, 0xC6, 0x3F,
  0x80, 0x00, 0x40, 0x03, 0xFE, 0x03, 0x83, 0x83, 0x00, 0x63, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x90, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x60, 0xE0, 0xE0, 0x3F, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x81, 0x83, 0xF8, 0xC7, 0x07, 0x67,
  0x00, 0xF3, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x00,
  0x06, 0x80, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0xE3, 0x00, 0xF0,
  0xE1, 0xD8, 0x3F, 0x8C, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xE0, 0xE0, 0x60,
  0x0C, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x09, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x08, 0x70,
  0x06, 0x0E, 0x07, 0x00, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xF0, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x80, 0x03, 0xF8, 0xC7, 0x07, 0x63, 0x00,
  0xF3, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0x40, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x00, 0x06,
  0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0xE3, 0x00, 0xF0, 0xE1,
  0xD8, 0x3F, 0x8C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x88,
  0x00, 0xC6, 0x00, 0xC1, 0xC1, 0xC0, 0x3F, 0xC0, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0xC0, 0xC7, 0xF8, 0xCE, 0x0C, 0xD8, 0x06, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x20,
  0x07, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x38, 0xFF, 0x03, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x06, 0x80, 0x1C, 0x80, 0x38, 0x80, 0x70, 0x80, 0xE0, 0x81,
  0x80, 0x83, 0x00, 0x86, 0x00, 0x8C, 0x00, 0x9C, 0x00, 0xB6, 0x00, 0xE3,
  0x00, 0xC1, 0x80, 0x80, 0xC0, 0x80, 0x60, 0x80, 0x70, 0x80, 0x30, 0x80,
  0x18, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x02,
  0x01, 0x09, 0xF8, 0xFE, 0xB0, 0xD8, 0x6C, 0x07, 0x03, 0xC0, 0x60, 0x3C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0xC7, 0xF8, 0xCC, 0x0C,
  0xD8, 0x06, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x00, 0x80, 0x01, 0xFE, 0x01, 0xC0, 0xE0, 0xE0, 0x1C, 0x30,
  0x03, 0x18, 0x00, 0x64, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x40, 0x00, 0x98, 0x00, 0x63, 0x00, 0x30, 0xE0, 0x1C, 0x1E,
  0x1E, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x67, 0xF8, 0x37, 0x07, 0x1E, 0x01,
  0x8E, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x01, 0x60,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x05,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB8, 0x01, 0x9E, 0x01, 0x8D, 0xC3,
  0x86, 0x3F, 0x83, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x03, 0xFC,
  0xC7, 0x07, 0x67, 0x00, 0xF3, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x06, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0D, 0x00, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xCC, 0x00,
  0xE3, 0x00, 0xF0, 0xE1, 0xD8, 0x3F, 0x8C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x13, 0x0F, 0xFC, 0xF0, 0x37, 0x00, 0xD0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x0E, 0x07, 0x8C, 0x00, 0xE6,
  0x00, 0x32, 0x00, 0x0D, 0x00, 0x06, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xCC, 0x00, 0xE3, 0xC1, 0xE0,
  0x7F, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x07, 0x70, 0x0F, 0x3C, 0x3B,
  0x1F, 0xE3, 0xC0, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C,
  0x30, 0x00, 0xC1, 0x00, 0x08, 0x18, 0x01, 0x81, 0x80, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x04, 0x06, 0x00, 0x60, 0x60, 0x02, 0x04, 0x00, 0x30,
  0xC0, 0x03, 0x08, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x0B, 0x00, 0x00,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x0D, 0x00, 0xC0,
  0x36, 0x03, 0x00, 0x98, 0x0E, 0x02, 0x60, 0x68, 0x18, 0x81, 0xA0, 0x62,
  0x04, 0x81, 0x0C, 0x13, 0x04, 0x30, 0xCC, 0x30, 0x43, 0x10, 0xC1, 0x08,
  0x43, 0x06, 0x21, 0x88, 0x19, 0x82, 0x20, 0x64, 0x09, 0x80, 0x90, 0x26,
  0x02, 0x40, 0xD0, 0x0F, 0x01, 0x40, 0x38, 0x05, 0x00, 0x60, 0x1C, 0x01,
  0x80, 0x70, 0x06, 0x00, 0x80, 0xE0, 0x00, 0xCE, 0x00, 0x30, 0xC0, 0x0C,
  0x0C, 0x03, 0x80, 0xC0, 0x60, 0x0C, 0x18, 0x01, 0x86, 0x00, 0x19, 0x80,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3B, 0x00,
  0x06, 0x30, 0x01, 0x83, 0x00, 0x60, 0x60, 0x18, 0x06, 0x07, 0x00, 0x60,
  0xC0, 0x06, 0x30, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x01,
  0x81, 0x80, 0x18, 0x0C, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x03, 0x00, 0x60,
  0x60, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x80, 0x01,
  0x98, 0x00, 0x0D, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x01, 0x80, 0x70, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0xF0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x0C, 0xE7, 0x00,
  0x36, 0x07, 0x00, 0x90, 0x0E, 0x06, 0xC0, 0x1C, 0x33, 0x00, 0x1F, 0x80,
  0x00, 0x18, 0x00,
};

const GFXglyph RobotoMono_ExtraLight40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 3, 28, 24, 10, -28 },
  { 12, 7, 8, 24, 8, -30 },
  { 19, 22, 28, 24, 1, -28 },
  { 96, 17, 37, 24, 4, -33 },
  { 175, 22, 29, 24, 1, -29 },
  { 255, 20, 29, 24, 3, -29 },
  { 328, 2, 8, 24, 10, -30 },
  { 330, 9, 41, 24, 8, -32 },
  { 377, 9, 41, 24, 7, -32 },
  { 424, 17, 16, 24, 4, -28 },
  { 458, 20, 21, 24, 2, -24 },
  { 511, 3, 8, 24, 8, -3 },
  { 514, 14, 2, 24, 5, -14 },
  { 518, 3, 3, 24, 11, -3 },
  { 520, 13, 30, 24, 6, -28 },
  { 569, 18, 29, 24, 3, -29 },
  { 635, 10, 28, 24, 4, -28 },
  { 670, 18, 29, 24, 2, -29 },
  { 736, 18, 29, 24, 2, -29 },
  { 802, 20, 28, 24, 2, -28 },
  { 872, 17, 28, 24, 4, -28 },
  { 932, 17, 29, 24, 3, -29 },
  { 994, 18, 28, 24, 3, -28 },
  { 1057, 19, 29, 24, 3, -29 },
  { 1126, 18, 29, 24, 3, -29 },
  { 1192, 3, 20, 24, 12, -20 },
  { 1200, 4, 25, 24, 11, -20 },
  { 1213, 17, 16, 24, 3, -21 },
  { 1247, 18, 10, 24, 3, -18 },
  { 1270, 17, 16, 24, 4, -21 },
  { 1304, 15, 29, 24, 5, -29 },
  { 1359, 22, 29, 24, 1, -29 },
  { 1439, 20, 28, 24, 2, -28 },
  { 1509, 18, 28, 24, 4, -28 },
  { 1572, 18, 29, 24, 3, -29 },
  { 1638, 18, 28, 24, 4, -28 },
  { 1701, 17, 28, 24, 4, -28 },
  { 1761, 17, 28, 24, 4, -28 },
  { 1821, 19, 29, 24, 2, -29 },
  { 1890, 18, 28, 24, 3, -28 },
  { 1953, 16, 28, 24, 4, -28 },
  { 2009, 18, 28, 24, 2, -28 },
  { 2072, 19, 28, 24, 4, -28 },
  { 2139, 16, 28, 24, 5, -28 },
  { 2195, 18, 28, 24, 3, -28 },
  { 2258, 18, 28, 24, 3, -28 },
  { 2321, 18, 29, 24, 3, -29 },
  { 2387, 18, 28, 24, 4, -28 },
  { 2450, 20, 34, 24, 2, -29 },
  { 2535, 18, 28, 24, 4, -28 },
  { 2598, 19, 29, 24, 3, -29 },
  { 2667, 20, 28, 24, 2, -28 },
  { 2737, 18, 28, 24, 3, -28 },
  { 2800, 20, 28, 24, 2, -28 },
  { 2870, 21, 28, 24, 2, -28 },
  { 2944, 20, 28, 24, 2, -28 },
  { 3014, 20, 28, 24, 2, -28 },
  { 3084, 18, 28, 24, 3, -28 },
  { 3147, 6, 39, 24, 9, -33 },
  { 3177, 14, 30, 24, 5, -28 },
  { 3230, 6, 39, 24, 9, -33 },
  { 3260, 14, 15, 24, 5, -28 },
  { 3287, 16, 2, 24, 4, 0 },
  { 3291, 6, 5, 24, 9, -29 },
  { 3295, 18, 22, 24, 3, -22 },
  { 3345, 17, 30, 24, 4, -30 },
  { 3409, 17, 22, 24, 3, -22 },
  { 3456, 17, 30, 24, 3, -30 },
  { 3520, 18, 22, 24, 3, -22 },
  { 3570, 18, 31, 24, 4, -31 },
  { 3640, 17, 30, 24, 3, -22 },
  { 3704, 16, 30, 24, 4, -30 },
  { 3764, 17, 29, 24, 4, -29 },
  { 3826, 12, 38, 24, 4, -29 },
  { 3883, 16, 30, 24, 5, -30 },
  { 3943, 17, 30, 24, 4, -30 },
  { 4007, 20, 22, 24, 2, -22 },
  { 4062, 16, 22, 24, 4, -22 },
  { 4106, 18, 22, 24, 3, -22 },
  { 4156, 17, 30, 24, 4, -22 },
  { 4220, 17, 30, 24, 3, -22 },
  { 4284, 14, 22, 24, 7, -22 },
  { 4323, 17, 22, 24, 4, -22 },
  { 4370, 16, 27, 24, 4, -27 },
  { 4424, 16, 21, 24, 4, -21 },
  { 4466, 20, 21, 24, 2, -21 },
  { 4519, 22, 21, 24, 1, -21 },
  { 4577, 19, 21, 24, 3, -21 },
  { 4627, 20, 30, 24, 2, -21 },
  { 4702, 19, 21, 24, 3, -21 },
  { 4752, 12, 39, 24, 7, -31 },
  { 4811, 2, 34, 24, 11, -28 },
  { 4820, 12, 39, 24, 7, -31 },
  { 4879, 22, 7, 24, 1, -15 },
};

const GFXfont RobotoMono_ExtraLight40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight40pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_EXTRALIGHT40PT7B_H_
