#ifndef _ROBOTOMONO_EXTRALIGHT18PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x88, 0xB6, 0xD0, 0x11, 0x08, 0x84, 0x42, 0x4F, 0xF9, 0x10,
  0x88, 0x44, 0x22, 0x7E, 0xD1, 0x08, 0x84, 0x40, 0x10, 0x20, 0xF2, 0x18,
  0x30, 0x60, 0x20, 0x38, 0x08, 0x0C, 0x18, 0x30, 0x5F, 0x08, 0x10, 0x70,
  0x22, 0x08, 0x92, 0x24, 0x8A, 0x1D, 0x00, 0x40, 0x26, 0x0A, 0x44, 0x91,
  0x24, 0x89, 0x01, 0xC0, 0x1C, 0x12, 0x10, 0x88, 0x82, 0x41, 0xC0, 0xC0,
  0x91, 0x44, 0xC1, 0x60, 0xC8, 0x63, 0xC8, 0xF0, 0x12, 0x24, 0x44, 0x48,
  0x88, 0x84, 0x44, 0x42, 0x21, 0x84, 0x22, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x22, 0x48, 0x10, 0x10, 0x11, 0xFE, 0x10, 0x28, 0x44, 0x46, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x00, 0xF0, 0xFE,
  0x80, 0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x82, 0x00,
  0x3C, 0x42, 0x41, 0x41, 0x83, 0x85, 0x89, 0x91, 0xA1, 0x41, 0x41, 0x41,
  0x3E, 0x17, 0x91, 0x11, 0x11, 0x11, 0x11, 0x10, 0x3C, 0x42, 0x82, 0x81,
  0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x3C, 0x42, 0x81,
  0x81, 0x01, 0x02, 0x1C, 0x02, 0x01, 0x81, 0x81, 0x82, 0x7C, 0x02, 0x03,
  0x02, 0x82, 0x41, 0x21, 0x11, 0x08, 0x84, 0x82, 0x7F, 0xC0, 0x80, 0x40,
  0x20, 0x7E, 0x40, 0x40, 0x40, 0x80, 0xFC, 0x82, 0x02, 0x01, 0x01, 0x82,
  0x42, 0x3C, 0x0E, 0x30, 0x20, 0x40, 0x48, 0xB6, 0xC1, 0x81, 0x81, 0x81,
  0x41, 0x41, 0x3E, 0xFF, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x3C, 0xC2, 0x82, 0x82, 0x82, 0x42, 0x3C, 0xC2,
  0x81, 0x81, 0x81, 0x82, 0x7C, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x41,
  0x43, 0x3D, 0x01, 0x02, 0x06, 0x38, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x68,
  0x03, 0x1C, 0x60, 0xC0, 0x38, 0x06, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0xC0,
  0x60, 0x30, 0x31, 0x8C, 0x20, 0x00, 0x38, 0x8A, 0x08, 0x10, 0x20, 0x82,
  0x08, 0x10, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x3D, 0x51,
  0x64, 0x59, 0x26, 0x49, 0x92, 0x55, 0x54, 0x88, 0x80, 0x1F, 0x00, 0x08,
  0x04, 0x05, 0x02, 0x81, 0x41, 0x10, 0x88, 0x44, 0x7F, 0x20, 0x90, 0x50,
  0x18, 0x08, 0xF8, 0x84, 0x82, 0x82, 0x82, 0x84, 0xFC, 0x82, 0x81, 0x81,
  0x81, 0x82, 0xFC, 0x1E, 0x30, 0x90, 0x50, 0x18, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x50, 0x48, 0x23, 0xE0, 0xF8, 0x84, 0x82, 0x82, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x84, 0xF8, 0xFF, 0x02, 0x04, 0x08, 0x10,
  0x3F, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xFF, 0x02, 0x04, 0x08, 0x10,
  0x3F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x00, 0x3E, 0x20, 0x90, 0x50, 0x18,
  0x04, 0x02, 0x01, 0x0F, 0x80, 0xC0, 0x50, 0x28, 0x13, 0xF0, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFE,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x81, 0x42, 0x3C,
  0x81, 0x82, 0x84, 0x88, 0x90, 0xA0, 0xE0, 0x90, 0x88, 0x84, 0x84, 0x82,
  0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F,
  0xE0, 0x83, 0x06, 0x1E, 0x3C, 0x75, 0x6A, 0xD9, 0x93, 0x06, 0x0C, 0x18,
  0x20, 0x81, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x83, 0x83,
  0x81, 0x81, 0x3C, 0x21, 0x10, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x90, 0x48, 0x23, 0xE0, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82,
  0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3C, 0x21, 0x90, 0x50, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x48, 0x23, 0xE0, 0x10, 0x06, 0xF8,
  0x86, 0x82, 0x81, 0x82, 0x82, 0x84, 0xF8, 0x84, 0x84, 0x82, 0x82, 0x81,
  0x3E, 0x20, 0x90, 0x48, 0x14, 0x01, 0x00, 0x70, 0x06, 0x01, 0x40, 0x60,
  0x28, 0x23, 0xE0, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3E, 0x80, 0xC0, 0x60, 0x48, 0x24,
  0x12, 0x10, 0x88, 0x44, 0x24, 0x0A, 0x05, 0x01, 0x00, 0x80, 0x88, 0xC4,
  0x62, 0x32, 0x99, 0x4C, 0xA5, 0x52, 0xAA, 0x63, 0x31, 0x98, 0xCC, 0x62,
  0x10, 0x80, 0xA0, 0x88, 0x44, 0x41, 0x40, 0xA0, 0x20, 0x28, 0x14, 0x11,
  0x08, 0x48, 0x28, 0x08, 0x80, 0xC0, 0x90, 0x48, 0x42, 0x21, 0x20, 0x50,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xFF, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0xFF, 0xF2, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x9C, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81,
  0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x3C, 0x10, 0x60, 0xA1,
  0x44, 0x48, 0xA1, 0x80, 0xFE, 0xCC, 0x39, 0x8A, 0x08, 0x11, 0xEC, 0x60,
  0xC1, 0x86, 0xF4, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x3F, 0x80, 0x1C, 0x22, 0x41, 0x41, 0x80, 0x80, 0x80, 0x41,
  0x41, 0x3E, 0x01, 0x01, 0x01, 0x01, 0x1D, 0x23, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x41, 0x41, 0x3F, 0x1C, 0x22, 0x41, 0x41, 0xFF, 0x80, 0x80, 0x40,
  0x41, 0x3E, 0x0F, 0x10, 0x20, 0x20, 0xFE, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x1D, 0x23, 0x41, 0x41, 0x81, 0x81, 0x81, 0x41,
  0x41, 0x3F, 0x01, 0x01, 0x42, 0x3C, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x18, 0x10, 0x00, 0xF0, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x08, 0x40, 0xF0, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x22, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x82,
  0x84, 0x88, 0x90, 0xA0, 0xD0, 0x88, 0x88, 0x84, 0x83, 0xF0, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0xF3,
  0x46, 0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4, 0x40, 0xB9,
  0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x1C, 0x11, 0x10, 0x50,
  0x28, 0x0C, 0x06, 0x03, 0x02, 0x41, 0x1F, 0x00, 0xB9, 0x8A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0xFA, 0x04, 0x08, 0x10, 0x00, 0x1D, 0x23, 0x41,
  0x41, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3F, 0x01, 0x01, 0x01, 0x01, 0x9E,
  0x8C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x38, 0x8E, 0x0C, 0x06, 0x03,
  0x80, 0xC1, 0x82, 0xF8, 0x20, 0x43, 0xF9, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x80, 0xF0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0xF4,
  0x80, 0xC0, 0x90, 0x48, 0x22, 0x21, 0x10, 0x90, 0x28, 0x18, 0x04, 0x00,
  0x88, 0xC4, 0x66, 0x32, 0x99, 0x4A, 0xA9, 0x94, 0xC6, 0x63, 0x11, 0x00,
  0x80, 0xA0, 0x88, 0x82, 0x80, 0x80, 0x40, 0x50, 0x44, 0x41, 0x60, 0xC0,
  0x80, 0xC0, 0x50, 0x48, 0x24, 0x21, 0x10, 0x90, 0x28, 0x14, 0x04, 0x02,
  0x02, 0x01, 0x07, 0x00, 0x7F, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x40, 0x7F, 0xC0, 0x0C, 0x41, 0x08, 0x20, 0x82, 0x08, 0xC1, 0x02,
  0x08, 0x20, 0x82, 0x04, 0x18, 0x10, 0xFF, 0xFF, 0xC0, 0x82, 0x08, 0x20,
  0x82, 0x04, 0x0C, 0x41, 0x08, 0x20, 0x82, 0x08, 0x42, 0x00, 0x70, 0xC4,
  0x61, 0xC0,
};

const GFXglyph RobotoMono_ExtraLight18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 1, 13, 11, 5, -13 },
  { 3, 3, 4, 11, 4, -14 },
  { 5, 9, 13, 11, 1, -13 },
  { 20, 7, 17, 11, 2, -15 },
  { 35, 10, 13, 11, 0, -13 },
  { 52, 9, 13, 11, 1, -13 },
  { 67, 1, 4, 11, 5, -14 },
  { 68, 4, 18, 11, 3, -14 },
  { 77, 4, 18, 11, 3, -14 },
  { 86, 8, 8, 11, 2, -13 },
  { 94, 9, 10, 11, 1, -11 },
  { 106, 1, 4, 11, 4, -2 },
  { 107, 7, 1, 11, 2, -6 },
  { 108, 1, 1, 11, 5, -1 },
  { 109, 6, 14, 11, 3, -13 },
  { 120, 8, 13, 11, 1, -13 },
  { 133, 4, 13, 11, 2, -13 },
  { 140, 8, 13, 11, 1, -13 },
  { 153, 8, 13, 11, 1, -13 },
  { 166, 9, 13, 11, 1, -13 },
  { 181, 8, 13, 11, 2, -13 },
  { 194, 8, 13, 11, 1, -13 },
  { 207, 8, 13, 11, 1, -13 },
  { 220, 8, 13, 11, 2, -13 },
  { 233, 8, 13, 11, 1, -13 },
  { 246, 2, 9, 11, 5, -9 },
  { 249, 2, 11, 11, 5, -9 },
  { 252, 8, 7, 11, 1, -9 },
  { 259, 7, 4, 11, 2, -8 },
  { 263, 7, 7, 11, 2, -9 },
  { 270, 7, 13, 11, 2, -13 },
  { 282, 10, 13, 11, 0, -13 },
  { 299, 9, 13, 11, 1, -13 },
  { 314, 8, 13, 11, 2, -13 },
  { 327, 9, 13, 11, 1, -13 },
  { 342, 8, 13, 11, 2, -13 },
  { 355, 7, 13, 11, 2, -13 },
  { 367, 7, 13, 11, 2, -13 },
  { 379, 9, 13, 11, 1, -13 },
  { 394, 8, 13, 11, 1, -13 },
  { 407, 7, 13, 11, 2, -13 },
  { 419, 8, 13, 11, 1, -13 },
  { 432, 8, 13, 11, 2, -13 },
  { 445, 7, 13, 11, 2, -13 },
  { 457, 7, 13, 11, 2, -13 },
  { 469, 8, 13, 11, 1, -13 },
  { 482, 9, 13, 11, 1, -13 },
  { 497, 8, 13, 11, 2, -13 },
  { 510, 9, 15, 11, 1, -13 },
  { 527, 8, 13, 11, 2, -13 },
  { 540, 9, 13, 11, 1, -13 },
  { 555, 9, 13, 11, 1, -13 },
  { 570, 8, 13, 11, 1, -13 },
  { 583, 9, 13, 11, 1, -13 },
  { 598, 9, 13, 11, 1, -13 },
  { 613, 9, 13, 11, 1, -13 },
  { 628, 9, 13, 11, 1, -13 },
  { 643, 8, 13, 11, 1, -13 },
  { 656, 3, 18, 11, 4, -15 },
  { 663, 6, 14, 11, 2, -13 },
  { 674, 3, 18, 11, 4, -15 },
  { 681, 7, 7, 11, 2, -13 },
  { 688, 7, 1, 11, 2, 0 },
  { 689, 3, 2, 11, 4, -13 },
  { 690, 7, 10, 11, 2, -10 },
  { 699, 7, 14, 11, 2, -14 },
  { 712, 8, 10, 11, 1, -10 },
  { 722, 8, 14, 11, 1, -14 },
  { 736, 8, 10, 11, 1, -10 },
  { 746, 8, 14, 11, 2, -14 },
  { 760, 8, 14, 11, 1, -10 },
  { 774, 7, 14, 11, 2, -14 },
  { 787, 8, 13, 11, 2, -13 },
  { 800, 5, 17, 11, 2, -13 },
  { 811, 8, 14, 11, 2, -14 },
  { 825, 8, 14, 11, 2, -14 },
  { 839, 9, 10, 11, 1, -10 },
  { 851, 7, 10, 11, 2, -10 },
  { 860, 9, 10, 11, 1, -10 },
  { 872, 7, 14, 11, 2, -10 },
  { 885, 8, 14, 11, 1, -10 },
  { 899, 6, 10, 11, 3, -10 },
  { 907, 7, 10, 11, 2, -10 },
  { 916, 7, 12, 11, 2, -12 },
  { 927, 7, 10, 11, 2, -10 },
  { 936, 9, 10, 11, 1, -10 },
  { 948, 9, 10, 11, 1, -10 },
  { 960, 9, 10, 11, 1, -10 },
  { 972, 9, 14, 11, 1, -10 },
  { 988, 9, 10, 11, 1, -10 },
  { 1000, 6, 18, 11, 3, -14 },
  { 1014, 1, 16, 11, 5, -13 },
  { 1016, 6, 18, 11, 3, -14 },
  { 1030, 9, 3, 11, 1, -7 },
};

const GFXfont RobotoMono_ExtraLight18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight18pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_EXTRALIGHT18PT7B_H_
