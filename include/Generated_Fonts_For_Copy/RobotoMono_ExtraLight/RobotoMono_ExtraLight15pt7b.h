#ifndef _ROBOTOMONO_EXTRALIGHT15PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0x80, 0x09, 0x09, 0x04, 0x8F, 0xF1, 0x20, 0x90,
  0x91, 0xFE, 0x24, 0x12, 0x09, 0x00, 0x10, 0x71, 0x12, 0x14, 0x08, 0x0E,
  0x02, 0x03, 0x05, 0x09, 0x61, 0x02, 0x00, 0x60, 0x49, 0x24, 0x92, 0x86,
  0x40, 0x40, 0x2C, 0x29, 0x24, 0x92, 0x41, 0xC0, 0x30, 0x48, 0x48, 0x48,
  0x30, 0x20, 0x52, 0x8A, 0x86, 0x84, 0x7B, 0xE0, 0x29, 0x49, 0x24, 0x92,
  0x44, 0x88, 0x91, 0x22, 0x49, 0x24, 0x94, 0xA0, 0x10, 0x23, 0x49, 0xE1,
  0x8C, 0x80, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0xE0, 0xF8, 0x80,
  0x08, 0x42, 0x21, 0x10, 0x84, 0x42, 0x21, 0x00, 0x38, 0x8A, 0x0C, 0x38,
  0xB2, 0x68, 0xE1, 0x82, 0x88, 0xE0, 0x3E, 0x92, 0x49, 0x24, 0x80, 0x79,
  0x0A, 0x10, 0x20, 0x41, 0x04, 0x10, 0x20, 0x83, 0xF8, 0x7A, 0x18, 0x41,
  0x04, 0xE0, 0x41, 0x86, 0x17, 0x80, 0x08, 0x10, 0x51, 0x22, 0x48, 0xA1,
  0x7F, 0x04, 0x08, 0x10, 0xFE, 0x08, 0x20, 0xF2, 0x20, 0x41, 0x86, 0x17,
  0x80, 0x18, 0x41, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x82, 0x88, 0xE0, 0xFE,
  0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x80, 0x38, 0x8A, 0x0C,
  0x14, 0x47, 0x11, 0xC1, 0x83, 0x05, 0xF0, 0x38, 0x8A, 0x0C, 0x18, 0x30,
  0x53, 0x99, 0x04, 0x08, 0xE0, 0x82, 0x40, 0x06, 0x80, 0x06, 0x31, 0x86,
  0x03, 0x80, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0xC0, 0x60, 0x30, 0x33, 0x98,
  0x00, 0x74, 0x62, 0x10, 0x88, 0x84, 0x00, 0x08, 0x1E, 0x10, 0x93, 0x4A,
  0x59, 0x4D, 0x26, 0x93, 0x4A, 0x9B, 0x20, 0x0F, 0x80, 0x10, 0x20, 0xA1,
  0x42, 0x88, 0x91, 0x3E, 0x83, 0x06, 0x08, 0xF2, 0x28, 0x61, 0x8B, 0xE8,
  0x61, 0x86, 0x1F, 0x80, 0x38, 0x8A, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x82,
  0x84, 0xF0, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0B, 0xE0,
  0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20,
  0x83, 0xE8, 0x20, 0x82, 0x08, 0x00, 0x38, 0x8A, 0x0C, 0x08, 0x10, 0x23,
  0xC1, 0x82, 0x84, 0xF0, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83,
  0x06, 0x08, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x86, 0x17, 0x80, 0x85, 0x12, 0x44,
  0x8A, 0x18, 0x28, 0x48, 0x89, 0x0A, 0x18, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0F, 0xC0, 0x83, 0x87, 0x1D, 0x3A, 0xB5, 0x64, 0xC9, 0x83,
  0x06, 0x08, 0x83, 0x87, 0x0D, 0x1A, 0x32, 0x64, 0xC5, 0x87, 0x0E, 0x08,
  0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x88, 0xE0, 0xF2, 0x38,
  0x61, 0x86, 0x3F, 0x20, 0x82, 0x08, 0x00, 0x38, 0x8A, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x82, 0x84, 0xF0, 0x20, 0x20, 0xF2, 0x28, 0x61, 0x86, 0x2F,
  0x24, 0x8A, 0x18, 0x40, 0x38, 0x8A, 0x0C, 0x04, 0x07, 0x01, 0x01, 0x83,
  0x05, 0xF0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x88, 0xE0, 0x83, 0x06,
  0x0A, 0x24, 0x48, 0x8A, 0x14, 0x28, 0x60, 0x40, 0x91, 0x91, 0x92, 0x9A,
  0xAA, 0xAA, 0xAA, 0x66, 0x44, 0x44, 0x44, 0x82, 0x85, 0x11, 0x42, 0x82,
  0x06, 0x14, 0x44, 0x86, 0x08, 0x83, 0x05, 0x12, 0x22, 0x85, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xFE, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x41, 0x03,
  0xF8, 0xF2, 0x49, 0x24, 0x92, 0x49, 0xC0, 0x84, 0x10, 0x84, 0x10, 0x82,
  0x10, 0x82, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x93, 0xC0, 0x21, 0x14, 0xA8,
  0xC4, 0xFE, 0xCC, 0x3C, 0x8A, 0x09, 0xF4, 0x30, 0x61, 0xBD, 0x82, 0x08,
  0x3C, 0x8A, 0x18, 0x61, 0x86, 0x2F, 0x00, 0x38, 0x8A, 0x0C, 0x08, 0x10,
  0x10, 0x9E, 0x04, 0x10, 0x4F, 0x46, 0x18, 0x61, 0x85, 0x13, 0xC0, 0x38,
  0x8A, 0x0F, 0xF8, 0x10, 0x10, 0x9E, 0x1E, 0x20, 0x87, 0xE2, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x3D, 0x18, 0x61, 0x86, 0x14, 0x4F, 0x05, 0x17,
  0x80, 0x81, 0x02, 0x05, 0xEC, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x20,
  0x00, 0x38, 0x20, 0x82, 0x08, 0x20, 0x8F, 0xC0, 0x08, 0x00, 0xF0, 0x84,
  0x21, 0x08, 0x42, 0x10, 0xF8, 0x82, 0x08, 0x23, 0x92, 0x8C, 0x28, 0x92,
  0x28, 0x40, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8F, 0xC0, 0xEF,
  0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xBE, 0xF2, 0x28, 0x61, 0x86,
  0x18, 0xBC, 0x82, 0x08, 0x00, 0x3D, 0x18, 0x61, 0x86, 0x14, 0x4F, 0x04,
  0x10, 0x40, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x3C, 0x85, 0x01, 0x80, 0xC0,
  0x60, 0xBE, 0x20, 0x43, 0xF1, 0x02, 0x04, 0x08, 0x10, 0x20, 0x3C, 0x86,
  0x18, 0x61, 0x86, 0x18, 0xFD, 0x83, 0x05, 0x12, 0x22, 0x85, 0x0A, 0x08,
  0x91, 0x92, 0xAA, 0xAA, 0xAA, 0x4A, 0x44, 0x44, 0x82, 0x88, 0xA0, 0x81,
  0x05, 0x11, 0x41, 0x83, 0x05, 0x12, 0x22, 0x45, 0x0A, 0x08, 0x10, 0x43,
  0x00, 0xFE, 0x08, 0x20, 0x82, 0x04, 0x10, 0x7F, 0x08, 0x88, 0x42, 0x10,
  0x98, 0x21, 0x08, 0x42, 0x08, 0x20, 0xFF, 0xF8, 0xC1, 0x08, 0x42, 0x10,
  0x41, 0x11, 0x08, 0x42, 0x13, 0x00, 0x30, 0xA4, 0x61, 0xC0,
};

const GFXglyph RobotoMono_ExtraLight15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 1, 11, 9, 4, -11 },
  { 3, 3, 3, 9, 3, -11 },
  { 5, 9, 11, 9, 0, -11 },
  { 18, 7, 14, 9, 1, -12 },
  { 31, 9, 11, 9, 0, -11 },
  { 44, 8, 11, 9, 1, -11 },
  { 55, 1, 3, 9, 4, -11 },
  { 56, 3, 15, 9, 3, -12 },
  { 62, 3, 15, 9, 3, -12 },
  { 68, 7, 6, 9, 1, -11 },
  { 74, 7, 8, 9, 1, -9 },
  { 81, 1, 3, 9, 3, -1 },
  { 82, 5, 1, 9, 2, -5 },
  { 83, 1, 1, 9, 4, -1 },
  { 84, 5, 12, 9, 2, -11 },
  { 92, 7, 11, 9, 1, -11 },
  { 102, 3, 11, 9, 2, -11 },
  { 107, 7, 11, 9, 1, -11 },
  { 117, 6, 11, 9, 1, -11 },
  { 126, 7, 11, 9, 1, -11 },
  { 136, 6, 11, 9, 2, -11 },
  { 145, 7, 11, 9, 1, -11 },
  { 155, 7, 11, 9, 1, -11 },
  { 165, 7, 11, 9, 1, -11 },
  { 175, 7, 11, 9, 1, -11 },
  { 185, 1, 7, 9, 5, -7 },
  { 186, 2, 9, 9, 4, -7 },
  { 189, 7, 6, 9, 1, -8 },
  { 195, 7, 4, 9, 1, -7 },
  { 199, 7, 6, 9, 1, -8 },
  { 205, 5, 11, 9, 2, -11 },
  { 212, 9, 11, 9, 0, -11 },
  { 225, 7, 11, 9, 1, -11 },
  { 235, 6, 11, 9, 2, -11 },
  { 244, 7, 11, 9, 1, -11 },
  { 254, 7, 11, 9, 1, -11 },
  { 264, 6, 11, 9, 2, -11 },
  { 273, 6, 11, 9, 2, -11 },
  { 282, 7, 11, 9, 1, -11 },
  { 292, 7, 11, 9, 1, -11 },
  { 302, 7, 11, 9, 1, -11 },
  { 312, 6, 11, 9, 1, -11 },
  { 321, 7, 11, 9, 2, -11 },
  { 331, 6, 11, 9, 2, -11 },
  { 340, 7, 11, 9, 1, -11 },
  { 350, 7, 11, 9, 1, -11 },
  { 360, 7, 11, 9, 1, -11 },
  { 370, 6, 11, 9, 2, -11 },
  { 379, 7, 13, 9, 1, -11 },
  { 391, 6, 11, 9, 2, -11 },
  { 400, 7, 11, 9, 1, -11 },
  { 410, 7, 11, 9, 1, -11 },
  { 420, 7, 11, 9, 1, -11 },
  { 430, 7, 11, 9, 1, -11 },
  { 440, 8, 11, 9, 1, -11 },
  { 451, 7, 11, 9, 1, -11 },
  { 461, 7, 11, 9, 1, -11 },
  { 471, 7, 11, 9, 1, -11 },
  { 481, 3, 14, 9, 3, -12 },
  { 487, 5, 12, 9, 2, -11 },
  { 495, 3, 14, 9, 3, -12 },
  { 501, 5, 6, 9, 2, -11 },
  { 505, 7, 1, 9, 1, 0 },
  { 506, 3, 2, 9, 3, -11 },
  { 507, 7, 8, 9, 1, -8 },
  { 514, 6, 11, 9, 2, -11 },
  { 523, 7, 8, 9, 1, -8 },
  { 530, 6, 11, 9, 1, -11 },
  { 539, 7, 8, 9, 1, -8 },
  { 546, 7, 11, 9, 1, -11 },
  { 556, 6, 11, 9, 1, -8 },
  { 565, 7, 11, 9, 1, -11 },
  { 575, 6, 11, 9, 2, -11 },
  { 584, 5, 14, 9, 1, -11 },
  { 593, 6, 11, 9, 2, -11 },
  { 602, 6, 11, 9, 2, -11 },
  { 611, 7, 8, 9, 1, -8 },
  { 618, 7, 8, 9, 1, -8 },
  { 625, 7, 8, 9, 1, -8 },
  { 632, 6, 11, 9, 2, -8 },
  { 641, 6, 11, 9, 1, -8 },
  { 650, 5, 8, 9, 3, -8 },
  { 655, 7, 8, 9, 1, -8 },
  { 662, 7, 10, 9, 1, -10 },
  { 671, 6, 8, 9, 2, -8 },
  { 677, 7, 8, 9, 1, -8 },
  { 684, 8, 8, 9, 1, -8 },
  { 692, 7, 8, 9, 1, -8 },
  { 699, 7, 11, 9, 1, -8 },
  { 709, 7, 8, 9, 1, -8 },
  { 716, 5, 15, 9, 2, -12 },
  { 726, 1, 13, 9, 4, -11 },
  { 728, 5, 15, 9, 2, -12 },
  { 738, 9, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_ExtraLight15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight15pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_EXTRALIGHT15PT7B_H_
