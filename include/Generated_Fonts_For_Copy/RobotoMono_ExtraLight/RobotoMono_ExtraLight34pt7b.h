#ifndef _ROBOTOMONO_EXTRALIGHT34PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC7, 0x1C, 0x61, 0x86, 0x18,
  0x61, 0x01, 0x83, 0x00, 0x30, 0x60, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10,
  0x20, 0x02, 0x0C, 0x00, 0xC1, 0x83, 0xFF, 0xFF, 0x02, 0x04, 0x00, 0x40,
  0x80, 0x08, 0x10, 0x03, 0x06, 0x00, 0x60, 0x80, 0x08, 0x10, 0x01, 0x02,
  0x00, 0x20, 0x40, 0xFF, 0xFF, 0x81, 0x83, 0x00, 0x20, 0x40, 0x04, 0x08,
  0x00, 0x81, 0x00, 0x10, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0xFF, 0x03, 0x07, 0x0C, 0x03, 0x30,
  0x06, 0x40, 0x04, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60, 0x04, 0xC0, 0x18, 0xE0,
  0xE0, 0x7F, 0x80, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0F,
  0x80, 0x03, 0x08, 0x00, 0x41, 0x82, 0x08, 0x10, 0x61, 0x02, 0x08, 0x20,
  0x42, 0x04, 0x08, 0xC0, 0x83, 0x10, 0x18, 0x46, 0x01, 0xF0, 0x80, 0x08,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x21, 0xC0, 0x08, 0x6C, 0x01,
  0x10, 0x40, 0x42, 0x08, 0x18, 0xC1, 0x82, 0x18, 0x30, 0xC3, 0x06, 0x10,
  0x20, 0xC2, 0x04, 0x10, 0x00, 0xC6, 0x00, 0x0F, 0x80, 0x01, 0x00, 0x01,
  0xF8, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x10, 0x10, 0x04, 0x04, 0x01, 0x01,
  0x00, 0x40, 0x80, 0x18, 0x60, 0x02, 0x30, 0x00, 0xD8, 0x00, 0x18, 0x00,
  0x0F, 0x00, 0x06, 0x40, 0x03, 0x18, 0x18, 0x83, 0x06, 0x60, 0x61, 0x90,
  0x0C, 0x44, 0x01, 0x13, 0x00, 0x6C, 0x40, 0x0E, 0x18, 0x01, 0x86, 0x00,
  0xF0, 0xE0, 0xC4, 0x0F, 0xE1, 0xC0, 0xFF, 0x02, 0x0C, 0x20, 0xC1, 0x06,
  0x08, 0x30, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x60, 0xC0, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0x08, 0x80, 0x80, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x08, 0x18,
  0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x06,
  0x08, 0x10, 0x60, 0x83, 0x04, 0x18, 0x61, 0x82, 0x00, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x04, 0x10, 0x3E, 0x23, 0xC7, 0xFC, 0x00, 0xC0,
  0x02, 0x80, 0x0C, 0x80, 0x31, 0x80, 0x41, 0x83, 0x81, 0x82, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x6D, 0xB5, 0xA4, 0xFF, 0xFF, 0xFF, 0xEC, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x00,
  0x1F, 0xC0, 0xC0, 0xC1, 0x00, 0xC6, 0x00, 0xC8, 0x01, 0xB0, 0x01, 0x40,
  0x06, 0x80, 0x1F, 0x00, 0x6E, 0x01, 0x9C, 0x06, 0x38, 0x18, 0x70, 0x60,
  0xE1, 0x81, 0xC6, 0x03, 0x98, 0x07, 0x40, 0x0F, 0x00, 0x16, 0x00, 0x24,
  0x00, 0xCC, 0x01, 0x08, 0x06, 0x0C, 0x18, 0x0F, 0xE0, 0x03, 0x0F, 0x39,
  0xE1, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x00, 0x3F,
  0xC0, 0xC0, 0xC3, 0x00, 0xCC, 0x00, 0x98, 0x01, 0xA0, 0x03, 0x40, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xFF, 0xFE, 0x01, 0x00, 0x3F, 0xC0,
  0xC0, 0xE3, 0x00, 0x44, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x58,
  0x00, 0x98, 0x03, 0x1C, 0x1C, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0D, 0x00, 0x04, 0x80, 0x06, 0x40, 0x06, 0x20, 0x02, 0x10,
  0x03, 0x08, 0x03, 0x04, 0x01, 0x02, 0x01, 0x81, 0x01, 0x80, 0x80, 0x80,
  0x40, 0xC0, 0x20, 0xC0, 0x10, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x3F, 0xFD,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x7F, 0x07, 0x0F, 0x30, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x19, 0x80,
  0xE3, 0x8F, 0x07, 0xF0, 0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x87, 0xC2, 0x7B, 0xCB, 0x01, 0xB0,
  0x02, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x70, 0x03, 0x40, 0x09, 0x80, 0x63, 0x83, 0x03, 0xF8, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x1F, 0xE0, 0xE0, 0xE1, 0x00, 0x66, 0x00, 0x48, 0x00, 0xD0, 0x01, 0xA0,
  0x03, 0x40, 0x04, 0xC0, 0x18, 0xC0, 0x20, 0xC1, 0x80, 0x7E, 0x03, 0x8E,
  0x0C, 0x03, 0x20, 0x02, 0xC0, 0x07, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x28, 0x00, 0xD8, 0x03, 0x1C, 0x1C, 0x0F, 0xF0, 0x02, 0x00, 0x3F,
  0xC0, 0xC0, 0xC3, 0x00, 0xC4, 0x00, 0x98, 0x01, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xE8, 0x01, 0x98,
  0x05, 0x1C, 0x32, 0x0F, 0xC4, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x1F, 0x00, 0xEC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x60, 0x77, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x22,
  0x64, 0xC4, 0x00, 0x04, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x10, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0xFE,
  0x1C, 0x18, 0x80, 0x6C, 0x01, 0x40, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x03, 0xFC, 0x01, 0x81, 0xC0, 0xC0, 0x10, 0x40, 0x02, 0x30,
  0x00, 0xC8, 0x3E, 0x14, 0x10, 0x85, 0x08, 0x21, 0x42, 0x08, 0x61, 0x02,
  0x18, 0x40, 0x86, 0x10, 0x21, 0x84, 0x08, 0x61, 0x06, 0x18, 0x41, 0x06,
  0x10, 0x41, 0x84, 0x38, 0xB1, 0x9A, 0x64, 0x3C, 0xF1, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0xE0,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x36, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C,
  0x60, 0x04, 0x10, 0x02, 0x08, 0x03, 0x06, 0x01, 0x01, 0x00, 0x80, 0x80,
  0xC0, 0x60, 0x40, 0x30, 0x20, 0x08, 0x3F, 0xFE, 0x10, 0x03, 0x08, 0x00,
  0x8C, 0x00, 0x64, 0x00, 0x32, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xC1, 0x80, 0xE3, 0x00, 0x66, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xB0, 0x01,
  0x60, 0x02, 0xC0, 0x0D, 0x80, 0x33, 0x01, 0xC7, 0xFF, 0x0C, 0x03, 0x98,
  0x01, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x58, 0x01, 0xB0, 0x1E, 0x7F, 0xF0, 0x00, 0x80, 0x07, 0xF0,
  0x1C, 0x1C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0x40, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x60, 0x03,
  0x60, 0x02, 0x30, 0x06, 0x10, 0x0C, 0x1C, 0x18, 0x07, 0xF0, 0xFF, 0x80,
  0xC0, 0xE0, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x04, 0xC0, 0x06,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x04,
  0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC1, 0xE0, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F,
  0xFC, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x07, 0xF0, 0x1C, 0x1C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x03, 0x40, 0x03,
  0x40, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x7F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01,
  0x60, 0x01, 0x60, 0x01, 0x30, 0x01, 0x18, 0x03, 0x0C, 0x0E, 0x07, 0xF8,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFF, 0xFC, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x3F, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x24, 0x00, 0xCC, 0x03, 0x0E, 0x0C, 0x07, 0xF0,
  0x80, 0x0E, 0x80, 0x18, 0x80, 0x10, 0x80, 0x30, 0x80, 0x60, 0x80, 0xC0,
  0x81, 0x80, 0x83, 0x00, 0x86, 0x00, 0x8C, 0x00, 0x98, 0x00, 0x9C, 0x00,
  0xB6, 0x00, 0xE3, 0x00, 0xC3, 0x00, 0x81, 0x80, 0x80, 0xC0, 0x80, 0x60,
  0x80, 0x20, 0x80, 0x30, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x07,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x2D,
  0x00, 0xDB, 0x01, 0x32, 0x02, 0xE4, 0x0D, 0xCC, 0x13, 0x88, 0x67, 0x10,
  0x8E, 0x31, 0x1C, 0x26, 0x38, 0x68, 0x70, 0x70, 0xE0, 0xC1, 0xC1, 0x83,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1D, 0x00, 0x3B, 0x00,
  0x72, 0x00, 0xE6, 0x01, 0xC6, 0x03, 0x84, 0x07, 0x0C, 0x0E, 0x08, 0x1C,
  0x18, 0x38, 0x10, 0x70, 0x30, 0xE0, 0x21, 0xC0, 0x63, 0x80, 0x67, 0x00,
  0x4E, 0x00, 0xDC, 0x00, 0xB8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x00, 0x80, 0x07, 0xF0, 0x1C, 0x18, 0x30, 0x0C, 0x20, 0x06, 0x60, 0x02,
  0x40, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x40, 0x03, 0x60, 0x02, 0x60, 0x06, 0x30, 0x04, 0x10, 0x0C, 0x0C, 0x18,
  0x07, 0xF0, 0xFF, 0xE1, 0x00, 0xE2, 0x00, 0x64, 0x00, 0x68, 0x00, 0x50,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x34, 0x00,
  0xC8, 0x0F, 0x1F, 0xF8, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x07, 0xF8, 0x07, 0x06, 0x06, 0x01, 0x82, 0x00, 0x63, 0x00, 0x11,
  0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xB0, 0x00, 0x48, 0x00, 0x66, 0x00, 0x21, 0x00, 0x30, 0xC0, 0x30,
  0x38, 0x30, 0x07, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0xFF, 0xC1, 0x01, 0xC2, 0x00, 0xC4, 0x00, 0xC8, 0x00, 0x90, 0x01,
  0xA0, 0x03, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x64, 0x01, 0x8F,
  0xFE, 0x1F, 0xF0, 0x20, 0x30, 0x40, 0x60, 0x80, 0x61, 0x00, 0x42, 0x00,
  0xC4, 0x00, 0x88, 0x01, 0x90, 0x01, 0x20, 0x03, 0x40, 0x03, 0x00, 0x80,
  0x0F, 0xF8, 0x18, 0x1C, 0x30, 0x06, 0x20, 0x02, 0x60, 0x03, 0x60, 0x01,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x60, 0x03, 0x30, 0x06, 0x1C, 0x0C, 0x07, 0xF8,
  0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x16, 0x00, 0x64, 0x00, 0xCC, 0x03, 0x0E, 0x0C, 0x07, 0xF0,
  0x80, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0xC8, 0x00, 0x46, 0x00, 0x23, 0x00,
  0x30, 0x80, 0x10, 0x60, 0x08, 0x30, 0x0C, 0x08, 0x06, 0x06, 0x02, 0x03,
  0x03, 0x00, 0x81, 0x80, 0x40, 0x80, 0x30, 0xC0, 0x08, 0x60, 0x04, 0x20,
  0x03, 0x10, 0x00, 0x98, 0x00, 0x48, 0x00, 0x34, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x80, 0x80, 0xE0, 0x30, 0x28, 0x1C, 0x0A, 0x05, 0x02,
  0xC1, 0x40, 0xB0, 0x50, 0x6C, 0x14, 0x19, 0x0D, 0x84, 0x43, 0x21, 0x10,
  0x88, 0x44, 0x22, 0x11, 0x88, 0x8C, 0x66, 0x33, 0x09, 0x8C, 0x82, 0x41,
  0x20, 0x90, 0x48, 0x24, 0x12, 0x0B, 0x06, 0x83, 0xC1, 0xE0, 0xE0, 0x38,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0xC0, 0x01, 0xB0,
  0x01, 0x8C, 0x01, 0x86, 0x00, 0x81, 0x80, 0xC0, 0x40, 0x40, 0x30, 0x60,
  0x0C, 0x60, 0x02, 0x20, 0x01, 0xB0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x1A, 0x00, 0x0D, 0x80, 0x0C, 0x60, 0x04, 0x10, 0x06, 0x0C, 0x06,
  0x03, 0x02, 0x00, 0x83, 0x00, 0x61, 0x00, 0x11, 0x80, 0x0D, 0x80, 0x03,
  0xC0, 0x00, 0xD8, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x0C, 0x10, 0x06, 0x06,
  0x01, 0x80, 0x80, 0xC0, 0x30, 0x30, 0x04, 0x18, 0x01, 0x84, 0x00, 0x23,
  0x00, 0x0C, 0x80, 0x01, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x7F, 0xFE, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x7F, 0xFF, 0xFF, 0xE1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8,
  0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x20, 0x03, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0xFC, 0x06, 0x00, 0x70, 0x07, 0x00, 0xD0, 0x09, 0x81,
  0x88, 0x10, 0xC3, 0x0C, 0x20, 0x42, 0x06, 0x60, 0x24, 0x03, 0xC0, 0x10,
  0xFF, 0xFC, 0xC3, 0x08, 0x30, 0x0F, 0xE0, 0x70, 0x61, 0x80, 0x62, 0x00,
  0x6C, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x0F, 0xFC, 0x70, 0x09,
  0x80, 0x16, 0x00, 0x28, 0x00, 0x50, 0x01, 0xB0, 0x03, 0x60, 0x0A, 0x70,
  0x64, 0x7F, 0x8C, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x9F, 0xC2, 0xC1, 0x8E, 0x03, 0x30, 0x06,
  0x80, 0x1A, 0x00, 0x28, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x01, 0x30, 0x0C, 0xB0, 0x62, 0x7F,
  0x00, 0x0F, 0xE0, 0x60, 0xC3, 0x01, 0x98, 0x03, 0x40, 0x07, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x05,
  0x00, 0x16, 0x00, 0xC8, 0x02, 0x18, 0x30, 0x3F, 0x80, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x0F,
  0xCC, 0xE1, 0xB2, 0x01, 0xD8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x36,
  0x00, 0xC8, 0x07, 0x38, 0x7C, 0x3F, 0x30, 0x0F, 0xE0, 0x30, 0x60, 0xC0,
  0x63, 0x00, 0x64, 0x00, 0x58, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x06, 0x18, 0x18, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xE2, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0F, 0xC4, 0xE1,
  0x92, 0x01, 0xD8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x36, 0x00, 0xC8,
  0x07, 0x38, 0x7C, 0x3F, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x09, 0x00, 0x66,
  0x01, 0x0E, 0x1C, 0x0F, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC7, 0xF3, 0x30, 0xED, 0x00,
  0xB8, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x10, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x18, 0x06, 0x3F, 0x80, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x1E, 0x00, 0xC8, 0x06, 0x20,
  0x30, 0x81, 0x82, 0x1C, 0x08, 0xC0, 0x26, 0x00, 0xBC, 0x03, 0x98, 0x0C,
  0x30, 0x20, 0x60, 0x81, 0x82, 0x03, 0x08, 0x06, 0x20, 0x0C, 0x80, 0x1A,
  0x00, 0x30, 0xFF, 0x03, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF, 0xF0,
  0xDF, 0x1F, 0x3C, 0x6C, 0x6E, 0x0E, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0x70,
  0x30, 0x1C, 0x0C, 0x07, 0x03, 0x01, 0xC0, 0xC0, 0x70, 0x30, 0x1C, 0x0C,
  0x07, 0x01, 0x01, 0xC0, 0x40, 0x70, 0x10, 0x1C, 0x04, 0x07, 0x01, 0x01,
  0xC0, 0x40, 0x70, 0x10, 0x10, 0xC7, 0xE3, 0x30, 0xED, 0x00, 0xB8, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x10, 0x07, 0xF0, 0x1C, 0x18, 0x30, 0x0C, 0x20, 0x06, 0x60, 0x02, 0x40,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x40, 0x03, 0x60, 0x02, 0x20, 0x06, 0x30, 0x0C, 0x1C, 0x18, 0x07,
  0xF0, 0xCF, 0xE1, 0xB0, 0xE3, 0x80, 0x67, 0x00, 0x4C, 0x00, 0xD8, 0x00,
  0xB0, 0x01, 0x60, 0x02, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x16, 0x00, 0x2C,
  0x00, 0x58, 0x01, 0xB0, 0x02, 0x70, 0x0C, 0xD8, 0x31, 0x9F, 0xC3, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x0F, 0xC4, 0xE1, 0x92, 0x01, 0xD8, 0x03, 0x40, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x36, 0x00, 0xC8, 0x07, 0x38, 0x3C, 0x3F, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0xC7, 0xFC, 0xC0, 0xD0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F,
  0xE0, 0x70, 0x71, 0x80, 0x32, 0x00, 0x24, 0x00, 0x6C, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0x30, 0x06, 0x38, 0x18, 0x3F, 0xE0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x03, 0xFF, 0xE0, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x1F, 0xC0, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x05, 0x00, 0x34, 0x00, 0xD8, 0x05, 0x30, 0x74, 0x7F, 0x10, 0xC0, 0x01,
  0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x20, 0x06, 0x30, 0x04, 0x10, 0x0C,
  0x18, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x10, 0x04, 0x30, 0x06, 0x20,
  0x02, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x40,
  0x78, 0x18, 0x09, 0x03, 0x81, 0x20, 0x50, 0x66, 0x0A, 0x08, 0xC3, 0x41,
  0x08, 0x4C, 0x21, 0x09, 0x84, 0x21, 0x11, 0x86, 0x62, 0x20, 0x48, 0x64,
  0x09, 0x04, 0x81, 0x20, 0xB0, 0x2C, 0x14, 0x07, 0x02, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x03, 0x30, 0x06, 0x10, 0x0C, 0x18,
  0x08, 0x0C, 0x18, 0x06, 0x30, 0x02, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x18, 0x18, 0x0C, 0x30,
  0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x26, 0x00, 0x18,
  0xC0, 0x04, 0x30, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x20, 0x20, 0x18, 0x0C,
  0x04, 0x01, 0x03, 0x00, 0x60, 0x80, 0x08, 0x60, 0x03, 0x10, 0x00, 0x4C,
  0x00, 0x1B, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0x00, 0x40, 0x30, 0x30, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0xE0, 0x30,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x30, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x01, 0xC0, 0x30,
  0x30, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x00, 0x1E, 0x00, 0x5C, 0xE0,
  0x14, 0x0C, 0x07, 0x01, 0x83, 0x80, 0x3F, 0x80, 0x03, 0x80,
};

const GFXglyph RobotoMono_ExtraLight34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 2, 24, 20, 9, -24 },
  { 7, 6, 8, 20, 7, -26 },
  { 13, 19, 24, 20, 1, -24 },
  { 70, 15, 31, 20, 3, -28 },
  { 129, 19, 25, 20, 1, -25 },
  { 189, 18, 25, 20, 2, -25 },
  { 246, 1, 8, 20, 9, -26 },
  { 247, 7, 35, 20, 7, -27 },
  { 278, 7, 35, 20, 6, -27 },
  { 309, 15, 14, 20, 3, -24 },
  { 336, 17, 18, 20, 2, -20 },
  { 375, 3, 8, 20, 7, -3 },
  { 378, 12, 2, 20, 4, -12 },
  { 381, 3, 2, 20, 9, -2 },
  { 382, 11, 26, 20, 5, -24 },
  { 418, 15, 25, 20, 3, -25 },
  { 465, 8, 24, 20, 4, -24 },
  { 489, 15, 25, 20, 2, -25 },
  { 536, 15, 25, 20, 2, -25 },
  { 583, 17, 24, 20, 1, -24 },
  { 634, 14, 24, 20, 4, -24 },
  { 676, 14, 24, 20, 3, -24 },
  { 718, 16, 24, 20, 2, -24 },
  { 766, 15, 25, 20, 3, -25 },
  { 813, 15, 25, 20, 3, -25 },
  { 860, 3, 17, 20, 10, -17 },
  { 867, 4, 22, 20, 9, -17 },
  { 878, 14, 14, 20, 3, -18 },
  { 903, 15, 8, 20, 3, -15 },
  { 918, 15, 14, 20, 3, -18 },
  { 945, 13, 25, 20, 4, -25 },
  { 986, 18, 24, 20, 1, -24 },
  { 1040, 17, 24, 20, 2, -24 },
  { 1091, 15, 24, 20, 3, -24 },
  { 1136, 16, 25, 20, 2, -25 },
  { 1186, 16, 24, 20, 3, -24 },
  { 1234, 14, 24, 20, 3, -24 },
  { 1276, 14, 24, 20, 4, -24 },
  { 1318, 16, 25, 20, 2, -25 },
  { 1368, 15, 24, 20, 3, -24 },
  { 1413, 14, 24, 20, 3, -24 },
  { 1455, 15, 24, 20, 2, -24 },
  { 1500, 16, 24, 20, 4, -24 },
  { 1548, 14, 24, 20, 4, -24 },
  { 1590, 15, 24, 20, 3, -24 },
  { 1635, 15, 24, 20, 3, -24 },
  { 1680, 16, 25, 20, 2, -25 },
  { 1730, 15, 24, 20, 4, -24 },
  { 1775, 17, 29, 20, 2, -25 },
  { 1837, 15, 24, 20, 4, -24 },
  { 1882, 16, 25, 20, 2, -25 },
  { 1932, 17, 24, 20, 2, -24 },
  { 1983, 15, 24, 20, 3, -24 },
  { 2028, 17, 24, 20, 2, -24 },
  { 2079, 18, 24, 20, 2, -24 },
  { 2133, 17, 24, 20, 2, -24 },
  { 2184, 18, 24, 20, 1, -24 },
  { 2238, 15, 24, 20, 2, -24 },
  { 2283, 5, 33, 20, 8, -28 },
  { 2304, 12, 26, 20, 4, -24 },
  { 2343, 6, 33, 20, 7, -28 },
  { 2368, 12, 13, 20, 4, -24 },
  { 2388, 14, 1, 20, 3, 0 },
  { 2390, 5, 4, 20, 8, -25 },
  { 2393, 15, 18, 20, 3, -18 },
  { 2427, 14, 26, 20, 4, -26 },
  { 2473, 14, 18, 20, 3, -18 },
  { 2505, 14, 26, 20, 3, -26 },
  { 2551, 15, 18, 20, 3, -18 },
  { 2585, 16, 26, 20, 3, -26 },
  { 2637, 14, 25, 20, 3, -18 },
  { 2681, 14, 26, 20, 3, -26 },
  { 2727, 14, 24, 20, 4, -24 },
  { 2769, 11, 31, 20, 3, -24 },
  { 2812, 14, 26, 20, 4, -26 },
  { 2858, 14, 26, 20, 4, -26 },
  { 2904, 18, 18, 20, 1, -18 },
  { 2945, 14, 18, 20, 3, -18 },
  { 2977, 16, 18, 20, 2, -18 },
  { 3013, 15, 25, 20, 3, -18 },
  { 3060, 14, 25, 20, 3, -18 },
  { 3104, 12, 18, 20, 6, -18 },
  { 3131, 15, 18, 20, 3, -18 },
  { 3165, 14, 23, 20, 3, -23 },
  { 3206, 14, 18, 20, 3, -18 },
  { 3238, 16, 18, 20, 2, -18 },
  { 3274, 19, 18, 20, 1, -18 },
  { 3317, 16, 18, 20, 2, -18 },
  { 3353, 18, 25, 20, 1, -18 },
  { 3410, 16, 18, 20, 2, -18 },
  { 3446, 10, 34, 20, 6, -27 },
  { 3489, 1, 29, 20, 10, -24 },
  { 3493, 10, 34, 20, 6, -27 },
  { 3536, 18, 6, 20, 1, -13 },
};

const GFXfont RobotoMono_ExtraLight34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight34pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_EXTRALIGHT34PT7B_H_
