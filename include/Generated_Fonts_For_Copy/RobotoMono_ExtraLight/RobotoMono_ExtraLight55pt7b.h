#ifndef _ROBOTOMONO_EXTRALIGHT55PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight55pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x02, 0xFF, 0x70, 0x60, 0xD8, 0x36,
  0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0xF0, 0x3C, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30,
  0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xF7, 0xE0, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x38,
  0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70,
  0x00, 0x06, 0x70, 0x00, 0x07, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x40, 0x30, 0x06,
  0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30,
  0x1C, 0x03, 0x00, 0x60, 0x30, 0x06, 0x00, 0xC0, 0xC0, 0x0E, 0x01, 0x81,
  0x80, 0x0C, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x30,
  0x00, 0x1F, 0xE0, 0x60, 0x00, 0x1F, 0x81, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x03, 0xF0, 0x00, 0x0C, 0x0F, 0xF8,
  0x00, 0x18, 0x30, 0x30, 0x00, 0x60, 0xE0, 0x30, 0x00, 0xC1, 0x80, 0x60,
  0x03, 0x03, 0x00, 0xE0, 0x0E, 0x06, 0x00, 0xC0, 0x18, 0x1C, 0x01, 0x80,
  0x70, 0x38, 0x03, 0x00, 0xC0, 0x70, 0x06, 0x03, 0x00, 0xE0, 0x0C, 0x06,
  0x00, 0xC0, 0x38, 0x18, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0E,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x80,
  0xC0, 0x0C, 0x38, 0x0E, 0x00, 0xC7, 0x00, 0x70, 0x0C, 0x60, 0x03, 0x80,
  0xCE, 0x00, 0x1C, 0x1C, 0xE0, 0x00, 0xC1, 0xCC, 0x00, 0x0E, 0x18, 0xC0,
  0x00, 0x73, 0x8C, 0x00, 0x03, 0xB0, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x7B, 0x81,
  0xE0, 0x0E, 0x1C, 0x0F, 0xFF, 0xC0, 0xC0, 0x3F, 0xF0, 0x0F, 0x00, 0x10,
  0x00, 0x00, 0xFF, 0xFF, 0xB6, 0xDB, 0x00, 0x00, 0x10, 0x03, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x40, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x18, 0x03, 0xF8, 0x18, 0x1F, 0x7F, 0x18, 0xFE,
  0x07, 0xFB, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x77, 0x00, 0x00, 0xE3, 0x00, 0x01, 0xC1, 0x80, 0x01, 0x81, 0xC0,
  0x03, 0x80, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x39,
  0xCE, 0x73, 0x98, 0xC6, 0x73, 0x39, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x77, 0xBE, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x38,
  0x70, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xF3, 0x00, 0x00, 0xDF, 0x80, 0x00,
  0xCF, 0xC0, 0x00, 0xC7, 0xE0, 0x00, 0xC3, 0xF0, 0x01, 0xC1, 0xF8, 0x01,
  0xC0, 0xFC, 0x01, 0xC0, 0x7E, 0x01, 0xC0, 0x3F, 0x01, 0xC0, 0x1F, 0x81,
  0xC0, 0x0F, 0xC1, 0xC0, 0x07, 0xE1, 0xC0, 0x03, 0xF1, 0xC0, 0x01, 0xD9,
  0xC0, 0x00, 0xED, 0xC0, 0x00, 0x77, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x19,
  0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x07,
  0x06, 0x00, 0x03, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x01, 0xF0, 0x1F, 0xC1, 0xF7, 0x3F, 0x1F, 0xE0, 0x7E, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xFB, 0xF8, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x03, 0x81,
  0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C,
  0x70, 0x00, 0x07, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x70, 0x00,
  0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x0C, 0x3C, 0x00, 0x1C, 0x1F, 0x00, 0x78, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x07, 0x18, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x18, 0x00, 0x30,
  0x01, 0x80, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x18,
  0x01, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x1F, 0x00, 0x1B, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xF8, 0x03,
  0xE1, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x78, 0xE0,
  0x00, 0xE0, 0xE0, 0x03, 0x80, 0xF8, 0x3F, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x1E,
  0x00, 0x61, 0xFF, 0xC0, 0x63, 0xF7, 0xF0, 0xEF, 0x00, 0x78, 0xFC, 0x00,
  0x38, 0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00,
  0x0C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x07, 0x80, 0x70, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x03,
  0x81, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x78, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x03, 0x98, 0x00, 0x01, 0xCE, 0x00,
  0x01, 0xC3, 0xC0, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x70, 0x00, 0x07, 0x30, 0x00, 0x07, 0x38, 0x00, 0x0F,
  0x1C, 0x00, 0x1B, 0x1E, 0x00, 0x73, 0x0F, 0x01, 0xE3, 0x03, 0xFF, 0xC3,
  0x01, 0xFF, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xEF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0x38, 0xF3, 0xCF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x38, 0xE3, 0x8E, 0x30, 0xC3, 0x1C, 0x63, 0x8C, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3C, 0x03, 0xC3, 0x80,
  0x07, 0x18, 0x00, 0x39, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x06, 0x1C, 0x03, 0xF0, 0x18, 0x60, 0x1F, 0xF0, 0x31, 0x80,
  0xC0, 0xC0, 0xCC, 0x06, 0x03, 0x03, 0x30, 0x30, 0x0C, 0x0C, 0xC0, 0xC0,
  0x30, 0x36, 0x06, 0x00, 0xC0, 0xD8, 0x18, 0x03, 0x01, 0x60, 0x60, 0x08,
  0x05, 0x81, 0x80, 0x20, 0x16, 0x0C, 0x01, 0x80, 0x58, 0x30, 0x06, 0x03,
  0x40, 0xC0, 0x18, 0x0D, 0x03, 0x00, 0x60, 0x34, 0x0C, 0x01, 0x80, 0xD8,
  0x30, 0x06, 0x03, 0x60, 0xC0, 0x38, 0x0D, 0x83, 0x00, 0xE0, 0x66, 0x06,
  0x07, 0x81, 0x98, 0x18, 0x36, 0x04, 0x60, 0x71, 0xCC, 0x31, 0xC0, 0xFE,
  0x3F, 0x83, 0x01, 0xF0, 0x7C, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x80,
  0x03, 0xC0, 0x0E, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x18, 0x03, 0x80, 0x01, 0x80, 0x18, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0,
  0x06, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x70, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xC0,
  0x07, 0xC0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xF0, 0xC0, 0x00, 0x78, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x78, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0xE0, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x18,
  0x60, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x30, 0x01, 0xF0, 0x18, 0x00, 0x1C, 0x0C,
  0x00, 0x07, 0x06, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x33, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x3C, 0x0C, 0x00, 0x7C, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x03, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00,
  0x0E, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0x07, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00,
  0xC0, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x70,
  0x00, 0xC0, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x7C, 0x00, 0x03,
  0x3B, 0x80, 0x00, 0xDC, 0x60, 0x00, 0x3E, 0x1C, 0x00, 0x0F, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x0C,
  0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1B, 0xD8, 0x00, 0x3B, 0xD8, 0x00, 0x33, 0xDC, 0x00, 0x33, 0xCC, 0x00,
  0x73, 0xCC, 0x00, 0x63, 0xC6, 0x00, 0xE3, 0xC6, 0x00, 0xC3, 0xC7, 0x00,
  0xC3, 0xC3, 0x01, 0xC3, 0xC3, 0x01, 0x83, 0xC3, 0x81, 0x83, 0xC1, 0x83,
  0x03, 0xC1, 0x83, 0x03, 0xC1, 0xC7, 0x03, 0xC0, 0xC6, 0x03, 0xC0, 0xC6,
  0x03, 0xC0, 0x6C, 0x03, 0xC0, 0x6C, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x38,
  0x03, 0xC0, 0x38, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7B, 0x00, 0x00,
  0xF7, 0x00, 0x01, 0xE6, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x8C, 0x00, 0x0F,
  0x1C, 0x00, 0x1E, 0x18, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x30, 0x00, 0xF0,
  0x30, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x60, 0x07, 0x80, 0xE0, 0x0F, 0x00,
  0xC0, 0x1E, 0x01, 0xC0, 0x3C, 0x01, 0x80, 0x78, 0x03, 0x80, 0xF0, 0x03,
  0x01, 0xE0, 0x03, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x06, 0x0F, 0x00, 0x0E,
  0x1E, 0x00, 0x0C, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x18, 0xF0, 0x00, 0x39,
  0xE0, 0x00, 0x33, 0xC0, 0x00, 0x37, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x60, 0x00,
  0x0C, 0x70, 0x00, 0x07, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x07, 0x18, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0xC0, 0x01, 0xF0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x78, 0xC0, 0x07, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x1C,
  0x00, 0x0C, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x80, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xC0, 0x03, 0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x03, 0xB0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03,
  0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x0E,
  0x30, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x03, 0x80,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x07, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0x00, 0x1D, 0x80, 0x0C, 0x00, 0x66, 0x00, 0x78, 0x01,
  0x98, 0x01, 0xE0, 0x06, 0x60, 0x07, 0x80, 0x19, 0x80, 0x1E, 0x00, 0x67,
  0x00, 0x78, 0x03, 0x8C, 0x01, 0xF0, 0x0C, 0x30, 0x0C, 0xC0, 0x30, 0xC0,
  0x33, 0x00, 0xC3, 0x00, 0xCC, 0x03, 0x0C, 0x03, 0x30, 0x0C, 0x38, 0x0C,
  0xE0, 0x30, 0xE0, 0x61, 0x81, 0xC1, 0x81, 0x86, 0x06, 0x06, 0x06, 0x18,
  0x18, 0x18, 0x18, 0x60, 0x60, 0x60, 0x61, 0xC1, 0x81, 0x83, 0x03, 0x06,
  0x07, 0x0C, 0x0C, 0x18, 0x0C, 0x30, 0x30, 0xC0, 0x30, 0xC0, 0xC3, 0x00,
  0xC3, 0x03, 0x0C, 0x03, 0x1C, 0x0E, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x31,
  0x80, 0x63, 0x00, 0xE6, 0x01, 0x9C, 0x01, 0x98, 0x06, 0x60, 0x06, 0xE0,
  0x1D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03,
  0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x18, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x18, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x18,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x38, 0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xF8, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x07, 0x70, 0x00, 0xC6,
  0x00, 0x38, 0xE0, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x38, 0x06, 0x03,
  0x01, 0xC0, 0x70, 0x30, 0x06, 0x06, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x01,
  0x8E, 0x00, 0x39, 0x80, 0x03, 0x70, 0x00, 0x7C, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xE0, 0xE0, 0xC1, 0xC1, 0xC1, 0x80, 0x00,
  0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xF0, 0x07, 0x83, 0x80,
  0x03, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x30, 0x00, 0x06, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFC, 0x07, 0x3E, 0x00, 0x0E,
  0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7D, 0xC0, 0x03, 0xB9, 0xC0, 0x1E, 0x71, 0xFF, 0xF8, 0x61, 0xFF,
  0xC0, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x0C, 0x3F, 0xF0, 0x18, 0xFF, 0xF8, 0x33, 0x80, 0x78,
  0x6C, 0x00, 0x70, 0xF0, 0x00, 0x71, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x66,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x67, 0x00, 0x01,
  0xCF, 0x00, 0x07, 0x1F, 0x00, 0x1C, 0x37, 0x80, 0x78, 0x63, 0xFF, 0xC0,
  0xC3, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x78, 0x07, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x38, 0x00, 0x07, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xB8, 0x00, 0x07, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x38, 0x70, 0x00, 0xE0,
  0x78, 0x07, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x30, 0x1F,
  0xF8, 0x60, 0x7F, 0xF8, 0xC3, 0xC0, 0x39, 0x87, 0x00, 0x1B, 0x1C, 0x00,
  0x1E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x37, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x70, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x71, 0xC0, 0x01, 0xE1, 0xC0,
  0x07, 0xC1, 0xC0, 0x3D, 0x81, 0xFF, 0xF3, 0x01, 0xFF, 0x86, 0x00, 0x20,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x18, 0x70,
  0x00, 0x0E, 0x30, 0x00, 0x03, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x02, 0x0E, 0x00, 0x01, 0x83, 0xC0,
  0x03, 0x80, 0xF0, 0x03, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x60,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x30, 0x7F, 0xF8, 0xC3, 0x80,
  0x73, 0x1C, 0x00, 0x6C, 0xE0, 0x00, 0xF7, 0x00, 0x01, 0xD8, 0x00, 0x07,
  0x60, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x36, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0xF1, 0xC0, 0x07, 0xC3, 0x80, 0x7B, 0x07, 0xFF, 0xCC, 0x0F, 0xFC,
  0x30, 0x02, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC8, 0x00, 0x06, 0x70, 0x00, 0x38, 0xE0, 0x01, 0xC1, 0xE0,
  0x1E, 0x03, 0xF3, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x60, 0x0E, 0x0F, 0xFC, 0x1C,
  0x3F, 0xFE, 0x39, 0xE0, 0x1E, 0x73, 0x00, 0x1C, 0xEC, 0x00, 0x1D, 0xF0,
  0x00, 0x1B, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0xC1, 0xF0, 0x7F, 0xF0, 0x1F,
  0xC0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0x70, 0x00, 0xE0,
  0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E,
  0x03, 0x80, 0x1C, 0x1E, 0x00, 0x38, 0x78, 0x00, 0x71, 0xE0, 0x00, 0xE7,
  0x80, 0x01, 0xDF, 0x80, 0x03, 0xF3, 0x80, 0x07, 0xC3, 0x80, 0x0F, 0x07,
  0x80, 0x1C, 0x07, 0x00, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07,
  0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x0F,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xC0,
  0x06, 0x06, 0x3F, 0xC1, 0xFE, 0x3B, 0xFF, 0x1F, 0xF9, 0xF0, 0x1D, 0x80,
  0xEF, 0x00, 0x78, 0x03, 0x78, 0x03, 0x80, 0x1B, 0x80, 0x1C, 0x00, 0xFC,
  0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01,
  0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80,
  0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F,
  0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00,
  0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0,
  0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F,
  0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0x0E, 0x01, 0xC1, 0xFF, 0x83, 0x87, 0xFF, 0xC7, 0x3C, 0x03, 0xCE, 0xE0,
  0x03, 0x9D, 0x80, 0x03, 0xBE, 0x00, 0x03, 0x78, 0x00, 0x06, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07,
  0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x03, 0x0F, 0xFC, 0x0C, 0x7F, 0xF8, 0x37,
  0x80, 0x78, 0xF8, 0x00, 0xE3, 0xC0, 0x01, 0xCE, 0x00, 0x03, 0xB0, 0x00,
  0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0xC0, 0x01, 0xCF, 0x80, 0x0E, 0x37, 0x00, 0x70, 0xCF, 0xFF, 0x83, 0x0F,
  0xFC, 0x0C, 0x02, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0xFC, 0x30, 0xFF, 0xF8, 0xC7, 0x80, 0x7B, 0x1C, 0x00, 0x6C, 0xE0, 0x00,
  0xF7, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0xDC,
  0x00, 0x03, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0xF1, 0xC0, 0x07, 0xC3, 0x80,
  0x3B, 0x07, 0xFF, 0xCC, 0x0F, 0xFC, 0x30, 0x02, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0x18, 0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xC0, 0x0C, 0xE0,
  0x01, 0x98, 0x00, 0x36, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1E, 0x00,
  0x78, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1E, 0x00,
  0x78, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x7D, 0xC0, 0x03, 0x73,
  0xC0, 0x3D, 0xC7, 0xFF, 0xC7, 0x07, 0xFE, 0x1C, 0x01, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x38, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x38, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xE0,
  0x0E, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x70, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x6E, 0x00, 0x70, 0x01,
  0x98, 0x01, 0xE0, 0x06, 0x60, 0x07, 0x80, 0x39, 0x80, 0x36, 0x00, 0xC7,
  0x00, 0xD8, 0x03, 0x0C, 0x03, 0x70, 0x0C, 0x30, 0x0C, 0xC0, 0x70, 0xC0,
  0x63, 0x01, 0x83, 0x01, 0x8C, 0x06, 0x0E, 0x06, 0x38, 0x18, 0x18, 0x18,
  0x60, 0x60, 0x60, 0xC1, 0x83, 0x01, 0x83, 0x06, 0x0C, 0x07, 0x0C, 0x1C,
  0x30, 0x0C, 0x30, 0x30, 0xC0, 0x31, 0x80, 0xC3, 0x00, 0xC6, 0x03, 0x18,
  0x03, 0x18, 0x06, 0x60, 0x06, 0x60, 0x19, 0x80, 0x1B, 0x00, 0x66, 0x00,
  0x6C, 0x01, 0xB0, 0x01, 0xB0, 0x02, 0xC0, 0x06, 0xC0, 0x0F, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80,
  0x06, 0x00, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x06,
  0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x06,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x18, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x03, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x9F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xF8, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xCE, 0x1F,
  0x00, 0x06, 0xE0, 0x3C, 0x00, 0x36, 0x00, 0x70, 0x03, 0xE0, 0x01, 0xC0,
  0x1B, 0x00, 0x07, 0x83, 0x98, 0x00, 0x1F, 0xFC, 0xC0, 0x00, 0x3F, 0x80,
};

const GFXglyph RobotoMono_ExtraLight55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 4, 39, 33, 14, -39 },
  { 21, 10, 11, 33, 11, -41 },
  { 35, 30, 39, 33, 2, -39 },
  { 182, 24, 51, 33, 5, -45 },
  { 335, 31, 41, 33, 1, -40 },
  { 494, 28, 41, 33, 4, -40 },
  { 638, 3, 11, 33, 14, -41 },
  { 643, 12, 57, 33, 11, -44 },
  { 729, 13, 57, 33, 9, -44 },
  { 822, 24, 22, 33, 5, -39 },
  { 888, 27, 28, 33, 3, -32 },
  { 983, 5, 12, 33, 11, -5 },
  { 991, 19, 2, 33, 7, -19 },
  { 996, 5, 4, 33, 15, -4 },
  { 999, 18, 42, 33, 8, -39 },
  { 1094, 25, 41, 33, 4, -40 },
  { 1223, 14, 39, 33, 6, -39 },
  { 1292, 25, 40, 33, 3, -40 },
  { 1417, 24, 41, 33, 3, -40 },
  { 1540, 28, 39, 33, 2, -39 },
  { 1677, 23, 40, 33, 6, -39 },
  { 1792, 24, 41, 33, 4, -40 },
  { 1915, 25, 39, 33, 4, -39 },
  { 2037, 25, 41, 33, 5, -40 },
  { 2166, 24, 40, 33, 4, -40 },
  { 2286, 4, 28, 33, 17, -28 },
  { 2300, 6, 35, 33, 15, -28 },
  { 2327, 24, 22, 33, 4, -29 },
  { 2393, 24, 13, 33, 5, -24 },
  { 2432, 23, 22, 33, 5, -29 },
  { 2496, 21, 40, 33, 6, -40 },
  { 2601, 30, 39, 33, 1, -39 },
  { 2748, 28, 39, 33, 3, -39 },
  { 2885, 24, 39, 33, 6, -39 },
  { 3002, 25, 41, 33, 4, -40 },
  { 3131, 25, 39, 33, 5, -39 },
  { 3253, 22, 39, 33, 6, -39 },
  { 3361, 23, 39, 33, 6, -39 },
  { 3474, 26, 41, 33, 3, -40 },
  { 3608, 24, 39, 33, 5, -39 },
  { 3725, 23, 39, 33, 5, -39 },
  { 3838, 24, 40, 33, 3, -39 },
  { 3958, 26, 39, 33, 6, -39 },
  { 4085, 23, 39, 33, 6, -39 },
  { 4198, 24, 39, 33, 5, -39 },
  { 4315, 23, 39, 33, 5, -39 },
  { 4428, 25, 41, 33, 4, -40 },
  { 4557, 24, 39, 33, 6, -39 },
  { 4674, 27, 47, 33, 3, -40 },
  { 4833, 24, 39, 33, 6, -39 },
  { 4950, 26, 41, 33, 4, -40 },
  { 5084, 27, 39, 33, 3, -39 },
  { 5216, 25, 40, 33, 4, -39 },
  { 5341, 27, 39, 33, 3, -39 },
  { 5473, 30, 39, 33, 2, -39 },
  { 5620, 28, 39, 33, 3, -39 },
  { 5757, 28, 39, 33, 2, -39 },
  { 5894, 24, 39, 33, 4, -39 },
  { 6011, 9, 53, 33, 12, -45 },
  { 6071, 19, 42, 33, 7, -39 },
  { 6171, 8, 53, 33, 12, -45 },
  { 6224, 19, 21, 33, 7, -39 },
  { 6274, 23, 2, 33, 5, 0 },
  { 6280, 7, 7, 33, 13, -40 },
  { 6287, 23, 31, 33, 5, -30 },
  { 6377, 23, 42, 33, 6, -41 },
  { 6498, 23, 31, 33, 5, -30 },
  { 6588, 23, 42, 33, 4, -41 },
  { 6709, 25, 31, 33, 4, -30 },
  { 6806, 25, 42, 33, 5, -42 },
  { 6938, 22, 42, 33, 5, -30 },
  { 7054, 23, 41, 33, 5, -41 },
  { 7172, 23, 39, 33, 6, -39 },
  { 7285, 17, 51, 33, 5, -39 },
  { 7394, 23, 41, 33, 6, -41 },
  { 7512, 23, 41, 33, 6, -41 },
  { 7630, 29, 30, 33, 2, -30 },
  { 7739, 23, 30, 33, 5, -30 },
  { 7826, 25, 31, 33, 4, -30 },
  { 7923, 22, 41, 33, 6, -30 },
  { 8036, 22, 41, 33, 5, -30 },
  { 8149, 19, 30, 33, 10, -30 },
  { 8221, 24, 31, 33, 5, -30 },
  { 8314, 23, 38, 33, 5, -37 },
  { 8424, 22, 30, 33, 6, -29 },
  { 8507, 27, 29, 33, 3, -29 },
  { 8605, 30, 29, 33, 2, -29 },
  { 8714, 26, 29, 33, 4, -29 },
  { 8809, 29, 41, 33, 2, -29 },
  { 8958, 26, 29, 33, 4, -29 },
  { 9053, 18, 54, 33, 9, -43 },
  { 9175, 3, 47, 33, 15, -39 },
  { 9193, 18, 54, 33, 9, -43 },
  { 9315, 29, 9, 33, 2, -21 },
};

const GFXfont RobotoMono_ExtraLight55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight55pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_EXTRALIGHT55PT7B_H_
