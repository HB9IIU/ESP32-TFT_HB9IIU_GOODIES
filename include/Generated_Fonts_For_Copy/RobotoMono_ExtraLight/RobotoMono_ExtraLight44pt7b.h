#ifndef _ROBOTOMONO_EXTRALIGHT44PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight44pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x00, 0x07,
  0xD8, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x30,
  0x18, 0x00, 0x20, 0x10, 0x00, 0x20, 0x10, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x20, 0x00, 0x40, 0x20, 0x00, 0x40,
  0x60, 0x3F, 0xFF, 0xFF, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x80,
  0x40, 0x00, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x80, 0x01, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0x01, 0x80, 0x02, 0x01, 0x00, 0x02, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x04, 0x02,
  0x00, 0x04, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x03, 0x81, 0xC0,
  0xC0, 0x1C, 0x30, 0x01, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x36,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x07, 0x30,
  0x00, 0xC7, 0x00, 0x70, 0x7C, 0x7C, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x40, 0x20, 0xC0, 0x40, 0x60,
  0xC0, 0x60, 0x40, 0xC0, 0x60, 0xC0, 0xC0, 0x60, 0x80, 0xC0, 0x41, 0x80,
  0xC0, 0x41, 0x00, 0x40, 0xC3, 0x00, 0x61, 0x86, 0x00, 0x3F, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x78, 0x00, 0x20, 0xFE, 0x00, 0x61, 0x86, 0x00, 0x43, 0x03,
  0x00, 0xC3, 0x03, 0x01, 0x82, 0x01, 0x01, 0x82, 0x01, 0x03, 0x02, 0x01,
  0x03, 0x02, 0x01, 0x06, 0x03, 0x01, 0x02, 0x03, 0x03, 0x00, 0x01, 0x03,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x60, 0xC0, 0x03, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x60, 0x08, 0x01, 0x80,
  0x20, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x30, 0x00, 0xC1, 0xC0,
  0x03, 0x0E, 0x00, 0x06, 0x70, 0x00, 0x1B, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x73, 0x80, 0x03, 0x86, 0x01, 0x8C, 0x0C,
  0x06, 0x60, 0x18, 0x19, 0x80, 0x30, 0x6C, 0x00, 0xE1, 0xB0, 0x01, 0xCC,
  0xC0, 0x03, 0x33, 0x00, 0x06, 0xCC, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x70,
  0x01, 0xF0, 0xE0, 0x0C, 0xC1, 0xF1, 0xE1, 0x81, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0x80, 0x60,
  0x30, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x01, 0x00, 0xC0, 0x7C, 0x18, 0x3B, 0xF3, 0x3E, 0x07, 0xFE, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xDC, 0x00, 0x31, 0x80, 0x06, 0x18, 0x01, 0x81,
  0x80, 0x60, 0x18, 0x18, 0x03, 0x81, 0x00, 0x20, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x6D, 0xB6, 0xDB,
  0xD0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0x80, 0x70, 0x38, 0x1C, 0x01, 0x83, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xB8, 0x00, 0xE7, 0x00, 0x38, 0xE0, 0x0C, 0x1C, 0x03,
  0x03, 0x80, 0xC0, 0x70, 0x30, 0x0E, 0x0C, 0x01, 0xC3, 0x00, 0x3C, 0xC0,
  0x07, 0xB0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0xC3, 0x00, 0x38, 0x30, 0x0E, 0x03, 0xC7,
  0x80, 0x3F, 0xC0, 0x00, 0xE0, 0x7C, 0x3D, 0xBE, 0x3E, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0xF0,
  0x00, 0x7F, 0xE0, 0x1E, 0x07, 0x03, 0x80, 0x38, 0x30, 0x01, 0xC6, 0x00,
  0x0C, 0x60, 0x00, 0xC4, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0E,
  0x07, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x0F, 0x0F, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x03,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x60, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x8F, 0xC0, 0x6F, 0xFC, 0x1E, 0x07, 0x86,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x76, 0x00, 0x19, 0xC0, 0x0E, 0x38, 0x07, 0x07, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0x03, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x07, 0x00, 0x63, 0xFE, 0x04, 0xF0,
  0x70, 0x5C, 0x03, 0x8F, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x24,
  0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C,
  0x18, 0x01, 0xC1, 0xC0, 0x38, 0x07, 0x0F, 0x00, 0x3F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1E, 0x07, 0x03,
  0x80, 0x38, 0x30, 0x01, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00,
  0xC3, 0x80, 0x18, 0x1C, 0x07, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xC0,
  0x70, 0x30, 0x01, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x66,
  0x00, 0x06, 0x70, 0x00, 0xC3, 0x80, 0x1C, 0x1F, 0x1F, 0x00, 0x7F, 0xE0,
  0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x38, 0x01,
  0xC3, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x64, 0x00,
  0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x07, 0x70, 0x00, 0x73, 0x00, 0x0B, 0x18, 0x01, 0xB0,
  0xE0, 0x72, 0x07, 0xFC, 0x60, 0x1F, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF7, 0x3B, 0xCC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x63, 0x18, 0xCC, 0x63, 0x31,
  0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0x07, 0x86, 0x00,
  0xC6, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xE0, 0x70, 0x03, 0x80, 0x18,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x10, 0x1F, 0x02,
  0x30, 0x3F, 0xC2, 0x20, 0x60, 0x83, 0x60, 0xC0, 0x83, 0x60, 0x80, 0x83,
  0x41, 0x80, 0x81, 0x41, 0x80, 0x81, 0xC1, 0x00, 0x81, 0xC1, 0x01, 0x81,
  0xC3, 0x01, 0x81, 0xC3, 0x01, 0x83, 0xC3, 0x01, 0x83, 0xC3, 0x01, 0x03,
  0xC3, 0x03, 0x02, 0xC1, 0x03, 0x02, 0x41, 0x07, 0x86, 0x41, 0x8D, 0x8C,
  0x60, 0xF8, 0xF8, 0x60, 0x70, 0x70, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x40, 0x07, 0xC3, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00,
  0xC6, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0x80, 0xFF, 0xF8, 0x0C, 0x07, 0xE0, 0xC0,
  0x07, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18,
  0xC0, 0x03, 0x8C, 0x00, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xC0, 0x03,
  0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x03, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0x07, 0x81, 0xC0, 0x1C, 0x18, 0x00,
  0xC3, 0x00, 0x06, 0x60, 0x00, 0x76, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00,
  0xC0, 0xC0, 0x18, 0x07, 0x0F, 0x00, 0x3F, 0xE0, 0xFF, 0xF0, 0x0C, 0x07,
  0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00,
  0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x70, 0xC0, 0x0E, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xE0, 0x0F, 0x07, 0x81, 0xC0, 0x1C, 0x38, 0x00, 0xE3, 0x00,
  0x06, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x60, 0x00,
  0x16, 0x00, 0x01, 0x30, 0x00, 0x13, 0x00, 0x01, 0x18, 0x00, 0x30, 0xE0,
  0x0E, 0x07, 0x87, 0xC0, 0x3F, 0xF0, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0xFF, 0xFF, 0xC0, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x19, 0x80, 0x06, 0x38, 0x01,
  0xC3, 0x80, 0x70, 0x3C, 0x3C, 0x01, 0xFE, 0x00, 0x80, 0x00, 0xE8, 0x00,
  0x1C, 0x80, 0x01, 0x88, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC0, 0x80,
  0x18, 0x08, 0x03, 0x80, 0x80, 0x70, 0x08, 0x0E, 0x00, 0x81, 0xC0, 0x08,
  0x38, 0x00, 0x83, 0x00, 0x08, 0x60, 0x00, 0x8F, 0x00, 0x09, 0xB0, 0x00,
  0xB1, 0x80, 0x0E, 0x0C, 0x00, 0xC0, 0xE0, 0x08, 0x06, 0x00, 0x80, 0x30,
  0x08, 0x01, 0x80, 0x80, 0x1C, 0x08, 0x00, 0xE0, 0x80, 0x06, 0x08, 0x00,
  0x30, 0x80, 0x01, 0x88, 0x00, 0x1C, 0x80, 0x00, 0xC8, 0x00, 0x06, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xA0, 0x06, 0xF6, 0x00, 0xDE, 0xC0, 0x33, 0xCC, 0x06, 0x79, 0x80, 0xCF,
  0x30, 0x31, 0xE3, 0x06, 0x3C, 0x61, 0x87, 0x84, 0x30, 0xF0, 0xC6, 0x1E,
  0x19, 0x83, 0xC1, 0xB0, 0x78, 0x34, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x3C,
  0x0C, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x18, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xB0, 0x00, 0xF6, 0x00, 0x1E, 0x60, 0x03, 0xCC, 0x00, 0x78,
  0xC0, 0x0F, 0x0C, 0x01, 0xE1, 0x80, 0x3C, 0x18, 0x07, 0x83, 0x00, 0xF0,
  0x30, 0x1E, 0x06, 0x03, 0xC0, 0x60, 0x78, 0x0C, 0x0F, 0x00, 0xC1, 0xE0,
  0x0C, 0x3C, 0x01, 0x87, 0x80, 0x18, 0xF0, 0x03, 0x1E, 0x00, 0x33, 0xC0,
  0x06, 0x78, 0x00, 0x6F, 0x00, 0x0D, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xC1, 0xC0,
  0x38, 0x03, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00,
  0x0C, 0x60, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x01, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x01, 0x81, 0x80, 0x1C, 0x06, 0x01, 0xC0, 0x1E,
  0x3C, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x18, 0x03, 0xE3, 0x00, 0x0E, 0x60,
  0x00, 0xEC, 0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xB0, 0x00, 0x66, 0x00, 0x38, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFC, 0x00,
  0x78, 0x38, 0x03, 0x80, 0x30, 0x1C, 0x00, 0x60, 0x60, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x02,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x1C,
  0x00, 0x60, 0x38, 0x03, 0x00, 0x7C, 0x78, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x20, 0xFF, 0xF0, 0x10, 0x0F, 0x82, 0x00, 0x18, 0x40, 0x01,
  0x88, 0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00,
  0xD0, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x19, 0x00, 0x07,
  0x20, 0x01, 0xC4, 0x00, 0x70, 0xFF, 0xF8, 0x1F, 0xFE, 0x02, 0x00, 0xC0,
  0x40, 0x0C, 0x08, 0x01, 0x81, 0x00, 0x18, 0x20, 0x03, 0x84, 0x00, 0x30,
  0x80, 0x03, 0x10, 0x00, 0x62, 0x00, 0x06, 0x40, 0x00, 0xC8, 0x00, 0x0D,
  0x00, 0x01, 0xA0, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xC0,
  0xE0, 0x38, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x39, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x13, 0x00, 0x00, 0x58, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xD8, 0x00, 0x0C, 0xE0, 0x00, 0x63, 0x00, 0x07, 0x0E, 0x00, 0x70,
  0x3E, 0x1F, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xDC, 0x00, 0x19, 0x80, 0x06, 0x18,
  0x01, 0xC3, 0x80, 0x70, 0x3C, 0x3C, 0x01, 0xFE, 0x00, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x80, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x10, 0x03, 0x00,
  0x60, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x04, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0xC0, 0x01, 0x82, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1A, 0x01, 0xC0, 0x34, 0x03,
  0x80, 0x6C, 0x05, 0x80, 0x98, 0x1B, 0x01, 0x30, 0x36, 0x06, 0x60, 0x64,
  0x0C, 0xC0, 0xC8, 0x18, 0x81, 0x18, 0x31, 0x02, 0x30, 0x43, 0x0C, 0x60,
  0x86, 0x18, 0xC1, 0x0C, 0x30, 0x86, 0x18, 0x41, 0x8C, 0x30, 0x83, 0x18,
  0x23, 0x06, 0x30, 0x66, 0x0C, 0x40, 0xCC, 0x08, 0x81, 0x90, 0x1B, 0x03,
  0x20, 0x36, 0x06, 0xC0, 0x6C, 0x05, 0x80, 0xD8, 0x0B, 0x00, 0xB0, 0x1E,
  0x01, 0x40, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x00, 0x19, 0x80, 0x00, 0xC3, 0x00,
  0x07, 0x0C, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x70, 0x03, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x18, 0xE0, 0x00,
  0x63, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00,
  0x03, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0x33, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1D, 0x80, 0x00,
  0x66, 0x00, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x06, 0x18, 0x00, 0x08, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0x58, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0xFF, 0xF0, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x07, 0xFF, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x04, 0x30, 0x0C, 0x30, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x06,
  0x60, 0x02, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xC3, 0x06,
  0x0C, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x70, 0x3C, 0x18, 0x01, 0xC6, 0x00,
  0x18, 0xC0, 0x01, 0xB0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x03, 0xFF, 0xE1, 0xF8, 0x0C, 0x70, 0x01, 0x98, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0xEE, 0x00, 0x3C, 0xE0, 0x1D, 0x8F, 0x0F, 0x30, 0xFF, 0x83, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x70, 0x08, 0xFF, 0x82, 0x70,
  0x70, 0xB0, 0x06, 0x38, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x06, 0x80, 0x01,
  0xA0, 0x00, 0x68, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x68, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x03, 0x38, 0x01, 0xCB, 0x00, 0xE2, 0x78, 0xF0, 0x87, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x78, 0x3C, 0x1C, 0x01, 0xC3, 0x00,
  0x18, 0xC0, 0x01, 0x98, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00,
  0x63, 0x00, 0x18, 0x30, 0x07, 0x03, 0x87, 0x80, 0x3F, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x30, 0xFF, 0x8C, 0x70,
  0x33, 0x38, 0x06, 0xDC, 0x00, 0xF6, 0x00, 0x1D, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x01, 0xCC, 0x00, 0x73, 0x80, 0x6C, 0x78, 0xF3, 0x07, 0xF8,
  0xC0, 0x00, 0x78, 0x00, 0x3F, 0xE0, 0x07, 0x07, 0x80, 0xC0, 0x1C, 0x18,
  0x00, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x34,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x60, 0xE0, 0x0E, 0x07, 0x83, 0x80, 0x1F,
  0xF0, 0x00, 0x01, 0x80, 0x03, 0xFF, 0x00, 0x78, 0x10, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x31, 0xC0, 0xCC, 0xE0, 0x1B, 0x70,
  0x03, 0xD8, 0x00, 0x76, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x07, 0x30,
  0x03, 0xCE, 0x01, 0xB1, 0xE1, 0xCC, 0x1F, 0xE3, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x20, 0x01, 0x98, 0x00, 0xC3, 0x80, 0x70,
  0x7C, 0xF0, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x1C, 0x0C, 0x3F, 0xE3, 0x1C, 0x1C, 0xCC, 0x01, 0xB6, 0x00,
  0x7F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0xF0,
  0x03, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x0E, 0x20, 0xF0, 0xFF, 0x80, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0B, 0x00, 0x0E, 0x60, 0x03,
  0x8C, 0x00, 0xE1, 0x80, 0x38, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xC0,
  0x18, 0x70, 0x03, 0x1C, 0x00, 0x67, 0x00, 0x0D, 0xF0, 0x01, 0xF6, 0x00,
  0x38, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0xE0,
  0x60, 0x0E, 0x0C, 0x00, 0xE1, 0x80, 0x0E, 0x30, 0x00, 0xC6, 0x00, 0x0C,
  0xC0, 0x00, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0xE1, 0xBF, 0x87, 0xF3,
  0xC1, 0xB8, 0x77, 0x01, 0xC0, 0x6C, 0x03, 0x80, 0xD8, 0x06, 0x00, 0xB0,
  0x0C, 0x01, 0xE0, 0x18, 0x03, 0xC0, 0x30, 0x07, 0x80, 0x60, 0x0F, 0x00,
  0xC0, 0x1E, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x78, 0x06, 0x00, 0xF0, 0x0C,
  0x01, 0xE0, 0x18, 0x03, 0xC0, 0x30, 0x07, 0x80, 0x60, 0x0F, 0x00, 0xC0,
  0x1E, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x78, 0x06, 0x00, 0xF0, 0x0C, 0x01,
  0xE0, 0x18, 0x03, 0x00, 0x70, 0x30, 0xFF, 0x8C, 0x70, 0x73, 0x30, 0x06,
  0xD8, 0x01, 0xBC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x7F, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x18, 0x38, 0x00, 0xC3, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x63, 0x00, 0x06, 0x38,
  0x00, 0xC1, 0xC0, 0x38, 0x0F, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0xE0, 0x18,
  0xFF, 0x83, 0x38, 0x38, 0x6C, 0x01, 0x8F, 0x00, 0x19, 0xC0, 0x03, 0x38,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x02, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x70, 0x00, 0xCF, 0x00, 0x39, 0xB0,
  0x0E, 0x33, 0x87, 0x86, 0x1F, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x31, 0xC0, 0xEC, 0xE0,
  0x1F, 0x70, 0x03, 0xD8, 0x00, 0x76, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x07, 0x30, 0x01, 0xCE, 0x01, 0xF1, 0xE1, 0xCC, 0x1F, 0xE3, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x7D, 0x87, 0xFF, 0x1E,
  0x0E, 0x60, 0x0D, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0x78, 0x1E, 0x18,
  0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x0C, 0x70, 0x03, 0x87, 0x83, 0xE0, 0x3F,
  0xF0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x0F, 0xFF, 0xF8, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0xC1, 0x00, 0x7F, 0xC0, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36,
  0x00, 0x1C, 0xC0, 0x0F, 0x38, 0x06, 0xC7, 0x8F, 0x30, 0xFF, 0x8C, 0xE0,
  0x00, 0x0D, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0x60, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x03, 0x01, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x00, 0x86, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x03, 0x60, 0x1C, 0x03, 0x60, 0x1C, 0x03,
  0x60, 0x14, 0x02, 0x20, 0x34, 0x06, 0x30, 0x36, 0x06, 0x30, 0x36, 0x06,
  0x30, 0x26, 0x04, 0x30, 0x62, 0x04, 0x10, 0x63, 0x0C, 0x18, 0x63, 0x0C,
  0x18, 0x43, 0x0C, 0x18, 0xC1, 0x08, 0x08, 0xC1, 0x98, 0x0C, 0x81, 0x98,
  0x0C, 0x81, 0x98, 0x0D, 0x80, 0x90, 0x0D, 0x80, 0xD0, 0x05, 0x00, 0xF0,
  0x07, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x02, 0x00, 0x60,
  0xE0, 0x00, 0x39, 0x80, 0x03, 0x06, 0x00, 0x30, 0x38, 0x03, 0x80, 0xC0,
  0x38, 0x03, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x31, 0x80, 0x01, 0xDC, 0x00,
  0x06, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xEC,
  0x00, 0x06, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x03, 0x00, 0x70, 0x1C, 0x03,
  0x00, 0x60, 0x30, 0x01, 0x83, 0x00, 0x06, 0x38, 0x00, 0x3B, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x63, 0x80, 0x00,
  0xC3, 0x00, 0x03, 0x07, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x00,
  0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x13, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0xF8, 0x03, 0x80,
  0x07, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x7C, 0x00, 0x70, 0x07, 0x80, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x30, 0x70,
  0x03, 0x60, 0x38, 0x03, 0x60, 0x1C, 0x06, 0x40, 0x07, 0x0C, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x70,
};

const GFXglyph RobotoMono_ExtraLight44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 3, 31, 26, 11, -31 },
  { 13, 8, 9, 26, 9, -33 },
  { 22, 24, 31, 26, 1, -31 },
  { 115, 19, 40, 26, 4, -36 },
  { 210, 24, 32, 26, 1, -32 },
  { 306, 22, 32, 26, 3, -32 },
  { 394, 2, 9, 26, 11, -33 },
  { 397, 10, 45, 26, 8, -35 },
  { 454, 9, 45, 26, 8, -35 },
  { 505, 19, 18, 26, 4, -31 },
  { 548, 21, 23, 26, 3, -26 },
  { 609, 3, 10, 26, 9, -4 },
  { 613, 16, 2, 26, 5, -15 },
  { 617, 4, 3, 26, 12, -3 },
  { 619, 15, 34, 26, 6, -31 },
  { 683, 19, 32, 26, 4, -32 },
  { 759, 11, 31, 26, 5, -31 },
  { 802, 20, 32, 26, 2, -32 },
  { 882, 20, 32, 26, 2, -32 },
  { 962, 22, 31, 26, 2, -31 },
  { 1048, 18, 31, 26, 5, -31 },
  { 1118, 20, 32, 26, 3, -32 },
  { 1198, 20, 31, 26, 3, -31 },
  { 1276, 20, 32, 26, 4, -32 },
  { 1356, 20, 32, 26, 3, -32 },
  { 1436, 4, 22, 26, 13, -22 },
  { 1447, 5, 28, 26, 12, -22 },
  { 1465, 18, 18, 26, 4, -23 },
  { 1506, 19, 11, 26, 4, -20 },
  { 1533, 19, 18, 26, 4, -23 },
  { 1576, 17, 32, 26, 5, -32 },
  { 1644, 24, 32, 26, 1, -32 },
  { 1740, 23, 31, 26, 2, -31 },
  { 1830, 20, 31, 26, 4, -31 },
  { 1908, 20, 32, 26, 3, -32 },
  { 1988, 20, 31, 26, 4, -31 },
  { 2066, 18, 31, 26, 5, -31 },
  { 2136, 18, 31, 26, 5, -31 },
  { 2206, 20, 32, 26, 3, -32 },
  { 2286, 19, 31, 26, 4, -31 },
  { 2360, 18, 31, 26, 4, -31 },
  { 2430, 19, 31, 26, 3, -31 },
  { 2504, 20, 31, 26, 5, -31 },
  { 2582, 18, 31, 26, 5, -31 },
  { 2652, 19, 31, 26, 4, -31 },
  { 2726, 19, 31, 26, 4, -31 },
  { 2800, 21, 32, 26, 3, -32 },
  { 2884, 19, 31, 26, 5, -31 },
  { 2958, 22, 38, 26, 2, -32 },
  { 3063, 19, 31, 26, 5, -31 },
  { 3137, 21, 32, 26, 3, -32 },
  { 3221, 22, 31, 26, 2, -31 },
  { 3307, 19, 31, 26, 4, -31 },
  { 3381, 22, 31, 26, 2, -31 },
  { 3467, 23, 31, 26, 2, -31 },
  { 3557, 22, 31, 26, 3, -31 },
  { 3643, 22, 31, 26, 2, -31 },
  { 3729, 20, 31, 26, 3, -31 },
  { 3807, 7, 43, 26, 10, -36 },
  { 3845, 15, 34, 26, 6, -31 },
  { 3909, 6, 43, 26, 10, -36 },
  { 3942, 16, 17, 26, 5, -31 },
  { 3976, 18, 2, 26, 4, 0 },
  { 3981, 6, 5, 26, 10, -32 },
  { 3985, 19, 24, 26, 4, -24 },
  { 4042, 18, 33, 26, 5, -33 },
  { 4117, 19, 24, 26, 4, -24 },
  { 4174, 18, 33, 26, 4, -33 },
  { 4249, 20, 24, 26, 3, -24 },
  { 4309, 20, 34, 26, 4, -34 },
  { 4394, 18, 33, 26, 4, -24 },
  { 4469, 18, 33, 26, 4, -33 },
  { 4544, 18, 32, 26, 5, -32 },
  { 4616, 14, 41, 26, 4, -32 },
  { 4688, 19, 33, 26, 5, -33 },
  { 4767, 18, 33, 26, 5, -33 },
  { 4842, 23, 24, 26, 2, -24 },
  { 4911, 18, 24, 26, 4, -24 },
  { 4965, 20, 24, 26, 3, -24 },
  { 5025, 19, 33, 26, 4, -24 },
  { 5104, 18, 33, 26, 4, -24 },
  { 5179, 15, 24, 26, 8, -24 },
  { 5224, 19, 24, 26, 4, -24 },
  { 5281, 18, 29, 26, 4, -29 },
  { 5347, 18, 23, 26, 4, -23 },
  { 5399, 22, 23, 26, 2, -23 },
  { 5463, 24, 23, 26, 1, -23 },
  { 5532, 21, 23, 26, 3, -23 },
  { 5593, 23, 32, 26, 2, -23 },
  { 5685, 21, 23, 26, 3, -23 },
  { 5746, 14, 43, 26, 7, -34 },
  { 5822, 2, 37, 26, 12, -31 },
  { 5832, 14, 43, 26, 7, -34 },
  { 5908, 24, 8, 26, 1, -17 },
};

const GFXfont RobotoMono_ExtraLight44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight44pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_EXTRALIGHT44PT7B_H_
