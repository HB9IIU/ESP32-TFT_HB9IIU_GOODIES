#ifndef _ROBOTOMONO_EXTRALIGHT59PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight59pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xF7, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xD8, 0x1B,
  0x03, 0x60, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x30, 0x03, 0x01, 0xC0, 0x18, 0x03, 0x80, 0xC0, 0x0C, 0x01, 0x80,
  0x60, 0x06, 0x01, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x01, 0x80, 0xE0,
  0x0E, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x60, 0x70, 0x01, 0x80, 0x30, 0x30,
  0x00, 0xE0, 0x38, 0x30, 0x00, 0x30, 0x38, 0x18, 0x00, 0x0E, 0x78, 0x18,
  0x00, 0x03, 0xF8, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0x81, 0xFE, 0x00, 0x01,
  0x81, 0xE7, 0x80, 0x00, 0xC1, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x30, 0x00,
  0xE0, 0xE0, 0x18, 0x00, 0x60, 0x60, 0x06, 0x00, 0x70, 0x30, 0x03, 0x00,
  0x30, 0x18, 0x01, 0x80, 0x38, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x0C,
  0x02, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x60, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x18, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x70,
  0x1C, 0x00, 0xE3, 0x80, 0x38, 0x03, 0x0C, 0x00, 0xF0, 0x0C, 0x70, 0x01,
  0xC0, 0x31, 0x80, 0x03, 0x81, 0xC6, 0x00, 0x07, 0x07, 0x38, 0x00, 0x0E,
  0x18, 0xE0, 0x00, 0x1C, 0xE3, 0x80, 0x00, 0x73, 0x8E, 0x00, 0x00, 0xFC,
  0x18, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1F, 0x03,
  0x80, 0x00, 0xFC, 0x07, 0x00, 0x07, 0x38, 0x0F, 0x00, 0x78, 0x70, 0x1F,
  0xFF, 0x80, 0xE0, 0x1F, 0xFC, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xDB, 0x60, 0x00, 0x08, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x06,
  0x00, 0x08, 0x40, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x1C, 0x01, 0x80, 0x08, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x0C, 0x03, 0xFE, 0x06,
  0x0F, 0xDF, 0xE3, 0x1F, 0xC1, 0xFD, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x60, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x18, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xC6, 0x73, 0xB9, 0x84, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03,
  0xEC, 0x00, 0x01, 0xDF, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x71, 0xF0, 0x00,
  0x38, 0x7C, 0x00, 0x1C, 0x1F, 0x00, 0x0E, 0x07, 0xC0, 0x07, 0x01, 0xF0,
  0x03, 0x80, 0x7C, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x07, 0xC0, 0x70, 0x01,
  0xF0, 0x38, 0x00, 0x7C, 0x1C, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0xE7, 0x00,
  0x01, 0xFB, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1B, 0xE0, 0x00, 0x06, 0xF0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x1F, 0xF0, 0xFC, 0xE7,
  0xC1, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x08, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x70, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x01, 0xF0,
  0x1E, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xC0, 0x00,
  0x0C, 0x70, 0x00, 0x03, 0x98, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0x70, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0x78, 0x00, 0x38, 0x0F, 0x80, 0x3C,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x30, 0x01, 0x80, 0x01,
  0x80, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x39, 0xFF, 0xC0,
  0x1B, 0xFF, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0x80, 0x0F, 0x83, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x60,
  0x00, 0x03, 0xB0, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x1F, 0x83, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x20, 0x01, 0xC1,
  0xFF, 0x80, 0x61, 0xFF, 0xF8, 0x19, 0xF0, 0x0F, 0x06, 0xF0, 0x01, 0xE1,
  0xB0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x03, 0x80, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x1B,
  0x3C, 0x00, 0x1D, 0x8F, 0x00, 0x1C, 0xC3, 0xE0, 0x7C, 0x60, 0xFF, 0xF8,
  0x70, 0x1F, 0xF8, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xF7, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xBF, 0xEF, 0x00, 0x3C, 0x78, 0xF9, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x30,
  0xE1, 0x87, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0x78, 0x3C, 0x00, 0x71, 0xC0, 0x00,
  0xE7, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x40, 0x0C, 0x18, 0x03, 0xF8, 0x0E, 0x38,
  0x0F, 0xFC, 0x06, 0x30, 0x1C, 0x0E, 0x06, 0x70, 0x18, 0x06, 0x06, 0x60,
  0x30, 0x06, 0x06, 0x60, 0x30, 0x04, 0x06, 0x60, 0x60, 0x0C, 0x03, 0xC0,
  0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0xC0, 0x0C, 0x03, 0xC0,
  0xC0, 0x0C, 0x03, 0xC0, 0xC0, 0x0C, 0x03, 0xC0, 0xC0, 0x0C, 0x03, 0xC0,
  0xC0, 0x0C, 0x06, 0xC0, 0xC0, 0x0C, 0x06, 0xC0, 0xC0, 0x18, 0x06, 0xC0,
  0xC0, 0x18, 0x06, 0xC0, 0xC0, 0x18, 0x06, 0xC0, 0xC0, 0x38, 0x04, 0xC0,
  0xC0, 0x2C, 0x0C, 0xC0, 0x60, 0x6C, 0x0C, 0xE0, 0x60, 0xCC, 0x18, 0x60,
  0x7F, 0x8E, 0x70, 0x60, 0x3F, 0x07, 0xE0, 0x70, 0x0C, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x01, 0xC0,
  0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x7F, 0x03, 0x00, 0x01, 0xE0, 0xC0, 0x00,
  0x3C, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x0F, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0C, 0x00, 0x03, 0xC3,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x03,
  0x8C, 0x00, 0x03, 0xC3, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0x38, 0x00, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0x80, 0x3F, 0x80, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x78, 0x38, 0x00, 0x3E, 0x07, 0x00, 0x3F, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xE0, 0x1F,
  0x00, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x3C,
  0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x1E, 0x01,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0xE7, 0xE0, 0x00,
  0x0E, 0xF7, 0x00, 0x00, 0xFE, 0x38, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0xF8,
  0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xD8, 0x00, 0x06,
  0xF6, 0x00, 0x03, 0xBD, 0xC0, 0x00, 0xEF, 0x30, 0x00, 0x33, 0xCE, 0x00,
  0x1C, 0xF1, 0x80, 0x06, 0x3C, 0x60, 0x03, 0x8F, 0x1C, 0x00, 0xE3, 0xE3,
  0x00, 0x30, 0xF8, 0xC0, 0x1C, 0x3E, 0x38, 0x06, 0x0F, 0x86, 0x03, 0x83,
  0xE1, 0xC0, 0xE0, 0xF8, 0x70, 0x30, 0x3E, 0x0C, 0x1C, 0x0F, 0x83, 0x86,
  0x03, 0xE0, 0x63, 0x80, 0xF8, 0x18, 0xE0, 0x3E, 0x07, 0x30, 0x0F, 0x80,
  0xDC, 0x03, 0xE0, 0x36, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x0F,
  0x80, 0x70, 0x03, 0xE0, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xF6, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x1F,
  0x38, 0x00, 0x07, 0xCE, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x7C, 0x30, 0x00,
  0x1F, 0x0E, 0x00, 0x07, 0xC1, 0x80, 0x01, 0xF0, 0x70, 0x00, 0x7C, 0x0C,
  0x00, 0x1F, 0x03, 0x80, 0x07, 0xC0, 0x70, 0x01, 0xF0, 0x1C, 0x00, 0x7C,
  0x03, 0x80, 0x1F, 0x00, 0x60, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x03, 0x00,
  0x7C, 0x00, 0xE0, 0x1F, 0x00, 0x18, 0x07, 0xC0, 0x07, 0x01, 0xF0, 0x00,
  0xE0, 0x7C, 0x00, 0x38, 0x1F, 0x00, 0x07, 0x07, 0xC0, 0x00, 0xC1, 0xF0,
  0x00, 0x38, 0x7C, 0x00, 0x06, 0x1F, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x31,
  0xF0, 0x00, 0x0E, 0x7C, 0x00, 0x01, 0xDF, 0x00, 0x00, 0x77, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0C, 0x00,
  0x3F, 0x83, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x1E, 0x30, 0x00, 0x03, 0xCC,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x1E,
  0x30, 0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xE0,
  0x1E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0E, 0x00, 0x3F, 0x03, 0x80, 0x01, 0xE0,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x60, 0x0E,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x38,
  0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x07,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x38, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x3C, 0x00,
  0x6E, 0x00, 0x78, 0x00, 0xDC, 0x00, 0xF0, 0x01, 0x98, 0x01, 0xF0, 0x03,
  0x30, 0x03, 0x60, 0x0E, 0x60, 0x06, 0xC0, 0x1C, 0xC0, 0x1D, 0x80, 0x31,
  0xC0, 0x33, 0x00, 0x63, 0x80, 0x67, 0x00, 0xC7, 0x00, 0xC6, 0x01, 0x86,
  0x01, 0x8C, 0x03, 0x0C, 0x07, 0x18, 0x0E, 0x18, 0x0C, 0x30, 0x1C, 0x30,
  0x18, 0x70, 0x30, 0x70, 0x30, 0xE0, 0x60, 0xE0, 0x60, 0xC0, 0xC0, 0xC1,
  0xC1, 0x81, 0x81, 0x83, 0x03, 0x03, 0x03, 0x06, 0x07, 0x0E, 0x06, 0x0C,
  0x0E, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x1C, 0x70, 0x18, 0x60, 0x38, 0xE0,
  0x30, 0xC0, 0x31, 0x80, 0x71, 0x80, 0x63, 0x00, 0xE3, 0x00, 0xC6, 0x00,
  0xCE, 0x01, 0x9C, 0x01, 0x98, 0x03, 0xB8, 0x03, 0x30, 0x07, 0x60, 0x06,
  0x60, 0x0E, 0xC0, 0x0E, 0xC0, 0x0D, 0x80, 0x0D, 0x80, 0x1B, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x70, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0D, 0xC0, 0x00, 0xEE, 0x00, 0x06, 0x30, 0x00, 0x31, 0xC0, 0x03, 0x86,
  0x00, 0x18, 0x38, 0x01, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x38, 0x07,
  0x00, 0xC0, 0x30, 0x07, 0x03, 0x80, 0x18, 0x18, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x18, 0x60, 0x00, 0xE7, 0x00, 0x03, 0x30, 0x00, 0x1F, 0x80,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38,
  0x18, 0x1C, 0x0E, 0x07, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0x03, 0x87,
  0xC0, 0x00, 0xE3, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x7E, 0x78,
  0x00, 0x7B, 0x8F, 0x80, 0x7C, 0xE1, 0xFF, 0xFC, 0x38, 0x1F, 0xFC, 0x07,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0xE0, 0x07, 0x0F, 0xFE, 0x03,
  0x9F, 0xFF, 0x81, 0xDE, 0x01, 0xE0, 0xFC, 0x00, 0x38, 0x7C, 0x00, 0x0E,
  0x3C, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70,
  0x00, 0x01, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x71, 0xF0, 0x00, 0x38, 0xFC, 0x00, 0x38,
  0x77, 0x80, 0x78, 0x39, 0xFF, 0xF8, 0x1C, 0x3F, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xF0,
  0x07, 0x80, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x8E, 0x00,
  0x01, 0xC3, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x3E, 0x03,
  0x01, 0xFF, 0x83, 0x07, 0xFF, 0xE3, 0x0F, 0x00, 0x73, 0x1E, 0x00, 0x3B,
  0x1C, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x03,
  0x30, 0x00, 0x07, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x3B,
  0x0F, 0x80, 0xF3, 0x03, 0xFF, 0xE3, 0x01, 0xFF, 0x83, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x00,
  0xF0, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0x98, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x10, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x01, 0xF0,
  0x07, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x0C, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x83, 0x07, 0xFF, 0xE3,
  0x0F, 0x00, 0x73, 0x1E, 0x00, 0x3B, 0x1C, 0x00, 0x1F, 0x38, 0x00, 0x0F,
  0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x70, 0x00, 0x03, 0x70, 0x00, 0x03, 0x30, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x3B, 0x0F, 0x80, 0xF3, 0x03, 0xFF, 0xE3,
  0x01, 0xFF, 0x83, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x1F, 0x00, 0xC0, 0xFF, 0xE0, 0xC1, 0xFF, 0xF0,
  0xC7, 0x80, 0x78, 0xCE, 0x00, 0x1C, 0xCC, 0x00, 0x0E, 0xD8, 0x00, 0x0E,
  0xF0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xF3, 0x00, 0x00, 0xF1, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x0C, 0x01,
  0xE0, 0x06, 0x01, 0xE0, 0x03, 0x01, 0xE0, 0x01, 0x81, 0xE0, 0x00, 0xC1,
  0xE0, 0x00, 0x61, 0xC0, 0x00, 0x31, 0xE0, 0x00, 0x19, 0xF8, 0x00, 0x0D,
  0xCE, 0x00, 0x07, 0xC3, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0x78, 0x00,
  0xC0, 0x1E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x18, 0x00, 0x70,
  0x0C, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0xF0, 0xC0, 0x00, 0x3C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x98, 0x00,
  0x00, 0xF0, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x07, 0x83, 0x3F, 0xE0, 0xFF, 0x8D, 0xFF, 0xC7,
  0xFF, 0x3E, 0x03, 0xB8, 0x0E, 0xF0, 0x07, 0xC0, 0x1B, 0x80, 0x1E, 0x00,
  0x7E, 0x00, 0x70, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x1F,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00,
  0xC0, 0x03, 0x00, 0x1F, 0x00, 0xC0, 0xFF, 0xE0, 0xC3, 0xFF, 0xF0, 0xC7,
  0x80, 0x78, 0xCE, 0x00, 0x1C, 0xCC, 0x00, 0x0E, 0xD8, 0x00, 0x0E, 0xF0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0x70,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0xE0, 0x0F, 0x80, 0x78, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x60, 0xFF, 0xE0,
  0x31, 0xFF, 0xF8, 0x19, 0xE0, 0x1E, 0x0D, 0xC0, 0x03, 0x87, 0xC0, 0x00,
  0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x1F, 0x00, 0x07, 0x8F, 0xC0, 0x07,
  0x87, 0x78, 0x07, 0x83, 0x9F, 0xFF, 0x81, 0xC3, 0xFF, 0x00, 0xE0, 0x08,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0x83, 0x07, 0xFF, 0xE3, 0x0F, 0x00, 0x73,
  0x1E, 0x00, 0x3B, 0x1C, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x07,
  0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x70, 0x00, 0x03, 0x30, 0x00, 0x07, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x0F,
  0x1E, 0x00, 0x3B, 0x0F, 0x00, 0x73, 0x03, 0xFF, 0xE3, 0x01, 0xFF, 0x83,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x0F, 0xCC, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3C, 0x00, 0xC7, 0x00,
  0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xC0, 0x0F, 0x83, 0x80, 0x01, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0xE0, 0xF0, 0x03, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x60, 0x00, 0x0F,
  0x70, 0x00, 0x1F, 0x70, 0x00, 0x3F, 0x38, 0x00, 0x77, 0x1E, 0x01, 0xE7,
  0x0F, 0xFF, 0xC7, 0x03, 0xFF, 0x07, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x70, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x80, 0x06, 0x60, 0x03,
  0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x0E, 0x70, 0x03,
  0xC0, 0x0E, 0x30, 0x06, 0xE0, 0x0C, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x06,
  0x60, 0x0C, 0x38, 0x06, 0x60, 0x1C, 0x38, 0x0C, 0x70, 0x18, 0x18, 0x0C,
  0x30, 0x18, 0x18, 0x0C, 0x30, 0x18, 0x18, 0x0C, 0x30, 0x38, 0x1C, 0x18,
  0x38, 0x38, 0x0C, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x18, 0x30, 0x0C, 0x18,
  0x18, 0x30, 0x0E, 0x30, 0x1C, 0x70, 0x0E, 0x30, 0x0C, 0x60, 0x06, 0x30,
  0x0C, 0x60, 0x06, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x07, 0x60,
  0x06, 0xC0, 0x03, 0x60, 0x06, 0xC0, 0x03, 0x60, 0x06, 0xC0, 0x03, 0xC0,
  0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x1F, 0xFC, 0x00, 0x06,
  0x38, 0x1E, 0x00, 0x06, 0x70, 0x07, 0x00, 0x06, 0x60, 0x03, 0xC0, 0x0E,
  0xE0, 0x01, 0xE0, 0x1C, 0xC0, 0x00, 0xF0, 0x3C, 0xC0, 0x00, 0x3F, 0xF8,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0x00,
};

const GFXglyph RobotoMono_ExtraLight59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 4, 42, 35, 15, -42 },
  { 22, 11, 12, 35, 12, -44 },
  { 39, 32, 42, 35, 2, -42 },
  { 207, 26, 54, 35, 5, -48 },
  { 383, 33, 44, 35, 1, -43 },
  { 565, 30, 44, 35, 4, -43 },
  { 730, 3, 12, 35, 15, -44 },
  { 735, 14, 61, 35, 11, -47 },
  { 842, 13, 61, 35, 10, -47 },
  { 942, 25, 24, 35, 6, -42 },
  { 1017, 29, 31, 35, 3, -35 },
  { 1130, 5, 13, 35, 12, -5 },
  { 1139, 21, 2, 35, 7, -20 },
  { 1145, 5, 4, 35, 16, -4 },
  { 1148, 20, 46, 35, 8, -42 },
  { 1263, 26, 44, 35, 5, -43 },
  { 1406, 15, 42, 35, 6, -42 },
  { 1485, 27, 43, 35, 3, -43 },
  { 1631, 26, 44, 35, 3, -43 },
  { 1774, 29, 42, 35, 3, -42 },
  { 1927, 25, 43, 35, 6, -42 },
  { 2062, 26, 43, 35, 4, -42 },
  { 2202, 27, 42, 35, 4, -42 },
  { 2344, 27, 44, 35, 5, -43 },
  { 2493, 25, 43, 35, 5, -43 },
  { 2628, 5, 29, 35, 18, -29 },
  { 2647, 7, 37, 35, 16, -29 },
  { 2680, 25, 24, 35, 5, -31 },
  { 2755, 26, 14, 35, 5, -26 },
  { 2801, 25, 24, 35, 5, -31 },
  { 2876, 22, 43, 35, 7, -43 },
  { 2995, 32, 42, 35, 2, -42 },
  { 3163, 30, 42, 35, 3, -42 },
  { 3321, 26, 42, 35, 6, -42 },
  { 3458, 27, 44, 35, 4, -43 },
  { 3607, 27, 42, 35, 5, -42 },
  { 3749, 24, 42, 35, 6, -42 },
  { 3875, 25, 42, 35, 6, -42 },
  { 4007, 27, 44, 35, 4, -43 },
  { 4156, 26, 42, 35, 5, -42 },
  { 4293, 24, 42, 35, 6, -42 },
  { 4419, 26, 43, 35, 3, -42 },
  { 4559, 28, 42, 35, 6, -42 },
  { 4706, 24, 42, 35, 7, -42 },
  { 4832, 26, 42, 35, 5, -42 },
  { 4969, 26, 42, 35, 5, -42 },
  { 5106, 28, 44, 35, 4, -43 },
  { 5260, 26, 42, 35, 7, -42 },
  { 5397, 29, 50, 35, 3, -43 },
  { 5579, 26, 42, 35, 6, -42 },
  { 5716, 28, 44, 35, 4, -43 },
  { 5870, 30, 42, 35, 3, -42 },
  { 6028, 26, 43, 35, 5, -42 },
  { 6168, 29, 42, 35, 3, -42 },
  { 6321, 31, 42, 35, 3, -42 },
  { 6484, 30, 42, 35, 3, -42 },
  { 6642, 30, 42, 35, 2, -42 },
  { 6800, 26, 42, 35, 4, -42 },
  { 6937, 10, 57, 35, 13, -48 },
  { 7009, 20, 46, 35, 8, -42 },
  { 7124, 9, 57, 35, 13, -48 },
  { 7189, 21, 23, 35, 7, -42 },
  { 7250, 25, 2, 35, 5, 0 },
  { 7257, 8, 7, 35, 14, -43 },
  { 7264, 26, 33, 35, 5, -32 },
  { 7372, 25, 45, 35, 6, -44 },
  { 7513, 25, 33, 35, 5, -32 },
  { 7617, 24, 45, 35, 5, -44 },
  { 7752, 26, 33, 35, 5, -32 },
  { 7860, 26, 45, 35, 6, -45 },
  { 8007, 24, 44, 35, 5, -32 },
  { 8139, 24, 44, 35, 6, -44 },
  { 8271, 24, 42, 35, 7, -42 },
  { 8397, 19, 55, 35, 5, -42 },
  { 8528, 25, 44, 35, 7, -44 },
  { 8666, 24, 44, 35, 7, -44 },
  { 8798, 30, 32, 35, 3, -32 },
  { 8918, 24, 32, 35, 6, -32 },
  { 9014, 27, 33, 35, 4, -32 },
  { 9126, 25, 44, 35, 6, -32 },
  { 9264, 24, 44, 35, 5, -32 },
  { 9396, 20, 32, 35, 11, -32 },
  { 9476, 25, 33, 35, 6, -32 },
  { 9580, 25, 40, 35, 5, -39 },
  { 9705, 24, 32, 35, 6, -31 },
  { 9801, 29, 31, 35, 3, -31 },
  { 9914, 32, 31, 35, 2, -31 },
  { 10038, 28, 31, 35, 4, -31 },
  { 10147, 31, 44, 35, 2, -31 },
  { 10318, 28, 31, 35, 4, -31 },
  { 10427, 19, 58, 35, 10, -46 },
  { 10565, 2, 51, 35, 17, -42 },
  { 10578, 19, 58, 35, 10, -46 },
  { 10716, 32, 11, 35, 2, -23 },
};

const GFXfont RobotoMono_ExtraLight59pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight59pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _ROBOTOMONO_EXTRALIGHT59PT7B_H_
