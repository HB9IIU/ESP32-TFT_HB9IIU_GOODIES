#ifndef _ROBOTOMONO_EXTRALIGHT63PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight63pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xBF, 0xF7, 0x00, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xE0, 0x7E, 0x01, 0xE0, 0x03, 0xE0, 0x78, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x18, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x30, 0x03, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x1C, 0x07,
  0x00, 0x70, 0x03, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x0C,
  0x06, 0x00, 0x18, 0x01, 0x81, 0xC0, 0x03, 0x80, 0x70, 0x30, 0x00, 0x38,
  0x1C, 0x0E, 0x00, 0x03, 0x87, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x60, 0x00,
  0x03, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x80, 0x00, 0x06, 0x03, 0xFC, 0x00,
  0x01, 0x81, 0xE3, 0xC0, 0x00, 0x70, 0x38, 0x1C, 0x00, 0x0C, 0x0E, 0x01,
  0x80, 0x03, 0x81, 0x80, 0x38, 0x00, 0x60, 0x70, 0x03, 0x00, 0x1C, 0x0E,
  0x00, 0x60, 0x03, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x18,
  0x07, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x1C, 0x00, 0xC0,
  0x30, 0x03, 0x80, 0x18, 0x06, 0x00, 0x30, 0x03, 0x00, 0x40, 0x06, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x07,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x38, 0xE0, 0x1C, 0x00, 0x71, 0xC0, 0x1C, 0x00, 0xE7,
  0x00, 0x1C, 0x01, 0xCC, 0x00, 0x1C, 0x03, 0x38, 0x00, 0x3C, 0x0E, 0x70,
  0x00, 0x38, 0x1C, 0xC0, 0x00, 0x38, 0x39, 0x80, 0x00, 0x38, 0xE3, 0x00,
  0x00, 0x39, 0xC6, 0x00, 0x00, 0x7F, 0x0E, 0x00, 0x00, 0x7E, 0x1C, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xF0, 0x78, 0x00,
  0x0F, 0xF0, 0x78, 0x00, 0x3C, 0xE0, 0x7C, 0x01, 0xE0, 0xE0, 0x3F, 0xFF,
  0x80, 0xE0, 0x3F, 0xFC, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x40, 0x06, 0x00, 0x2F, 0x00, 0x60, 0x1E, 0xFE, 0x06,
  0x0F, 0xF3, 0xFC, 0x63, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x0E,
  0x00, 0x0F, 0x00, 0x60, 0x00, 0x40, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE7, 0x1C, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x7E, 0x00, 0x00, 0xE7, 0xE0,
  0x00, 0x1C, 0x7E, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x70, 0x7E, 0x00, 0x0E,
  0x07, 0xE0, 0x01, 0xC0, 0x7E, 0x00, 0x38, 0x07, 0xE0, 0x07, 0x00, 0x7E,
  0x00, 0xE0, 0x07, 0xE0, 0x1C, 0x00, 0x7E, 0x03, 0x80, 0x07, 0xE0, 0x70,
  0x00, 0x7E, 0x0E, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x7E, 0x78, 0x00, 0x07,
  0xEF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x0F, 0xF0, 0x7E, 0x63, 0xF0, 0xFF, 0x01, 0xF8, 0x03, 0xC0,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x1F, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x7F, 0xF0, 0x03, 0x7F, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x7C, 0x00,
  0x7E, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x1F,
  0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x7F, 0xE0, 0x1C, 0x3F, 0xFF, 0x03,
  0x8F, 0x81, 0xF0, 0x77, 0x80, 0x0F, 0x0F, 0xC0, 0x00, 0x71, 0xB0, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x1F, 0x00, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0x63, 0xC0, 0x01, 0xCC, 0x3C, 0x00,
  0x71, 0x83, 0xE0, 0x7C, 0x70, 0x3F, 0xFF, 0x0E, 0x01, 0xFF, 0x81, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x27, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xFF, 0xEE, 0x08, 0x7C,
  0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x70, 0xE1, 0xC7, 0x0E, 0x38, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF8, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x07, 0x00, 0x1E, 0x00, 0xE1, 0x80,
  0x3F, 0xE0, 0x38, 0xE0, 0x1F, 0x7C, 0x06, 0x30, 0x0E, 0x03, 0x01, 0x8C,
  0x03, 0x00, 0xC0, 0x67, 0x01, 0x80, 0x30, 0x1D, 0x80, 0x60, 0x0C, 0x03,
  0x60, 0x30, 0x03, 0x00, 0xD8, 0x0C, 0x00, 0xC0, 0x3E, 0x07, 0x00, 0x30,
  0x0F, 0x01, 0x80, 0x0C, 0x03, 0xC0, 0x60, 0x03, 0x00, 0xF0, 0x18, 0x01,
  0xC0, 0x3C, 0x06, 0x00, 0x60, 0x0F, 0x01, 0x80, 0x18, 0x03, 0xC0, 0xE0,
  0x06, 0x00, 0xF0, 0x38, 0x01, 0x80, 0x7C, 0x0E, 0x00, 0x60, 0x1B, 0x01,
  0x80, 0x38, 0x06, 0xC0, 0x60, 0x0E, 0x01, 0xB0, 0x18, 0x07, 0x80, 0x6C,
  0x06, 0x01, 0xE0, 0x33, 0x81, 0xC0, 0xD8, 0x0C, 0xE0, 0x30, 0x77, 0x06,
  0x18, 0x0E, 0x38, 0xE3, 0x86, 0x01, 0xFC, 0x3F, 0xC1, 0xC0, 0x3E, 0x03,
  0xE0, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x30, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0E, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x03, 0xE0, 0xE0, 0x01, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0E, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xF0, 0xE0, 0x01, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x0F,
  0x80, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0F, 0x0C,
  0x00, 0x00, 0x78, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x78,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x3C, 0x0C, 0x00,
  0x0F, 0x80, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x80, 0x7C, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xF6, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0xF1, 0x80, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x07, 0x80, 0x30,
  0x00, 0x78, 0x01, 0x80, 0x07, 0x80, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x03,
  0x80, 0x03, 0x00, 0x38, 0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x3C, 0x00,
  0x06, 0x03, 0xC0, 0x00, 0x30, 0x3C, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x0C,
  0x3C, 0x00, 0x00, 0x63, 0xF0, 0x00, 0x03, 0x1D, 0xC0, 0x00, 0x19, 0xCF,
  0x00, 0x00, 0xDC, 0x3C, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x3C, 0x03, 0x80,
  0x01, 0xC0, 0x1E, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xF0, 0x06, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01,
  0xE0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xBF, 0xC0, 0x00, 0x3B, 0xEC, 0x00, 0x03, 0xBE, 0xE0,
  0x00, 0x33, 0xEE, 0x00, 0x07, 0x3E, 0x60, 0x00, 0x63, 0xE7, 0x00, 0x0E,
  0x3E, 0x30, 0x00, 0xE3, 0xE3, 0x80, 0x0C, 0x3E, 0x38, 0x01, 0xC3, 0xE1,
  0x80, 0x18, 0x3E, 0x1C, 0x03, 0x83, 0xE1, 0xC0, 0x38, 0x3E, 0x0C, 0x03,
  0x03, 0xE0, 0xE0, 0x70, 0x3E, 0x06, 0x06, 0x07, 0xE0, 0x70, 0xE0, 0x7E,
  0x07, 0x0E, 0x07, 0xE0, 0x30, 0xC0, 0x7E, 0x03, 0x9C, 0x07, 0xE0, 0x39,
  0x80, 0x7E, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x07,
  0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xEC, 0x00, 0x00,
  0x7E, 0xE0, 0x00, 0x07, 0xE6, 0x00, 0x00, 0x7E, 0x70, 0x00, 0x07, 0xE3,
  0x80, 0x00, 0x7E, 0x38, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x7E, 0x1C, 0x00,
  0x07, 0xE0, 0xE0, 0x00, 0x7E, 0x06, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x7E,
  0x03, 0x80, 0x07, 0xE0, 0x38, 0x00, 0x7E, 0x01, 0xC0, 0x07, 0xE0, 0x1C,
  0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x07,
  0xE0, 0x03, 0x00, 0x7E, 0x00, 0x38, 0x07, 0xE0, 0x01, 0xC0, 0x7E, 0x00,
  0x1C, 0x07, 0xE0, 0x00, 0xE0, 0x7E, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x70,
  0x7E, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x38, 0x7E, 0x00, 0x01, 0x87, 0xE0,
  0x00, 0x1C, 0x7E, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x0E, 0x7E, 0x00, 0x00,
  0x77, 0xE0, 0x00, 0x07, 0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x3E, 0x0C, 0x00, 0x01, 0xE1, 0x80, 0x00,
  0x1C, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x0F, 0x06, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0x00, 0x07, 0x00,
  0x60, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x0E, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0E, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x07,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3B, 0x00, 0x1F, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x0C, 0xC0, 0x06,
  0xC0, 0x06, 0x70, 0x03, 0x60, 0x07, 0x38, 0x01, 0xB8, 0x03, 0x9C, 0x01,
  0xDC, 0x01, 0xCE, 0x00, 0xE6, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x61, 0x80,
  0x31, 0x80, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0x70, 0x1C, 0x70, 0x1C, 0x38,
  0x0E, 0x38, 0x0E, 0x1C, 0x06, 0x0C, 0x07, 0x06, 0x03, 0x06, 0x03, 0x03,
  0x01, 0x83, 0x01, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60,
  0x70, 0x60, 0x30, 0x70, 0x38, 0x30, 0x18, 0x38, 0x1C, 0x18, 0x0C, 0x1C,
  0x06, 0x1C, 0x07, 0x0C, 0x03, 0x0E, 0x03, 0x86, 0x01, 0x86, 0x00, 0xC3,
  0x00, 0xE3, 0x00, 0x61, 0x80, 0x71, 0x80, 0x31, 0xC0, 0x39, 0xC0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x0E, 0x60, 0x06, 0x70, 0x07, 0x30, 0x03, 0x30, 0x01,
  0x98, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xEC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0xFF,
  0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x30,
  0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x1C, 0x00,
  0x30, 0x30, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80, 0x38, 0x06, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x60, 0x03, 0x83, 0x80, 0x07,
  0x0E, 0x00, 0x1C, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0xC0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x1E, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x0E, 0x0F,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3E, 0x70, 0x00,
  0x07, 0xE7, 0x80, 0x00, 0xEE, 0x3C, 0x00, 0x3C, 0xE1, 0xF0, 0x0F, 0x8E,
  0x0F, 0xFF, 0xF0, 0xE0, 0x3F, 0xF8, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x1F, 0xC0, 0x0C, 0x1F, 0xFC, 0x03,
  0x1F, 0xFF, 0xC0, 0xCF, 0x00, 0x78, 0x37, 0x00, 0x0F, 0x0F, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x33, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x3C, 0x00, 0x03, 0x8F, 0x80, 0x01, 0xC3, 0x70, 0x00, 0xF0, 0xCF, 0x00,
  0xF8, 0x31, 0xFF, 0xFC, 0x0C, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xC0, 0x30, 0x1F, 0xFE, 0x0C, 0x0F,
  0xFF, 0xE3, 0x07, 0x80, 0x3C, 0xC3, 0xC0, 0x03, 0xB1, 0xE0, 0x00, 0x6C,
  0x70, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x3B, 0x07, 0xC0, 0x7C,
  0xC0, 0xFF, 0xFE, 0x30, 0x0F, 0xFE, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3C, 0x01, 0xF0,
  0x0F, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x40, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x3E,
  0x00, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF8, 0x70,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x30, 0x3F, 0xFF, 0x8C, 0x1E,
  0x00, 0xF3, 0x0F, 0x00, 0x0E, 0xC7, 0x80, 0x01, 0xB1, 0xC0, 0x00, 0x3C,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xC7,
  0x80, 0x01, 0xF0, 0xF0, 0x00, 0xEC, 0x1F, 0x01, 0xF3, 0x03, 0xFF, 0xF8,
  0xC0, 0x3F, 0xF8, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x10,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x07, 0xC0, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0xF0, 0x0E, 0x07, 0xFF, 0x83, 0x87,
  0xFF, 0xF0, 0xE3, 0xC0, 0x1E, 0x39, 0xC0, 0x03, 0xCE, 0xE0, 0x00, 0x7B,
  0xB0, 0x00, 0x0E, 0xF8, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x0E,
  0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0xF0,
  0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x71,
  0xE0, 0x00, 0x0E, 0x7E, 0x00, 0x01, 0xDF, 0xC0, 0x00, 0x3F, 0x9C, 0x00,
  0x07, 0xE1, 0xC0, 0x00, 0xF8, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80,
  0x3C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x78, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x78, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0xC7, 0xFC, 0x0F, 0xF8,
  0xCF, 0xFE, 0x3F, 0xFC, 0xDC, 0x07, 0x70, 0x1E, 0xF0, 0x03, 0xE0, 0x0E,
  0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x07,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0F, 0xC0, 0x38,
  0x1F, 0xFE, 0x0E, 0x1F, 0xFF, 0xC3, 0x8F, 0x00, 0x78, 0xE7, 0x00, 0x0F,
  0x3B, 0x80, 0x01, 0xCE, 0xC0, 0x00, 0x3B, 0xE0, 0x00, 0x0E, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xF0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x1C, 0x1F, 0xFC, 0x03, 0x8F, 0xFF, 0xE0, 0x73, 0xC0, 0x3E,
  0x0E, 0xE0, 0x01, 0xE1, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x1C, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x03, 0x8F, 0x80, 0x00,
  0x71, 0xF8, 0x00, 0x1C, 0x3B, 0x80, 0x07, 0x87, 0x3C, 0x03, 0xE0, 0xE3,
  0xFF, 0xF0, 0x1C, 0x1F, 0xFC, 0x03, 0x80, 0x14, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x30, 0x3F, 0xFF, 0x8C,
  0x1E, 0x00, 0xF3, 0x0F, 0x00, 0x0E, 0xC7, 0x80, 0x01, 0xF1, 0xC0, 0x00,
  0x3C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0xEC, 0x1F, 0x00, 0xF3, 0x03, 0xFF,
  0xF8, 0xC0, 0x3F, 0xF8, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xF6, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xC0, 0x0C, 0x70, 0x00,
  0x67, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0x80, 0x0F, 0x81, 0xC0, 0x00, 0x78, 0x70, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x01, 0xE0, 0xFC, 0x00, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x1F, 0x38, 0x00, 0x0D, 0xC7, 0x00,
  0x0F, 0x70, 0xF0, 0x0F, 0x9C, 0x1F, 0xFF, 0x87, 0x03, 0xFF, 0xC1, 0xC0,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xD8, 0x00, 0x38, 0x00, 0x76, 0x00, 0x1E, 0x00, 0x1D,
  0xC0, 0x07, 0x80, 0x06, 0x70, 0x01, 0xE0, 0x01, 0x9C, 0x00, 0x7C, 0x00,
  0xE3, 0x00, 0x3B, 0x00, 0x38, 0xC0, 0x0C, 0xC0, 0x0C, 0x38, 0x03, 0x30,
  0x03, 0x0E, 0x00, 0xCE, 0x01, 0xC1, 0x80, 0x73, 0x80, 0x70, 0x60, 0x18,
  0x60, 0x18, 0x1C, 0x06, 0x18, 0x06, 0x07, 0x01, 0x87, 0x01, 0x81, 0xC0,
  0xE0, 0xC0, 0xE0, 0x30, 0x30, 0x30, 0x38, 0x0C, 0x0C, 0x0C, 0x0C, 0x03,
  0x83, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x61, 0xC0, 0x18, 0x60, 0x18, 0x70,
  0x06, 0x18, 0x06, 0x18, 0x01, 0xC6, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x31,
  0x80, 0x1C, 0xC0, 0x0C, 0xE0, 0x03, 0x30, 0x03, 0x38, 0x00, 0xCC, 0x00,
  0xEC, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x07,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x71, 0xF7, 0xE0, 0x00, 0x1C, 0xE0,
  0x3E, 0x00, 0x06, 0x70, 0x03, 0xC0, 0x01, 0x98, 0x00, 0x78, 0x00, 0xEE,
  0x00, 0x0F, 0x00, 0x73, 0x80, 0x01, 0xF0, 0x3C, 0xC0, 0x00, 0x1F, 0xFE,
  0x30, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00,
};

const GFXglyph RobotoMono_ExtraLight63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 5, 45, 38, 16, -45 },
  { 30, 11, 13, 38, 13, -47 },
  { 48, 34, 45, 38, 2, -45 },
  { 240, 27, 57, 38, 6, -51 },
  { 433, 35, 46, 38, 1, -45 },
  { 635, 31, 46, 38, 5, -45 },
  { 814, 3, 13, 38, 16, -47 },
  { 819, 14, 64, 38, 12, -50 },
  { 931, 14, 64, 38, 11, -50 },
  { 1043, 28, 26, 38, 6, -45 },
  { 1134, 30, 33, 38, 4, -37 },
  { 1258, 6, 13, 38, 12, -5 },
  { 1268, 22, 2, 38, 8, -21 },
  { 1274, 5, 5, 38, 17, -5 },
  { 1278, 21, 49, 38, 9, -45 },
  { 1407, 28, 46, 38, 5, -45 },
  { 1568, 15, 45, 38, 7, -45 },
  { 1653, 29, 45, 38, 3, -45 },
  { 1817, 28, 46, 38, 3, -45 },
  { 1978, 31, 45, 38, 3, -45 },
  { 2153, 26, 46, 38, 7, -45 },
  { 2303, 27, 46, 38, 5, -45 },
  { 2459, 29, 45, 38, 4, -45 },
  { 2623, 29, 46, 38, 5, -45 },
  { 2790, 27, 45, 38, 5, -45 },
  { 2942, 5, 32, 38, 19, -32 },
  { 2962, 7, 40, 38, 17, -32 },
  { 2997, 27, 25, 38, 5, -33 },
  { 3082, 28, 15, 38, 5, -28 },
  { 3135, 26, 25, 38, 6, -33 },
  { 3217, 24, 45, 38, 7, -45 },
  { 3352, 34, 45, 38, 2, -45 },
  { 3544, 32, 45, 38, 3, -45 },
  { 3724, 28, 45, 38, 6, -45 },
  { 3882, 30, 46, 38, 4, -45 },
  { 4055, 28, 45, 38, 6, -45 },
  { 4213, 26, 45, 38, 6, -45 },
  { 4360, 26, 45, 38, 7, -45 },
  { 4507, 29, 46, 38, 4, -45 },
  { 4674, 28, 45, 38, 5, -45 },
  { 4832, 26, 45, 38, 6, -45 },
  { 4979, 27, 46, 38, 4, -45 },
  { 5135, 29, 45, 38, 7, -45 },
  { 5299, 26, 45, 38, 7, -45 },
  { 5446, 28, 45, 38, 5, -45 },
  { 5604, 28, 45, 38, 5, -45 },
  { 5762, 30, 46, 38, 4, -45 },
  { 5935, 28, 45, 38, 7, -45 },
  { 6093, 32, 53, 38, 3, -45 },
  { 6305, 27, 45, 38, 7, -45 },
  { 6457, 29, 46, 38, 5, -45 },
  { 6624, 32, 45, 38, 3, -45 },
  { 6804, 28, 46, 38, 5, -45 },
  { 6965, 32, 45, 38, 3, -45 },
  { 7145, 33, 45, 38, 3, -45 },
  { 7331, 31, 45, 38, 4, -45 },
  { 7506, 31, 45, 38, 3, -45 },
  { 7681, 28, 45, 38, 4, -45 },
  { 7839, 10, 61, 38, 14, -51 },
  { 7916, 22, 49, 38, 8, -45 },
  { 8051, 9, 61, 38, 14, -51 },
  { 8120, 22, 25, 38, 8, -45 },
  { 8189, 26, 2, 38, 6, 0 },
  { 8196, 8, 8, 38, 15, -46 },
  { 8204, 28, 35, 38, 5, -34 },
  { 8327, 26, 48, 38, 7, -47 },
  { 8483, 27, 35, 38, 5, -34 },
  { 8602, 26, 48, 38, 5, -47 },
  { 8758, 28, 35, 38, 5, -34 },
  { 8881, 28, 48, 38, 6, -48 },
  { 9049, 26, 47, 38, 5, -34 },
  { 9202, 26, 47, 38, 6, -47 },
  { 9355, 26, 45, 38, 7, -45 },
  { 9502, 19, 58, 38, 6, -45 },
  { 9640, 27, 47, 38, 7, -47 },
  { 9799, 26, 47, 38, 7, -47 },
  { 9952, 32, 34, 38, 3, -34 },
  { 10088, 26, 34, 38, 6, -34 },
  { 10199, 30, 35, 38, 4, -34 },
  { 10331, 27, 47, 38, 6, -34 },
  { 10490, 26, 47, 38, 5, -34 },
  { 10643, 21, 34, 38, 12, -34 },
  { 10733, 27, 35, 38, 6, -34 },
  { 10852, 26, 43, 38, 6, -42 },
  { 10992, 26, 34, 38, 6, -33 },
  { 11103, 31, 33, 38, 3, -33 },
  { 11231, 34, 33, 38, 2, -33 },
  { 11372, 30, 33, 38, 4, -33 },
  { 11496, 33, 46, 38, 2, -33 },
  { 11686, 30, 33, 38, 4, -33 },
  { 11810, 21, 62, 38, 10, -49 },
  { 11973, 2, 54, 38, 18, -45 },
  { 11987, 20, 62, 38, 10, -49 },
  { 12142, 34, 11, 38, 2, -24 },
};

const GFXfont RobotoMono_ExtraLight63pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight63pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOMONO_EXTRALIGHT63PT7B_H_
