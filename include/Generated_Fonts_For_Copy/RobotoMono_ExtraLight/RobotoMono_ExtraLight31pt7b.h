#ifndef _ROBOTOMONO_EXTRALIGHT31PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x45, 0x14, 0x51, 0xC7, 0x10,
  0x01, 0x04, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x41, 0x80, 0x20, 0x80, 0x10,
  0x41, 0xFF, 0xFE, 0x0C, 0x10, 0x04, 0x08, 0x02, 0x0C, 0x01, 0x04, 0x00,
  0x82, 0x00, 0x41, 0x00, 0x60, 0x80, 0x20, 0xC1, 0xFF, 0xFE, 0x08, 0x20,
  0x04, 0x10, 0x06, 0x08, 0x02, 0x04, 0x01, 0x06, 0x00, 0x82, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x3F, 0x83, 0x06, 0x30, 0x09, 0x00, 0x68, 0x01,
  0x40, 0x0A, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x05, 0x80,
  0x66, 0x0E, 0x1F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0x62,
  0x00, 0x20, 0x82, 0x10, 0x41, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x81,
  0x0C, 0x40, 0x6C, 0x40, 0x18, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0xC0, 0x19, 0x98, 0x08, 0x84, 0x08, 0x41, 0x04, 0x60, 0x84, 0x30, 0x42,
  0x18, 0x22, 0x04, 0x30, 0x02, 0x10, 0x00, 0xF0, 0x0F, 0x80, 0x18, 0x40,
  0x10, 0x60, 0x30, 0x20, 0x30, 0x20, 0x30, 0x60, 0x10, 0x40, 0x11, 0x80,
  0x0B, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1A, 0x00, 0x31, 0x02, 0x61, 0x82,
  0x40, 0xC2, 0xC0, 0x66, 0xC0, 0x24, 0xC0, 0x1C, 0x40, 0x18, 0x60, 0x1C,
  0x30, 0x66, 0x1F, 0xC3, 0xFC, 0x02, 0x0C, 0x30, 0xC1, 0x06, 0x08, 0x30,
  0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x18,
  0x10, 0x20, 0x60, 0x40, 0x80, 0x81, 0x01, 0x01, 0x01, 0x80, 0x80, 0x80,
  0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x18, 0x20, 0xC1, 0x04, 0x18,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0xC2, 0x19, 0xE9, 0xD0,
  0xF8, 0x01, 0xC0, 0x05, 0x80, 0x23, 0x01, 0x86, 0x0C, 0x0C, 0x20, 0x20,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x6D, 0xB4, 0xA0, 0xFF, 0xFF, 0xFC,
  0xF0, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x0F, 0xE0,
  0x60, 0xC3, 0x01, 0x88, 0x02, 0x40, 0x0D, 0x00, 0x34, 0x01, 0xD0, 0x0D,
  0xC0, 0x67, 0x03, 0x1C, 0x18, 0x70, 0xC1, 0xC6, 0x07, 0x30, 0x15, 0x80,
  0x5C, 0x01, 0x40, 0x0D, 0x80, 0x32, 0x00, 0x8C, 0x06, 0x18, 0x30, 0x3F,
  0x80, 0x03, 0x0F, 0x39, 0xE1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x1F,
  0xC0, 0xC1, 0x84, 0x03, 0x30, 0x04, 0x80, 0x12, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0xFF, 0xF0, 0x0F, 0xE0, 0x60, 0xC2, 0x01, 0x98, 0x02, 0x40, 0x0D, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x7C, 0x00, 0x3C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x05, 0x00, 0x16, 0x00, 0xC8,
  0x02, 0x18, 0x30, 0x3F, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00, 0x50, 0x00,
  0xD0, 0x00, 0x90, 0x01, 0x10, 0x03, 0x10, 0x02, 0x10, 0x04, 0x10, 0x0C,
  0x10, 0x08, 0x10, 0x10, 0x10, 0x30, 0x10, 0x20, 0x10, 0x40, 0x10, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x3F, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x6F, 0x83, 0xC7, 0x18, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0xC0, 0x0A, 0x00, 0xD0, 0x06, 0xC0, 0x63, 0x87, 0x07,
  0xE0, 0x01, 0xE0, 0x1C, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x4F, 0xE1, 0x40, 0xCE, 0x01, 0xB0, 0x02, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0x40, 0x0D, 0x00, 0x26, 0x00, 0x8C, 0x06,
  0x18, 0x30, 0x3F, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0xC1, 0x86, 0x01,
  0x10, 0x06, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0x90, 0x06, 0x60, 0x10, 0xC1,
  0x80, 0xFC, 0x0E, 0x38, 0x60, 0x33, 0x00, 0x68, 0x00, 0xA0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x90, 0x06, 0x70, 0x30, 0x7F, 0x00, 0x0F, 0xC0,
  0x60, 0xC2, 0x01, 0x18, 0x02, 0x40, 0x09, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x05, 0x00, 0x14, 0x00, 0xD8, 0x07, 0x30, 0x34, 0x73, 0xB0, 0x78,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x7C,
  0x00, 0xEC, 0x00, 0x00, 0x00, 0x01, 0xD8, 0x73, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x22, 0x22, 0x64, 0xC0, 0x00, 0x0C, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x00, 0x3F,
  0x8C, 0x1B, 0x01, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x01, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0xF8, 0x07, 0x06, 0x06, 0x01,
  0x86, 0x00, 0x62, 0x0C, 0x12, 0x0F, 0x89, 0x08, 0x45, 0x88, 0x21, 0x84,
  0x10, 0xC6, 0x08, 0x62, 0x04, 0x31, 0x04, 0x18, 0x82, 0x14, 0x41, 0x0A,
  0x20, 0x85, 0x08, 0xE6, 0xC7, 0x9E, 0x21, 0x84, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x3F, 0x80, 0x01, 0x00, 0x07, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x6C, 0x00, 0x88, 0x01, 0x10, 0x06, 0x30, 0x08, 0x20, 0x10, 0x40,
  0x60, 0xC0, 0x80, 0x81, 0x01, 0x06, 0x03, 0x0F, 0xFE, 0x1F, 0xFC, 0x20,
  0x0C, 0x80, 0x09, 0x00, 0x12, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x40, 0xFF,
  0x82, 0x03, 0x88, 0x03, 0x20, 0x04, 0x80, 0x1A, 0x00, 0x68, 0x01, 0xA0,
  0x04, 0x80, 0x32, 0x01, 0x8F, 0xF8, 0x20, 0x38, 0x80, 0x12, 0x00, 0x28,
  0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x63,
  0xFF, 0x00, 0x0F, 0xE0, 0x30, 0x60, 0xC0, 0x63, 0x00, 0x64, 0x00, 0x48,
  0x00, 0xB0, 0x01, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x03, 0x40, 0x04, 0x80, 0x09,
  0x80, 0x31, 0x80, 0xC1, 0x83, 0x01, 0xFC, 0x00, 0xFF, 0x02, 0x07, 0x08,
  0x06, 0x20, 0x0C, 0x80, 0x1A, 0x00, 0x28, 0x00, 0xA0, 0x03, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x02,
  0x80, 0x0A, 0x00, 0x68, 0x03, 0x20, 0x18, 0x81, 0xC3, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xF9, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFC, 0xFF,
  0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xFD, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x0F,
  0xE0, 0x60, 0xC3, 0x01, 0x98, 0x03, 0x40, 0x07, 0x00, 0x1C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0xFE, 0x00, 0x18,
  0x00, 0x70, 0x01, 0x40, 0x05, 0x00, 0x16, 0x00, 0x4C, 0x01, 0x18, 0x18,
  0x3F, 0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x7F, 0xFC, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x06, 0xC0, 0x63, 0x06,
  0x0F, 0xE0, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0xC6, 0x03, 0x0C, 0x0C, 0x18,
  0x10, 0x30, 0x40, 0x61, 0x80, 0xC6, 0x01, 0x98, 0x03, 0x70, 0x07, 0xB0,
  0x0E, 0x30, 0x18, 0x20, 0x30, 0x60, 0x60, 0x60, 0xC0, 0x61, 0x80, 0x43,
  0x00, 0x46, 0x00, 0xCC, 0x00, 0xD8, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFC, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0xC0, 0x5A, 0x02, 0xD8, 0x36, 0x41, 0x32, 0x19, 0x98, 0x8C, 0x44,
  0x62, 0x63, 0x1A, 0x18, 0x50, 0xC3, 0x06, 0x08, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x1A, 0x00, 0xC8, 0x06, 0x60, 0x31, 0x01, 0x8C, 0x0C, 0x20,
  0x61, 0x83, 0x04, 0x18, 0x30, 0xC0, 0x86, 0x02, 0x30, 0x19, 0x80, 0x4C,
  0x03, 0x60, 0x0B, 0x00, 0x78, 0x01, 0xC0, 0x0C, 0x0F, 0xC0, 0x30, 0x60,
  0xC0, 0x63, 0x00, 0x44, 0x00, 0xC8, 0x00, 0xB0, 0x01, 0x40, 0x02, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0x60, 0x02, 0x40, 0x04, 0x80, 0x19, 0x80, 0x21, 0x80, 0xC1, 0x83, 0x01,
  0xF8, 0x00, 0xFF, 0xC3, 0x01, 0xCC, 0x01, 0xB0, 0x02, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x2C, 0x01, 0xB0, 0x3C, 0xFF,
  0x83, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x30, 0x60, 0x80, 0x63, 0x00,
  0x64, 0x00, 0x58, 0x00, 0xA0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xC0,
  0x04, 0x80, 0x09, 0x80, 0x31, 0x80, 0xC1, 0x83, 0x01, 0xFC, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xFF, 0x83, 0x03, 0x8C, 0x03, 0x30,
  0x06, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0xC0, 0x1B, 0x00, 0x4C,
  0x03, 0x3F, 0xF0, 0xFF, 0x83, 0x02, 0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x23,
  0x00, 0xCC, 0x01, 0x30, 0x06, 0xC0, 0x0B, 0x00, 0x30, 0x0F, 0xE0, 0x30,
  0x70, 0x80, 0x23, 0x00, 0x64, 0x00, 0x48, 0x00, 0xD0, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x63, 0x81,
  0x81, 0xFE, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xF0, 0x04, 0xC0, 0x63, 0x06, 0x0F, 0xE0, 0xC0, 0x03, 0x40,
  0x03, 0x60, 0x02, 0x20, 0x06, 0x20, 0x06, 0x30, 0x04, 0x10, 0x04, 0x10,
  0x0C, 0x18, 0x08, 0x08, 0x08, 0x08, 0x18, 0x0C, 0x10, 0x0C, 0x10, 0x04,
  0x30, 0x04, 0x20, 0x06, 0x20, 0x02, 0x60, 0x02, 0x40, 0x03, 0x40, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x80, 0xA0, 0x60, 0xD0, 0x30, 0x48,
  0x28, 0x24, 0x14, 0x12, 0x0A, 0x09, 0x85, 0x04, 0xC2, 0xC6, 0x23, 0x23,
  0x11, 0x11, 0x08, 0x88, 0x84, 0x44, 0x43, 0x23, 0x21, 0xB0, 0x90, 0x50,
  0x58, 0x28, 0x28, 0x14, 0x14, 0x0A, 0x0E, 0x07, 0x03, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x40, 0x60, 0xC0, 0x06, 0xC0, 0x08, 0x80, 0x31, 0x80, 0xC1,
  0x01, 0x03, 0x06, 0x03, 0x08, 0x02, 0x20, 0x06, 0xC0, 0x05, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x28, 0x00, 0xC8, 0x03, 0x18, 0x04, 0x10, 0x18, 0x30,
  0x20, 0x30, 0x80, 0x23, 0x00, 0x64, 0x00, 0x58, 0x00, 0xC0, 0xC0, 0x03,
  0x60, 0x02, 0x20, 0x06, 0x30, 0x04, 0x10, 0x0C, 0x18, 0x08, 0x08, 0x10,
  0x0C, 0x10, 0x04, 0x20, 0x06, 0x20, 0x02, 0x40, 0x03, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0xFC, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x7C, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10,
  0x03, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFC, 0x04, 0x01, 0x80, 0x28,
  0x0D, 0x01, 0x30, 0x62, 0x08, 0x61, 0x04, 0x60, 0x88, 0x1B, 0x01, 0x40,
  0x30, 0xFF, 0xF8, 0xC6, 0x21, 0x07, 0x01, 0xFF, 0x18, 0x0D, 0x80, 0x2C,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x1F, 0xFB, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0xEC, 0x1B, 0x3F, 0x98, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x1C, 0x1B, 0xF8, 0xE0, 0x66,
  0x01, 0xB0, 0x05, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x2E, 0x03, 0x58, 0x32, 0x3F, 0x00, 0x07,
  0x00, 0xFE, 0x08, 0x08, 0x80, 0x2C, 0x01, 0xC0, 0x0E, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0xA0, 0x0D, 0x80, 0x46,
  0x0C, 0x1F, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x0E, 0x13, 0xFD, 0x60, 0x74, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x60, 0x33, 0x07,
  0x1F, 0x90, 0x03, 0x80, 0x3F, 0x81, 0x01, 0x88, 0x02, 0x60, 0x0D, 0x00,
  0x14, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0xC6, 0x06, 0x07, 0xE0, 0x00, 0x78, 0x0F, 0xF0,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xF0,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0E, 0x03, 0xFD, 0x60, 0x74, 0x03, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x60,
  0x33, 0x05, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x40, 0x36, 0x06, 0x3F,
  0xC0, 0x20, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x0C, 0x11, 0xFC, 0xB0, 0x35, 0x00, 0xB0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x7F, 0xFC, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0xDF, 0xC7,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x50, 0x0C, 0x80, 0xC4, 0x0C, 0x20, 0xC1, 0x0C, 0x08, 0xC0, 0x48, 0x03,
  0xE0, 0x19, 0x80, 0x86, 0x04, 0x18, 0x20, 0x61, 0x01, 0x88, 0x04, 0x40,
  0x12, 0x00, 0xE0, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x83, 0xFF, 0xE0, 0x0E, 0x18, 0xFF, 0x3E, 0xE1, 0xC3, 0xC0,
  0x81, 0xC0, 0x81, 0xC0, 0x81, 0xC0, 0x81, 0xC0, 0x81, 0xC0, 0x81, 0xC0,
  0x81, 0xC0, 0x81, 0xC0, 0x81, 0xC0, 0x81, 0xC0, 0x81, 0xC0, 0x81, 0xC0,
  0x81, 0xC0, 0x81, 0x03, 0x04, 0x7F, 0x2C, 0x0D, 0x40, 0x2C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x03, 0x80, 0x3F, 0xC0, 0xC0,
  0xC3, 0x00, 0x44, 0x00, 0xC8, 0x00, 0xB0, 0x01, 0x40, 0x02, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x16, 0x00, 0x24, 0x00, 0x4C, 0x01, 0x88, 0x06, 0x0C,
  0x18, 0x0F, 0xE0, 0x07, 0x04, 0xFE, 0x28, 0x19, 0x80, 0x6C, 0x01, 0x40,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x60, 0x0B, 0x00, 0xD6, 0x0C, 0x9F, 0xC4, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x00, 0x0F, 0x03, 0xFD, 0x60, 0x74, 0x03, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x1C, 0x01, 0x60, 0x33, 0x07, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0xE7, 0xFB, 0x03, 0x80, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x00, 0x07, 0x01, 0xFF, 0x18, 0x0C, 0x80, 0x34, 0x00, 0xA0, 0x01,
  0x80, 0x07, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x05, 0x00, 0x6E, 0x06, 0x1F, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x7F, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x3F, 0x80, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xA0, 0x1C, 0x81, 0x63, 0xF3, 0x80, 0x07, 0x80, 0x09, 0x00,
  0x33, 0x00, 0x42, 0x01, 0x86, 0x02, 0x04, 0x04, 0x08, 0x10, 0x18, 0x20,
  0x10, 0xC0, 0x31, 0x00, 0x26, 0x00, 0x68, 0x00, 0x50, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x81, 0xE0, 0xC0, 0x90, 0x50, 0x48, 0x28, 0x24, 0x14, 0x33,
  0x1A, 0x10, 0x89, 0x88, 0x44, 0x44, 0x22, 0x22, 0x1B, 0x13, 0x05, 0x05,
  0x02, 0x82, 0x81, 0x41, 0x40, 0xE0, 0xA0, 0x60, 0x20, 0x10, 0x10, 0xE0,
  0x0E, 0x60, 0x30, 0x40, 0x40, 0xC1, 0x80, 0xC6, 0x00, 0xD8, 0x00, 0xA0,
  0x00, 0x80, 0x03, 0x80, 0x0D, 0x80, 0x31, 0x80, 0x41, 0x01, 0x03, 0x06,
  0x03, 0x18, 0x03, 0x60, 0x03, 0xC0, 0x03, 0x60, 0x02, 0x20, 0x02, 0x30,
  0x06, 0x30, 0x04, 0x10, 0x0C, 0x18, 0x08, 0x08, 0x18, 0x0C, 0x10, 0x04,
  0x30, 0x06, 0x20, 0x02, 0x20, 0x03, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x7C,
  0x00, 0x20, 0x00, 0x7F, 0xFC, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0x00, 0xC0, 0xC0,
  0x20, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x0E, 0x03, 0x80, 0x10, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x03, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xE0, 0xC0, 0x0C, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x1C, 0x07, 0x02,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x30, 0x38, 0x00, 0x1C, 0x00, 0x3B, 0x80, 0xD0, 0x60, 0x50,
  0x18, 0x68, 0x07, 0xE0,
};

const GFXglyph RobotoMono_ExtraLight31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 2, 22, 19, 8, -22 },
  { 7, 6, 6, 19, 6, -23 },
  { 12, 17, 22, 19, 1, -22 },
  { 59, 13, 28, 19, 3, -25 },
  { 105, 17, 22, 19, 1, -22 },
  { 152, 16, 22, 19, 2, -22 },
  { 196, 1, 6, 19, 8, -23 },
  { 197, 7, 32, 19, 6, -25 },
  { 225, 7, 32, 19, 5, -25 },
  { 253, 14, 13, 19, 3, -22 },
  { 276, 15, 16, 19, 2, -18 },
  { 306, 3, 7, 19, 6, -3 },
  { 309, 11, 2, 19, 4, -11 },
  { 312, 2, 2, 19, 9, -2 },
  { 313, 11, 24, 19, 4, -22 },
  { 346, 14, 22, 19, 2, -22 },
  { 385, 8, 22, 19, 3, -22 },
  { 407, 14, 22, 19, 2, -22 },
  { 446, 14, 22, 19, 1, -22 },
  { 485, 16, 22, 19, 1, -22 },
  { 529, 13, 22, 19, 3, -22 },
  { 565, 14, 22, 19, 2, -22 },
  { 604, 14, 22, 19, 2, -22 },
  { 643, 14, 22, 19, 3, -22 },
  { 682, 14, 22, 19, 2, -22 },
  { 721, 3, 15, 19, 9, -15 },
  { 727, 4, 19, 19, 8, -15 },
  { 737, 14, 12, 19, 2, -16 },
  { 758, 13, 8, 19, 3, -14 },
  { 771, 13, 12, 19, 3, -16 },
  { 791, 11, 22, 19, 4, -22 },
  { 822, 17, 22, 19, 1, -22 },
  { 869, 15, 22, 19, 2, -22 },
  { 911, 14, 22, 19, 3, -22 },
  { 950, 15, 22, 19, 2, -22 },
  { 992, 14, 22, 19, 3, -22 },
  { 1031, 13, 22, 19, 3, -22 },
  { 1067, 13, 22, 19, 3, -22 },
  { 1103, 14, 22, 19, 2, -22 },
  { 1142, 13, 22, 19, 3, -22 },
  { 1178, 13, 22, 19, 3, -22 },
  { 1214, 13, 22, 19, 2, -22 },
  { 1250, 15, 22, 19, 3, -22 },
  { 1292, 13, 22, 19, 3, -22 },
  { 1328, 13, 22, 19, 3, -22 },
  { 1364, 13, 22, 19, 3, -22 },
  { 1400, 15, 22, 19, 2, -22 },
  { 1442, 14, 22, 19, 3, -22 },
  { 1481, 15, 26, 19, 2, -22 },
  { 1530, 14, 22, 19, 3, -22 },
  { 1569, 15, 22, 19, 2, -22 },
  { 1611, 15, 22, 19, 2, -22 },
  { 1653, 13, 22, 19, 3, -22 },
  { 1689, 16, 22, 19, 1, -22 },
  { 1733, 17, 22, 19, 1, -22 },
  { 1780, 15, 22, 19, 2, -22 },
  { 1822, 16, 22, 19, 1, -22 },
  { 1866, 14, 22, 19, 2, -22 },
  { 1905, 5, 30, 19, 7, -25 },
  { 1924, 11, 24, 19, 4, -22 },
  { 1957, 5, 30, 19, 7, -25 },
  { 1976, 11, 12, 19, 4, -22 },
  { 1993, 13, 1, 19, 3, 0 },
  { 1995, 4, 4, 19, 7, -23 },
  { 1997, 13, 17, 19, 3, -17 },
  { 2025, 13, 23, 19, 3, -23 },
  { 2063, 13, 17, 19, 3, -17 },
  { 2091, 12, 23, 19, 3, -23 },
  { 2126, 14, 17, 19, 2, -17 },
  { 2156, 14, 24, 19, 3, -24 },
  { 2198, 12, 24, 19, 3, -17 },
  { 2234, 13, 23, 19, 3, -23 },
  { 2272, 13, 22, 19, 3, -22 },
  { 2308, 9, 29, 19, 3, -22 },
  { 2341, 13, 23, 19, 4, -23 },
  { 2379, 13, 23, 19, 3, -23 },
  { 2417, 16, 17, 19, 1, -17 },
  { 2451, 13, 17, 19, 3, -17 },
  { 2479, 15, 17, 19, 2, -17 },
  { 2511, 13, 23, 19, 3, -17 },
  { 2549, 12, 23, 19, 3, -17 },
  { 2584, 10, 17, 19, 6, -17 },
  { 2606, 13, 17, 19, 3, -17 },
  { 2634, 13, 21, 19, 3, -21 },
  { 2669, 13, 16, 19, 3, -16 },
  { 2695, 15, 16, 19, 2, -16 },
  { 2725, 17, 16, 19, 1, -16 },
  { 2759, 15, 16, 19, 2, -16 },
  { 2789, 16, 23, 19, 1, -16 },
  { 2835, 15, 16, 19, 2, -16 },
  { 2865, 10, 30, 19, 5, -24 },
  { 2903, 1, 27, 19, 9, -22 },
  { 2907, 10, 30, 19, 5, -24 },
  { 2945, 17, 5, 19, 1, -12 },
};

const GFXfont RobotoMono_ExtraLight31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight31pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_EXTRALIGHT31PT7B_H_
