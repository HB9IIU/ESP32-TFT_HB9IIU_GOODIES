#ifndef _ROBOTOMONO_EXTRALIGHT17PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight17pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x83, 0xB6, 0xD0, 0x09, 0x02, 0x40, 0x91, 0xFF, 0x11,
  0x04, 0x41, 0x20, 0x48, 0xFF, 0x88, 0x82, 0x20, 0x90, 0x10, 0x21, 0xB4,
  0x28, 0x30, 0x20, 0x38, 0x0C, 0x04, 0x0C, 0x18, 0x2D, 0x84, 0x08, 0x70,
  0x22, 0x48, 0xA2, 0x28, 0x74, 0x01, 0x00, 0x90, 0x2A, 0x12, 0x44, 0x92,
  0x24, 0x0E, 0x3C, 0x22, 0x11, 0x08, 0x82, 0x81, 0x81, 0x40, 0x92, 0x85,
  0x41, 0x90, 0xCF, 0xB0, 0xF0, 0x11, 0x24, 0x44, 0x88, 0x88, 0x88, 0x84,
  0x42, 0x21, 0x88, 0x42, 0x22, 0x11, 0x11, 0x11, 0x12, 0x24, 0x48, 0x10,
  0x22, 0x5B, 0xC2, 0x89, 0x11, 0x00, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08,
  0x08, 0x08, 0x08, 0x58, 0xFC, 0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08,
  0x20, 0x84, 0x10, 0x80, 0x3C, 0x42, 0x41, 0x83, 0x85, 0x89, 0x91, 0xA1,
  0xC1, 0x41, 0x42, 0x3C, 0x3D, 0x11, 0x11, 0x11, 0x11, 0x11, 0x7C, 0x82,
  0x82, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0xFF, 0x7D, 0x06,
  0x08, 0x10, 0x27, 0x81, 0x01, 0x03, 0x06, 0x0B, 0xE0, 0x04, 0x0C, 0x0C,
  0x14, 0x24, 0x24, 0x44, 0x84, 0xFF, 0x04, 0x04, 0x04, 0x7E, 0x82, 0x04,
  0x0B, 0x98, 0x80, 0x81, 0x03, 0x06, 0x13, 0xE0, 0x1C, 0x20, 0x40, 0x40,
  0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFF, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x3E, 0x41, 0x41, 0x41,
  0x42, 0x3C, 0x22, 0x41, 0x81, 0x81, 0x41, 0x3E, 0x3C, 0x42, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x3D, 0x01, 0x02, 0x04, 0x38, 0xC0, 0x03, 0x81, 0xC0,
  0x03, 0x0C, 0x30, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0xC0, 0x70, 0x11, 0xCC, 0x20, 0x00, 0x7A, 0x18, 0x41, 0x04, 0x21,
  0x04, 0x20, 0x00, 0x0C, 0x1F, 0x08, 0x24, 0x45, 0x29, 0x52, 0x64, 0x99,
  0x26, 0x49, 0x96, 0x92, 0x44, 0x00, 0xFC, 0x08, 0x0C, 0x05, 0x02, 0x82,
  0x41, 0x10, 0x88, 0x84, 0x7F, 0x20, 0xA0, 0x50, 0x30, 0xF9, 0x0A, 0x0C,
  0x18, 0x5F, 0x21, 0x41, 0x83, 0x06, 0x0F, 0xE0, 0x3C, 0x42, 0x81, 0x81,
  0x80, 0x80, 0x80, 0x80, 0x81, 0x81, 0x42, 0x3C, 0xF9, 0x0A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x17, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x1F,
  0xA0, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0,
  0x40, 0x81, 0x02, 0x04, 0x00, 0x3E, 0x42, 0x81, 0x80, 0x80, 0x80, 0x8F,
  0x81, 0x81, 0x81, 0x41, 0x3E, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x47, 0xF0, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03,
  0x06, 0x0B, 0xE0, 0x82, 0x84, 0x88, 0x90, 0xA0, 0xA0, 0xD0, 0x90, 0x88,
  0x84, 0x82, 0x83, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x07, 0xF0, 0xC1, 0xC3, 0xA3, 0xA5, 0xA5, 0x95, 0x99, 0x89, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x83,
  0x83, 0x81, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0x40, 0x81, 0x02, 0x04,
  0x00, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0x02, 0x01, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xBE, 0x44, 0x85, 0x0A,
  0x0C, 0x10, 0x3E, 0x41, 0x81, 0x40, 0x40, 0x38, 0x06, 0x01, 0x01, 0x81,
  0x41, 0x3E, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0x81, 0x81, 0x41, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18,
  0x18, 0x08, 0x88, 0xC4, 0x66, 0x33, 0x29, 0x54, 0xA9, 0x94, 0xCA, 0x65,
  0x31, 0x18, 0x88, 0x40, 0x81, 0x21, 0x08, 0x84, 0x81, 0x40, 0x40, 0x60,
  0x28, 0x24, 0x21, 0x10, 0x50, 0x30, 0x81, 0x81, 0x42, 0x44, 0x24, 0x28,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x20, 0x40, 0x40, 0xFF, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24,
  0xE0, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0xD5,
  0x55, 0x55, 0x55, 0xC0, 0x10, 0xC2, 0x92, 0x4A, 0x10, 0xFE, 0x94, 0x3C,
  0x42, 0x01, 0x01, 0x3F, 0x41, 0x81, 0x43, 0x7D, 0x81, 0x02, 0x04, 0x0F,
  0x90, 0xA0, 0xC1, 0x83, 0x06, 0x0C, 0x2F, 0x80, 0x3C, 0x42, 0x41, 0x80,
  0x80, 0x80, 0x41, 0x42, 0x3C, 0x02, 0x04, 0x08, 0x13, 0xE8, 0x50, 0xC1,
  0x83, 0x05, 0x0A, 0x13, 0xE0, 0x3C, 0x42, 0x41, 0x81, 0xFE, 0x80, 0x40,
  0x41, 0x3E, 0x1E, 0x40, 0x81, 0x0F, 0xC4, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x00, 0x3E, 0x85, 0x0C, 0x18, 0x30, 0x50, 0xA1, 0x3E, 0x04, 0x0B,
  0x31, 0x80, 0x81, 0x02, 0x04, 0x0F, 0xD0, 0xA0, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x20, 0x10, 0x00, 0x07, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x47,
  0xF0, 0x18, 0x01, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x10, 0x88, 0x5C, 0x81,
  0x02, 0x04, 0x08, 0x71, 0x24, 0x50, 0xE1, 0x22, 0x24, 0x28, 0x20, 0xF0,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0xF7,
  0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0xFD, 0x0A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x82, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0xF9, 0x02, 0x04, 0x00,
  0x3E, 0x85, 0x0C, 0x18, 0x30, 0x50, 0xA1, 0x3E, 0x04, 0x08, 0x10, 0xBF,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x7D, 0x06, 0x06, 0x03, 0x80, 0x80,
  0xC1, 0x7C, 0x20, 0x43, 0xF1, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x78,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x7A, 0x81, 0x81, 0x42, 0x42,
  0x24, 0x24, 0x14, 0x18, 0x08, 0x88, 0xC4, 0x66, 0x53, 0x29, 0x53, 0x29,
  0x98, 0xC4, 0x42, 0x00, 0xC1, 0x42, 0x24, 0x18, 0x08, 0x14, 0x24, 0x42,
  0x81, 0x81, 0xC0, 0x90, 0x88, 0x42, 0x21, 0x20, 0x50, 0x30, 0x08, 0x08,
  0x04, 0x04, 0x0C, 0x00, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40,
  0xFF, 0x19, 0x08, 0x42, 0x10, 0x88, 0xC1, 0x08, 0x42, 0x10, 0x82, 0x08,
  0xFF, 0xFE, 0xC1, 0x08, 0x42, 0x10, 0x82, 0x19, 0x08, 0x42, 0x10, 0x88,
  0x80, 0xF0, 0xC7, 0x80,
};

const GFXglyph RobotoMono_ExtraLight17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 3, 4, 10, 4, -13 },
  { 6, 10, 12, 10, 0, -12 },
  { 21, 7, 16, 10, 2, -14 },
  { 35, 10, 12, 10, 0, -12 },
  { 50, 9, 12, 10, 1, -12 },
  { 64, 1, 4, 10, 4, -13 },
  { 65, 4, 18, 10, 3, -14 },
  { 74, 4, 18, 10, 3, -14 },
  { 83, 7, 7, 10, 2, -12 },
  { 90, 8, 9, 10, 1, -10 },
  { 99, 2, 3, 10, 3, -1 },
  { 100, 6, 1, 10, 2, -6 },
  { 101, 1, 1, 10, 5, -1 },
  { 102, 6, 13, 10, 2, -12 },
  { 112, 8, 12, 10, 1, -12 },
  { 124, 4, 12, 10, 2, -12 },
  { 130, 8, 12, 10, 1, -12 },
  { 142, 7, 12, 10, 1, -12 },
  { 153, 8, 12, 10, 1, -12 },
  { 165, 7, 12, 10, 2, -12 },
  { 176, 8, 12, 10, 1, -12 },
  { 188, 8, 12, 10, 1, -12 },
  { 200, 8, 12, 10, 1, -12 },
  { 212, 8, 12, 10, 1, -12 },
  { 224, 2, 8, 10, 5, -8 },
  { 226, 1, 10, 10, 5, -8 },
  { 228, 8, 7, 10, 1, -9 },
  { 235, 8, 5, 10, 1, -8 },
  { 240, 7, 7, 10, 2, -9 },
  { 247, 6, 12, 10, 2, -12 },
  { 256, 10, 12, 10, 0, -12 },
  { 271, 9, 12, 10, 1, -12 },
  { 285, 7, 12, 10, 2, -12 },
  { 296, 8, 12, 10, 1, -12 },
  { 308, 7, 12, 10, 2, -12 },
  { 319, 7, 12, 10, 2, -12 },
  { 330, 7, 12, 10, 2, -12 },
  { 341, 8, 12, 10, 1, -12 },
  { 353, 8, 12, 10, 1, -12 },
  { 365, 7, 12, 10, 2, -12 },
  { 376, 7, 12, 10, 1, -12 },
  { 387, 8, 12, 10, 2, -12 },
  { 399, 7, 12, 10, 2, -12 },
  { 410, 8, 12, 10, 1, -12 },
  { 422, 8, 12, 10, 1, -12 },
  { 434, 8, 12, 10, 1, -12 },
  { 446, 7, 12, 10, 2, -12 },
  { 457, 8, 14, 10, 1, -12 },
  { 471, 7, 12, 10, 2, -12 },
  { 482, 8, 12, 10, 1, -12 },
  { 494, 8, 12, 10, 1, -12 },
  { 506, 8, 12, 10, 1, -12 },
  { 518, 8, 12, 10, 1, -12 },
  { 530, 9, 12, 10, 1, -12 },
  { 544, 9, 12, 10, 1, -12 },
  { 558, 8, 12, 10, 1, -12 },
  { 570, 8, 12, 10, 1, -12 },
  { 582, 3, 17, 10, 4, -14 },
  { 589, 6, 13, 10, 2, -12 },
  { 599, 2, 17, 10, 4, -14 },
  { 604, 6, 6, 10, 2, -12 },
  { 609, 7, 1, 10, 2, 0 },
  { 610, 2, 3, 10, 4, -13 },
  { 611, 8, 9, 10, 1, -9 },
  { 620, 7, 13, 10, 2, -13 },
  { 632, 8, 9, 10, 1, -9 },
  { 641, 7, 13, 10, 1, -13 },
  { 653, 8, 9, 10, 1, -9 },
  { 662, 7, 13, 10, 2, -13 },
  { 674, 7, 13, 10, 1, -9 },
  { 686, 7, 13, 10, 2, -13 },
  { 698, 7, 12, 10, 2, -12 },
  { 709, 5, 16, 10, 2, -12 },
  { 719, 7, 13, 10, 2, -13 },
  { 731, 7, 13, 10, 2, -13 },
  { 743, 8, 9, 10, 1, -9 },
  { 752, 7, 9, 10, 2, -9 },
  { 760, 8, 9, 10, 1, -9 },
  { 769, 7, 12, 10, 2, -9 },
  { 780, 7, 12, 10, 1, -9 },
  { 791, 6, 9, 10, 3, -9 },
  { 798, 7, 9, 10, 2, -9 },
  { 806, 7, 11, 10, 2, -11 },
  { 816, 7, 9, 10, 2, -9 },
  { 824, 8, 9, 10, 1, -9 },
  { 833, 9, 9, 10, 1, -9 },
  { 844, 8, 9, 10, 1, -9 },
  { 853, 9, 13, 10, 1, -9 },
  { 868, 8, 9, 10, 1, -9 },
  { 877, 5, 17, 10, 3, -13 },
  { 888, 1, 15, 10, 5, -12 },
  { 890, 5, 17, 10, 3, -13 },
  { 901, 9, 2, 10, 1, -6 },
};

const GFXfont RobotoMono_ExtraLight17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight17pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_EXTRALIGHT17PT7B_H_
