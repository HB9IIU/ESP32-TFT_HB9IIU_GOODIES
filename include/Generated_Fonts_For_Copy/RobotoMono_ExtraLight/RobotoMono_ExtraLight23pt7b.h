#ifndef _ROBOTOMONO_EXTRALIGHT23PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight23pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA8, 0x03, 0x99, 0x99, 0x90, 0x04, 0x40, 0x84, 0x08,
  0x40, 0x84, 0x7F, 0xF0, 0x88, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0xFF,
  0xE1, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x20, 0x04, 0x01, 0x00, 0xC0,
  0xCC, 0x40, 0x90, 0x14, 0x05, 0x00, 0x40, 0x08, 0x01, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x06, 0x01, 0x40, 0x58, 0x23, 0xF0, 0x10, 0x04, 0x00, 0x30,
  0x02, 0x40, 0x11, 0x19, 0x08, 0x88, 0x44, 0x22, 0x41, 0x12, 0x07, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x1C, 0x09, 0x10, 0x88, 0x84, 0x44, 0x42, 0x20,
  0x11, 0x00, 0x70, 0x08, 0x06, 0xC1, 0x88, 0x20, 0x84, 0x20, 0x84, 0x09,
  0x01, 0xC0, 0x30, 0x0D, 0x03, 0x10, 0xC1, 0x18, 0x35, 0x02, 0xA0, 0x26,
  0x0A, 0x3E, 0x20, 0xF8, 0x0C, 0x41, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x82, 0x04, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0xC0, 0x82, 0x08,
  0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x84, 0x42, 0x22,
  0x00, 0x04, 0x01, 0x00, 0x43, 0x97, 0x1E, 0x03, 0x01, 0x20, 0xC4, 0x20,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x6D, 0x2C, 0xFF, 0x70, 0x01,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x40, 0xC0, 0x0C, 0x0C, 0xC4, 0x09, 0x02, 0x80, 0x60, 0x38,
  0x16, 0x09, 0x84, 0x62, 0x19, 0x06, 0x81, 0xC0, 0x60, 0x14, 0x09, 0x86,
  0x3E, 0x00, 0x1B, 0x62, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x0C, 0x06, 0x61, 0x02, 0x20, 0x28, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x7F, 0xE0,
  0x0C, 0x0C, 0xE4, 0x09, 0x01, 0x80, 0x40, 0x10, 0x04, 0x06, 0x0E, 0x00,
  0x60, 0x04, 0x01, 0x80, 0x60, 0x14, 0x05, 0x82, 0x3F, 0x00, 0x01, 0x80,
  0x50, 0x0A, 0x02, 0x40, 0x88, 0x11, 0x04, 0x21, 0x04, 0x20, 0x88, 0x12,
  0x02, 0x7F, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x3F, 0xC8, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x07, 0xF1, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x40,
  0x50, 0x32, 0x18, 0x7C, 0x01, 0x03, 0x83, 0x01, 0x80, 0x40, 0x20, 0x09,
  0xE2, 0x84, 0xC0, 0xA0, 0x28, 0x06, 0x01, 0x80, 0x60, 0x14, 0x09, 0x86,
  0x3E, 0x00, 0xFF, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x0C, 0x0C, 0xC4, 0x09, 0x01, 0x80, 0x60, 0x14, 0x0C, 0x86, 0x1E, 0x08,
  0x64, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x02, 0x3F, 0x00, 0x0C, 0x0C,
  0xC4, 0x1A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xD0, 0x36, 0x34,
  0x71, 0x00, 0x80, 0x20, 0x10, 0x08, 0x3C, 0x00, 0xB0, 0x00, 0x0B, 0x4C,
  0x00, 0x00, 0x01, 0x24, 0xA0, 0x00, 0xC0, 0xC0, 0xC1, 0xC0, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xE0, 0xC0, 0xC0, 0xC0, 0x00,
  0x18, 0x66, 0x81, 0x81, 0x01, 0x01, 0x01, 0x02, 0x06, 0x08, 0x08, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x1F, 0xC2, 0x02, 0x40, 0x24, 0x71, 0x88,
  0x99, 0x09, 0x90, 0x99, 0x11, 0x91, 0x19, 0x11, 0x91, 0x19, 0x32, 0x8C,
  0xC4, 0x00, 0x60, 0x81, 0xF8, 0x06, 0x00, 0x60, 0x06, 0x00, 0x90, 0x09,
  0x00, 0x90, 0x10, 0x81, 0x08, 0x10, 0x82, 0x04, 0x3F, 0xC2, 0x04, 0x40,
  0x24, 0x02, 0x40, 0x28, 0x01, 0xFF, 0x20, 0x28, 0x0E, 0x01, 0x80, 0x60,
  0x28, 0x1B, 0xF8, 0x81, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0B,
  0xFC, 0x06, 0x03, 0x30, 0x81, 0x20, 0x14, 0x02, 0x80, 0x50, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x02, 0x80, 0x48, 0x19, 0x82, 0x1F,
  0x80, 0xFE, 0x10, 0x22, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20, 0x47, 0xF0, 0xFF,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFE, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF, 0xE0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xFE, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x06, 0x03, 0x30, 0x81, 0x20, 0x14, 0x02, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x7E, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x48, 0x09,
  0x81, 0x0F, 0xC0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07,
  0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF,
  0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x83, 0xFF, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x50,
  0x16, 0x08, 0x7C, 0x80, 0x70, 0x12, 0x04, 0x41, 0x08, 0x41, 0x18, 0x26,
  0x05, 0xC0, 0xA8, 0x18, 0x82, 0x08, 0x40, 0x88, 0x19, 0x01, 0x20, 0x14,
  0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xC0, 0xF0, 0x3C, 0x0E, 0x85,
  0xA1, 0x68, 0x99, 0x26, 0x49, 0x8C, 0x63, 0x18, 0x86, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x06, 0x81, 0x90, 0x64, 0x18, 0x86,
  0x21, 0x84, 0x61, 0x18, 0x26, 0x09, 0x81, 0x60, 0x38, 0x0E, 0x01, 0x06,
  0x03, 0x30, 0x81, 0x20, 0x24, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x48, 0x11, 0x86, 0x1F, 0x00, 0xFF,
  0x20, 0x68, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x06, 0xFE, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x06, 0x01, 0x98, 0x20, 0x44,
  0x02, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x02, 0x40, 0x24, 0x02, 0x60, 0x42, 0x0C, 0x1F, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x34, 0x0C,
  0xFE, 0x10, 0x42, 0x04, 0x40, 0x88, 0x09, 0x01, 0x20, 0x14, 0x03, 0x0C,
  0x0C, 0xC4, 0x0A, 0x01, 0x80, 0x60, 0x04, 0x00, 0x80, 0x1C, 0x00, 0xC0,
  0x0C, 0x01, 0x00, 0x60, 0x18, 0x05, 0x03, 0x3F, 0x00, 0xFF, 0xF0, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x50, 0x26, 0x18, 0xFC, 0x80, 0x34, 0x02, 0x40, 0x24, 0x04, 0x20,
  0x42, 0x04, 0x20, 0x81, 0x08, 0x10, 0x81, 0x10, 0x09, 0x00, 0x90, 0x0A,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x82, 0x18, 0x61, 0x86, 0x14, 0x61, 0x45,
  0x14, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x8A, 0x28, 0xA3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0x43, 0x04, 0xC0, 0x32, 0x06, 0x20, 0x41, 0x08, 0x08,
  0x80, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00, 0x90, 0x09, 0x01, 0x08, 0x10,
  0x42, 0x04, 0x40, 0x2C, 0x03, 0xC0, 0x34, 0x06, 0x60, 0x42, 0x0C, 0x30,
  0x81, 0x10, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x03,
  0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0xF0, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x03, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18, 0x18, 0x28, 0x24, 0x44, 0x42,
  0x42, 0x81, 0x81, 0xFF, 0xC0, 0xC8, 0x80, 0x3F, 0x10, 0x28, 0x08, 0x01,
  0x00, 0x47, 0xF6, 0x06, 0x01, 0x80, 0x60, 0x3C, 0x15, 0xF9, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x2F, 0xCC, 0x0B, 0x02, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x0B, 0x86, 0x9F, 0x00, 0x3F, 0x10, 0x24, 0x0A,
  0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x50, 0x26, 0x08, 0xFC, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x09, 0xF5, 0x06, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x05, 0x02, 0x83, 0x3E, 0x80, 0x3F, 0x10, 0x24, 0x0E, 0x01,
  0x80, 0x7F, 0xF8, 0x02, 0x00, 0x80, 0x10, 0x06, 0x0C, 0x7C, 0x01, 0xC0,
  0xC4, 0x20, 0x04, 0x00, 0x80, 0x20, 0x3F, 0xE0, 0x80, 0x10, 0x02, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x3E,
  0xA0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x67,
  0xD0, 0x08, 0x05, 0x02, 0xC2, 0x1E, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x27, 0xCA, 0x0B, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x18, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0x06,
  0x00, 0x00, 0x07, 0xE0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x6F, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x0E, 0x09, 0x08, 0x98, 0x58, 0x3C, 0x12, 0x08, 0x84, 0x22, 0x09, 0x02,
  0x80, 0x80, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0xFF, 0x80, 0xFD, 0xE8,
  0x61, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18,
  0x41, 0x84, 0x18, 0x41, 0x9F, 0x28, 0x2C, 0x0A, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x3F, 0x10, 0x28, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x24, 0x18, 0xFC, 0xBF, 0x30,
  0x6C, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x2C, 0x1A,
  0xFC, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x3E, 0xA0, 0xD0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x67, 0xD0, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x9F, 0xA0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x3F, 0x10, 0x24, 0x05, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x03, 0x00, 0x60, 0x14, 0x08, 0xFC, 0x08, 0x02, 0x00, 0x83, 0xFE,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x7C, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x50, 0x34, 0x14, 0xF9, 0xC0, 0x28, 0x05, 0x01, 0x10, 0x22, 0x08,
  0x21, 0x04, 0x20, 0x48, 0x09, 0x01, 0x40, 0x18, 0x03, 0x00, 0x86, 0x18,
  0x61, 0x86, 0x14, 0x62, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x30, 0xC3,
  0x0C, 0x30, 0xC2, 0x0C, 0xC0, 0x48, 0x10, 0x84, 0x09, 0x01, 0xE0, 0x18,
  0x03, 0x00, 0x90, 0x31, 0x04, 0x31, 0x02, 0x40, 0x30, 0x80, 0x34, 0x02,
  0x40, 0x22, 0x04, 0x20, 0x41, 0x08, 0x10, 0x81, 0x90, 0x09, 0x00, 0xB0,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x60, 0x00, 0xFF,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x03, 0xFF, 0x02, 0x18, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x86,
  0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x81, 0x80, 0x80, 0xFF,
  0xFF, 0xE0, 0x80, 0xC0, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20,
  0x30, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x08, 0x20, 0x00, 0x30,
  0x0C, 0xC1, 0x82, 0x18, 0x1E,
};

const GFXglyph RobotoMono_ExtraLight23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 16, 14, 6, -16 },
  { 5, 4, 5, 14, 5, -17 },
  { 8, 12, 16, 14, 1, -16 },
  { 32, 10, 21, 14, 2, -19 },
  { 59, 13, 17, 14, 0, -17 },
  { 87, 11, 17, 14, 2, -17 },
  { 111, 1, 5, 14, 6, -17 },
  { 112, 6, 23, 14, 4, -18 },
  { 130, 5, 23, 14, 4, -18 },
  { 145, 10, 9, 14, 2, -16 },
  { 157, 12, 12, 14, 1, -14 },
  { 175, 3, 5, 14, 4, -2 },
  { 177, 8, 1, 14, 3, -8 },
  { 178, 2, 2, 14, 6, -2 },
  { 179, 8, 17, 14, 3, -16 },
  { 196, 10, 17, 14, 2, -17 },
  { 218, 5, 16, 14, 3, -16 },
  { 228, 11, 17, 14, 1, -17 },
  { 252, 10, 17, 14, 1, -17 },
  { 274, 11, 16, 14, 1, -16 },
  { 296, 10, 16, 14, 2, -16 },
  { 316, 10, 17, 14, 2, -17 },
  { 338, 11, 16, 14, 1, -16 },
  { 360, 10, 17, 14, 2, -17 },
  { 382, 10, 17, 14, 2, -17 },
  { 404, 2, 12, 14, 7, -12 },
  { 407, 3, 15, 14, 6, -12 },
  { 413, 10, 9, 14, 2, -12 },
  { 425, 10, 5, 14, 2, -10 },
  { 432, 10, 9, 14, 2, -12 },
  { 444, 8, 17, 14, 3, -17 },
  { 461, 12, 16, 14, 1, -16 },
  { 485, 12, 16, 14, 1, -16 },
  { 509, 10, 16, 14, 2, -16 },
  { 529, 11, 17, 14, 1, -17 },
  { 553, 11, 16, 14, 2, -16 },
  { 575, 10, 16, 14, 2, -16 },
  { 595, 10, 16, 14, 2, -16 },
  { 615, 11, 17, 14, 1, -17 },
  { 639, 10, 16, 14, 2, -16 },
  { 659, 10, 16, 14, 2, -16 },
  { 679, 10, 16, 14, 1, -16 },
  { 699, 11, 16, 14, 2, -16 },
  { 721, 9, 16, 14, 3, -16 },
  { 739, 10, 16, 14, 2, -16 },
  { 759, 10, 16, 14, 2, -16 },
  { 779, 11, 17, 14, 1, -17 },
  { 803, 10, 16, 14, 3, -16 },
  { 823, 12, 20, 14, 1, -17 },
  { 853, 11, 16, 14, 2, -16 },
  { 875, 10, 17, 14, 2, -17 },
  { 897, 12, 16, 14, 1, -16 },
  { 921, 10, 16, 14, 2, -16 },
  { 941, 12, 16, 14, 1, -16 },
  { 965, 12, 16, 14, 1, -16 },
  { 989, 12, 16, 14, 1, -16 },
  { 1013, 12, 16, 14, 1, -16 },
  { 1037, 10, 16, 14, 2, -16 },
  { 1057, 4, 23, 14, 5, -19 },
  { 1069, 8, 17, 14, 3, -16 },
  { 1086, 4, 23, 14, 5, -19 },
  { 1098, 8, 9, 14, 3, -16 },
  { 1107, 10, 1, 14, 2, 0 },
  { 1109, 3, 3, 14, 5, -17 },
  { 1111, 10, 12, 14, 2, -12 },
  { 1126, 10, 17, 14, 2, -17 },
  { 1148, 10, 12, 14, 2, -12 },
  { 1163, 9, 17, 14, 2, -17 },
  { 1183, 10, 12, 14, 2, -12 },
  { 1198, 11, 18, 14, 2, -18 },
  { 1223, 9, 17, 14, 2, -12 },
  { 1243, 10, 17, 14, 2, -17 },
  { 1265, 9, 16, 14, 3, -16 },
  { 1283, 7, 21, 14, 2, -16 },
  { 1302, 9, 17, 14, 3, -17 },
  { 1322, 9, 17, 14, 3, -17 },
  { 1342, 12, 12, 14, 1, -12 },
  { 1360, 10, 12, 14, 2, -12 },
  { 1375, 10, 12, 14, 2, -12 },
  { 1390, 10, 17, 14, 2, -12 },
  { 1412, 9, 17, 14, 2, -12 },
  { 1432, 8, 12, 14, 4, -12 },
  { 1444, 10, 12, 14, 2, -12 },
  { 1459, 10, 15, 14, 2, -15 },
  { 1478, 10, 12, 14, 2, -12 },
  { 1493, 11, 12, 14, 1, -12 },
  { 1510, 12, 12, 14, 1, -12 },
  { 1528, 11, 12, 14, 2, -12 },
  { 1545, 12, 17, 14, 1, -12 },
  { 1571, 10, 12, 14, 2, -12 },
  { 1586, 7, 23, 14, 4, -18 },
  { 1607, 1, 19, 14, 6, -16 },
  { 1610, 7, 23, 14, 4, -18 },
  { 1631, 12, 4, 14, 1, -9 },
};

const GFXfont RobotoMono_ExtraLight23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight23pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_EXTRALIGHT23PT7B_H_
