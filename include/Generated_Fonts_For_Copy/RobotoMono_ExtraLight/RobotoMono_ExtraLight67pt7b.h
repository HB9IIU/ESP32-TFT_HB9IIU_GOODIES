#ifndef _ROBOTOMONO_EXTRALIGHT67PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight67pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xEE, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x6C,
  0x06, 0xC0, 0x6C, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x03, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x18, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x60, 0x00, 0x70,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x70,
  0x00, 0x07, 0xFF, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x7F,
  0xC0, 0x00, 0x07, 0x03, 0xC7, 0x80, 0x00, 0x38, 0x1C, 0x07, 0x00, 0x00,
  0xC0, 0x60, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x38, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x30, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x04, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x1C,
  0x03, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x01, 0xC7, 0x80, 0x0F, 0x00, 0x71,
  0xC0, 0x01, 0xC0, 0x1C, 0x70, 0x00, 0x38, 0x0E, 0x38, 0x00, 0x0F, 0x03,
  0x8E, 0x00, 0x01, 0xE0, 0xE3, 0x80, 0x00, 0x3C, 0x78, 0xE0, 0x00, 0x07,
  0x1C, 0x38, 0x00, 0x00, 0xE7, 0x0E, 0x00, 0x00, 0x1F, 0x83, 0x80, 0x00,
  0x07, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1E, 0x70, 0x1E, 0x00, 0x0F, 0x1E, 0x03,
  0xE0, 0x1F, 0x83, 0xC0, 0x7F, 0xFF, 0x80, 0x70, 0x07, 0xFF, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x04, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x38, 0x00, 0x20, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x67, 0xC0, 0x30, 0x0F, 0xBF, 0xC0, 0xC0, 0xFF,
  0x1F, 0xE3, 0x1F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x9C, 0x73, 0x84, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xBF, 0xFF, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x0F, 0xD8, 0x00, 0x00, 0x77, 0x60, 0x00, 0x03,
  0x9F, 0x80, 0x00, 0x1C, 0x7E, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0x07, 0x07,
  0xE0, 0x00, 0x38, 0x1F, 0x80, 0x01, 0xC0, 0x7E, 0x00, 0x0E, 0x01, 0xF8,
  0x00, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x3C, 0x00, 0x7E, 0x01,
  0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x1F, 0x83, 0xC0,
  0x00, 0x7E, 0x1E, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x07, 0x77, 0x00, 0x00,
  0x1D, 0xF8, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xB8,
  0x7F, 0x1C, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x83, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x80,
  0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x7F, 0xE0, 0x03, 0x9F, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x03, 0xF0, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0xFF, 0x80, 0x1C, 0x3F, 0xFF, 0x00,
  0xC3, 0xF0, 0xFE, 0x0E, 0x7C, 0x00, 0xF8, 0x77, 0x80, 0x01, 0xE3, 0xB0,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x78, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x0F, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0x61, 0xE0, 0x00, 0x1D, 0x83, 0xC0, 0x00, 0xE6, 0x07, 0x80, 0x0F, 0x38,
  0x0F, 0x81, 0xF8, 0xE0, 0x1F, 0xFF, 0x83, 0x80, 0x1F, 0xFC, 0x0E, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x71,
  0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xBF, 0xF9,
  0xE0, 0x1C, 0x1E, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x40, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x7E, 0x03, 0xE0, 0x07, 0x83, 0xC0,
  0x01, 0xE3, 0xC0, 0x00, 0x79, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x7E, 0x00, 0xE1, 0xC0, 0x1F, 0xF8, 0x06, 0x18, 0x03,
  0xE7, 0xC0, 0x63, 0x80, 0x70, 0x0C, 0x07, 0x30, 0x0E, 0x00, 0xC0, 0x73,
  0x00, 0xC0, 0x0C, 0x03, 0x70, 0x1C, 0x00, 0xC0, 0x36, 0x01, 0x80, 0x0C,
  0x03, 0x60, 0x18, 0x01, 0xC0, 0x36, 0x03, 0x80, 0x1C, 0x03, 0xE0, 0x30,
  0x01, 0x80, 0x3E, 0x03, 0x00, 0x18, 0x03, 0xC0, 0x30, 0x01, 0x80, 0x3C,
  0x07, 0x00, 0x18, 0x03, 0xC0, 0x70, 0x01, 0x80, 0x3C, 0x07, 0x00, 0x18,
  0x03, 0xC0, 0x60, 0x01, 0x80, 0x3C, 0x06, 0x00, 0x38, 0x03, 0xC0, 0x60,
  0x03, 0x80, 0x7C, 0x07, 0x00, 0x38, 0x06, 0xC0, 0x70, 0x07, 0x00, 0x6C,
  0x07, 0x00, 0x78, 0x06, 0xE0, 0x30, 0x0F, 0x80, 0xEE, 0x03, 0x00, 0xD8,
  0x0C, 0x60, 0x38, 0x19, 0x81, 0xC6, 0x01, 0xC3, 0x9C, 0x38, 0x70, 0x1F,
  0xF0, 0xFF, 0x07, 0x00, 0xFC, 0x07, 0xE0, 0x38, 0x03, 0x00, 0x10, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x60, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xC0, 0x01, 0xFC,
  0x0E, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x0F, 0x8E, 0x00, 0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x07, 0xE0, 0x0E,
  0x00, 0x03, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF8, 0x0E, 0x00,
  0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0xE1, 0xF0, 0x00, 0x00, 0xE3, 0xF8, 0x00, 0x00, 0xE7, 0xBC,
  0x00, 0x00, 0xEF, 0x1C, 0x00, 0x00, 0xFE, 0x0E, 0x00, 0x00, 0xFC, 0x0F,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0D, 0xEE, 0x00,
  0x00, 0xEF, 0x70, 0x00, 0x07, 0x7B, 0x80, 0x00, 0x73, 0xCE, 0x00, 0x03,
  0x9E, 0x70, 0x00, 0x18, 0xF1, 0x80, 0x01, 0xC7, 0xCE, 0x00, 0x0E, 0x7E,
  0x70, 0x00, 0xE3, 0xF1, 0x80, 0x07, 0x1F, 0x8E, 0x00, 0x30, 0xFC, 0x70,
  0x03, 0x87, 0xE1, 0xC0, 0x1C, 0x3F, 0x0E, 0x00, 0xC1, 0xF8, 0x30, 0x0E,
  0x0F, 0xC1, 0xC0, 0x70, 0x7E, 0x0E, 0x07, 0x03, 0xF0, 0x30, 0x38, 0x1F,
  0x81, 0xC1, 0x80, 0xFC, 0x0E, 0x1C, 0x07, 0xE0, 0x38, 0xE0, 0x3F, 0x01,
  0xCE, 0x01, 0xF8, 0x06, 0x70, 0x0F, 0xC0, 0x3B, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3C, 0x00, 0xFC, 0x01, 0xE0, 0x07,
  0xE0, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0xFB,
  0x80, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x01, 0xF1, 0xC0,
  0x00, 0x0F, 0x87, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x03, 0xE0, 0xE0, 0x00,
  0x1F, 0x07, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x3E,
  0x03, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x7C, 0x01,
  0xC0, 0x03, 0xE0, 0x0E, 0x00, 0x1F, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xC0,
  0x07, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0x38, 0x01, 0xF0, 0x00, 0xE0, 0x0F,
  0x80, 0x07, 0x00, 0x7C, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x70, 0x1F, 0x00,
  0x03, 0x80, 0xF8, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x70, 0x3E, 0x00, 0x01,
  0xC1, 0xF0, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x38, 0x7C, 0x00, 0x01, 0xC3,
  0xE0, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0xE7, 0xC0,
  0x00, 0x03, 0xBE, 0x00, 0x00, 0x1D, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x07, 0xE0, 0xE0,
  0x00, 0x07, 0xC3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xF8, 0xE0, 0x00, 0x0F, 0xC3, 0x80, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0C, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x38, 0x00,
  0x1F, 0x80, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0xC0,
  0x7C, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x06, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03,
  0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x76, 0x00, 0x0F, 0x00, 0x0E, 0xC0,
  0x03, 0xE0, 0x01, 0xDC, 0x00, 0x7C, 0x00, 0x3B, 0x80, 0x0F, 0x80, 0x06,
  0x70, 0x01, 0xB8, 0x00, 0xCE, 0x00, 0x37, 0x00, 0x19, 0xC0, 0x06, 0xE0,
  0x07, 0x18, 0x01, 0xCC, 0x00, 0xE3, 0x00, 0x39, 0x80, 0x1C, 0x70, 0x06,
  0x38, 0x03, 0x0E, 0x00, 0xC7, 0x00, 0x61, 0xC0, 0x18, 0xE0, 0x0C, 0x38,
  0x07, 0x0C, 0x03, 0x83, 0x00, 0xE1, 0x80, 0x70, 0x60, 0x1C, 0x38, 0x0E,
  0x0C, 0x03, 0x07, 0x01, 0xC1, 0xC0, 0x60, 0xE0, 0x30, 0x38, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x0C, 0x0C,
  0x07, 0x07, 0x01, 0x81, 0x80, 0xE0, 0xE0, 0x38, 0x70, 0x1C, 0x1C, 0x07,
  0x0E, 0x01, 0x83, 0x00, 0xE1, 0xC0, 0x30, 0x60, 0x1C, 0x30, 0x07, 0x0C,
  0x03, 0x86, 0x00, 0xE3, 0x80, 0x31, 0xC0, 0x1C, 0x70, 0x06, 0x38, 0x01,
  0x8E, 0x00, 0xE7, 0x00, 0x31, 0x80, 0x1C, 0xC0, 0x07, 0x30, 0x03, 0x98,
  0x00, 0xE6, 0x00, 0x77, 0x00, 0x1C, 0xC0, 0x06, 0xE0, 0x01, 0xB8, 0x00,
  0xDC, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x76, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0x80,
  0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0D, 0xCF, 0x00,
  0x01, 0xEE, 0x3C, 0x00, 0x1E, 0x70, 0xF8, 0x07, 0xC3, 0x83, 0xFF, 0xFC,
  0x1C, 0x07, 0xFF, 0x80, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x3F,
  0xC0, 0x0E, 0x0F, 0xFF, 0x00, 0xE3, 0xFF, 0xFC, 0x0E, 0x78, 0x03, 0xE0,
  0xEE, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x70, 0xF8, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x07, 0x8F, 0xC0,
  0x00, 0xF0, 0xEE, 0x00, 0x1E, 0x0E, 0x7C, 0x07, 0xC0, 0xE3, 0xFF, 0xF8,
  0x0E, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C,
  0x0F, 0x80, 0x07, 0x80, 0x7E, 0x01, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xC0, 0x70, 0x0F,
  0xFF, 0x87, 0x01, 0xFF, 0xFC, 0x70, 0x7C, 0x01, 0xE7, 0x07, 0x80, 0x07,
  0x70, 0xE0, 0x00, 0x3F, 0x1E, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3F, 0x07,
  0x80, 0x07, 0x70, 0x3E, 0x03, 0xE3, 0x01, 0xFF, 0xFC, 0x30, 0x07, 0xFF,
  0x03, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0xF0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x1F,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE,
  0x0C, 0x0F, 0xFF, 0xE1, 0x83, 0xC0, 0x1E, 0x30, 0xF0, 0x00, 0xE6, 0x3C,
  0x00, 0x0E, 0xCF, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x0E, 0xE0, 0xF8, 0x0F,
  0x9C, 0x0F, 0xFF, 0xE3, 0x80, 0x7F, 0xF0, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x40, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x3F, 0x8F, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x07, 0xF8, 0x07, 0x03, 0xFF,
  0xE0, 0xE1, 0xFF, 0xFE, 0x1C, 0x78, 0x03, 0xE3, 0x9C, 0x00, 0x1E, 0x77,
  0x00, 0x01, 0xCE, 0xC0, 0x00, 0x1D, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC1, 0x80, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x2E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x0E, 0x00,
  0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x0F, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x0E, 0xFF, 0x00,
  0x00, 0xFE, 0x78, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x31, 0xFF, 0xC1,
  0xFF, 0x8C, 0xFF, 0xF8, 0xFF, 0xF3, 0xF0, 0x1E, 0x70, 0x1E, 0xF8, 0x01,
  0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x03, 0x80, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x3E,
  0x00, 0x0C, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00,
  0xF8, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x03, 0x00,
  0x03, 0xE0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x0C,
  0x00, 0x0F, 0x80, 0x03, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0xF8, 0x00,
  0x30, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x03, 0xE0,
  0x00, 0xC0, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x0F,
  0x80, 0x03, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x30, 0x00,
  0x3E, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x03, 0xE0, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x1F, 0xE0, 0x18, 0x0F, 0xFF, 0x83, 0x07, 0xFF, 0xF8,
  0x61, 0xE0, 0x0F, 0x8C, 0x70, 0x00, 0x79, 0x9C, 0x00, 0x07, 0x37, 0x00,
  0x00, 0x76, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x0E,
  0x1F, 0xFF, 0x00, 0xE3, 0xFF, 0xFC, 0x0E, 0x78, 0x03, 0xE0, 0xEE, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x70, 0xF8, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0xF0,
  0xEE, 0x00, 0x1E, 0x0E, 0x78, 0x07, 0xC0, 0xE3, 0xFF, 0xF8, 0x0E, 0x0F,
  0xFE, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x83, 0x01, 0xFF,
  0xFC, 0x30, 0x7C, 0x01, 0xF3, 0x07, 0x80, 0x07, 0x30, 0xF0, 0x00, 0x3B,
  0x1E, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3F, 0x07, 0x80, 0x07, 0x70, 0x3E,
  0x01, 0xE7, 0x01, 0xFF, 0xFC, 0x70, 0x07, 0xFF, 0x07, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0x80, 0x0E, 0x3C, 0x00,
  0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x76, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x1C, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xCE, 0x00, 0x03, 0xB8, 0xE0,
  0x00, 0xE7, 0x1F, 0x00, 0xF8, 0xE0, 0xFF, 0xFE, 0x1C, 0x0F, 0xFF, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x76, 0x00, 0x07, 0x00, 0x07, 0x70, 0x00, 0x70,
  0x00, 0x77, 0x00, 0x0F, 0x00, 0x07, 0x70, 0x00, 0xF8, 0x00, 0x63, 0x00,
  0x0D, 0x80, 0x0E, 0x38, 0x00, 0xD8, 0x00, 0xE3, 0x80, 0x1D, 0x80, 0x0E,
  0x38, 0x01, 0x9C, 0x00, 0xC1, 0x80, 0x19, 0xC0, 0x0C, 0x18, 0x01, 0x8C,
  0x01, 0xC1, 0xC0, 0x38, 0xC0, 0x1C, 0x1C, 0x03, 0x0E, 0x01, 0xC1, 0xC0,
  0x30, 0xE0, 0x18, 0x0C, 0x03, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x60, 0x38,
  0x0E, 0x06, 0x07, 0x03, 0x80, 0xE0, 0x60, 0x70, 0x30, 0x06, 0x06, 0x03,
  0x03, 0x00, 0x60, 0xE0, 0x30, 0x70, 0x07, 0x0C, 0x03, 0x87, 0x00, 0x70,
  0xC0, 0x18, 0x60, 0x07, 0x0C, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x18, 0x60,
  0x03, 0x18, 0x01, 0xCE, 0x00, 0x39, 0x80, 0x0C, 0xE0, 0x03, 0x98, 0x00,
  0xCC, 0x00, 0x1B, 0x80, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x1B,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x0F,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0x1F, 0xFF, 0x00, 0x00, 0x71, 0xE0, 0xF8, 0x00, 0x07,
  0x38, 0x03, 0xC0, 0x00, 0x77, 0x00, 0x1E, 0x00, 0x06, 0x70, 0x00, 0xF8,
  0x00, 0xE6, 0x00, 0x03, 0xC0, 0x1C, 0xE0, 0x00, 0x1F, 0x03, 0xCE, 0x00,
  0x00, 0xFF, 0xF8, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoMono_ExtraLight67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 5, 48, 40, 17, -48 },
  { 31, 12, 14, 40, 14, -50 },
  { 52, 37, 48, 40, 2, -48 },
  { 274, 29, 62, 40, 6, -55 },
  { 499, 38, 49, 40, 1, -48 },
  { 732, 34, 49, 40, 5, -48 },
  { 941, 3, 14, 40, 17, -50 },
  { 947, 15, 68, 40, 13, -53 },
  { 1075, 15, 68, 40, 12, -53 },
  { 1203, 30, 28, 40, 6, -48 },
  { 1308, 33, 34, 40, 4, -39 },
  { 1449, 6, 15, 40, 13, -6 },
  { 1461, 24, 3, 40, 8, -23 },
  { 1470, 5, 5, 40, 19, -5 },
  { 1474, 22, 52, 40, 10, -48 },
  { 1617, 30, 49, 40, 5, -48 },
  { 1801, 17, 48, 40, 7, -48 },
  { 1903, 31, 48, 40, 3, -48 },
  { 2089, 30, 49, 40, 3, -48 },
  { 2273, 33, 48, 40, 3, -48 },
  { 2471, 28, 49, 40, 7, -48 },
  { 2643, 29, 49, 40, 5, -48 },
  { 2821, 31, 48, 40, 4, -48 },
  { 3007, 30, 49, 40, 6, -48 },
  { 3191, 30, 48, 40, 5, -48 },
  { 3371, 6, 34, 40, 20, -34 },
  { 3397, 8, 43, 40, 18, -34 },
  { 3440, 29, 27, 40, 5, -35 },
  { 3538, 29, 16, 40, 6, -30 },
  { 3596, 29, 27, 40, 6, -35 },
  { 3694, 25, 48, 40, 8, -48 },
  { 3844, 36, 48, 40, 2, -48 },
  { 4060, 33, 48, 40, 4, -48 },
  { 4258, 29, 48, 40, 7, -48 },
  { 4432, 32, 49, 40, 4, -48 },
  { 4628, 31, 48, 40, 6, -48 },
  { 4814, 27, 48, 40, 7, -48 },
  { 4976, 28, 48, 40, 7, -48 },
  { 5144, 32, 49, 40, 4, -48 },
  { 5340, 29, 48, 40, 6, -48 },
  { 5514, 27, 48, 40, 7, -48 },
  { 5676, 29, 49, 40, 4, -48 },
  { 5854, 32, 48, 40, 7, -48 },
  { 6046, 27, 48, 40, 8, -48 },
  { 6208, 29, 48, 40, 6, -48 },
  { 6382, 29, 48, 40, 6, -48 },
  { 6556, 32, 49, 40, 4, -48 },
  { 6752, 30, 48, 40, 7, -48 },
  { 6932, 33, 56, 40, 4, -48 },
  { 7163, 30, 48, 40, 7, -48 },
  { 7343, 31, 49, 40, 5, -48 },
  { 7533, 34, 48, 40, 3, -48 },
  { 7737, 30, 49, 40, 5, -48 },
  { 7921, 34, 48, 40, 3, -48 },
  { 8125, 35, 48, 40, 3, -48 },
  { 8335, 33, 48, 40, 4, -48 },
  { 8533, 34, 48, 40, 3, -48 },
  { 8737, 30, 48, 40, 4, -48 },
  { 8917, 11, 64, 40, 15, -54 },
  { 9005, 23, 52, 40, 9, -48 },
  { 9155, 11, 64, 40, 14, -54 },
  { 9243, 24, 26, 40, 8, -48 },
  { 9321, 28, 3, 40, 6, 0 },
  { 9332, 10, 8, 40, 15, -49 },
  { 9342, 29, 37, 40, 6, -36 },
  { 9477, 28, 51, 40, 7, -50 },
  { 9656, 28, 37, 40, 6, -36 },
  { 9786, 28, 51, 40, 5, -50 },
  { 9965, 30, 37, 40, 5, -36 },
  { 10104, 31, 51, 40, 6, -51 },
  { 10302, 27, 50, 40, 6, -36 },
  { 10471, 27, 50, 40, 7, -50 },
  { 10640, 27, 48, 40, 8, -48 },
  { 10802, 21, 62, 40, 6, -48 },
  { 10965, 28, 50, 40, 8, -50 },
  { 11140, 27, 50, 40, 8, -50 },
  { 11309, 34, 36, 40, 3, -36 },
  { 11462, 27, 36, 40, 7, -36 },
  { 11584, 32, 37, 40, 4, -36 },
  { 11732, 28, 50, 40, 7, -36 },
  { 11907, 28, 50, 40, 5, -36 },
  { 12082, 23, 36, 40, 12, -36 },
  { 12186, 29, 37, 40, 6, -36 },
  { 12321, 28, 46, 40, 6, -45 },
  { 12482, 27, 36, 40, 7, -35 },
  { 12604, 32, 35, 40, 4, -35 },
  { 12744, 36, 35, 40, 2, -35 },
  { 12902, 31, 35, 40, 5, -35 },
  { 13038, 34, 49, 40, 3, -35 },
  { 13247, 31, 35, 40, 5, -35 },
  { 13383, 21, 66, 40, 11, -52 },
  { 13557, 2, 58, 40, 19, -48 },
  { 13572, 21, 66, 40, 11, -52 },
  { 13746, 36, 12, 40, 2, -26 },
};

const GFXfont RobotoMono_ExtraLight67pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight67pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _ROBOTOMONO_EXTRALIGHT67PT7B_H_
