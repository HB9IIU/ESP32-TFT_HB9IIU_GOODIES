#ifndef _ROBOTOMONO_EXTRALIGHT66PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight66pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xEF, 0xFD, 0xC0, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x01, 0x80, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x70, 0x03, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x01, 0xF8, 0x01,
  0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x40, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x38, 0x07, 0x00,
  0x18, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x60, 0x01, 0x80, 0x0C,
  0x07, 0x00, 0x0C, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x07, 0x03, 0x80, 0x01,
  0x80, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x81, 0x80, 0x00, 0x3C, 0xF8, 0x1C,
  0x00, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x3E, 0x00, 0x00, 0x1C, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x7D, 0xF0,
  0x00, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x60, 0x70, 0x0E, 0x00, 0x07, 0x03,
  0x00, 0x30, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x0E, 0x00,
  0x18, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x1C, 0x03, 0x80,
  0x0C, 0x00, 0xE0, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x60,
  0x07, 0x00, 0x18, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x10, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0xC1,
  0xC0, 0x38, 0x00, 0x61, 0xC0, 0x0E, 0x00, 0x31, 0xE0, 0x03, 0x80, 0x38,
  0xE0, 0x01, 0xE0, 0x1C, 0x70, 0x00, 0x78, 0x0E, 0x70, 0x00, 0x1C, 0x07,
  0x38, 0x00, 0x07, 0x07, 0x1C, 0x00, 0x01, 0xC3, 0x8E, 0x00, 0x00, 0xF1,
  0xC7, 0x00, 0x00, 0x3D, 0xC3, 0x80, 0x00, 0x0E, 0xE1, 0xC0, 0x00, 0x03,
  0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0xFE, 0x07, 0x80, 0x00, 0xF7, 0x01, 0xE0, 0x00, 0xF1, 0xC0, 0x7C, 0x03,
  0xE0, 0x70, 0x1F, 0xFF, 0xE0, 0x3C, 0x03, 0xFF, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xED, 0x80, 0x00, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x40, 0x60, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x0B, 0x80, 0x18,
  0x03, 0xDF, 0x80, 0xC0, 0x7F, 0xFF, 0x06, 0x1F, 0xE0, 0xFF, 0x37, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x1C, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC6, 0x38, 0xE3, 0x9C, 0x73, 0x84, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x33, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x03, 0xEC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xBF, 0x00, 0x00, 0x39, 0xF8, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x38, 0x3E,
  0x00, 0x03, 0x81, 0xF0, 0x00, 0x38, 0x0F, 0x80, 0x03, 0x80, 0x7C, 0x00,
  0x38, 0x03, 0xE0, 0x03, 0x80, 0x1F, 0x00, 0x78, 0x00, 0xF8, 0x07, 0x80,
  0x07, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3B, 0xF0,
  0x00, 0x01, 0xDF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x1E,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xF3, 0x1F, 0x83, 0x7E, 0x03, 0xF8,
  0x03, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x00,
  0x78, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x3C, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x39, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x01, 0xF0,
  0x38, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x0F, 0xC0, 0x03, 0x83, 0xFF, 0xC0,
  0x18, 0x7F, 0xFF, 0x81, 0xC7, 0x80, 0x3E, 0x0E, 0x70, 0x00, 0x78, 0x77,
  0x00, 0x01, 0xE3, 0xF0, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x78,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0xF9, 0xC0, 0x00, 0x07, 0xC7, 0x00, 0x00, 0x6E, 0x3C, 0x00,
  0x07, 0x70, 0xF0, 0x00, 0xF3, 0x83, 0xE0, 0x1F, 0x1C, 0x0F, 0xFF, 0xE0,
  0xC0, 0x1F, 0xFE, 0x06, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0x78, 0x1C,
  0x7C, 0xF9, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0xE0, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x03, 0xC1, 0xC0, 0x00,
  0xF1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0x1C, 0x1C, 0x00, 0xFF,
  0x00, 0xC1, 0x80, 0x3F, 0xF8, 0x0E, 0x38, 0x07, 0x83, 0xC0, 0x63, 0x80,
  0x70, 0x0C, 0x06, 0x30, 0x0E, 0x01, 0xC0, 0x67, 0x01, 0xC0, 0x18, 0x06,
  0x60, 0x18, 0x01, 0x80, 0x66, 0x01, 0x80, 0x18, 0x07, 0x60, 0x38, 0x01,
  0x80, 0x7E, 0x03, 0x00, 0x18, 0x07, 0xE0, 0x30, 0x01, 0x80, 0x7C, 0x07,
  0x00, 0x18, 0x07, 0xC0, 0x70, 0x01, 0x80, 0x7C, 0x06, 0x00, 0x38, 0x07,
  0xC0, 0x60, 0x03, 0x80, 0x7C, 0x06, 0x00, 0x30, 0x06, 0xC0, 0x60, 0x03,
  0x00, 0x6C, 0x06, 0x00, 0x30, 0x06, 0xC0, 0x60, 0x03, 0x00, 0x6C, 0x06,
  0x00, 0x70, 0x06, 0xC0, 0x70, 0x07, 0x00, 0xCE, 0x07, 0x00, 0xF0, 0x0C,
  0xE0, 0x30, 0x0F, 0x01, 0xC6, 0x03, 0x81, 0xB8, 0x18, 0x60, 0x38, 0x31,
  0x83, 0x86, 0x01, 0xFF, 0x1F, 0xF0, 0x70, 0x0F, 0xC0, 0xFE, 0x03, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x0E, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x07, 0xE0,
  0xC0, 0x00, 0x1F, 0x0C, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x07, 0x8C, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x3E, 0x0C,
  0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xC0, 0x00,
  0x3E, 0x0C, 0x00, 0x00, 0xF8, 0xC0, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xEC, 0x00, 0x00,
  0x3C, 0xC0, 0x00, 0x07, 0x8C, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x1F, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x03,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x70, 0x07,
  0x80, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x38, 0xFC, 0x00, 0x00, 0x73, 0xFC, 0x00, 0x00, 0xEF, 0x3C, 0x00,
  0x01, 0xFC, 0x38, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x07, 0xC0, 0x38, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xF0, 0x03,
  0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xEC, 0x00, 0x00, 0xDF, 0x70, 0x00,
  0x0E, 0xFB, 0x80, 0x00, 0x77, 0xCE, 0x00, 0x07, 0x3E, 0x70, 0x00, 0x39,
  0xF1, 0x80, 0x01, 0x8F, 0x8E, 0x00, 0x1C, 0x7C, 0x70, 0x00, 0xE3, 0xE1,
  0x80, 0x0E, 0x1F, 0x0E, 0x00, 0x70, 0xF8, 0x70, 0x03, 0x07, 0xC1, 0xC0,
  0x38, 0x3E, 0x0E, 0x01, 0xC1, 0xF0, 0x30, 0x0C, 0x0F, 0x81, 0xC0, 0xE0,
  0x7C, 0x0E, 0x07, 0x03, 0xE0, 0x30, 0x70, 0x1F, 0x01, 0xC3, 0x80, 0xF8,
  0x0E, 0x18, 0x07, 0xC0, 0x31, 0xC0, 0x3E, 0x01, 0xCE, 0x01, 0xF0, 0x06,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xDC, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x7C, 0x60,
  0x00, 0x07, 0xC7, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x07, 0xC3, 0x80, 0x00,
  0x7C, 0x1C, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x7C, 0x0E, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x7C, 0x07, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x7C, 0x03, 0x80,
  0x07, 0xC0, 0x1C, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x7C,
  0x00, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x7C, 0x00, 0x70, 0x07, 0xC0, 0x03,
  0x80, 0x7C, 0x00, 0x1C, 0x07, 0xC0, 0x01, 0xC0, 0x7C, 0x00, 0x0E, 0x07,
  0xC0, 0x00, 0xE0, 0x7C, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x70, 0x7C, 0x00,
  0x03, 0x87, 0xC0, 0x00, 0x38, 0x7C, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x0E,
  0x7C, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x07, 0x7C, 0x00, 0x00, 0x77, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x1F,
  0x0E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x3F, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x7C, 0x0E,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC0,
  0xE0, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xC0,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x1E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70,
  0x00, 0x66, 0x00, 0x1F, 0x00, 0x0C, 0xC0, 0x03, 0xE0, 0x01, 0x9C, 0x00,
  0x7C, 0x00, 0x73, 0x80, 0x0D, 0x80, 0x0E, 0x70, 0x01, 0xB0, 0x01, 0xCE,
  0x00, 0x77, 0x00, 0x31, 0xC0, 0x0E, 0xE0, 0x06, 0x18, 0x01, 0x9C, 0x00,
  0xC3, 0x00, 0x31, 0x80, 0x38, 0x70, 0x06, 0x30, 0x07, 0x0E, 0x01, 0xC7,
  0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x03, 0x03, 0x00,
  0xC1, 0x80, 0x60, 0x60, 0x18, 0x30, 0x0C, 0x0C, 0x07, 0x06, 0x03, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x30, 0x0C, 0x1C, 0x06, 0x06, 0x01, 0x83, 0x80,
  0xE0, 0xC0, 0x38, 0x70, 0x1C, 0x38, 0x07, 0x0C, 0x03, 0x87, 0x00, 0xE1,
  0x80, 0x30, 0xE0, 0x1C, 0x70, 0x06, 0x18, 0x03, 0x8E, 0x00, 0xE3, 0x00,
  0x31, 0xC0, 0x1C, 0x60, 0x06, 0x30, 0x03, 0x8C, 0x00, 0xE6, 0x00, 0x33,
  0x80, 0x1C, 0xC0, 0x06, 0x70, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x77, 0x00,
  0x1D, 0x80, 0x06, 0xE0, 0x03, 0xB0, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x1B,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x39, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x87,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0x00, 0x0F, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE1, 0xF8, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xE7, 0x00, 0x00,
  0xEE, 0x3C, 0x00, 0x3C, 0xE3, 0xF0, 0x0F, 0x87, 0x0F, 0xFF, 0xF0, 0x70,
  0x7F, 0xF8, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x01, 0x00, 0x07, 0x07, 0xFF,
  0x00, 0xE1, 0xFF, 0xF8, 0x1C, 0xF8, 0x1F, 0x83, 0xBC, 0x00, 0x78, 0x7E,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xCF,
  0x80, 0x00, 0x71, 0xF8, 0x00, 0x1E, 0x3B, 0x80, 0x07, 0x87, 0x3C, 0x03,
  0xE0, 0xE3, 0xFF, 0xF8, 0x1C, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x03, 0xC0,
  0x1F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x70, 0x07, 0xFE, 0x07, 0x01,
  0xFF, 0xF8, 0x70, 0x3E, 0x03, 0xC7, 0x07, 0x80, 0x0E, 0x70, 0xF0, 0x00,
  0x77, 0x1E, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3F, 0x07, 0x80, 0x0F, 0x70,
  0x3E, 0x03, 0xE7, 0x01, 0xFF, 0xFC, 0x70, 0x07, 0xFF, 0x07, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0xE0, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x81, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x07,
  0x01, 0xFF, 0xF8, 0x70, 0x3E, 0x03, 0xC7, 0x07, 0x80, 0x0E, 0x70, 0xF0,
  0x00, 0x77, 0x1E, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3F, 0x07, 0x80, 0x0F,
  0x70, 0x3E, 0x03, 0xE7, 0x01, 0xFF, 0xFC, 0x70, 0x07, 0xFF, 0x07, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x07, 0xC0,
  0x1F, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x01, 0xFF, 0x80, 0xC0, 0xFF, 0xFC, 0x18, 0x7C, 0x07,
  0xC3, 0x1E, 0x00, 0x3C, 0x67, 0x00, 0x03, 0xCC, 0xC0, 0x00, 0x39, 0xB0,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x7F, 0x81, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x07,
  0x98, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x3C, 0x0C, 0x00,
  0x0F, 0x01, 0x80, 0x03, 0xC0, 0x30, 0x00, 0xF0, 0x06, 0x00, 0x3C, 0x00,
  0xC0, 0x0F, 0x00, 0x18, 0x03, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x78,
  0x00, 0x0C, 0x1E, 0x00, 0x01, 0x87, 0x80, 0x00, 0x31, 0xF0, 0x00, 0x06,
  0x7F, 0x00, 0x00, 0xDE, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x70, 0x0F, 0x00, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xE0, 0x06, 0x00, 0x1E, 0x00, 0xC0, 0x01, 0xE0, 0x18, 0x00, 0x1E,
  0x03, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0xE1, 0x80,
  0x00, 0x1C, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03,
  0xD8, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x20, 0x00, 0x40, 0x30, 0xFF, 0x80, 0xFF, 0x0C, 0x7F, 0xF0, 0xFF, 0xE3,
  0x38, 0x3E, 0x78, 0x3C, 0xD8, 0x03, 0xB8, 0x07, 0xBC, 0x00, 0x7C, 0x00,
  0xEF, 0x00, 0x1E, 0x00, 0x1B, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x01, 0xC0,
  0x01, 0xF8, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x07,
  0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x1C, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x01,
  0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x1C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x02, 0x00, 0x30,
  0x0F, 0xFC, 0x0C, 0x0F, 0xFF, 0xC3, 0x0F, 0x80, 0xF8, 0xC7, 0x80, 0x0F,
  0x33, 0x80, 0x01, 0xEC, 0xC0, 0x00, 0x3B, 0x60, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x1F, 0xFC, 0x03,
  0x0F, 0xFF, 0xC0, 0x63, 0xE0, 0x7E, 0x0C, 0xE0, 0x03, 0xE1, 0xB8, 0x00,
  0x1E, 0x3E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x3C, 0x00,
  0x01, 0xC7, 0xC0, 0x00, 0x78, 0xFE, 0x00, 0x1E, 0x1D, 0xF0, 0x0F, 0x83,
  0x8F, 0xFF, 0xE0, 0x70, 0x7F, 0xF0, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x07, 0x01, 0xFF,
  0xF8, 0x70, 0x3E, 0x03, 0xE7, 0x07, 0x80, 0x0F, 0x70, 0xF0, 0x00, 0x77,
  0x1E, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3F, 0x07, 0x80, 0x07, 0x70, 0x3E,
  0x03, 0xE7, 0x01, 0xFF, 0xFC, 0x70, 0x07, 0xFF, 0x07, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x41, 0xC0, 0x3F,
  0xFF, 0x81, 0xFF, 0xF7, 0x0F, 0xE0, 0x2E, 0x3E, 0x00, 0x1C, 0xF0, 0x00,
  0x3B, 0x80, 0x00, 0x76, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xF3, 0x80,
  0x00, 0xFC, 0xF0, 0x00, 0xF7, 0x1F, 0x00, 0xF9, 0xC3, 0xFF, 0xF8, 0x70,
  0x3F, 0xFC, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x76, 0x00, 0x07, 0x00, 0x07, 0x60,
  0x00, 0xF0, 0x00, 0x67, 0x00, 0x0F, 0x00, 0x0E, 0x70, 0x00, 0xF0, 0x00,
  0xE7, 0x00, 0x0F, 0x80, 0x0E, 0x30, 0x01, 0xF8, 0x00, 0xC3, 0x80, 0x19,
  0x80, 0x0C, 0x38, 0x01, 0x98, 0x01, 0xC3, 0x80, 0x19, 0xC0, 0x1C, 0x18,
  0x03, 0x9C, 0x01, 0xC1, 0x80, 0x39, 0xC0, 0x18, 0x1C, 0x03, 0x0C, 0x03,
  0x81, 0xC0, 0x30, 0xE0, 0x38, 0x1C, 0x07, 0x0E, 0x03, 0x80, 0xC0, 0x70,
  0x60, 0x30, 0x0E, 0x06, 0x06, 0x03, 0x00, 0xE0, 0x60, 0x70, 0x70, 0x0E,
  0x0E, 0x07, 0x07, 0x00, 0x60, 0xC0, 0x30, 0x60, 0x06, 0x0C, 0x03, 0x06,
  0x00, 0x70, 0xC0, 0x38, 0x60, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x31, 0x80,
  0x18, 0xE0, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x1C, 0xC0, 0x03,
  0xB8, 0x01, 0xCC, 0x00, 0x3B, 0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x7D,
  0xFC, 0x00, 0x01, 0x9E, 0x03, 0xE0, 0x00, 0x37, 0x00, 0x1E, 0x00, 0x0E,
  0xE0, 0x01, 0xE0, 0x01, 0xD8, 0x00, 0x1E, 0x00, 0x77, 0x00, 0x01, 0xF0,
  0x1C, 0xE0, 0x00, 0x1F, 0xFF, 0x9C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00,
};

const GFXglyph RobotoMono_ExtraLight66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 5, 47, 40, 17, -47 },
  { 31, 11, 14, 40, 14, -50 },
  { 51, 36, 47, 40, 2, -47 },
  { 263, 29, 61, 40, 6, -54 },
  { 485, 37, 49, 40, 1, -48 },
  { 712, 33, 49, 40, 5, -48 },
  { 915, 3, 14, 40, 17, -50 },
  { 921, 14, 67, 40, 13, -52 },
  { 1039, 15, 67, 40, 11, -52 },
  { 1165, 29, 27, 40, 6, -47 },
  { 1263, 32, 34, 40, 4, -39 },
  { 1399, 6, 15, 40, 13, -6 },
  { 1411, 23, 3, 40, 8, -23 },
  { 1420, 5, 5, 40, 18, -5 },
  { 1424, 23, 51, 40, 9, -47 },
  { 1571, 29, 49, 40, 5, -48 },
  { 1749, 16, 47, 40, 7, -47 },
  { 1843, 30, 48, 40, 3, -48 },
  { 2023, 29, 49, 40, 3, -48 },
  { 2201, 33, 47, 40, 3, -47 },
  { 2395, 28, 48, 40, 7, -47 },
  { 2563, 29, 48, 40, 5, -47 },
  { 2737, 31, 47, 40, 4, -47 },
  { 2920, 30, 49, 40, 6, -48 },
  { 3104, 29, 48, 40, 5, -48 },
  { 3278, 5, 33, 40, 20, -33 },
  { 3299, 7, 42, 40, 18, -33 },
  { 3336, 28, 27, 40, 5, -35 },
  { 3431, 28, 16, 40, 6, -29 },
  { 3487, 28, 27, 40, 6, -35 },
  { 3582, 25, 48, 40, 8, -48 },
  { 3732, 36, 47, 40, 2, -47 },
  { 3944, 33, 47, 40, 4, -47 },
  { 4138, 28, 47, 40, 7, -47 },
  { 4303, 31, 49, 40, 4, -48 },
  { 4493, 30, 47, 40, 6, -47 },
  { 4670, 27, 47, 40, 7, -47 },
  { 4829, 27, 47, 40, 7, -47 },
  { 4988, 31, 49, 40, 4, -48 },
  { 5178, 29, 47, 40, 5, -47 },
  { 5349, 26, 47, 40, 7, -47 },
  { 5502, 29, 48, 40, 4, -47 },
  { 5676, 31, 47, 40, 7, -47 },
  { 5859, 28, 47, 40, 7, -47 },
  { 6024, 29, 47, 40, 6, -47 },
  { 6195, 28, 47, 40, 6, -47 },
  { 6360, 31, 49, 40, 4, -48 },
  { 6550, 29, 47, 40, 7, -47 },
  { 6721, 32, 56, 40, 4, -48 },
  { 6945, 29, 47, 40, 7, -47 },
  { 7116, 31, 49, 40, 5, -48 },
  { 7306, 33, 47, 40, 3, -47 },
  { 7500, 29, 48, 40, 5, -47 },
  { 7674, 33, 47, 40, 3, -47 },
  { 7868, 35, 47, 40, 3, -47 },
  { 8074, 33, 47, 40, 4, -47 },
  { 8268, 33, 47, 40, 3, -47 },
  { 8462, 30, 47, 40, 4, -47 },
  { 8639, 10, 64, 40, 15, -54 },
  { 8719, 22, 51, 40, 9, -47 },
  { 8860, 11, 64, 40, 14, -54 },
  { 8948, 23, 26, 40, 8, -47 },
  { 9023, 28, 3, 40, 6, 0 },
  { 9034, 9, 9, 40, 15, -49 },
  { 9045, 28, 37, 40, 6, -36 },
  { 9175, 27, 51, 40, 7, -50 },
  { 9348, 29, 37, 40, 5, -36 },
  { 9483, 28, 51, 40, 5, -50 },
  { 9662, 30, 37, 40, 5, -36 },
  { 9801, 30, 50, 40, 6, -50 },
  { 9989, 28, 50, 40, 5, -36 },
  { 10164, 27, 50, 40, 7, -50 },
  { 10333, 28, 47, 40, 7, -47 },
  { 10498, 21, 61, 40, 6, -47 },
  { 10659, 27, 50, 40, 8, -50 },
  { 10828, 28, 50, 40, 7, -50 },
  { 11003, 34, 36, 40, 3, -36 },
  { 11156, 26, 36, 40, 7, -36 },
  { 11273, 31, 37, 40, 4, -36 },
  { 11417, 27, 49, 40, 7, -36 },
  { 11583, 28, 49, 40, 5, -36 },
  { 11755, 23, 36, 40, 12, -36 },
  { 11859, 28, 37, 40, 6, -36 },
  { 11989, 27, 45, 40, 6, -44 },
  { 12141, 26, 36, 40, 7, -35 },
  { 12258, 32, 35, 40, 4, -35 },
  { 12398, 36, 35, 40, 2, -35 },
  { 12556, 31, 35, 40, 5, -35 },
  { 12692, 34, 49, 40, 3, -35 },
  { 12901, 31, 35, 40, 5, -35 },
  { 13037, 21, 65, 40, 11, -51 },
  { 13208, 2, 57, 40, 19, -47 },
  { 13223, 21, 65, 40, 11, -51 },
  { 13394, 35, 11, 40, 2, -25 },
};

const GFXfont RobotoMono_ExtraLight66pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight66pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _ROBOTOMONO_EXTRALIGHT66PT7B_H_
