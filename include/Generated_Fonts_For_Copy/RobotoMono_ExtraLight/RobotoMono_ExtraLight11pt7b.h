#ifndef _ROBOTOMONO_EXTRALIGHT11PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF0, 0x24, 0xA7, 0xCA, 0x2B, 0xF4, 0x94, 0x23, 0xA3, 0x04,
  0x18, 0x31, 0x51, 0x00, 0xE2, 0xAA, 0x94, 0x18, 0xD5, 0x43, 0x64, 0xA8,
  0x8A, 0x4E, 0x3F, 0xC0, 0x2A, 0x49, 0x24, 0x89, 0x10, 0xA5, 0x55, 0x5A,
  0x25, 0x5C, 0xA5, 0x00, 0x21, 0x3E, 0x42, 0x00, 0xC0, 0xF0, 0x80, 0x24,
  0xA4, 0xA4, 0x80, 0x74, 0x63, 0x7C, 0xC6, 0x2E, 0x74, 0x92, 0x49, 0x64,
  0x84, 0x22, 0x22, 0x1F, 0x69, 0x11, 0x71, 0x9F, 0x08, 0x62, 0x8A, 0x4B,
  0xF0, 0x82, 0x7C, 0x21, 0xE0, 0x86, 0x2E, 0x74, 0x21, 0xE8, 0xC6, 0x2E,
  0xF8, 0x44, 0x22, 0x11, 0x08, 0x74, 0x62, 0xE9, 0x46, 0x2E, 0x74, 0x63,
  0x19, 0xB4, 0x4C, 0x84, 0x86, 0x1B, 0x20, 0xE0, 0x80, 0xF8, 0x3E, 0x83,
  0x06, 0xC8, 0x00, 0x79, 0x11, 0x22, 0x02, 0x39, 0x5A, 0xEB, 0xAE, 0xD8,
  0x9E, 0x23, 0x14, 0xA9, 0x7A, 0x31, 0xF4, 0x63, 0xE8, 0xC6, 0x3E, 0x74,
  0x63, 0x08, 0x42, 0x2E, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0xFC, 0x21, 0xE8,
  0x42, 0x1F, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0x74, 0x61, 0x0B, 0xC6, 0x2F,
  0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF9, 0x08, 0x42, 0x10, 0x9F, 0x11, 0x11,
  0x11, 0x9F, 0x8C, 0xA9, 0x8A, 0x4A, 0x51, 0x84, 0x21, 0x08, 0x42, 0x1F,
  0x8C, 0x67, 0xBA, 0xD6, 0x31, 0x8C, 0x73, 0x9A, 0xCE, 0x71, 0x74, 0x63,
  0x18, 0xC6, 0x2E, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x74, 0x63, 0x18, 0xC6,
  0x2E, 0x08, 0xF4, 0x63, 0x1F, 0x4A, 0x51, 0x74, 0x60, 0x83, 0x06, 0x2E,
  0xF9, 0x08, 0x42, 0x10, 0x84, 0x8C, 0x63, 0x18, 0xC6, 0x2E, 0x8C, 0x63,
  0x25, 0x29, 0x84, 0x96, 0x57, 0x5B, 0x6D, 0xB4, 0x92, 0x8C, 0x94, 0x42,
  0x2A, 0x51, 0x85, 0x14, 0x8A, 0x10, 0x41, 0x04, 0xF8, 0x84, 0x44, 0x22,
  0x1F, 0xEA, 0xAA, 0xAC, 0x84, 0x44, 0x22, 0x11, 0x10, 0xD5, 0x55, 0x5C,
  0x26, 0x59, 0xF8, 0x80, 0x74, 0x4F, 0x98, 0xFC, 0x84, 0x3D, 0x18, 0xC6,
  0x3E, 0x74, 0x61, 0x08, 0xB8, 0x11, 0x79, 0x99, 0x97, 0x74, 0x7F, 0x08,
  0x3C, 0x3A, 0x3C, 0x84, 0x21, 0x08, 0x79, 0x99, 0x97, 0x1F, 0x84, 0x3D,
  0x18, 0xC6, 0x31, 0x20, 0x38, 0x42, 0x10, 0x9F, 0x21, 0x92, 0x49, 0x3C,
  0x84, 0x27, 0x4C, 0x52, 0x51, 0xE1, 0x08, 0x42, 0x10, 0x9F, 0xEE, 0x59,
  0x65, 0x96, 0x50, 0xF4, 0x63, 0x18, 0xC4, 0x74, 0x63, 0x18, 0xB8, 0xF4,
  0x63, 0x18, 0xFA, 0x10, 0x79, 0x99, 0x97, 0x11, 0xF8, 0x88, 0x88, 0x74,
  0x70, 0x68, 0xF8, 0x47, 0x90, 0x84, 0x20, 0xE0, 0x8C, 0x63, 0x18, 0xFC,
  0x8C, 0x64, 0xA6, 0x10, 0x96, 0x57, 0x5B, 0x49, 0x20, 0x8A, 0x88, 0x45,
  0x44, 0x85, 0x14, 0x8A, 0x30, 0x41, 0x18, 0xF8, 0x88, 0x84, 0x7C, 0x29,
  0x25, 0x12, 0x48, 0x80, 0xFF, 0xC0, 0x89, 0x24, 0x52, 0x4A, 0x00, 0xF6,
  0x20,
};

const GFXglyph RobotoMono_ExtraLight11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 2, 2, 7, 2, -8 },
  { 3, 6, 8, 7, 0, -8 },
  { 9, 5, 10, 7, 1, -9 },
  { 16, 6, 8, 7, 0, -8 },
  { 22, 5, 8, 7, 1, -8 },
  { 27, 1, 2, 7, 3, -8 },
  { 28, 3, 12, 7, 2, -9 },
  { 33, 2, 12, 7, 2, -9 },
  { 36, 5, 5, 7, 1, -8 },
  { 40, 5, 5, 7, 1, -6 },
  { 44, 1, 2, 7, 2, -1 },
  { 45, 4, 1, 7, 1, -4 },
  { 46, 1, 1, 7, 3, -1 },
  { 47, 3, 9, 7, 2, -8 },
  { 51, 5, 8, 7, 1, -8 },
  { 56, 3, 8, 7, 1, -8 },
  { 59, 5, 8, 7, 1, -8 },
  { 64, 4, 8, 7, 1, -8 },
  { 68, 6, 8, 7, 0, -8 },
  { 74, 5, 8, 7, 1, -8 },
  { 79, 5, 8, 7, 1, -8 },
  { 84, 5, 8, 7, 1, -8 },
  { 89, 5, 8, 7, 1, -8 },
  { 94, 5, 8, 7, 1, -8 },
  { 99, 1, 6, 7, 3, -6 },
  { 100, 1, 7, 7, 3, -6 },
  { 101, 5, 5, 7, 1, -6 },
  { 105, 5, 3, 7, 1, -5 },
  { 107, 5, 5, 7, 1, -6 },
  { 111, 4, 8, 7, 1, -8 },
  { 115, 6, 8, 7, 0, -8 },
  { 121, 5, 8, 7, 1, -8 },
  { 126, 5, 8, 7, 1, -8 },
  { 131, 5, 8, 7, 1, -8 },
  { 136, 5, 8, 7, 1, -8 },
  { 141, 5, 8, 7, 1, -8 },
  { 146, 5, 8, 7, 1, -8 },
  { 151, 5, 8, 7, 1, -8 },
  { 156, 5, 8, 7, 1, -8 },
  { 161, 5, 8, 7, 1, -8 },
  { 166, 4, 8, 7, 1, -8 },
  { 170, 5, 8, 7, 1, -8 },
  { 175, 5, 8, 7, 1, -8 },
  { 180, 5, 8, 7, 1, -8 },
  { 185, 5, 8, 7, 1, -8 },
  { 190, 5, 8, 7, 1, -8 },
  { 195, 5, 8, 7, 1, -8 },
  { 200, 5, 9, 7, 1, -8 },
  { 206, 5, 8, 7, 1, -8 },
  { 211, 5, 8, 7, 1, -8 },
  { 216, 5, 8, 7, 1, -8 },
  { 221, 5, 8, 7, 1, -8 },
  { 226, 5, 8, 7, 1, -8 },
  { 231, 6, 8, 7, 0, -8 },
  { 237, 5, 8, 7, 1, -8 },
  { 242, 6, 8, 7, 0, -8 },
  { 248, 5, 8, 7, 1, -8 },
  { 253, 2, 11, 7, 2, -9 },
  { 256, 4, 9, 7, 1, -8 },
  { 261, 2, 11, 7, 2, -9 },
  { 264, 4, 4, 7, 1, -8 },
  { 266, 5, 1, 7, 1, 0 },
  { 267, 1, 1, 7, 3, -8 },
  { 268, 5, 6, 7, 1, -6 },
  { 272, 5, 8, 7, 1, -8 },
  { 277, 5, 6, 7, 1, -6 },
  { 281, 4, 8, 7, 1, -8 },
  { 285, 5, 6, 7, 1, -6 },
  { 289, 5, 8, 7, 1, -8 },
  { 294, 4, 8, 7, 1, -6 },
  { 298, 5, 8, 7, 1, -8 },
  { 303, 5, 8, 7, 1, -8 },
  { 308, 3, 10, 7, 1, -8 },
  { 312, 5, 8, 7, 1, -8 },
  { 317, 5, 8, 7, 1, -8 },
  { 322, 6, 6, 7, 0, -6 },
  { 327, 5, 6, 7, 1, -6 },
  { 331, 5, 6, 7, 1, -6 },
  { 335, 5, 8, 7, 1, -6 },
  { 340, 4, 8, 7, 1, -6 },
  { 344, 4, 6, 7, 2, -6 },
  { 347, 5, 6, 7, 1, -6 },
  { 351, 5, 7, 7, 1, -7 },
  { 356, 5, 6, 7, 1, -6 },
  { 360, 5, 6, 7, 1, -6 },
  { 364, 6, 6, 7, 0, -6 },
  { 369, 5, 6, 7, 1, -6 },
  { 373, 6, 8, 7, 0, -6 },
  { 379, 5, 6, 7, 1, -6 },
  { 383, 3, 11, 7, 2, -9 },
  { 388, 1, 10, 7, 3, -8 },
  { 390, 3, 11, 7, 2, -9 },
  { 395, 6, 2, 7, 0, -4 },
};

const GFXfont RobotoMono_ExtraLight11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight11pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_EXTRALIGHT11PT7B_H_
