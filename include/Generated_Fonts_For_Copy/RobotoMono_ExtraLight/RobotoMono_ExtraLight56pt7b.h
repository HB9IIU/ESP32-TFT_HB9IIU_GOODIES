#ifndef _ROBOTOMONO_EXTRALIGHT56PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight56pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x27, 0xF7, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x06,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x18, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60,
  0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0x80, 0xF8, 0x0E, 0x00, 0x3C,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x30, 0x00, 0x07,
  0x30, 0x00, 0x07, 0x70, 0x00, 0x03, 0x70, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x1C, 0x03, 0x00, 0x30, 0x30, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x01,
  0x80, 0xC0, 0x0C, 0x06, 0x01, 0x80, 0x18, 0x1C, 0x03, 0x00, 0x30, 0x30,
  0x06, 0x00, 0xE0, 0xE0, 0x06, 0x01, 0x81, 0x80, 0x0C, 0x03, 0x07, 0x00,
  0x1C, 0x0C, 0x0C, 0x00, 0x1C, 0x38, 0x30, 0x00, 0x1F, 0xE0, 0x60, 0x00,
  0x0F, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0x03, 0xF8, 0x00, 0x0E, 0x0E, 0x38, 0x00, 0x18, 0x38, 0x18, 0x00,
  0x60, 0x60, 0x30, 0x00, 0xC1, 0x80, 0x30, 0x03, 0x03, 0x00, 0x60, 0x06,
  0x06, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x70, 0x18, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x03, 0x80, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x01,
  0x80, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x63, 0x80, 0xE0, 0x06, 0x38, 0x07, 0x00,
  0xE7, 0x00, 0x38, 0x0E, 0x60, 0x01, 0x80, 0xEE, 0x00, 0x1C, 0x0C, 0xE0,
  0x00, 0xE0, 0xCE, 0x00, 0x07, 0x1C, 0xC0, 0x00, 0x39, 0x8E, 0x00, 0x01,
  0xB8, 0xE0, 0x00, 0x1F, 0x06, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xF8, 0x38, 0x00, 0x39, 0x81, 0xE0, 0x0F, 0x1C, 0x0F, 0xFF,
  0xC0, 0xE0, 0x3F, 0xF0, 0x07, 0x00, 0x10, 0x00, 0x00, 0x6D, 0xB6, 0xDB,
  0x7F, 0x60, 0x00, 0x10, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x80, 0x18, 0x02, 0x70, 0x0C, 0x07,
  0x7F, 0x06, 0x1F, 0xC7, 0xF3, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x70, 0x01, 0xE0, 0x10, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE6, 0x33, 0x99, 0x84, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0xFE, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0x00, 0xF0, 0x1C,
  0x00, 0x70, 0x18, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60,
  0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x63, 0xC0,
  0x01, 0xC3, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x03, 0xC0, 0x0E, 0x03, 0xC0,
  0x1C, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0xE0, 0x03, 0xC1,
  0xC0, 0x03, 0xC3, 0x80, 0x03, 0xC7, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xDC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38,
  0x00, 0x18, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC0, 0xFF,
  0x1F, 0x9D, 0xF0, 0x7F, 0x01, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x0F, 0x03, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x01, 0xC1,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x87, 0x00, 0x01,
  0xC1, 0xC0, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x18, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00,
  0x38, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x0E, 0x00,
  0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0,
  0x30, 0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x31, 0xFF,
  0x00, 0x37, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x78, 0x00, 0xF8, 0x30, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x0E, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x81, 0xFE, 0x00, 0xC3, 0xFF, 0xC0, 0x67, 0xC0, 0xF0, 0x37, 0x00, 0x1C,
  0x3F, 0x00, 0x07, 0x1F, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x03, 0x80, 0xE0, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x38, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x07,
  0x80, 0x3C, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x78, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x30, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0xC0,
  0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x3C,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x7C,
  0x70, 0x00, 0x6E, 0x1C, 0x00, 0xE7, 0x07, 0x81, 0xE3, 0x01, 0xFF, 0xE1,
  0x80, 0x3F, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0x1C, 0xF3,
  0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0x8C,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x01, 0xF0, 0x1E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x31,
  0xC0, 0x00, 0xE6, 0x00, 0x01, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x01, 0xF0, 0x0C, 0x38,
  0x0F, 0xF0, 0x18, 0x60, 0x3C, 0x78, 0x31, 0xC0, 0xE0, 0x20, 0x63, 0x01,
  0x80, 0x40, 0x66, 0x06, 0x01, 0x80, 0xCC, 0x0C, 0x03, 0x01, 0xB0, 0x30,
  0x06, 0x03, 0x60, 0x60, 0x0C, 0x06, 0xC0, 0xC0, 0x18, 0x0D, 0x81, 0x80,
  0x30, 0x1B, 0x03, 0x00, 0x60, 0x36, 0x0C, 0x00, 0xC0, 0x6C, 0x18, 0x01,
  0x00, 0xD8, 0x30, 0x02, 0x01, 0xB0, 0x60, 0x0C, 0x02, 0x60, 0xC0, 0x18,
  0x0C, 0xC1, 0x80, 0x70, 0x19, 0x81, 0x80, 0xE0, 0x33, 0x03, 0x03, 0xC0,
  0xC6, 0x06, 0x06, 0xC1, 0x8C, 0x06, 0x39, 0x86, 0x0C, 0x0F, 0xE1, 0xF8,
  0x18, 0x0F, 0x81, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x10, 0x00,
  0x7C, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x1C,
  0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0xC0, 0x1F, 0xC0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x78, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x01,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xC0, 0x00,
  0x78, 0xC0, 0x00, 0x3C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x78, 0xC0, 0x03,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03,
  0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x0E, 0x01, 0xFC, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x06, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x01, 0xF0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x98, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x3C, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x03, 0x81, 0xC0,
  0x03, 0xC0, 0x78, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x0C, 0x00,
  0x0E, 0x03, 0x00, 0x07, 0x80, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x0C,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x0E, 0x00,
  0x0C, 0x07, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC1, 0xE0, 0x00, 0x30, 0x70,
  0x00, 0x0C, 0x3C, 0x00, 0x03, 0x1F, 0x80, 0x00, 0xCE, 0xE0, 0x00, 0x37,
  0x1C, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00,
  0x30, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x03,
  0x80, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xD8,
  0x00, 0x1B, 0xD8, 0x00, 0x1B, 0xDC, 0x00, 0x3B, 0xCC, 0x00, 0x33, 0xCC,
  0x00, 0x73, 0xC6, 0x00, 0x63, 0xC6, 0x00, 0x63, 0xC7, 0x00, 0xE3, 0xC3,
  0x00, 0xC3, 0xC3, 0x01, 0xC3, 0xC3, 0x81, 0x83, 0xC1, 0x81, 0x83, 0xC1,
  0x83, 0x83, 0xC0, 0xC3, 0x03, 0xC0, 0xC3, 0x03, 0xC0, 0xE6, 0x03, 0xC0,
  0x66, 0x03, 0xC0, 0x6E, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xD8, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xC6,
  0x00, 0x03, 0xC7, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC3, 0x80, 0x03, 0xC1,
  0x80, 0x03, 0xC1, 0xC0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x60, 0x03, 0xC0,
  0x70, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x1C, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x07, 0x03, 0xC0,
  0x03, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0x83, 0xC0, 0x01, 0xC3, 0xC0,
  0x00, 0xC3, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x73, 0xC0,
  0x00, 0x3B, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x38, 0x00, 0xFC, 0x1C, 0x00, 0x0F, 0x0E, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x06,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03,
  0x8E, 0x00, 0x07, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x30, 0x01, 0xF8, 0x18, 0x00, 0x1E,
  0x0C, 0x00, 0x07, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x1C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x18,
  0x00, 0x0E, 0x0C, 0x00, 0x1E, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01,
  0x80, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x07, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x07, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x78, 0x07, 0xC0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x18, 0xE0,
  0x00, 0x0E, 0x1E, 0x00, 0x07, 0x03, 0xE0, 0x07, 0x80, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x38, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x00, 0x60,
  0x00, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x30, 0x01, 0x80, 0x03, 0x80, 0x18, 0x00, 0x18, 0x03, 0x80, 0x01,
  0x80, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0D, 0x80, 0x0E, 0x00, 0x36, 0x00, 0x38,
  0x00, 0xD8, 0x00, 0xE0, 0x07, 0x60, 0x07, 0x80, 0x1D, 0xC0, 0x1E, 0x00,
  0x67, 0x00, 0x6C, 0x01, 0x8C, 0x01, 0xB0, 0x06, 0x30, 0x06, 0xC0, 0x18,
  0xC0, 0x3B, 0x00, 0x63, 0x00, 0xCC, 0x03, 0x8C, 0x03, 0x38, 0x0C, 0x38,
  0x0C, 0x60, 0x30, 0xE0, 0x31, 0x80, 0xC1, 0x80, 0xC6, 0x03, 0x06, 0x06,
  0x18, 0x0C, 0x18, 0x18, 0x70, 0x30, 0x60, 0x60, 0xC1, 0xC1, 0x81, 0x83,
  0x06, 0x07, 0x06, 0x0C, 0x18, 0x0C, 0x38, 0x30, 0x60, 0x30, 0xC0, 0xE1,
  0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0xE0,
  0x31, 0xC0, 0x63, 0x00, 0xE6, 0x01, 0xCC, 0x01, 0x98, 0x07, 0x30, 0x06,
  0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x6E, 0x00, 0xDC, 0x01, 0xB0,
  0x03, 0x60, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFF, 0xFE,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xB8, 0x00, 0x19, 0x80,
  0x03, 0x98, 0x00, 0x31, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xE0, 0x06, 0x06,
  0x00, 0xE0, 0x60, 0x0C, 0x07, 0x01, 0xC0, 0x30, 0x18, 0x03, 0x81, 0x80,
  0x18, 0x30, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x00, 0xC6, 0x00, 0x0E, 0xE0,
  0x00, 0x6C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70,
  0x38, 0x18, 0x1C, 0x0E, 0x07, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F,
  0x81, 0xF0, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x60,
  0x00, 0x0E, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xC0, 0x06, 0x3C, 0x00, 0x06, 0x78, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x36, 0x70,
  0x00, 0x76, 0x3C, 0x01, 0xC6, 0x1F, 0xFF, 0x87, 0x07, 0xFE, 0x07, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x0F, 0xE0, 0x18, 0x7F, 0xF0, 0x33, 0xC0, 0xF8, 0x6E, 0x00, 0x70,
  0xF8, 0x00, 0x71, 0xE0, 0x00, 0x73, 0x80, 0x00, 0x67, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03,
  0x9E, 0x00, 0x06, 0x36, 0x00, 0x1C, 0x6F, 0x00, 0xF0, 0xC7, 0xFF, 0xC1,
  0x83, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0x81, 0xF0, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x1F, 0xE0, 0xE0, 0xFF, 0xF1, 0xC3, 0xE0, 0xF3, 0x8F, 0x00,
  0x37, 0x38, 0x00, 0x3E, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x73, 0x00,
  0x01, 0xE7, 0x00, 0x03, 0xC7, 0x00, 0x1F, 0x87, 0x80, 0x77, 0x07, 0xFF,
  0xC6, 0x07, 0xFE, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0xF0, 0x3E, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x01, 0xC0, 0xF8, 0x03, 0xC0, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x78, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xFE, 0x06, 0x07, 0xFF, 0x0C, 0x3E, 0x0F,
  0x18, 0xF0, 0x03, 0x33, 0xC0, 0x03, 0x67, 0x00, 0x03, 0xDC, 0x00, 0x07,
  0xB0, 0x00, 0x07, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x30, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0x70, 0x01, 0xF8, 0x78, 0x07,
  0x70, 0x7F, 0xFC, 0xE0, 0x3F, 0xE1, 0xC0, 0x06, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x31, 0x00, 0x00, 0xE7,
  0x00, 0x03, 0x87, 0x00, 0x0E, 0x07, 0x00, 0x3C, 0x07, 0xE3, 0xF0, 0x03,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x07, 0xF0, 0x18, 0x3F, 0xF8, 0x31, 0xE0, 0x7C,
  0x67, 0x00, 0x38, 0xDC, 0x00, 0x39, 0xB0, 0x00, 0x3B, 0xC0, 0x00, 0x77,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x20, 0x3E, 0x0F, 0xFF,
  0x03, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0xF0, 0x00,
  0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0xC0, 0x00, 0xEF, 0xC0, 0x00,
  0xFC, 0xE0, 0x00, 0xF8, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xC7, 0x3F, 0xE1, 0xFF, 0x3B, 0x07,
  0x9C, 0x3D, 0xF0, 0x1D, 0x80, 0x6F, 0x00, 0x78, 0x03, 0xF0, 0x03, 0x80,
  0x0F, 0x80, 0x0C, 0x00, 0x7C, 0x00, 0x60, 0x03, 0xE0, 0x03, 0x00, 0x1F,
  0x00, 0x18, 0x00, 0xF8, 0x00, 0xC0, 0x07, 0xC0, 0x06, 0x00, 0x3E, 0x00,
  0x30, 0x01, 0xF0, 0x01, 0x80, 0x0F, 0x80, 0x0C, 0x00, 0x7C, 0x00, 0x60,
  0x03, 0xE0, 0x03, 0x00, 0x1F, 0x00, 0x18, 0x00, 0xF8, 0x00, 0xC0, 0x07,
  0xC0, 0x06, 0x00, 0x3E, 0x00, 0x30, 0x01, 0xF0, 0x01, 0x80, 0x0F, 0x80,
  0x0C, 0x00, 0x7C, 0x00, 0x60, 0x03, 0xE0, 0x03, 0x00, 0x1F, 0x00, 0x18,
  0x00, 0xF8, 0x00, 0xC0, 0x07, 0xC0, 0x06, 0x00, 0x3E, 0x00, 0x30, 0x01,
  0xF0, 0x01, 0x80, 0x0C, 0xC0, 0x7F, 0x03, 0x07, 0xFF, 0x0C, 0x78, 0x1F,
  0x33, 0x80, 0x1C, 0xDC, 0x00, 0x3B, 0x60, 0x00, 0x6F, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0xFE, 0x01, 0x8F,
  0xFF, 0x03, 0x3C, 0x0F, 0x06, 0xE0, 0x07, 0x0F, 0x80, 0x07, 0x1E, 0x00,
  0x07, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0,
  0x00, 0x07, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0xE3, 0xE0,
  0x03, 0xC6, 0xF0, 0x0F, 0x0C, 0x7F, 0xFC, 0x18, 0x7F, 0xE0, 0x30, 0x04,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x06, 0x0F, 0xFF, 0x0C,
  0x3E, 0x07, 0x18, 0xF0, 0x03, 0x33, 0xC0, 0x03, 0x67, 0x00, 0x03, 0xDC,
  0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xD8, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x3C, 0x70, 0x00, 0xF8,
  0x78, 0x07, 0x70, 0x7F, 0xFC, 0xE0, 0x7F, 0xE1, 0xC0, 0x06, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x8F, 0xC0, 0xF3,
  0xC0, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x80,
  0xF8, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x38, 0x00,
  0x0E, 0x1E, 0x00, 0x3C, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x3D,
  0xC0, 0x01, 0xB3, 0x80, 0x0E, 0xCF, 0x00, 0xF3, 0x1F, 0xFF, 0x8C, 0x1F,
  0xF8, 0x30, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x03, 0x00, 0x07, 0x00, 0x70, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x38, 0x00, 0x38, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x30,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x30, 0x01, 0xD8, 0x01,
  0xE0, 0x06, 0x60, 0x07, 0x80, 0x19, 0x80, 0x1E, 0x00, 0x67, 0x00, 0x78,
  0x01, 0x8C, 0x03, 0x30, 0x0E, 0x30, 0x0C, 0xC0, 0x30, 0xC0, 0x33, 0x00,
  0xC3, 0x00, 0xCC, 0x03, 0x0E, 0x06, 0x18, 0x1C, 0x18, 0x18, 0x60, 0x60,
  0x60, 0x61, 0x81, 0x81, 0x81, 0x86, 0x06, 0x07, 0x0C, 0x0C, 0x18, 0x0C,
  0x30, 0x30, 0xC0, 0x30, 0xC0, 0xC3, 0x00, 0xC3, 0x03, 0x0C, 0x03, 0x18,
  0x06, 0x30, 0x0E, 0x60, 0x19, 0xC0, 0x19, 0x80, 0x66, 0x00, 0x66, 0x01,
  0x98, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0F, 0x00, 0x34,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x60, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0xFF, 0xE0, 0x00,
  0x33, 0x83, 0xC0, 0x01, 0xDC, 0x03, 0xC0, 0x06, 0xE0, 0x07, 0x80, 0x1B,
  0x00, 0x0F, 0x00, 0xCC, 0x00, 0x0F, 0x0F, 0x30, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0x80,
};

const GFXglyph RobotoMono_ExtraLight56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 4, 40, 34, 14, -40 },
  { 21, 10, 12, 34, 12, -42 },
  { 36, 30, 40, 34, 2, -40 },
  { 186, 24, 52, 34, 5, -46 },
  { 342, 31, 41, 34, 1, -40 },
  { 501, 28, 41, 34, 4, -40 },
  { 645, 3, 12, 34, 14, -42 },
  { 650, 12, 58, 34, 11, -45 },
  { 737, 12, 58, 34, 10, -45 },
  { 824, 25, 23, 34, 5, -40 },
  { 896, 28, 29, 34, 3, -33 },
  { 998, 5, 13, 34, 11, -5 },
  { 1007, 20, 2, 34, 7, -19 },
  { 1012, 5, 4, 34, 15, -4 },
  { 1015, 19, 43, 34, 8, -40 },
  { 1118, 24, 41, 34, 5, -40 },
  { 1241, 14, 40, 34, 6, -40 },
  { 1311, 25, 40, 34, 3, -40 },
  { 1436, 25, 41, 34, 3, -40 },
  { 1565, 28, 40, 34, 2, -40 },
  { 1705, 24, 41, 34, 6, -40 },
  { 1828, 25, 41, 34, 4, -40 },
  { 1957, 25, 40, 34, 4, -40 },
  { 2082, 25, 41, 34, 5, -40 },
  { 2211, 25, 40, 34, 4, -40 },
  { 2336, 4, 28, 34, 17, -28 },
  { 2350, 6, 36, 34, 15, -28 },
  { 2377, 24, 22, 34, 4, -29 },
  { 2443, 24, 14, 34, 5, -25 },
  { 2485, 24, 23, 34, 5, -30 },
  { 2554, 22, 40, 34, 6, -40 },
  { 2664, 31, 40, 34, 1, -40 },
  { 2819, 28, 40, 34, 3, -40 },
  { 2959, 24, 40, 34, 6, -40 },
  { 3079, 26, 41, 34, 4, -40 },
  { 3213, 26, 40, 34, 5, -40 },
  { 3343, 23, 40, 34, 6, -40 },
  { 3458, 23, 40, 34, 6, -40 },
  { 3573, 27, 41, 34, 3, -40 },
  { 3712, 24, 40, 34, 5, -40 },
  { 3832, 22, 40, 34, 6, -40 },
  { 3942, 25, 41, 34, 3, -40 },
  { 4071, 26, 40, 34, 6, -40 },
  { 4201, 23, 40, 34, 6, -40 },
  { 4316, 24, 40, 34, 5, -40 },
  { 4436, 24, 40, 34, 5, -40 },
  { 4556, 26, 41, 34, 4, -40 },
  { 4690, 25, 40, 34, 6, -40 },
  { 4815, 28, 47, 34, 3, -40 },
  { 4980, 25, 40, 34, 6, -40 },
  { 5105, 26, 41, 34, 4, -40 },
  { 5239, 28, 40, 34, 3, -40 },
  { 5379, 24, 41, 34, 5, -40 },
  { 5502, 28, 40, 34, 3, -40 },
  { 5642, 30, 40, 34, 2, -40 },
  { 5792, 28, 40, 34, 3, -40 },
  { 5932, 29, 40, 34, 2, -40 },
  { 6077, 25, 40, 34, 4, -40 },
  { 6202, 9, 55, 34, 13, -46 },
  { 6264, 19, 43, 34, 7, -40 },
  { 6367, 9, 55, 34, 12, -46 },
  { 6429, 20, 22, 34, 7, -40 },
  { 6484, 24, 2, 34, 5, 0 },
  { 6490, 8, 7, 34, 13, -41 },
  { 6497, 24, 31, 34, 5, -30 },
  { 6590, 23, 43, 34, 6, -42 },
  { 6714, 24, 31, 34, 5, -30 },
  { 6807, 23, 43, 34, 5, -42 },
  { 6931, 25, 31, 34, 4, -30 },
  { 7028, 26, 43, 34, 5, -43 },
  { 7168, 23, 42, 34, 5, -30 },
  { 7289, 23, 42, 34, 6, -42 },
  { 7410, 24, 40, 34, 6, -40 },
  { 7530, 18, 52, 34, 5, -40 },
  { 7647, 24, 42, 34, 6, -42 },
  { 7773, 24, 42, 34, 6, -42 },
  { 7899, 29, 30, 34, 2, -30 },
  { 8008, 22, 30, 34, 6, -30 },
  { 8091, 26, 31, 34, 4, -30 },
  { 8192, 23, 41, 34, 6, -30 },
  { 8310, 23, 41, 34, 5, -30 },
  { 8428, 19, 30, 34, 10, -30 },
  { 8500, 24, 31, 34, 5, -30 },
  { 8593, 23, 38, 34, 5, -37 },
  { 8703, 22, 31, 34, 6, -30 },
  { 8789, 27, 30, 34, 3, -30 },
  { 8891, 30, 30, 34, 2, -30 },
  { 9004, 26, 30, 34, 4, -30 },
  { 9102, 29, 42, 34, 2, -30 },
  { 9255, 26, 30, 34, 4, -30 },
  { 9353, 18, 56, 34, 9, -44 },
  { 9479, 2, 48, 34, 16, -40 },
  { 9491, 18, 56, 34, 9, -44 },
  { 9617, 30, 9, 34, 2, -21 },
};

const GFXfont RobotoMono_ExtraLight56pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight56pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOMONO_EXTRALIGHT56PT7B_H_
