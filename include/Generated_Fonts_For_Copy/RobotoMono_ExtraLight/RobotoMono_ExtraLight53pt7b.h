#ifndef _ROBOTOMONO_EXTRALIGHT53PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight53pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x0F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xF0, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x70, 0x70, 0x00, 0x70, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00,
  0x03, 0x30, 0x00, 0x07, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x76, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x1E, 0x00, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x30, 0x04, 0x03, 0x00, 0x60, 0x18, 0x0C, 0x01,
  0x80, 0x60, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0x60,
  0x60, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x06, 0x0C, 0x00, 0x60, 0x30, 0x70,
  0x01, 0x80, 0xC1, 0x80, 0x03, 0x06, 0x0E, 0x00, 0x07, 0xF8, 0x30, 0x00,
  0x0F, 0x81, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x1E, 0x00, 0x00,
  0xC0, 0xFE, 0x00, 0x07, 0x06, 0x1C, 0x00, 0x18, 0x30, 0x30, 0x00, 0xE1,
  0x80, 0x60, 0x03, 0x06, 0x01, 0x80, 0x18, 0x18, 0x06, 0x00, 0x60, 0x60,
  0x0C, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x07,
  0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x0C,
  0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x38, 0x30, 0x03, 0x0E, 0x07, 0x00, 0x63, 0x80, 0x70, 0x0C,
  0x60, 0x07, 0x01, 0x9C, 0x00, 0x60, 0x33, 0x00, 0x06, 0x0E, 0x60, 0x00,
  0xE1, 0x8C, 0x00, 0x0E, 0x31, 0x80, 0x00, 0xEE, 0x30, 0x00, 0x0D, 0x87,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0xC0, 0xE0, 0x01,
  0xDC, 0x0E, 0x00, 0xF1, 0xC0, 0xFF, 0xF8, 0x18, 0x0F, 0xFC, 0x03, 0xC0,
  0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x40, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x20, 0x0C, 0x03, 0xF8,
  0x18, 0x3E, 0xFC, 0x31, 0xF8, 0x3F, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x63, 0x80, 0x01, 0x83,
  0x80, 0x07, 0x03, 0x80, 0x1C, 0x03, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x07,
  0x01, 0x80, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xC6, 0x31, 0x8C,
  0xE7, 0x33, 0x99, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x6F, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x1E, 0xE0, 0x00, 0x36, 0xE0,
  0x00, 0x67, 0xE0, 0x00, 0xC7, 0xE0, 0x01, 0x87, 0xE0, 0x03, 0x07, 0xE0,
  0x06, 0x07, 0xE0, 0x0C, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0xE0, 0x07, 0xE1, 0xC0, 0x07, 0xE3, 0x80, 0x07, 0xE7, 0x00, 0x07, 0xEE,
  0x00, 0x07, 0x7C, 0x00, 0x06, 0x78, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x0C, 0x00, 0x30, 0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x7E, 0x0F, 0xB1,
  0xF1, 0xFC, 0x0F, 0x80, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x0E, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03,
  0x83, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x07, 0x30, 0x00, 0x06,
  0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0xE0, 0xF0, 0x07, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x38,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00,
  0xC0, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x1F, 0xC0, 0x19, 0xFF, 0xC0, 0x7F,
  0x0F, 0xC1, 0xE0, 0x0F, 0x86, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01,
  0xC3, 0xC0, 0x0F, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x07, 0xC0, 0x18, 0x7F, 0xE0, 0x73, 0xE1,
  0xF0, 0xCE, 0x00, 0xF1, 0xB0, 0x00, 0x73, 0xC0, 0x00, 0x67, 0x80, 0x00,
  0xEE, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x38, 0x00, 0x06, 0x30,
  0x00, 0x1C, 0x30, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x78, 0x07, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x38, 0x30, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0E, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x70, 0x00,
  0x1C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x07, 0xC7,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0E, 0x00, 0xF0, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x07,
  0x80, 0xF0, 0x03, 0x81, 0x80, 0x03, 0x87, 0x00, 0x03, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x06, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0xF3, 0x80, 0x01, 0xE3, 0x80, 0x0E, 0xC7, 0x80, 0x39, 0x83, 0xC3,
  0xE3, 0x03, 0xFF, 0x06, 0x01, 0xF0, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0x70, 0x18, 0xF3, 0xC7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x86, 0x18, 0x61, 0x8E, 0x38, 0xC3, 0x1C, 0xE1, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x03,
  0xC3, 0x80, 0x1C, 0x70, 0x00, 0xE6, 0x00, 0x06, 0x60, 0x00, 0x7E, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x70, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x1C, 0x03, 0xE0,
  0x30, 0xC0, 0x7F, 0xC1, 0x8E, 0x07, 0x06, 0x06, 0x60, 0x70, 0x30, 0x33,
  0x03, 0x01, 0x81, 0xB0, 0x30, 0x0C, 0x0D, 0x81, 0x80, 0x60, 0x6C, 0x0C,
  0x03, 0x03, 0x60, 0xC0, 0x18, 0x1B, 0x06, 0x00, 0xC0, 0xD0, 0x30, 0x04,
  0x06, 0x81, 0x80, 0x20, 0x34, 0x0C, 0x01, 0x01, 0xE0, 0x60, 0x18, 0x0F,
  0x03, 0x00, 0xC0, 0x68, 0x18, 0x06, 0x03, 0x60, 0xC0, 0x70, 0x13, 0x06,
  0x03, 0x81, 0x98, 0x30, 0x3C, 0x0C, 0xC0, 0xC3, 0x30, 0xC6, 0x07, 0x79,
  0xCC, 0x18, 0x1F, 0x07, 0xC0, 0xC0, 0x20, 0x08, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x00, 0x07,
  0x80, 0x18, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x00, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x07, 0x00, 0x30, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70,
  0x30, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0xE0, 0x1F, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x1F,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x78, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0xE0,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x70,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x37, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x07, 0x03,
  0x80, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x3F, 0x80,
  0xC0, 0x03, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0,
  0xC0, 0x0F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x60, 0x00,
  0x1C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x37, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x87, 0x00,
  0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x06,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x70, 0x07, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x07, 0x00,
  0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00,
  0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC3, 0x80, 0x00,
  0xC7, 0x80, 0x00, 0xCF, 0xC0, 0x00, 0xDC, 0xC0, 0x00, 0xF8, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80,
  0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0x7F, 0x00, 0x06, 0xF6, 0x00, 0x1D, 0xEC, 0x00, 0x33, 0xDC,
  0x00, 0xE7, 0x98, 0x01, 0x8F, 0x30, 0x03, 0x1E, 0x30, 0x0E, 0x3C, 0x60,
  0x18, 0x78, 0xC0, 0x30, 0xF0, 0xC0, 0xC1, 0xE1, 0x81, 0x83, 0xC3, 0x87,
  0x07, 0x83, 0x0C, 0x0F, 0x06, 0x18, 0x1E, 0x06, 0x60, 0x3C, 0x0C, 0xC0,
  0x78, 0x1B, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x70, 0x07,
  0x80, 0x60, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFB, 0x00, 0x01, 0xF7, 0x00,
  0x03, 0xE6, 0x00, 0x07, 0xCE, 0x00, 0x0F, 0x8C, 0x00, 0x1F, 0x1C, 0x00,
  0x3E, 0x18, 0x00, 0x7C, 0x18, 0x00, 0xF8, 0x38, 0x01, 0xF0, 0x30, 0x03,
  0xE0, 0x70, 0x07, 0xC0, 0x60, 0x0F, 0x80, 0xE0, 0x1F, 0x00, 0xC0, 0x3E,
  0x01, 0xC0, 0x7C, 0x01, 0x80, 0xF8, 0x01, 0x81, 0xF0, 0x03, 0x83, 0xE0,
  0x03, 0x07, 0xC0, 0x07, 0x0F, 0x80, 0x06, 0x1F, 0x00, 0x0E, 0x3E, 0x00,
  0x0C, 0x7C, 0x00, 0x1C, 0xF8, 0x00, 0x19, 0xF0, 0x00, 0x1B, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x60,
  0x00, 0x18, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x18, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x06,
  0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03,
  0x00, 0x1F, 0x86, 0x00, 0x07, 0x8C, 0x00, 0x03, 0x98, 0x00, 0x03, 0xB0,
  0x00, 0x03, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x00, 0x01,
  0xE6, 0x00, 0x07, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x0C, 0x00, 0x0C,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x43, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x03, 0x00, 0x3E, 0x06, 0x00, 0x0E, 0x0C, 0x00,
  0x0E, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00, 0x01,
  0xD8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0xE3, 0x00, 0x03, 0x86, 0x00, 0x1E, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x30, 0x03, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x07, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x18, 0x00,
  0x1C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x73, 0x00, 0x00, 0x66, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x07, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x0E, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x07,
  0x00, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x70,
  0x00, 0xE0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x36,
  0x00, 0x70, 0x03, 0x60, 0x07, 0x00, 0x36, 0x00, 0x70, 0x03, 0x60, 0x07,
  0x00, 0x36, 0x00, 0xF0, 0x03, 0x60, 0x0D, 0x80, 0x77, 0x00, 0xD8, 0x06,
  0x30, 0x0D, 0x80, 0x63, 0x00, 0xD8, 0x06, 0x30, 0x19, 0x80, 0x63, 0x01,
  0x8C, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x0C, 0x38, 0x18, 0xC0,
  0xC1, 0x83, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x70, 0x61, 0x80, 0xC6, 0x07,
  0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80,
  0xC6, 0x03, 0x18, 0x0C, 0xC0, 0x3B, 0x00, 0xEC, 0x01, 0xB0, 0x06, 0xC0,
  0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x78, 0x01, 0xB0,
  0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0x70, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x60, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x38, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x30,
  0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x0E,
  0x00, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0x70, 0x00, 0xCC, 0x00, 0x73, 0x00, 0x18, 0x60, 0x06, 0x18, 0x03,
  0x07, 0x00, 0xC0, 0xC0, 0x70, 0x30, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00,
  0x70, 0xC0, 0x0C, 0x70, 0x03, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x07,
  0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x70, 0x38,
  0x18, 0x0C, 0x0E, 0x07, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0x00, 0x38, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0xB8,
  0x00, 0x06, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xC0, 0x07,
  0x38, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x7D, 0xC0, 0x03, 0x77, 0x80, 0x39, 0xCF, 0xFF, 0xC3, 0x0F, 0xFC, 0x0C,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x80, 0x0E, 0x1F, 0xF0, 0x1C, 0xFF, 0xF8, 0x3B, 0x80, 0x78, 0x7E, 0x00,
  0x38, 0xF8, 0x00, 0x31, 0xE0, 0x00, 0x73, 0x80, 0x00, 0x67, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x06,
  0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x33, 0x80, 0x00, 0xE7, 0x80, 0x01, 0x8F, 0x80,
  0x07, 0x1D, 0xC0, 0x3C, 0x39, 0xFF, 0xF0, 0x70, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x38, 0x03,
  0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x07,
  0x70, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x04,
  0x03, 0x01, 0xFF, 0x0C, 0x1F, 0xFF, 0x30, 0xF0, 0x0E, 0xC7, 0x00, 0x1B,
  0x18, 0x00, 0x3C, 0xE0, 0x00, 0x73, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x70, 0x00, 0x0C, 0xC0,
  0x00, 0x33, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x1C, 0x00, 0x7C, 0x3C, 0x03,
  0xB0, 0x7F, 0xFC, 0xC0, 0x7F, 0xC3, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x06,
  0x0E, 0x00, 0x0C, 0x07, 0x80, 0x38, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x30, 0x7F, 0xFC, 0xC3,
  0xC0, 0x3B, 0x1C, 0x00, 0x7C, 0x60, 0x00, 0xF3, 0x80, 0x01, 0xCC, 0x00,
  0x03, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00,
  0x0D, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCE, 0x00, 0x07, 0x18, 0x00, 0x1C,
  0x70, 0x00, 0xF0, 0xF0, 0x0E, 0xC1, 0xFF, 0xF3, 0x01, 0xFF, 0x0C, 0x00,
  0x40, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x71, 0x00, 0x01, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x3C, 0x07, 0x80,
  0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x02, 0x00, 0xE0, 0xFF, 0x83, 0x8F, 0xFF, 0x8E, 0x70, 0x0F, 0x3B, 0x00,
  0x0C, 0xF8, 0x00, 0x3B, 0xC0, 0x00, 0x6F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0xFF, 0xE0, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0xCC, 0x00, 0x1E, 0x30,
  0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00, 0x38, 0x0C, 0x01, 0xC0, 0x30, 0x0E,
  0x00, 0xC0, 0x70, 0x03, 0x03, 0x80, 0x0C, 0x1C, 0x00, 0x31, 0xE0, 0x00,
  0xCF, 0x80, 0x03, 0x77, 0x00, 0x0F, 0x8E, 0x00, 0x3C, 0x38, 0x00, 0xE0,
  0x70, 0x03, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x30, 0x03, 0x80, 0xC0, 0x07,
  0x03, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xE3,
  0x00, 0x01, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80,
  0x04, 0x0C, 0x7F, 0x07, 0xF8, 0xCF, 0xFC, 0xFF, 0xCD, 0x81, 0xD8, 0x0E,
  0xF0, 0x0F, 0x00, 0x6E, 0x00, 0x70, 0x06, 0xE0, 0x06, 0x00, 0x6E, 0x00,
  0x60, 0x07, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0x60, 0x07, 0xC0, 0x06, 0x00,
  0x7C, 0x00, 0x60, 0x07, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0x60, 0x07, 0xC0,
  0x06, 0x00, 0x7C, 0x00, 0x60, 0x07, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0x60,
  0x07, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0x60, 0x07, 0xC0, 0x06, 0x00, 0x7C,
  0x00, 0x60, 0x07, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0x60, 0x07, 0xC0, 0x06,
  0x00, 0x7C, 0x00, 0x60, 0x07, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0x60, 0x07,
  0xC0, 0x06, 0x00, 0x70, 0x00, 0x08, 0x03, 0x03, 0xFE, 0x0C, 0x3F, 0xFE,
  0x31, 0xC0, 0x3C, 0xCC, 0x00, 0x33, 0x60, 0x00, 0xED, 0x00, 0x01, 0xBC,
  0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF0,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E,
  0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x10, 0x03, 0x87, 0xFC, 0x0E,
  0x7F, 0xFC, 0x3B, 0x80, 0x78, 0xFC, 0x00, 0xF3, 0xC0, 0x01, 0xCF, 0x00,
  0x03, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x0E,
  0xF0, 0x00, 0x73, 0xE0, 0x03, 0x8E, 0xE0, 0x1E, 0x39, 0xFF, 0xF0, 0xE1,
  0xFF, 0x03, 0x80, 0x40, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0xFC, 0x30, 0x7F, 0xFC, 0xC3, 0xC0, 0x3B, 0x1C, 0x00, 0x7C, 0x60, 0x00,
  0xF3, 0x80, 0x01, 0xCC, 0x00, 0x03, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCE,
  0x00, 0x07, 0x18, 0x00, 0x1C, 0x70, 0x00, 0xF0, 0xF0, 0x0E, 0xC1, 0xFF,
  0xF3, 0x01, 0xFF, 0x0C, 0x00, 0x40, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x04,
  0x30, 0x3F, 0xFC, 0x3F, 0xFF, 0x1E, 0x00, 0xCE, 0x00, 0x36, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE,
  0x07, 0x80, 0x3C, 0x38, 0x00, 0x38, 0xC0, 0x00, 0x76, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x77, 0x00, 0x03, 0xCC, 0x00, 0x1F,
  0x38, 0x00, 0xFC, 0x70, 0x07, 0x70, 0xFF, 0xF9, 0xC1, 0xFF, 0x87, 0x00,
  0x40, 0x00, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0xE0,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x07, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0xE0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xE0, 0x07, 0x00, 0x36, 0x00, 0xF0, 0x07, 0x60,
  0x0F, 0x00, 0x66, 0x00, 0xF0, 0x06, 0x60, 0x09, 0x80, 0x67, 0x01, 0x98,
  0x06, 0x30, 0x19, 0x80, 0xC3, 0x01, 0x98, 0x0C, 0x30, 0x18, 0xC0, 0xC3,
  0x83, 0x0C, 0x0C, 0x18, 0x30, 0xC0, 0xC1, 0x83, 0x0C, 0x18, 0x18, 0x20,
  0x61, 0x81, 0x86, 0x06, 0x18, 0x0C, 0x60, 0x61, 0x80, 0xC6, 0x06, 0x30,
  0x0C, 0x40, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x6C,
  0x03, 0x30, 0x06, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x03, 0x80,
  0xC0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x07, 0x01, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x70,
  0x38, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x38,
  0x00, 0x30, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18,
  0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x60, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x23, 0xFF, 0x00,
  0x03, 0x70, 0x38, 0x00, 0x36, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x6C,
  0x00, 0x38, 0x0E, 0xC0, 0x01, 0xE3, 0xCC, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1E, 0x00,
};

const GFXglyph RobotoMono_ExtraLight53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 3, 38, 32, 14, -38 },
  { 16, 9, 11, 32, 11, -40 },
  { 29, 28, 38, 32, 2, -38 },
  { 162, 23, 48, 32, 5, -43 },
  { 300, 30, 39, 32, 1, -38 },
  { 447, 27, 39, 32, 4, -38 },
  { 579, 2, 11, 32, 14, -40 },
  { 582, 12, 54, 32, 10, -42 },
  { 663, 12, 54, 32, 9, -42 },
  { 744, 23, 22, 32, 5, -38 },
  { 808, 26, 27, 32, 3, -31 },
  { 896, 5, 12, 32, 10, -5 },
  { 904, 19, 2, 32, 6, -18 },
  { 909, 4, 4, 32, 15, -4 },
  { 911, 18, 41, 32, 8, -38 },
  { 1004, 24, 39, 32, 4, -38 },
  { 1121, 13, 38, 32, 6, -38 },
  { 1183, 24, 38, 32, 3, -38 },
  { 1297, 23, 39, 32, 3, -38 },
  { 1410, 27, 38, 32, 2, -38 },
  { 1539, 22, 39, 32, 6, -38 },
  { 1647, 23, 39, 32, 4, -38 },
  { 1760, 25, 38, 32, 3, -38 },
  { 1879, 24, 39, 32, 5, -38 },
  { 1996, 23, 38, 32, 4, -38 },
  { 2106, 4, 27, 32, 16, -27 },
  { 2120, 6, 34, 32, 14, -27 },
  { 2146, 23, 22, 32, 4, -28 },
  { 2210, 23, 13, 32, 5, -24 },
  { 2248, 22, 22, 32, 5, -28 },
  { 2309, 20, 38, 32, 6, -38 },
  { 2404, 29, 38, 32, 1, -38 },
  { 2542, 27, 38, 32, 3, -38 },
  { 2671, 24, 38, 32, 5, -38 },
  { 2785, 25, 39, 32, 3, -38 },
  { 2907, 24, 38, 32, 5, -38 },
  { 3021, 22, 38, 32, 5, -38 },
  { 3126, 22, 38, 32, 6, -38 },
  { 3231, 25, 39, 32, 3, -38 },
  { 3353, 23, 38, 32, 4, -38 },
  { 3463, 22, 38, 32, 5, -38 },
  { 3568, 23, 39, 32, 3, -38 },
  { 3681, 24, 38, 32, 6, -38 },
  { 3795, 22, 38, 32, 6, -38 },
  { 3900, 23, 38, 32, 5, -38 },
  { 4010, 23, 38, 32, 4, -38 },
  { 4120, 25, 39, 32, 3, -38 },
  { 4242, 23, 38, 32, 6, -38 },
  { 4352, 26, 45, 32, 3, -38 },
  { 4499, 23, 38, 32, 6, -38 },
  { 4609, 25, 39, 32, 4, -38 },
  { 4731, 26, 38, 32, 3, -38 },
  { 4855, 24, 39, 32, 4, -38 },
  { 4972, 26, 38, 32, 3, -38 },
  { 5096, 28, 38, 32, 2, -38 },
  { 5229, 27, 38, 32, 3, -38 },
  { 5358, 27, 38, 32, 2, -38 },
  { 5487, 23, 38, 32, 4, -38 },
  { 5597, 8, 51, 32, 12, -43 },
  { 5648, 18, 41, 32, 7, -38 },
  { 5741, 9, 51, 32, 11, -43 },
  { 5799, 18, 21, 32, 7, -38 },
  { 5847, 22, 2, 32, 5, 0 },
  { 5853, 8, 7, 32, 12, -39 },
  { 5860, 22, 30, 32, 5, -29 },
  { 5943, 23, 41, 32, 5, -40 },
  { 6061, 23, 30, 32, 4, -29 },
  { 6148, 22, 41, 32, 4, -40 },
  { 6261, 24, 30, 32, 4, -29 },
  { 6351, 24, 40, 32, 5, -40 },
  { 6471, 22, 40, 32, 4, -29 },
  { 6581, 22, 40, 32, 5, -40 },
  { 6691, 22, 38, 32, 6, -38 },
  { 6796, 16, 49, 32, 5, -38 },
  { 6894, 22, 40, 32, 6, -40 },
  { 7004, 22, 40, 32, 6, -40 },
  { 7114, 28, 29, 32, 2, -29 },
  { 7216, 22, 29, 32, 5, -29 },
  { 7296, 24, 30, 32, 4, -29 },
  { 7386, 22, 40, 32, 5, -29 },
  { 7496, 22, 40, 32, 4, -29 },
  { 7606, 18, 29, 32, 10, -29 },
  { 7672, 22, 30, 32, 5, -29 },
  { 7755, 22, 36, 32, 5, -35 },
  { 7854, 22, 29, 32, 5, -28 },
  { 7934, 26, 28, 32, 3, -28 },
  { 8025, 28, 28, 32, 2, -28 },
  { 8123, 25, 28, 32, 4, -28 },
  { 8211, 28, 39, 32, 2, -28 },
  { 8348, 25, 28, 32, 4, -28 },
  { 8436, 17, 52, 32, 9, -41 },
  { 8547, 2, 46, 32, 15, -38 },
  { 8559, 17, 52, 32, 9, -41 },
  { 8670, 28, 9, 32, 2, -20 },
};

const GFXfont RobotoMono_ExtraLight53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight53pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_EXTRALIGHT53PT7B_H_
