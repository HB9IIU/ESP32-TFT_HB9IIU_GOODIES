#ifndef _ROBOTOMONO_EXTRALIGHT69PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight69pt7bBitmaps[] PROGMEM = {
  0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xF0, 0x60, 0x3B, 0x01, 0xD8,
  0x0E, 0xC0, 0x76, 0x03, 0xB0, 0x1D, 0x80, 0xCC, 0x06, 0xE0, 0x37, 0x01,
  0xB8, 0x0D, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x80, 0xC0, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x02, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x06, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x0E, 0x00, 0x18,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x38, 0x00,
  0x30, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x0E,
  0x03, 0x00, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x18, 0x00,
  0x01, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x07,
  0xFC, 0x00, 0x00, 0x30, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x78, 0x3C, 0x00,
  0x03, 0x80, 0xC0, 0x18, 0x00, 0x07, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x06,
  0x00, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x38, 0x3C, 0x03, 0x80, 0x07, 0x0F, 0x00, 0x78, 0x00, 0xE1,
  0xC0, 0x07, 0x80, 0x1C, 0x78, 0x00, 0x78, 0x03, 0x8E, 0x00, 0x07, 0x00,
  0x71, 0xC0, 0x00, 0x70, 0x1C, 0x70, 0x00, 0x07, 0x03, 0x8E, 0x00, 0x00,
  0xF0, 0x71, 0xC0, 0x00, 0x0F, 0x1C, 0x38, 0x00, 0x00, 0xF3, 0x87, 0x00,
  0x00, 0x0E, 0xF0, 0xE0, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0x1F, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7E, 0x03, 0x80, 0x00, 0x1F,
  0xC0, 0x78, 0x00, 0x07, 0x9C, 0x07, 0xC0, 0x03, 0xE3, 0xC0, 0x7E, 0x01,
  0xF8, 0x3C, 0x03, 0xFF, 0xFC, 0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x6D, 0xB0, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0xEF,
  0x80, 0x30, 0x0F, 0xBF, 0xC0, 0xC1, 0xFF, 0x3F, 0xE3, 0x1F, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x3C, 0x01, 0x80, 0x00, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0x8E, 0x38, 0xE7,
  0x1C, 0xF3, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x73, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x0E, 0x7E, 0x00,
  0x00, 0x71, 0xF0, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x1C, 0x1F, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0,
  0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x07,
  0xC0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7E, 0x0F, 0x00, 0x01, 0xF8,
  0x78, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x1F, 0x9C, 0x00, 0x00, 0x7E, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1B, 0xC0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x7F, 0x38, 0xFE, 0x1D, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x0F, 0xFC, 0x00, 0x33, 0xFF,
  0xF8, 0x03, 0xBF, 0xFF, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xF8, 0x00, 0x3F,
  0x07, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x01,
  0xFF, 0x80, 0x1C, 0x1F, 0xFF, 0x80, 0x71, 0xFE, 0xFF, 0x01, 0x8F, 0x80,
  0x1F, 0x06, 0x78, 0x00, 0x3E, 0x3B, 0x80, 0x00, 0x78, 0xFC, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x3E, 0x70, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xB0, 0xF0, 0x00,
  0x07, 0x60, 0xF0, 0x00, 0x1C, 0xC1, 0xF0, 0x00, 0x73, 0x81, 0xF0, 0x07,
  0xC7, 0x00, 0xFF, 0xFF, 0x0E, 0x00, 0xFF, 0xF8, 0x1C, 0x00, 0x3F, 0xC0,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xDF, 0xFF, 0xDE, 0x1C, 0x7C, 0xF9, 0xF1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xC3, 0x87, 0x0E, 0x38, 0x71, 0xE3, 0x86, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x79, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0x83, 0x80, 0x1F, 0xC0,
  0x1C, 0x38, 0x01, 0xFF, 0x80, 0x61, 0xC0, 0x3E, 0x3E, 0x03, 0x1C, 0x01,
  0xC0, 0x70, 0x1C, 0xE0, 0x1C, 0x01, 0x80, 0xE6, 0x01, 0xC0, 0x0C, 0x03,
  0x70, 0x0C, 0x00, 0xE0, 0x1B, 0x80, 0xE0, 0x07, 0x00, 0xD8, 0x06, 0x00,
  0x30, 0x06, 0xC0, 0x30, 0x01, 0x80, 0x36, 0x03, 0x80, 0x0C, 0x01, 0xF0,
  0x1C, 0x00, 0x60, 0x0F, 0x80, 0xC0, 0x03, 0x00, 0x7C, 0x06, 0x00, 0x18,
  0x03, 0xC0, 0x30, 0x00, 0xC0, 0x1E, 0x01, 0x80, 0x0E, 0x00, 0xF0, 0x0C,
  0x00, 0x70, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x18, 0x01,
  0xE0, 0x38, 0x00, 0xC0, 0x1F, 0x00, 0xC0, 0x0E, 0x00, 0xDC, 0x06, 0x00,
  0x70, 0x06, 0xE0, 0x30, 0x07, 0x80, 0x37, 0x01, 0xC0, 0x3E, 0x03, 0x18,
  0x0E, 0x03, 0x70, 0x18, 0xC0, 0x38, 0x39, 0x81, 0x87, 0x01, 0xE7, 0x8E,
  0x1C, 0x38, 0x07, 0xF8, 0x3F, 0xC0, 0xC0, 0x1F, 0x80, 0xFC, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x01, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x0F, 0xC0, 0xE0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x7E, 0x0E, 0x00, 0x00,
  0x7C, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3E,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC7, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x1E, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x00, 0x70, 0x07, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03,
  0x87, 0xC0, 0x00, 0x01, 0xC7, 0xF0, 0x00, 0x00, 0xE3, 0xBC, 0x00, 0x00,
  0x73, 0x8F, 0x00, 0x00, 0x3B, 0x83, 0x80, 0x00, 0x1F, 0x80, 0xE0, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xEF, 0xF0, 0x00, 0x03, 0xBF, 0xC0, 0x00, 0x0E, 0xFB, 0x80,
  0x00, 0x77, 0xEE, 0x00, 0x01, 0xDF, 0x98, 0x00, 0x0E, 0x7E, 0x70, 0x00,
  0x39, 0xF9, 0xC0, 0x00, 0xE7, 0xE3, 0x80, 0x07, 0x1F, 0x8E, 0x00, 0x1C,
  0x7E, 0x38, 0x00, 0xE1, 0xF8, 0x70, 0x03, 0x87, 0xE1, 0xC0, 0x0E, 0x1F,
  0x83, 0x00, 0x70, 0x7E, 0x0E, 0x01, 0xC1, 0xF8, 0x38, 0x0E, 0x07, 0xE0,
  0x60, 0x38, 0x1F, 0x81, 0xC0, 0xE0, 0x7E, 0x07, 0x07, 0x01, 0xF8, 0x0E,
  0x1C, 0x07, 0xE0, 0x38, 0x60, 0x1F, 0x80, 0x63, 0x80, 0x7E, 0x01, 0xCE,
  0x01, 0xF8, 0x07, 0x70, 0x07, 0xE0, 0x0D, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x1F,
  0x80, 0x1C, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFB, 0x80, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x1F, 0x9C, 0x00,
  0x00, 0x7E, 0x70, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x07, 0xE1, 0xC0, 0x00,
  0x1F, 0x87, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x07,
  0xE0, 0x70, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x7E, 0x03, 0x80, 0x01, 0xF8,
  0x0E, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x1F, 0x80, 0x38, 0x00, 0x7E, 0x00,
  0xE0, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x0E,
  0x00, 0x7E, 0x00, 0x38, 0x01, 0xF8, 0x00, 0x70, 0x07, 0xE0, 0x01, 0xE0,
  0x1F, 0x80, 0x03, 0x80, 0x7E, 0x00, 0x07, 0x01, 0xF8, 0x00, 0x1C, 0x07,
  0xE0, 0x00, 0x38, 0x1F, 0x80, 0x00, 0xE0, 0x7E, 0x00, 0x01, 0xC1, 0xF8,
  0x00, 0x07, 0x07, 0xE0, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0x3C, 0x7E, 0x00,
  0x00, 0x71, 0xF8, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x03, 0x9F, 0x80, 0x00,
  0x07, 0x7E, 0x00, 0x00, 0x1D, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x38, 0x00,
  0x03, 0xE0, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0xC3, 0x80, 0x00, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x0F, 0x01, 0xC0, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00,
  0x03, 0x80, 0x01, 0xB8, 0x00, 0x1C, 0x00, 0x0C, 0xC0, 0x01, 0xE0, 0x00,
  0xE7, 0x00, 0x0F, 0x80, 0x07, 0x38, 0x00, 0x7C, 0x00, 0x39, 0xC0, 0x03,
  0xE0, 0x01, 0xCE, 0x00, 0x1B, 0x00, 0x0C, 0x70, 0x01, 0xD8, 0x00, 0x63,
  0x80, 0x0E, 0xE0, 0x03, 0x0C, 0x00, 0x77, 0x00, 0x38, 0x70, 0x03, 0x38,
  0x01, 0xC3, 0x80, 0x18, 0xC0, 0x0E, 0x1C, 0x01, 0xC6, 0x00, 0x70, 0xE0,
  0x0E, 0x38, 0x03, 0x07, 0x00, 0x71, 0xC0, 0x18, 0x18, 0x03, 0x0E, 0x01,
  0xC0, 0xC0, 0x18, 0x70, 0x0E, 0x07, 0x01, 0xC1, 0x80, 0x70, 0x38, 0x0E,
  0x0C, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0xC0,
  0x70, 0x18, 0x1C, 0x06, 0x01, 0x81, 0xC0, 0x60, 0x70, 0x0C, 0x0E, 0x03,
  0x03, 0x80, 0x70, 0x70, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x1C,
  0x18, 0x07, 0x06, 0x00, 0xE0, 0xC0, 0x18, 0x30, 0x07, 0x0E, 0x00, 0xC1,
  0x80, 0x18, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x07, 0x18,
  0x01, 0xC7, 0x00, 0x38, 0xC0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x31, 0x80,
  0x0E, 0x70, 0x01, 0xCC, 0x00, 0x33, 0x80, 0x0E, 0x60, 0x01, 0x98, 0x00,
  0x77, 0x00, 0x0E, 0xC0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x03,
  0xF0, 0x00, 0x6E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xC3, 0x00, 0x01, 0x83, 0x80, 0x03, 0x83, 0x80, 0x03, 0x81,
  0xC0, 0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x38, 0x0E,
  0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x0E, 0x1F,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x1F, 0x9C, 0x00, 0x00, 0xEE, 0x78, 0x00, 0x07, 0x38,
  0xF0, 0x00, 0x78, 0xE1, 0xF8, 0x0F, 0xC3, 0x83, 0xFF, 0xFE, 0x0E, 0x03,
  0xFF, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x07, 0xFC, 0x00, 0xE0, 0xFF, 0xF8, 0x07, 0x1F, 0xFF, 0xF0,
  0x39, 0xE0, 0x07, 0xC1, 0xDE, 0x00, 0x1F, 0x0E, 0xC0, 0x00, 0x38, 0x7C,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x0F, 0x1F, 0xC0, 0x00,
  0xF0, 0xEF, 0x00, 0x0F, 0x07, 0x3F, 0x03, 0xF0, 0x38, 0x7F, 0xFF, 0x01,
  0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xF8,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x00,
  0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07, 0x01, 0xFF,
  0xF0, 0x70, 0x3F, 0xFF, 0xC7, 0x07, 0xC0, 0x1E, 0x70, 0xF0, 0x00, 0x77,
  0x1E, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xF0, 0xE0,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x70, 0x7E, 0x03, 0xE7, 0x01, 0xFF, 0xFC,
  0x70, 0x0F, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x02, 0x07, 0x80, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x38, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x07, 0x03, 0xFF, 0xFC,
  0x70, 0x7C, 0x01, 0xE7, 0x0F, 0x00, 0x07, 0x71, 0xE0, 0x00, 0x3F, 0x1C,
  0x00, 0x01, 0xF3, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0xF7, 0x07, 0xE0, 0x3E, 0x70, 0x1F, 0xFF, 0xC7, 0x00, 0xFF, 0xF0, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x10, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0x00,
  0xE0, 0x7F, 0xFC, 0x0E, 0x0F, 0xFF, 0xF0, 0xE3, 0xE0, 0x0F, 0x8E, 0x78,
  0x00, 0x3C, 0xE6, 0x00, 0x01, 0xCE, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0xEF, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x02, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x3C, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x7C, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x7C,
  0x00, 0x00, 0xE7, 0xF0, 0x00, 0x07, 0x7B, 0xC0, 0x00, 0x3F, 0x8F, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x03,
  0x80, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0xF0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x0E, 0x3F, 0xF0,
  0x3F, 0xF0, 0xEF, 0xFF, 0x8F, 0xFF, 0x8E, 0xE0, 0x3C, 0xE0, 0x3C, 0xF8,
  0x01, 0xD8, 0x01, 0xEF, 0x00, 0x0F, 0x80, 0x0E, 0xF0, 0x00, 0xF0, 0x00,
  0xEE, 0x00, 0x0F, 0x00, 0x0E, 0xE0, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x07, 0xE0,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0x00, 0x06, 0xE0,
  0x00, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0x00, 0x06, 0xE0, 0x00, 0xE0, 0x00,
  0x6E, 0x00, 0x0E, 0x00, 0x06, 0xE0, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0x0E,
  0x00, 0x06, 0xE0, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0x00, 0x06, 0xE0,
  0x00, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0x00, 0x06, 0xE0, 0x00, 0xE0, 0x00,
  0x6E, 0x00, 0x0E, 0x00, 0x06, 0xE0, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0x0E,
  0x00, 0x06, 0xE0, 0x00, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0x00, 0x06, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x0E, 0x07, 0xFF, 0xC0, 0xE0,
  0xFF, 0xFF, 0x0E, 0x3E, 0x00, 0xF8, 0xE7, 0x80, 0x03, 0xCE, 0x60, 0x00,
  0x1C, 0xEC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0E, 0xF8, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0x07, 0xFF, 0xC0, 0x38, 0xFF, 0xFF, 0x01, 0xCF, 0x00, 0x7E,
  0x0E, 0xE0, 0x00, 0xF0, 0x7E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0x1F, 0x00, 0x00, 0x70, 0xFC, 0x00, 0x07, 0x87, 0x78, 0x00,
  0x78, 0x39, 0xF0, 0x1F, 0x81, 0xC3, 0xFF, 0xF8, 0x0E, 0x07, 0xFF, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x87, 0x03, 0xFF,
  0xFC, 0x70, 0x7C, 0x01, 0xE7, 0x0F, 0x00, 0x07, 0x71, 0xE0, 0x00, 0x3F,
  0x1C, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x77, 0x07, 0xE0, 0x3E, 0x70, 0x1F, 0xFF, 0xC7, 0x00, 0xFF, 0xF0,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0x80, 0x0E, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x20, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x03, 0x73, 0xC0,
  0x00, 0x77, 0x1E, 0x00, 0x1E, 0x70, 0xF8, 0x0F, 0xC7, 0x07, 0xFF, 0xF0,
  0x70, 0x1F, 0xFE, 0x07, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1D, 0xC0, 0x01, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0x80, 0x03, 0x9C, 0x00, 0x1E, 0x00, 0x0E, 0x70, 0x00, 0x78, 0x00,
  0x30, 0xC0, 0x03, 0xF0, 0x01, 0xC3, 0x80, 0x0D, 0xC0, 0x07, 0x0E, 0x00,
  0x33, 0x00, 0x1C, 0x38, 0x00, 0xCC, 0x00, 0x70, 0x60, 0x07, 0x38, 0x01,
  0x81, 0xC0, 0x1C, 0xE0, 0x0E, 0x07, 0x00, 0x63, 0x80, 0x38, 0x1C, 0x01,
  0x86, 0x00, 0xE0, 0x70, 0x0E, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x70, 0x0C,
  0x03, 0x80, 0xC0, 0xC0, 0x70, 0x0E, 0x03, 0x03, 0x01, 0xC0, 0x38, 0x1C,
  0x0E, 0x07, 0x00, 0x60, 0x70, 0x38, 0x18, 0x01, 0xC1, 0x80, 0x60, 0xE0,
  0x07, 0x06, 0x01, 0x83, 0x80, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0x30, 0xE0,
  0x1C, 0x30, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0xC7, 0x00,
  0x0E, 0x70, 0x03, 0x9C, 0x00, 0x39, 0x80, 0x0E, 0x60, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x01, 0x98, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x07,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC7, 0xEF, 0xE0,
  0x00, 0x0E, 0x78, 0x07, 0x80, 0x00, 0x73, 0x80, 0x1F, 0x00, 0x03, 0xB8,
  0x00, 0x7C, 0x00, 0x39, 0xC0, 0x00, 0xF0, 0x01, 0xCC, 0x00, 0x03, 0xE0,
  0x1C, 0xE0, 0x00, 0x0F, 0xC3, 0xC7, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0,
};

const GFXglyph RobotoMono_ExtraLight69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 5, 49, 41, 18, -49 },
  { 32, 13, 15, 41, 14, -52 },
  { 57, 38, 49, 41, 2, -49 },
  { 290, 30, 63, 41, 6, -56 },
  { 527, 39, 51, 41, 1, -50 },
  { 776, 35, 51, 41, 5, -50 },
  { 1000, 3, 15, 41, 18, -52 },
  { 1006, 16, 71, 41, 13, -55 },
  { 1148, 15, 71, 41, 12, -55 },
  { 1282, 30, 28, 41, 7, -49 },
  { 1387, 34, 36, 41, 4, -41 },
  { 1540, 6, 15, 41, 14, -6 },
  { 1552, 25, 3, 41, 8, -24 },
  { 1562, 6, 5, 41, 19, -5 },
  { 1566, 23, 53, 41, 10, -49 },
  { 1719, 30, 51, 41, 6, -50 },
  { 1911, 17, 49, 41, 8, -49 },
  { 2016, 31, 50, 41, 4, -50 },
  { 2210, 31, 51, 41, 3, -50 },
  { 2408, 34, 49, 41, 3, -49 },
  { 2617, 29, 50, 41, 7, -49 },
  { 2799, 30, 51, 41, 5, -50 },
  { 2991, 32, 49, 41, 4, -49 },
  { 3187, 31, 51, 41, 6, -50 },
  { 3385, 31, 51, 41, 5, -50 },
  { 3583, 5, 35, 41, 21, -35 },
  { 3605, 7, 44, 41, 19, -35 },
  { 3644, 29, 28, 41, 6, -36 },
  { 3746, 30, 17, 41, 6, -31 },
  { 3810, 30, 28, 41, 6, -36 },
  { 3915, 26, 50, 41, 8, -50 },
  { 4078, 37, 49, 41, 2, -49 },
  { 4305, 35, 49, 41, 4, -49 },
  { 4520, 30, 49, 41, 7, -49 },
  { 4704, 32, 51, 41, 5, -50 },
  { 4908, 32, 49, 41, 6, -49 },
  { 5104, 28, 49, 41, 7, -49 },
  { 5276, 29, 49, 41, 7, -49 },
  { 5454, 33, 51, 41, 4, -50 },
  { 5665, 30, 49, 41, 6, -49 },
  { 5849, 28, 49, 41, 7, -49 },
  { 6021, 30, 50, 41, 4, -49 },
  { 6209, 33, 49, 41, 7, -49 },
  { 6412, 28, 49, 41, 8, -49 },
  { 6584, 30, 49, 41, 6, -49 },
  { 6768, 30, 49, 41, 6, -49 },
  { 6952, 33, 51, 41, 4, -50 },
  { 7163, 30, 49, 41, 8, -49 },
  { 7347, 34, 59, 41, 4, -50 },
  { 7598, 31, 49, 41, 7, -49 },
  { 7788, 32, 51, 41, 5, -50 },
  { 7992, 35, 49, 41, 3, -49 },
  { 8207, 30, 50, 41, 6, -49 },
  { 8395, 35, 49, 41, 3, -49 },
  { 8610, 37, 49, 41, 3, -49 },
  { 8837, 35, 49, 41, 4, -49 },
  { 9052, 35, 49, 41, 3, -49 },
  { 9267, 30, 49, 41, 5, -49 },
  { 9451, 10, 67, 41, 16, -56 },
  { 9535, 23, 53, 41, 9, -49 },
  { 9688, 11, 67, 41, 15, -56 },
  { 9781, 24, 27, 41, 9, -49 },
  { 9862, 29, 3, 41, 6, 0 },
  { 9873, 9, 9, 41, 16, -51 },
  { 9884, 30, 38, 41, 6, -37 },
  { 10027, 29, 53, 41, 7, -52 },
  { 10220, 29, 38, 41, 6, -37 },
  { 10358, 28, 53, 41, 6, -52 },
  { 10544, 31, 38, 41, 5, -37 },
  { 10692, 31, 53, 41, 7, -53 },
  { 10898, 28, 52, 41, 6, -37 },
  { 11080, 28, 52, 41, 7, -52 },
  { 11262, 28, 49, 41, 8, -49 },
  { 11434, 22, 64, 41, 6, -49 },
  { 11610, 29, 52, 41, 8, -52 },
  { 11799, 28, 52, 41, 8, -52 },
  { 11981, 36, 37, 41, 3, -37 },
  { 12148, 28, 37, 41, 7, -37 },
  { 12278, 32, 38, 41, 5, -37 },
  { 12430, 29, 51, 41, 7, -37 },
  { 12615, 28, 51, 41, 6, -37 },
  { 12794, 23, 37, 41, 13, -37 },
  { 12901, 29, 38, 41, 7, -37 },
  { 13039, 29, 47, 41, 6, -46 },
  { 13210, 28, 37, 41, 7, -36 },
  { 13340, 33, 36, 41, 4, -36 },
  { 13489, 38, 36, 41, 2, -36 },
  { 13660, 33, 36, 41, 5, -36 },
  { 13809, 36, 51, 41, 3, -36 },
  { 14039, 32, 36, 41, 5, -36 },
  { 14183, 22, 68, 41, 11, -54 },
  { 14370, 3, 59, 41, 19, -49 },
  { 14393, 22, 68, 41, 11, -54 },
  { 14580, 37, 11, 41, 2, -26 },
};

const GFXfont RobotoMono_ExtraLight69pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight69pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _ROBOTOMONO_EXTRALIGHT69PT7B_H_
