#ifndef _ROBOTOMONO_EXTRALIGHT24PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight24pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x01, 0xC0, 0x99, 0x99, 0x90, 0x04, 0x20, 0x21,
  0x01, 0x10, 0x10, 0x80, 0x84, 0x3F, 0xFC, 0x21, 0x01, 0x08, 0x10, 0x80,
  0x84, 0x04, 0x21, 0xFF, 0xE1, 0x08, 0x08, 0x80, 0x84, 0x04, 0x20, 0x21,
  0x00, 0x04, 0x00, 0x80, 0x10, 0x0F, 0x82, 0x0C, 0x80, 0x90, 0x12, 0x03,
  0x40, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x80, 0x14, 0x01, 0x80,
  0x28, 0x09, 0x83, 0x0F, 0xC0, 0x40, 0x08, 0x00, 0x70, 0x04, 0x40, 0x22,
  0x11, 0x11, 0x08, 0x88, 0x44, 0x83, 0x44, 0x04, 0x40, 0x02, 0x00, 0x22,
  0x01, 0x24, 0x12, 0x11, 0x10, 0x88, 0x84, 0x84, 0x20, 0x22, 0x00, 0xF0,
  0x1E, 0x02, 0x10, 0x41, 0x04, 0x10, 0x41, 0x02, 0x20, 0x2C, 0x01, 0x80,
  0x28, 0x04, 0x42, 0xC6, 0x28, 0x22, 0x81, 0x28, 0x0C, 0x80, 0xC4, 0x1E,
  0x3E, 0x30, 0xF8, 0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x10, 0x84, 0x10, 0x43, 0x08, 0x81, 0x02, 0x04, 0x10, 0x40,
  0x82, 0x08, 0x20, 0x82, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x82,
  0x10, 0x80, 0x04, 0x00, 0x80, 0x10, 0x62, 0x33, 0xF8, 0x08, 0x02, 0x80,
  0x88, 0x30, 0x84, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x56, 0x80,
  0xFF, 0xB0, 0x01, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x60, 0x00, 0x3F,
  0x0C, 0x11, 0x01, 0x40, 0x28, 0x05, 0x01, 0xA0, 0x5C, 0x11, 0x84, 0x31,
  0x06, 0x40, 0xD0, 0x2C, 0x05, 0x80, 0x90, 0x31, 0x04, 0x1F, 0x00, 0x0C,
  0xEC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x1F, 0x0C, 0x11, 0x01, 0x60, 0x28, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x7F, 0xE0,
  0x1F, 0x04, 0x19, 0x01, 0x20, 0x28, 0x04, 0x00, 0x80, 0x10, 0x0C, 0x0F,
  0x00, 0x18, 0x01, 0x00, 0x18, 0x03, 0x00, 0x50, 0x13, 0x06, 0x1F, 0x80,
  0x00, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x88, 0x08, 0x81, 0x08,
  0x20, 0x82, 0x08, 0x40, 0x88, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x7F, 0x90, 0x04, 0x01, 0x00, 0x40, 0x20, 0x09, 0xC3, 0x8C,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xE0, 0x28, 0x09, 0x86, 0x3E, 0x00,
  0x0F, 0x06, 0x02, 0x01, 0x00, 0x40, 0x20, 0x09, 0xF3, 0x82, 0xC0, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x0D, 0x82, 0x1F, 0x00, 0xFF, 0xE0,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x00, 0x1F, 0x0C,
  0x19, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x11, 0x8C, 0x1F, 0x0C, 0x19,
  0x01, 0x40, 0x18, 0x03, 0x00, 0x70, 0x1B, 0x06, 0x3F, 0x80, 0x3F, 0x18,
  0x64, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x50, 0x33, 0xF4,
  0x01, 0x00, 0x40, 0x20, 0x18, 0x0C, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x2C,
  0x00, 0x00, 0x01, 0xB4, 0xB0, 0x00, 0x40, 0x70, 0x70, 0x60, 0x60, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x80, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x30, 0x30,
  0x30, 0x70, 0x30, 0x00, 0x3E, 0x20, 0xA0, 0x70, 0x10, 0x08, 0x04, 0x04,
  0x04, 0x06, 0x04, 0x02, 0x01, 0x01, 0x00, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x0F, 0xC0, 0x81, 0x08, 0x04, 0x82, 0x24, 0x49, 0x44, 0x46, 0x42, 0x32,
  0x11, 0x90, 0x8C, 0x84, 0x64, 0x45, 0x23, 0x29, 0xAB, 0x46, 0x21, 0x00,
  0x04, 0x08, 0x1F, 0x80, 0x02, 0x00, 0x60, 0x05, 0x00, 0x50, 0x09, 0x00,
  0x88, 0x08, 0x81, 0x08, 0x10, 0x41, 0x04, 0x20, 0x43, 0xFE, 0x20, 0x24,
  0x02, 0x40, 0x14, 0x01, 0xC0, 0x10, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28,
  0x05, 0x00, 0xA0, 0x34, 0x0C, 0xFF, 0x10, 0x1A, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x14, 0x06, 0xFF, 0x00, 0x1F, 0x0C, 0x11, 0x01, 0x40, 0x28,
  0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x90, 0x13, 0x04, 0x1F, 0x00, 0xFE, 0x10, 0x32, 0x02, 0x40, 0x28,
  0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xA0, 0x24, 0x08, 0xFE, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00,
  0x1F, 0x83, 0x04, 0x20, 0x24, 0x02, 0x40, 0x14, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x3F, 0xC0, 0x14, 0x01, 0x40, 0x14, 0x01, 0x20, 0x11, 0x02,
  0x0F, 0xC0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xFF, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC0, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x18, 0x02, 0x80, 0x50, 0x11, 0x06, 0x1F, 0x00, 0x80, 0xD0,
  0x12, 0x04, 0x41, 0x08, 0x41, 0x10, 0x24, 0x05, 0x80, 0xF0, 0x19, 0x02,
  0x10, 0x43, 0x08, 0x21, 0x02, 0x20, 0x24, 0x06, 0x80, 0x60, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0xC0, 0x78, 0x0F, 0x02,
  0xD0, 0x5A, 0x13, 0x22, 0x64, 0x4C, 0x91, 0x8A, 0x31, 0x86, 0x30, 0xC2,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x80, 0x70, 0x1C, 0x06,
  0x81, 0xB0, 0x64, 0x18, 0x86, 0x21, 0x84, 0x61, 0x18, 0x26, 0x09, 0x81,
  0x60, 0x78, 0x0E, 0x01, 0x80, 0x40, 0x3F, 0x0C, 0x11, 0x01, 0x40, 0x28,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x05,
  0x00, 0x90, 0x33, 0x04, 0x1F, 0x00, 0xFE, 0x20, 0x68, 0x0E, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x81, 0xBF, 0x88, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x1F, 0x83, 0x04, 0x20, 0x24, 0x02, 0x40, 0x14,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x40, 0x14,
  0x02, 0x20, 0x23, 0x04, 0x0F, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFE, 0x20,
  0x48, 0x0A, 0x02, 0x80, 0xE0, 0x28, 0x0A, 0x02, 0x83, 0x3F, 0x08, 0x22,
  0x08, 0x81, 0x20, 0x48, 0x0A, 0x02, 0x80, 0x40, 0x3F, 0x0C, 0x1B, 0x01,
  0x40, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x03, 0x00, 0x70, 0x1B, 0x06, 0x3F, 0x80, 0xFF, 0xF0, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x14, 0x05, 0x82, 0x1F, 0x00, 0x80, 0x14, 0x01, 0x40,
  0x24, 0x02, 0x20, 0x22, 0x04, 0x20, 0x41, 0x04, 0x10, 0x81, 0x08, 0x08,
  0x80, 0x90, 0x09, 0x00, 0x50, 0x06, 0x00, 0x60, 0x06, 0x00, 0x82, 0x0C,
  0x10, 0x61, 0x84, 0x8A, 0x24, 0x51, 0x22, 0x89, 0x14, 0x49, 0x22, 0x48,
  0x92, 0x45, 0x0A, 0x28, 0x51, 0x42, 0x8A, 0x18, 0x30, 0xC1, 0x86, 0x08,
  0x10, 0x40, 0x40, 0x12, 0x02, 0x20, 0x61, 0x04, 0x18, 0x80, 0x88, 0x05,
  0x00, 0x70, 0x02, 0x00, 0x50, 0x0D, 0x00, 0x88, 0x10, 0xC1, 0x04, 0x20,
  0x24, 0x03, 0xC0, 0x10, 0x80, 0x14, 0x02, 0x40, 0x22, 0x04, 0x20, 0x41,
  0x08, 0x10, 0x80, 0x90, 0x09, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xFF, 0xC0, 0x30, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x60, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x04,
  0x02, 0x00, 0xFF, 0xC0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x8F, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x18,
  0x14, 0x24, 0x24, 0x62, 0x42, 0x41, 0x81, 0xFF, 0xC0, 0x99, 0x80, 0x1F,
  0x18, 0x64, 0x06, 0x01, 0x00, 0x40, 0x13, 0xFD, 0x01, 0x80, 0x60, 0x18,
  0x0D, 0x07, 0x3E, 0x40, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0x8E,
  0x1B, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xA0, 0xA7, 0xC0, 0x1F, 0x08, 0x64, 0x05, 0x01, 0x80, 0x60, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x14, 0x04, 0x82, 0x1F, 0x00, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x47, 0x92, 0x15, 0x03, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x05, 0x01, 0x60, 0xCF, 0xD0, 0x1F, 0x04, 0x31, 0x01, 0x60,
  0x28, 0x05, 0x00, 0x7F, 0xFC, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x21,
  0xF8, 0x07, 0xE1, 0x80, 0x20, 0x04, 0x00, 0x81, 0xFF, 0x82, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x1E, 0x48, 0x54, 0x0F, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x14, 0x05, 0x83, 0x3F, 0x40, 0x10, 0x05, 0x02, 0x61, 0x87,
  0x80, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x23, 0xCB, 0x0A, 0x81, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC0, 0x03, 0x02,
  0x00, 0x00, 0x3E, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x28, 0x12, 0x08, 0x8C, 0x26, 0x0B, 0x03, 0xC0, 0x88,
  0x21, 0x08, 0x62, 0x0C, 0x81, 0xA0, 0x30, 0xF8, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0xB8, 0xEC, 0x51, 0x82, 0x18, 0x21,
  0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21,
  0x82, 0x10, 0x8F, 0x2C, 0x2A, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x1E, 0x04, 0x31, 0x03, 0x40,
  0x28, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x09, 0x01, 0x30, 0x43,
  0xF0, 0x8E, 0x28, 0x6C, 0x0B, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x0E, 0x82, 0x9F, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00,
  0x1E, 0x48, 0x54, 0x0F, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x14, 0x05, 0x83, 0x3F, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x8F,
  0xC8, 0x28, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x40, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x40, 0x1C, 0x05, 0x03, 0x3F, 0x80, 0x08, 0x02, 0x00, 0x83, 0xFE,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x1F, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x50, 0x14, 0x0D, 0x83, 0x3F, 0x40, 0x80, 0x14, 0x03, 0x40,
  0x22, 0x02, 0x20, 0x41, 0x04, 0x10, 0x81, 0x08, 0x08, 0x80, 0x90, 0x05,
  0x00, 0x60, 0x02, 0x00, 0x82, 0x0C, 0x10, 0x61, 0x84, 0x8A, 0x24, 0x51,
  0x22, 0x89, 0x24, 0x89, 0x14, 0x28, 0xA1, 0x45, 0x0C, 0x28, 0x60, 0x81,
  0x04, 0x00, 0x80, 0x68, 0x08, 0x82, 0x18, 0x81, 0x30, 0x1C, 0x01, 0x00,
  0x70, 0x13, 0x06, 0x20, 0x82, 0x20, 0x28, 0x06, 0x80, 0x1C, 0x01, 0x40,
  0x26, 0x02, 0x20, 0x63, 0x04, 0x10, 0x41, 0x08, 0x08, 0x80, 0x90, 0x05,
  0x00, 0x60, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x07, 0x00, 0xFF,
  0xC0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x60, 0x0F, 0xFE, 0x01, 0x06, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x60, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x18, 0x08, 0x04, 0x03, 0xFF, 0xFF, 0xF8, 0x80, 0x60, 0x20, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x08, 0x06, 0x07, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0x60, 0x80, 0x78, 0x0C, 0x30, 0xA0,
  0xC5, 0x01, 0xC0,
};

const GFXglyph RobotoMono_ExtraLight24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 17, 14, 6, -17 },
  { 6, 4, 5, 14, 5, -18 },
  { 9, 13, 17, 14, 1, -17 },
  { 37, 11, 22, 14, 2, -20 },
  { 68, 13, 17, 14, 1, -17 },
  { 96, 12, 17, 14, 2, -17 },
  { 122, 1, 5, 14, 6, -18 },
  { 123, 5, 25, 14, 5, -19 },
  { 139, 6, 25, 14, 4, -19 },
  { 158, 11, 10, 14, 2, -17 },
  { 172, 12, 12, 14, 1, -14 },
  { 190, 2, 5, 14, 5, -2 },
  { 192, 8, 1, 14, 3, -8 },
  { 193, 2, 2, 14, 7, -2 },
  { 194, 9, 18, 14, 3, -17 },
  { 215, 11, 17, 14, 2, -17 },
  { 239, 6, 17, 14, 3, -17 },
  { 252, 11, 17, 14, 1, -17 },
  { 276, 11, 17, 14, 1, -17 },
  { 300, 12, 17, 14, 1, -17 },
  { 326, 10, 17, 14, 3, -17 },
  { 348, 10, 17, 14, 2, -17 },
  { 370, 11, 17, 14, 2, -17 },
  { 394, 11, 17, 14, 2, -17 },
  { 418, 10, 17, 14, 2, -17 },
  { 440, 2, 12, 14, 7, -12 },
  { 443, 3, 15, 14, 6, -12 },
  { 449, 10, 10, 14, 2, -13 },
  { 462, 11, 6, 14, 2, -11 },
  { 471, 10, 10, 14, 2, -13 },
  { 484, 9, 17, 14, 3, -17 },
  { 504, 13, 17, 14, 1, -17 },
  { 532, 12, 17, 14, 1, -17 },
  { 558, 11, 17, 14, 2, -17 },
  { 582, 11, 17, 14, 2, -17 },
  { 606, 11, 17, 14, 2, -17 },
  { 630, 10, 17, 14, 2, -17 },
  { 652, 9, 17, 14, 3, -17 },
  { 672, 12, 17, 14, 1, -17 },
  { 698, 10, 17, 14, 2, -17 },
  { 720, 10, 17, 14, 2, -17 },
  { 742, 11, 17, 14, 1, -17 },
  { 766, 11, 17, 14, 3, -17 },
  { 790, 10, 17, 14, 3, -17 },
  { 812, 11, 17, 14, 2, -17 },
  { 836, 10, 17, 14, 2, -17 },
  { 858, 11, 17, 14, 2, -17 },
  { 882, 10, 17, 14, 3, -17 },
  { 904, 12, 20, 14, 1, -17 },
  { 934, 10, 17, 14, 3, -17 },
  { 956, 11, 17, 14, 2, -17 },
  { 980, 12, 17, 14, 1, -17 },
  { 1006, 10, 17, 14, 2, -17 },
  { 1028, 12, 17, 14, 1, -17 },
  { 1054, 13, 17, 14, 1, -17 },
  { 1082, 12, 17, 14, 1, -17 },
  { 1108, 12, 17, 14, 1, -17 },
  { 1134, 10, 17, 14, 2, -17 },
  { 1156, 4, 24, 14, 5, -20 },
  { 1168, 8, 18, 14, 3, -17 },
  { 1186, 4, 24, 14, 5, -20 },
  { 1198, 8, 9, 14, 3, -17 },
  { 1207, 10, 1, 14, 2, 0 },
  { 1209, 3, 3, 14, 6, -18 },
  { 1211, 10, 13, 14, 2, -13 },
  { 1228, 10, 18, 14, 2, -18 },
  { 1251, 10, 13, 14, 2, -13 },
  { 1268, 10, 18, 14, 2, -18 },
  { 1291, 11, 13, 14, 2, -13 },
  { 1309, 11, 18, 14, 2, -18 },
  { 1334, 10, 18, 14, 2, -13 },
  { 1357, 10, 18, 14, 2, -18 },
  { 1380, 10, 17, 14, 3, -17 },
  { 1402, 8, 22, 14, 2, -17 },
  { 1424, 10, 18, 14, 3, -18 },
  { 1447, 10, 18, 14, 3, -18 },
  { 1470, 12, 13, 14, 1, -13 },
  { 1490, 10, 13, 14, 2, -13 },
  { 1507, 11, 13, 14, 2, -13 },
  { 1525, 10, 18, 14, 2, -13 },
  { 1548, 10, 18, 14, 2, -13 },
  { 1571, 9, 13, 14, 4, -13 },
  { 1586, 10, 13, 14, 2, -13 },
  { 1603, 10, 16, 14, 2, -16 },
  { 1623, 10, 13, 14, 2, -13 },
  { 1640, 12, 13, 14, 1, -13 },
  { 1660, 13, 13, 14, 1, -13 },
  { 1682, 11, 13, 14, 2, -13 },
  { 1700, 12, 18, 14, 1, -13 },
  { 1727, 11, 13, 14, 2, -13 },
  { 1745, 8, 24, 14, 4, -19 },
  { 1769, 1, 21, 14, 7, -17 },
  { 1772, 8, 24, 14, 4, -19 },
  { 1796, 13, 4, 14, 1, -9 },
};

const GFXfont RobotoMono_ExtraLight24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight24pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_EXTRALIGHT24PT7B_H_
