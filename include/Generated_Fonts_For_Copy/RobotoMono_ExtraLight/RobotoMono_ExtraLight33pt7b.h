#ifndef _ROBOTOMONO_EXTRALIGHT33PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight33pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x3C, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xC0, 0x01, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x18, 0x03, 0x04,
  0x00, 0x81, 0x07, 0xFF, 0xFC, 0x08, 0x10, 0x02, 0x0C, 0x01, 0x82, 0x00,
  0x60, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x06, 0x00, 0x41, 0x83, 0xFF,
  0xFE, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x18, 0x20,
  0x06, 0x08, 0x01, 0x02, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x01, 0xF0,
  0x1E, 0xF0, 0xC0, 0x66, 0x00, 0x98, 0x03, 0x40, 0x05, 0x00, 0x14, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x50, 0x03, 0x60,
  0x08, 0xE0, 0xE0, 0xFE, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x38, 0x00,
  0x1B, 0x00, 0x0C, 0x20, 0x02, 0x08, 0x10, 0x83, 0x0C, 0x20, 0xC2, 0x08,
  0x31, 0x82, 0x0C, 0x40, 0xC2, 0x30, 0x19, 0x88, 0x03, 0xC6, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0xF8, 0x0C, 0x42, 0x02, 0x30,
  0xC1, 0x88, 0x10, 0x42, 0x04, 0x30, 0x81, 0x08, 0x20, 0x46, 0x0C, 0x30,
  0x01, 0x08, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x70, 0x06, 0x08, 0x02, 0x06,
  0x01, 0x03, 0x00, 0x81, 0x80, 0x40, 0x80, 0x20, 0xC0, 0x18, 0xC0, 0x04,
  0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x01, 0xB0, 0x01, 0x8C, 0x00, 0x82, 0x04,
  0xC1, 0x82, 0x40, 0x63, 0x60, 0x19, 0xB0, 0x06, 0x88, 0x01, 0xC4, 0x00,
  0xC3, 0x00, 0xF0, 0xE0, 0xCC, 0x3F, 0xC3, 0x55, 0x5C, 0x03, 0x06, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20,
  0x30, 0x10, 0x08, 0x0C, 0x04, 0x03, 0x01, 0x80, 0x80, 0x81, 0x81, 0x03,
  0x02, 0x06, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC0, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x20, 0x41, 0x02, 0x08, 0x20, 0x81,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x0E, 0x10, 0xEF, 0x2F,
  0x01, 0xF0, 0x01, 0xC0, 0x06, 0xC0, 0x18, 0x80, 0x20, 0x80, 0xC1, 0x83,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x24, 0x92, 0xF0, 0xFF, 0xF0, 0xFC, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x10, 0x06, 0x00, 0x80, 0x00, 0x07, 0x80, 0x7F, 0x83, 0x03, 0x18, 0x06,
  0x40, 0x0B, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x36, 0x01, 0x98, 0x0C,
  0x60, 0x61, 0x83, 0x06, 0x18, 0x18, 0xC0, 0x66, 0x01, 0xA0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x02, 0x40, 0x18, 0x80, 0x43, 0x87, 0x03, 0xF0, 0x07,
  0x1F, 0x73, 0xC3, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x00,
  0x3F, 0xC1, 0x80, 0xC2, 0x00, 0xCC, 0x00, 0x90, 0x01, 0x20, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0x07, 0x80, 0x7F, 0x83, 0x03,
  0x18, 0x06, 0xC0, 0x0B, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x03, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x0D, 0x80, 0x63, 0x03, 0x07,
  0xF8, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1A, 0x00, 0x09, 0x00, 0x0C, 0x80,
  0x0C, 0x40, 0x04, 0x20, 0x06, 0x10, 0x06, 0x08, 0x02, 0x04, 0x03, 0x02,
  0x03, 0x01, 0x01, 0x00, 0x81, 0x80, 0x41, 0x80, 0x20, 0x80, 0x10, 0xFF,
  0xFF, 0x80, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x7F, 0xFB, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x4F, 0x87, 0xFF, 0x30, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x07, 0x80, 0x36, 0x03,
  0x1C, 0x70, 0x7F, 0x00, 0x00, 0x30, 0x07, 0xE0, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x9F, 0xE1, 0x60,
  0xE3, 0x80, 0x66, 0x00, 0x58, 0x00, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x06,
  0x80, 0x0D, 0x00, 0x1B, 0x00, 0x22, 0x00, 0xC6, 0x01, 0x07, 0x0E, 0x03,
  0xF0, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x00, 0x03, 0x80, 0x3F,
  0xE0, 0xC0, 0x63, 0x00, 0x44, 0x00, 0xC8, 0x00, 0xB0, 0x01, 0x20, 0x02,
  0x40, 0x0C, 0xC0, 0x10, 0xC0, 0xC0, 0x7F, 0x01, 0xFE, 0x06, 0x03, 0x18,
  0x03, 0x60, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x4C, 0x01, 0x8C, 0x0E, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0x83, 0x03, 0x18,
  0x06, 0xC0, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x03, 0xC0, 0x0D, 0x80, 0x53, 0x06, 0xC7, 0xF3, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x3C, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x76, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x66, 0x64, 0x4C, 0x00, 0x0C, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x00, 0x80, 0x00, 0x0F, 0x03, 0xFC, 0x60, 0x6C, 0x03, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0x00, 0xC0, 0x60, 0x60,
  0x04, 0x30, 0x01, 0x88, 0x18, 0x26, 0x1B, 0x89, 0x0C, 0x23, 0x42, 0x08,
  0x71, 0x02, 0x18, 0x41, 0x06, 0x10, 0x41, 0x84, 0x10, 0x63, 0x04, 0x18,
  0xC1, 0x0A, 0x10, 0xC2, 0x84, 0x30, 0xB1, 0x16, 0x44, 0x3C, 0xF1, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x1F, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x03, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20,
  0x04, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x18, 0x18, 0x08,
  0x10, 0x08, 0x10, 0x0C, 0x3F, 0xFC, 0x20, 0x04, 0x20, 0x06, 0x60, 0x02,
  0x40, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0xFF, 0xE1, 0x80, 0x63,
  0x00, 0x66, 0x00, 0x4C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0,
  0x19, 0x80, 0x63, 0xFF, 0x87, 0xFF, 0x8C, 0x01, 0x98, 0x01, 0xB0, 0x01,
  0x60, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x16, 0x00, 0x6C, 0x01, 0x98,
  0x0E, 0x3F, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C,
  0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x03, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C,
  0x1C, 0x18, 0x07, 0xF0, 0xFF, 0xC1, 0x00, 0xC2, 0x00, 0xC4, 0x00, 0xC8,
  0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x05,
  0x00, 0x1A, 0x00, 0x24, 0x00, 0xC8, 0x03, 0x10, 0x3C, 0x3F, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFD, 0xFF,
  0xE8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x18,
  0x18, 0x30, 0x04, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x01, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x20,
  0x03, 0x10, 0x02, 0x1C, 0x0C, 0x07, 0xF8, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x0F, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0xD0, 0x02, 0x60, 0x18, 0xC0, 0xC1, 0xFE, 0x00, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0x80,
  0xC3, 0x00, 0xC2, 0x00, 0xC4, 0x00, 0xCC, 0x00, 0xDE, 0x00, 0xF3, 0x00,
  0xE1, 0x80, 0xC0, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x18,
  0xC0, 0x08, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0xC0, 0x0F,
  0x00, 0x3E, 0x01, 0xE8, 0x05, 0xB0, 0x36, 0x40, 0x99, 0x02, 0x66, 0x19,
  0x88, 0x46, 0x23, 0x18, 0xC8, 0x61, 0x21, 0x87, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0x81, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x68, 0x01, 0xB0, 0x06,
  0x40, 0x18, 0x80, 0x63, 0x01, 0x84, 0x06, 0x18, 0x18, 0x20, 0x60, 0xC1,
  0x81, 0x06, 0x06, 0x18, 0x08, 0x60, 0x11, 0x80, 0x66, 0x00, 0x98, 0x03,
  0x60, 0x05, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0xF0,
  0x18, 0x18, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x02,
  0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x06,
  0x20, 0x04, 0x30, 0x08, 0x1C, 0x38, 0x07, 0xE0, 0xFF, 0xE2, 0x00, 0xC8,
  0x01, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xA0, 0x1C, 0xFF, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C, 0x60, 0x06, 0x40,
  0x02, 0xC0, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0,
  0x03, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x1C, 0x38, 0x07,
  0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xE1, 0x80,
  0x63, 0x00, 0x66, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xB0, 0x01, 0x60, 0x02,
  0xC0, 0x0D, 0x80, 0x13, 0x00, 0x66, 0x03, 0x8F, 0xFC, 0x18, 0x18, 0x30,
  0x10, 0x60, 0x30, 0xC0, 0x31, 0x80, 0x23, 0x00, 0x66, 0x00, 0x4C, 0x00,
  0xD8, 0x00, 0xB0, 0x01, 0x80, 0x03, 0xC0, 0x0F, 0xF8, 0x38, 0x0C, 0x20,
  0x06, 0x60, 0x06, 0x60, 0x02, 0x60, 0x03, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x02, 0x30,
  0x06, 0x18, 0x1C, 0x0F, 0xF0, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x3C, 0x00,
  0xD0, 0x02, 0x60, 0x18, 0xE1, 0xC0, 0xFC, 0x00, 0x80, 0x03, 0xC0, 0x02,
  0x40, 0x02, 0x40, 0x06, 0x60, 0x04, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x0C,
  0x30, 0x08, 0x10, 0x18, 0x18, 0x18, 0x18, 0x10, 0x08, 0x30, 0x08, 0x30,
  0x0C, 0x20, 0x04, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0xC0, 0x50, 0x30, 0x34, 0x0C,
  0x0D, 0x03, 0x82, 0x60, 0xA0, 0x98, 0x68, 0x26, 0x12, 0x08, 0x84, 0x86,
  0x21, 0x31, 0x88, 0x4C, 0x42, 0x31, 0x10, 0xCC, 0x44, 0x32, 0x11, 0x04,
  0x86, 0x41, 0x21, 0xB0, 0x58, 0x2C, 0x16, 0x0A, 0x05, 0x02, 0x81, 0xC0,
  0xA0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x60, 0xC0, 0x03,
  0x60, 0x06, 0x30, 0x04, 0x10, 0x0C, 0x18, 0x08, 0x08, 0x10, 0x0C, 0x30,
  0x06, 0x20, 0x02, 0x60, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0,
  0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x18, 0x18, 0x10, 0x0C,
  0x30, 0x04, 0x60, 0x06, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xB0, 0x01,
  0x88, 0x00, 0x86, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x60, 0x30, 0x20, 0x18,
  0x30, 0x06, 0x10, 0x01, 0x18, 0x00, 0xC8, 0x00, 0x2C, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x7F, 0xFE, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0xF8, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x3F, 0x06, 0x00, 0x60, 0x0B, 0x00, 0x90, 0x19, 0x81, 0x08,
  0x30, 0x82, 0x0C, 0x20, 0x46, 0x06, 0x40, 0x2C, 0x03, 0xFF, 0xFC, 0xC6,
  0x23, 0x07, 0x80, 0x7F, 0x86, 0x03, 0x10, 0x06, 0xC0, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x0F, 0xFC, 0xF0, 0x36, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xF0, 0x0F, 0x60, 0x6C, 0xFE, 0x30, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x31, 0xE0, 0xDF,
  0xE3, 0xC0, 0xCE, 0x01, 0xB0, 0x02, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0B, 0x00, 0x6E,
  0x01, 0xB6, 0x1C, 0xCF, 0xC0, 0x07, 0x80, 0x7F, 0x83, 0x03, 0x18, 0x06,
  0x40, 0x0F, 0x00, 0x38, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0x34, 0x00, 0x98, 0x06, 0x38, 0x30, 0x3F,
  0x80, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0xE1, 0x1F, 0xC9, 0x81, 0x58, 0x06, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xA0,
  0x05, 0x80, 0x66, 0x0D, 0x1F, 0xC8, 0x07, 0x80, 0x7F, 0x83, 0x03, 0x18,
  0x06, 0x40, 0x0F, 0x00, 0x38, 0x00, 0x60, 0x01, 0xFF, 0xFE, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x03, 0x18, 0x18,
  0x3F, 0x80, 0x00, 0xFE, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0xFF, 0xF8, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x07, 0x00, 0xFE, 0x4C, 0x0A, 0xC0, 0x34, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x05,
  0x00, 0x2C, 0x03, 0x30, 0x68, 0xFE, 0x40, 0x02, 0x00, 0x10, 0x01, 0xA0,
  0x0D, 0x80, 0xC7, 0x1C, 0x0F, 0x80, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0xE0, 0xCF, 0xF3, 0x60, 0x6E,
  0x00, 0xB8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0C, 0x02, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x1F, 0xFF, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x01, 0x81, 0xCF, 0xC0, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x02, 0x80, 0x32,
  0x01, 0x88, 0x0C, 0x20, 0x60, 0x83, 0x02, 0x30, 0x09, 0x80, 0x2E, 0x00,
  0xEC, 0x03, 0x18, 0x08, 0x30, 0x20, 0x60, 0x80, 0xC2, 0x01, 0x88, 0x02,
  0x20, 0x04, 0x80, 0x1C, 0xFE, 0x07, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8, 0x0E, 0x0E, 0x6F,
  0xDF, 0xB8, 0x38, 0x78, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03,
  0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C,
  0x0E, 0x06, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x40,
  0x03, 0x83, 0x3F, 0xCD, 0x81, 0xB8, 0x02, 0xE0, 0x0B, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0F, 0xF0,
  0x18, 0x18, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x06,
  0x60, 0x04, 0x30, 0x0C, 0x18, 0x38, 0x0F, 0xE0, 0x07, 0x83, 0x7F, 0x8F,
  0x03, 0x38, 0x06, 0xC0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x2C, 0x01, 0xB8, 0x04,
  0xF0, 0x73, 0x3F, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xFE, 0x4C, 0x0E, 0xC0, 0x34, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x05, 0x00, 0x2C, 0x03, 0x30, 0x68, 0xFE, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x03, 0xF1, 0xFE,
  0x60, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x80,
  0x7F, 0xC3, 0x01, 0x98, 0x03, 0x40, 0x0D, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0xD8, 0x03, 0x30, 0x38, 0x7F, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x03, 0xFF, 0xE0, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x07, 0xF0, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40, 0x0D, 0x00, 0x76, 0x01, 0xCC,
  0x1B, 0x1F, 0xCC, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x60, 0x04, 0x20,
  0x0C, 0x30, 0x08, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x0C,
  0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0xC0, 0xD0, 0x30, 0x34, 0x0C, 0x09, 0x07, 0x82, 0x61, 0x20,
  0x98, 0x48, 0x62, 0x12, 0x10, 0x8C, 0xC4, 0x22, 0x11, 0x0C, 0x84, 0xC1,
  0x21, 0x20, 0x58, 0x68, 0x14, 0x0A, 0x05, 0x02, 0x81, 0xC0, 0xE0, 0x30,
  0x30, 0x08, 0x04, 0x00, 0x60, 0x07, 0x30, 0x0C, 0x18, 0x08, 0x08, 0x18,
  0x0C, 0x30, 0x06, 0x60, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0,
  0x06, 0x60, 0x04, 0x30, 0x0C, 0x10, 0x18, 0x18, 0x30, 0x0C, 0x60, 0x06,
  0xC0, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0xC8, 0x00, 0x46, 0x00, 0x61, 0x00,
  0x20, 0xC0, 0x30, 0x20, 0x10, 0x18, 0x18, 0x0C, 0x08, 0x02, 0x0C, 0x01,
  0x86, 0x00, 0x42, 0x00, 0x33, 0x00, 0x09, 0x00, 0x07, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0x00, 0x20, 0x18, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x01,
  0xC0, 0xE0, 0x06, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40, 0x06, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x1E, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x06, 0x07, 0x80, 0x40, 0x00, 0x08, 0x00, 0x0F, 0xC0, 0x34, 0x18,
  0x0B, 0x03, 0x02, 0x80, 0x73, 0xA0, 0x07, 0x80,
};

const GFXglyph RobotoMono_ExtraLight33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 2, 23, 20, 9, -23 },
  { 7, 6, 7, 20, 7, -25 },
  { 13, 18, 23, 20, 1, -23 },
  { 65, 14, 30, 20, 3, -27 },
  { 118, 18, 24, 20, 1, -24 },
  { 172, 17, 24, 20, 2, -24 },
  { 223, 2, 7, 20, 8, -25 },
  { 225, 8, 34, 20, 6, -26 },
  { 259, 7, 34, 20, 6, -26 },
  { 289, 15, 13, 20, 3, -23 },
  { 314, 16, 17, 20, 2, -19 },
  { 348, 3, 7, 20, 6, -3 },
  { 351, 12, 1, 20, 4, -11 },
  { 353, 3, 2, 20, 9, -2 },
  { 354, 11, 25, 20, 5, -23 },
  { 389, 14, 24, 20, 3, -24 },
  { 431, 8, 23, 20, 4, -23 },
  { 454, 15, 24, 20, 2, -24 },
  { 499, 14, 24, 20, 2, -24 },
  { 541, 17, 23, 20, 1, -23 },
  { 590, 13, 23, 20, 4, -23 },
  { 628, 15, 24, 20, 2, -24 },
  { 673, 15, 23, 20, 2, -23 },
  { 717, 15, 24, 20, 3, -24 },
  { 762, 14, 24, 20, 3, -24 },
  { 804, 3, 16, 20, 10, -16 },
  { 810, 4, 20, 20, 9, -16 },
  { 820, 14, 13, 20, 3, -17 },
  { 843, 14, 8, 20, 3, -15 },
  { 857, 14, 13, 20, 3, -17 },
  { 880, 12, 24, 20, 4, -24 },
  { 916, 18, 24, 20, 1, -24 },
  { 970, 16, 23, 20, 2, -23 },
  { 1016, 15, 23, 20, 3, -23 },
  { 1060, 16, 24, 20, 2, -24 },
  { 1108, 15, 23, 20, 3, -23 },
  { 1152, 14, 23, 20, 3, -23 },
  { 1193, 13, 23, 20, 4, -23 },
  { 1231, 16, 24, 20, 2, -24 },
  { 1279, 14, 23, 20, 3, -23 },
  { 1320, 14, 23, 20, 3, -23 },
  { 1361, 14, 23, 20, 2, -23 },
  { 1402, 16, 23, 20, 3, -23 },
  { 1448, 13, 23, 20, 4, -23 },
  { 1486, 14, 23, 20, 3, -23 },
  { 1527, 14, 23, 20, 3, -23 },
  { 1568, 16, 24, 20, 2, -24 },
  { 1616, 14, 23, 20, 4, -23 },
  { 1657, 16, 28, 20, 2, -24 },
  { 1713, 15, 23, 20, 3, -23 },
  { 1757, 16, 24, 20, 2, -24 },
  { 1805, 16, 23, 20, 2, -23 },
  { 1851, 14, 23, 20, 3, -23 },
  { 1892, 16, 23, 20, 2, -23 },
  { 1938, 18, 23, 20, 1, -23 },
  { 1990, 16, 23, 20, 2, -23 },
  { 2036, 17, 23, 20, 1, -23 },
  { 2085, 15, 23, 20, 2, -23 },
  { 2129, 6, 32, 20, 7, -27 },
  { 2153, 12, 25, 20, 4, -23 },
  { 2191, 5, 32, 20, 7, -27 },
  { 2211, 12, 12, 20, 4, -23 },
  { 2229, 14, 1, 20, 3, 0 },
  { 2231, 4, 4, 20, 8, -24 },
  { 2233, 14, 18, 20, 3, -18 },
  { 2265, 14, 25, 20, 3, -25 },
  { 2309, 14, 18, 20, 3, -18 },
  { 2341, 13, 25, 20, 3, -25 },
  { 2382, 14, 18, 20, 3, -18 },
  { 2414, 15, 25, 20, 3, -25 },
  { 2461, 13, 25, 20, 3, -18 },
  { 2502, 14, 25, 20, 3, -25 },
  { 2546, 13, 24, 20, 4, -24 },
  { 2585, 10, 31, 20, 3, -24 },
  { 2624, 14, 25, 20, 4, -25 },
  { 2668, 13, 25, 20, 4, -25 },
  { 2709, 17, 18, 20, 1, -18 },
  { 2748, 14, 18, 20, 3, -18 },
  { 2780, 16, 18, 20, 2, -18 },
  { 2816, 14, 25, 20, 3, -18 },
  { 2860, 13, 25, 20, 3, -18 },
  { 2901, 11, 18, 20, 6, -18 },
  { 2926, 14, 18, 20, 3, -18 },
  { 2958, 14, 22, 20, 3, -22 },
  { 2997, 14, 17, 20, 3, -17 },
  { 3027, 16, 17, 20, 2, -17 },
  { 3061, 18, 17, 20, 1, -17 },
  { 3100, 16, 17, 20, 2, -17 },
  { 3134, 17, 24, 20, 1, -17 },
  { 3185, 16, 17, 20, 2, -17 },
  { 3219, 11, 33, 20, 5, -26 },
  { 3265, 2, 28, 20, 9, -23 },
  { 3272, 11, 33, 20, 5, -26 },
  { 3318, 18, 6, 20, 1, -13 },
};

const GFXfont RobotoMono_ExtraLight33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight33pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_EXTRALIGHT33PT7B_H_
