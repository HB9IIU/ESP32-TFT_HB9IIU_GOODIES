#ifndef _ROBOTOMONO_EXTRALIGHT65PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight65pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x60, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x40, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x03, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0x80, 0x38, 0x00,
  0xC0, 0x18, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0xE0, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x0C, 0x00, 0xC0,
  0x60, 0x00, 0x70, 0x06, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x30, 0x00, 0x07,
  0x0F, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x18, 0x00, 0x00, 0x7F, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x80, 0xFE, 0x00, 0x00, 0x18,
  0x0F, 0xFC, 0x00, 0x01, 0xC0, 0xE0, 0xF0, 0x00, 0x0C, 0x0E, 0x03, 0x80,
  0x00, 0xE0, 0x60, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x30, 0x00, 0x70, 0x30,
  0x01, 0x80, 0x07, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x60, 0x03, 0x80, 0x18, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x18, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x06, 0x00,
  0x38, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x38, 0x03,
  0xC0, 0x0E, 0x78, 0x01, 0xC0, 0x0E, 0x70, 0x00, 0xE0, 0x0E, 0x60, 0x00,
  0x70, 0x0C, 0xE0, 0x00, 0x78, 0x1C, 0xE0, 0x00, 0x3C, 0x1C, 0xE0, 0x00,
  0x1C, 0x1C, 0xE0, 0x00, 0x0E, 0x38, 0xE0, 0x00, 0x07, 0x38, 0xE0, 0x00,
  0x07, 0xF0, 0xE0, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x07, 0x78, 0x1E, 0x00,
  0x1E, 0x3C, 0x0F, 0x80, 0x7C, 0x1C, 0x07, 0xFF, 0xF8, 0x0E, 0x01, 0xFF,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xF6, 0xDB, 0x6D, 0x80,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x08, 0x40, 0x00, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x40, 0x07, 0x00, 0x33, 0xC0, 0x38, 0x07,
  0xBF, 0xC1, 0xC1, 0xFE, 0x3F, 0xCE, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x30, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x18, 0xC6, 0x31, 0x9C, 0xE7,
  0x39, 0xDC, 0xEE, 0x71, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x77,
  0xFF, 0xF7, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x38, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x79,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x07, 0x3F, 0x00,
  0x00, 0x71, 0xF8, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0x70, 0x7E, 0x00, 0x07,
  0x03, 0xF0, 0x00, 0x70, 0x1F, 0x80, 0x07, 0x00, 0xFC, 0x00, 0x70, 0x07,
  0xE0, 0x07, 0x00, 0x3F, 0x00, 0x70, 0x01, 0xF8, 0x0F, 0x00, 0x0F, 0xC0,
  0xF0, 0x00, 0x7E, 0x0F, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x8F, 0x00,
  0x00, 0xFC, 0xF0, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x07,
  0xE7, 0x3F, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x80,
  0x7E, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x1F, 0xFC, 0x00, 0xEF, 0xFF, 0xE0, 0x1F, 0xF9,
  0xFE, 0x03, 0xE0, 0x07, 0xE0, 0x70, 0x00, 0x3E, 0x04, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xF8, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x03, 0xFF, 0x00,
  0x60, 0xFF, 0xFC, 0x0E, 0x3F, 0x07, 0xE0, 0xE7, 0x80, 0x0F, 0x0E, 0xE0,
  0x00, 0x78, 0xFC, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0xF8,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1B, 0x1E, 0x00, 0x03, 0x30, 0xF0, 0x00, 0xF3, 0x07, 0x80,
  0x3E, 0x70, 0x3F, 0xFF, 0x87, 0x01, 0xFF, 0xF0, 0x70, 0x03, 0xF8, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x67, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7F,
  0xFF, 0xF0, 0x0C, 0x1E, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x30, 0x30, 0x01, 0xF0, 0x07, 0x0E, 0x00, 0xFF, 0x80, 0x61, 0x80,
  0x3E, 0xF8, 0x0C, 0x70, 0x0E, 0x03, 0x01, 0x8C, 0x03, 0x80, 0x60, 0x3B,
  0x80, 0xE0, 0x0C, 0x03, 0x60, 0x18, 0x01, 0x80, 0x6C, 0x03, 0x00, 0x30,
  0x0D, 0x80, 0xC0, 0x06, 0x01, 0xF0, 0x18, 0x00, 0xC0, 0x3E, 0x03, 0x00,
  0x38, 0x07, 0x80, 0xE0, 0x06, 0x00, 0xF0, 0x18, 0x00, 0xC0, 0x1E, 0x03,
  0x00, 0x18, 0x03, 0xC0, 0x60, 0x03, 0x00, 0x78, 0x0C, 0x00, 0x60, 0x0F,
  0x01, 0x80, 0x0C, 0x01, 0xE0, 0x30, 0x01, 0x80, 0x7C, 0x06, 0x00, 0x70,
  0x0D, 0x80, 0xC0, 0x0E, 0x01, 0xB0, 0x18, 0x03, 0xC0, 0x36, 0x03, 0x00,
  0x78, 0x0E, 0xE0, 0x70, 0x1B, 0x01, 0x9C, 0x06, 0x03, 0x60, 0x71, 0x80,
  0xE0, 0xCE, 0x0C, 0x30, 0x0F, 0xF0, 0xE7, 0x87, 0x01, 0xFC, 0x0F, 0xE0,
  0x60, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x03, 0xF8, 0x0C, 0x00,
  0x03, 0xE0, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x1F, 0xC0,
  0xC0, 0x00, 0x1F, 0x0C, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x03, 0xCC, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0xCC,
  0x00, 0x00, 0x78, 0xC0, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0xFE, 0x01, 0xC0, 0x00,
  0xF8, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x1F, 0x01, 0xC0,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x03, 0x8F, 0xC0, 0x00, 0x0E, 0x7F, 0x00, 0x00, 0x3B, 0xCE, 0x00, 0x00,
  0xFE, 0x3C, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01,
  0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xBD, 0x80, 0x00, 0x3B, 0xDC, 0x00, 0x03, 0x3D,
  0xC0, 0x00, 0x73, 0xCE, 0x00, 0x07, 0x3C, 0xE0, 0x00, 0xE3, 0xC6, 0x00,
  0x0E, 0x3C, 0x70, 0x00, 0xC3, 0xC7, 0x00, 0x1C, 0x3C, 0x30, 0x01, 0xC3,
  0xC3, 0x80, 0x18, 0x3C, 0x38, 0x03, 0x87, 0xC1, 0x80, 0x30, 0x7C, 0x1C,
  0x07, 0x07, 0xC0, 0xC0, 0x70, 0x7C, 0x0E, 0x06, 0x07, 0xC0, 0xE0, 0xE0,
  0x7C, 0x06, 0x0C, 0x07, 0xC0, 0x71, 0xC0, 0x7C, 0x07, 0x1C, 0x07, 0xC0,
  0x31, 0x80, 0x7C, 0x03, 0xB8, 0x07, 0xC0, 0x1B, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x7C,
  0x00, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xB8, 0x00, 0x00, 0xFC, 0xC0, 0x00, 0x07, 0xE7, 0x00, 0x00,
  0x3F, 0x1C, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x7E,
  0x1C, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x1F, 0x83, 0x80, 0x00, 0xFC, 0x0E,
  0x00, 0x07, 0xE0, 0x30, 0x00, 0x3F, 0x01, 0xC0, 0x01, 0xF8, 0x07, 0x00,
  0x0F, 0xC0, 0x38, 0x00, 0x7E, 0x00, 0xE0, 0x03, 0xF0, 0x07, 0x00, 0x1F,
  0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x3F, 0x00,
  0x0C, 0x01, 0xF8, 0x00, 0x70, 0x0F, 0xC0, 0x01, 0xC0, 0x7E, 0x00, 0x0E,
  0x03, 0xF0, 0x00, 0x38, 0x1F, 0x80, 0x01, 0xC0, 0xFC, 0x00, 0x07, 0x07,
  0xE0, 0x00, 0x38, 0x3F, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0x03, 0x0F, 0xC0,
  0x00, 0x1C, 0x7E, 0x00, 0x00, 0x73, 0xF0, 0x00, 0x03, 0x9F, 0x80, 0x00,
  0x0E, 0xFC, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x07, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x1F, 0x0E,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x7F, 0x01, 0xC0,
  0x00, 0x7C, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x1C,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x1C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x01, 0x80, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x07, 0x80, 0x07, 0x60, 0x01, 0xE0, 0x01, 0xD8, 0x00, 0x7C, 0x00, 0x67,
  0x00, 0x1F, 0x00, 0x19, 0xC0, 0x0F, 0xC0, 0x06, 0x70, 0x03, 0xB0, 0x03,
  0x9C, 0x00, 0xCC, 0x00, 0xE7, 0x00, 0x33, 0x00, 0x38, 0xC0, 0x0C, 0xE0,
  0x0E, 0x30, 0x07, 0x38, 0x03, 0x0E, 0x01, 0xC6, 0x00, 0xC3, 0x80, 0x71,
  0x80, 0x30, 0xE0, 0x18, 0x60, 0x1C, 0x38, 0x06, 0x1C, 0x07, 0x06, 0x03,
  0x87, 0x01, 0xC1, 0x80, 0xE1, 0xC0, 0x70, 0x60, 0x38, 0x30, 0x18, 0x1C,
  0x0C, 0x0C, 0x06, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC1, 0xC0, 0xE0, 0xE0,
  0x70, 0x70, 0x38, 0x38, 0x0C, 0x1C, 0x06, 0x0E, 0x03, 0x06, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0x70, 0xC0, 0x38, 0x60, 0x1C, 0x30, 0x0E, 0x38, 0x07,
  0x0C, 0x03, 0x8E, 0x00, 0xC7, 0x00, 0xE3, 0x00, 0x31, 0xC0, 0x18, 0xC0,
  0x0E, 0x70, 0x06, 0x30, 0x03, 0x98, 0x01, 0x9C, 0x00, 0xE6, 0x00, 0x77,
  0x00, 0x39, 0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x07, 0x60, 0x01, 0xB8, 0x00,
  0xD8, 0x00, 0x7E, 0x00, 0x36, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x18, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x0C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x60, 0x00, 0xC1,
  0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x30,
  0x00, 0x06, 0xE0, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xC0, 0x00, 0xE3, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x7E, 0x70, 0x00, 0x0E, 0xE7,
  0x80, 0x03, 0xCE, 0x3E, 0x01, 0xF8, 0xE1, 0xFF, 0xFE, 0x0E, 0x07, 0xFF,
  0x80, 0xF0, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x0F, 0xE0, 0x06, 0x0F, 0xFF, 0x00, 0xC3,
  0xFF, 0xF8, 0x19, 0xE0, 0x0F, 0x83, 0x38, 0x00, 0x78, 0x6C, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8D, 0x80, 0x00,
  0xE1, 0xBC, 0x00, 0x78, 0x33, 0xE0, 0x3F, 0x06, 0x1F, 0xFF, 0x80, 0xC0,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x0F, 0xE0, 0x18, 0x07, 0xFF, 0x83, 0x03, 0xFF, 0xF8, 0x60, 0xF8, 0x03,
  0xCC, 0x3C, 0x00, 0x39, 0x87, 0x00, 0x01, 0xB1, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x36, 0x0F, 0x00, 0x1E, 0xC0,
  0xF8, 0x0F, 0x98, 0x0F, 0xFF, 0xC3, 0x00, 0xFF, 0xE0, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x07, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x07, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0x80, 0x10, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x0C, 0x0F, 0xFF, 0xE1,
  0x83, 0xE0, 0x0F, 0x30, 0xF0, 0x00, 0xE6, 0x1C, 0x00, 0x06, 0xC7, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xD8, 0x3C,
  0x00, 0x7B, 0x03, 0xE0, 0x3E, 0x60, 0x3F, 0xFF, 0x0C, 0x03, 0xFF, 0x81,
  0x80, 0x03, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x03, 0xF8, 0x07, 0x03, 0xFF, 0xE0, 0xE0, 0xFF, 0xFE, 0x1C, 0x3C, 0x01,
  0xE3, 0x8E, 0x00, 0x1E, 0x73, 0x00, 0x01, 0xCE, 0xC0, 0x00, 0x1D, 0xD0,
  0x00, 0x03, 0xBE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x40, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x83, 0x00,
  0x01, 0xE0, 0x60, 0x00, 0x78, 0x0C, 0x00, 0x1E, 0x01, 0x80, 0x07, 0x80,
  0x30, 0x01, 0xE0, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x1E, 0x00, 0x18, 0x07,
  0x80, 0x03, 0x01, 0xC0, 0x00, 0x60, 0xF0, 0x00, 0x0C, 0x3C, 0x00, 0x01,
  0x8F, 0x80, 0x00, 0x33, 0xF8, 0x00, 0x06, 0xF7, 0x00, 0x00, 0xFC, 0x70,
  0x00, 0x1F, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x60, 0x0F, 0x00, 0x0C,
  0x00, 0xF0, 0x01, 0x80, 0x0F, 0x00, 0x30, 0x00, 0xF0, 0x06, 0x00, 0x0F,
  0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x1E, 0x0C, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x1E, 0x30, 0x00, 0x01,
  0xE6, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x63, 0xFF,
  0x07, 0xFE, 0x33, 0xFF, 0xC7, 0xFF, 0x9B, 0x80, 0xF7, 0x01, 0xED, 0x80,
  0x3F, 0x00, 0x77, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x0F, 0xC0,
  0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x0F, 0xE0, 0x1C, 0x0F,
  0xFF, 0x83, 0x83, 0xFF, 0xF8, 0x70, 0xF0, 0x07, 0x8E, 0x38, 0x00, 0x79,
  0xCC, 0x00, 0x07, 0x3B, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x0E, 0xF8, 0x00,
  0x00, 0xDE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x18, 0x3F, 0xFC, 0x03, 0x1F, 0xFF, 0xE0,
  0x67, 0x80, 0x3E, 0x0D, 0xC0, 0x01, 0xE1, 0xB0, 0x00, 0x1C, 0x3C, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0x86, 0xF0,
  0x01, 0xE0, 0xCF, 0x80, 0xF8, 0x18, 0x7F, 0xFE, 0x03, 0x03, 0xFF, 0x80,
  0x60, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xFE, 0x0C, 0x0F, 0xFF, 0xF1, 0x83, 0xE0, 0x0F, 0x30, 0xF0, 0x00,
  0xF6, 0x1C, 0x00, 0x06, 0xC7, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x7B, 0x03, 0xC0, 0x3E, 0x60,
  0x3F, 0xFF, 0x0C, 0x03, 0xFF, 0x81, 0x80, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFC,
  0x00, 0xE7, 0x80, 0x03, 0xBC, 0x00, 0x0E, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x80, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x1F, 0x70, 0x00, 0x0F,
  0xCE, 0x00, 0x07, 0x73, 0xC0, 0x03, 0x9C, 0x7C, 0x03, 0xC7, 0x0F, 0xFF,
  0xE1, 0xC0, 0xFF, 0xE0, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xEC, 0x00, 0x1C, 0x00, 0x1D, 0xC0, 0x03, 0xC0, 0x03, 0xB8, 0x00, 0x78,
  0x00, 0x67, 0x00, 0x1F, 0x00, 0x0C, 0x60, 0x03, 0x60, 0x03, 0x8C, 0x00,
  0x6E, 0x00, 0x71, 0xC0, 0x0D, 0xC0, 0x0E, 0x38, 0x03, 0x98, 0x01, 0x87,
  0x00, 0x73, 0x00, 0x70, 0x60, 0x0C, 0x70, 0x0E, 0x0C, 0x01, 0x8E, 0x01,
  0xC1, 0xC0, 0x70, 0xC0, 0x30, 0x38, 0x0E, 0x18, 0x06, 0x03, 0x01, 0x83,
  0x81, 0xC0, 0x60, 0x30, 0x70, 0x38, 0x0E, 0x0E, 0x06, 0x06, 0x01, 0xC1,
  0xC0, 0xC0, 0xC0, 0x38, 0x30, 0x1C, 0x18, 0x03, 0x06, 0x03, 0x87, 0x00,
  0x61, 0xC0, 0x30, 0xE0, 0x0E, 0x30, 0x06, 0x18, 0x01, 0xC6, 0x00, 0xE3,
  0x00, 0x18, 0xC0, 0x1C, 0xE0, 0x03, 0x38, 0x01, 0x9C, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x0E, 0xC0, 0x06, 0x60, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1C, 0x7F, 0xFC, 0x00, 0x03, 0x9E, 0x07, 0xC0,
  0x00, 0x73, 0x80, 0x3C, 0x00, 0x0C, 0xE0, 0x03, 0xC0, 0x03, 0x98, 0x00,
  0x3C, 0x00, 0x77, 0x00, 0x01, 0xE0, 0x1C, 0xE0, 0x00, 0x1F, 0x8F, 0x18,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
};

const GFXglyph RobotoMono_ExtraLight65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 4, 46, 39, 17, -46 },
  { 24, 11, 14, 39, 14, -49 },
  { 44, 35, 46, 39, 2, -46 },
  { 246, 28, 60, 39, 6, -53 },
  { 456, 37, 48, 39, 1, -47 },
  { 678, 32, 48, 39, 5, -47 },
  { 870, 3, 14, 39, 17, -49 },
  { 876, 15, 67, 39, 12, -52 },
  { 1002, 15, 67, 39, 11, -52 },
  { 1128, 29, 26, 39, 6, -46 },
  { 1223, 31, 33, 39, 4, -38 },
  { 1351, 5, 15, 39, 13, -6 },
  { 1361, 23, 2, 39, 8, -22 },
  { 1367, 5, 5, 39, 18, -5 },
  { 1371, 22, 50, 39, 9, -46 },
  { 1509, 29, 48, 39, 5, -47 },
  { 1683, 16, 46, 39, 7, -46 },
  { 1775, 30, 47, 39, 3, -47 },
  { 1952, 29, 48, 39, 3, -47 },
  { 2126, 32, 46, 39, 3, -46 },
  { 2310, 27, 47, 39, 7, -46 },
  { 2469, 28, 48, 39, 5, -47 },
  { 2637, 30, 46, 39, 4, -46 },
  { 2810, 29, 48, 39, 6, -47 },
  { 2984, 28, 47, 39, 5, -47 },
  { 3149, 5, 33, 39, 20, -33 },
  { 3170, 8, 42, 39, 17, -33 },
  { 3212, 28, 26, 39, 5, -34 },
  { 3303, 28, 16, 39, 6, -29 },
  { 3359, 27, 26, 39, 6, -34 },
  { 3447, 25, 47, 39, 7, -47 },
  { 3594, 35, 47, 39, 2, -47 },
  { 3800, 32, 46, 39, 4, -46 },
  { 3984, 28, 46, 39, 7, -46 },
  { 4145, 31, 48, 39, 4, -47 },
  { 4331, 29, 46, 39, 6, -46 },
  { 4498, 26, 46, 39, 7, -46 },
  { 4648, 27, 46, 39, 7, -46 },
  { 4804, 31, 48, 39, 4, -47 },
  { 4990, 29, 46, 39, 5, -46 },
  { 5157, 27, 46, 39, 6, -46 },
  { 5313, 28, 47, 39, 4, -46 },
  { 5478, 30, 46, 39, 7, -46 },
  { 5651, 27, 46, 39, 7, -46 },
  { 5807, 28, 46, 39, 6, -46 },
  { 5968, 29, 46, 39, 5, -46 },
  { 6135, 31, 48, 39, 4, -47 },
  { 6321, 29, 46, 39, 7, -46 },
  { 6488, 32, 55, 39, 4, -47 },
  { 6708, 29, 46, 39, 7, -46 },
  { 6875, 30, 48, 39, 5, -47 },
  { 7055, 33, 46, 39, 3, -46 },
  { 7245, 29, 47, 39, 5, -46 },
  { 7416, 33, 46, 39, 3, -46 },
  { 7606, 34, 46, 39, 3, -46 },
  { 7802, 32, 46, 39, 4, -46 },
  { 7986, 32, 46, 39, 3, -46 },
  { 8170, 29, 46, 39, 4, -46 },
  { 8337, 10, 63, 39, 15, -53 },
  { 8416, 22, 50, 39, 9, -46 },
  { 8554, 10, 63, 39, 14, -53 },
  { 8633, 23, 25, 39, 8, -46 },
  { 8705, 27, 2, 39, 6, 0 },
  { 8712, 9, 9, 39, 15, -48 },
  { 8723, 28, 36, 39, 6, -35 },
  { 8849, 27, 50, 39, 7, -49 },
  { 9018, 28, 36, 39, 5, -35 },
  { 9144, 27, 50, 39, 5, -49 },
  { 9313, 29, 36, 39, 5, -35 },
  { 9444, 29, 50, 39, 6, -50 },
  { 9626, 27, 49, 39, 5, -35 },
  { 9792, 27, 49, 39, 6, -49 },
  { 9958, 27, 47, 39, 7, -47 },
  { 10117, 20, 61, 39, 6, -47 },
  { 10270, 27, 49, 39, 8, -49 },
  { 10436, 27, 49, 39, 7, -49 },
  { 10602, 33, 35, 39, 3, -35 },
  { 10747, 27, 35, 39, 6, -35 },
  { 10866, 31, 36, 39, 4, -35 },
  { 11006, 27, 48, 39, 7, -35 },
  { 11168, 27, 48, 39, 5, -35 },
  { 11330, 22, 35, 39, 12, -35 },
  { 11427, 28, 36, 39, 6, -35 },
  { 11553, 27, 44, 39, 6, -43 },
  { 11702, 26, 35, 39, 7, -34 },
  { 11816, 31, 34, 39, 4, -34 },
  { 11948, 35, 34, 39, 2, -34 },
  { 12097, 31, 34, 39, 4, -34 },
  { 12229, 33, 48, 39, 3, -34 },
  { 12427, 30, 34, 39, 5, -34 },
  { 12555, 20, 64, 39, 11, -51 },
  { 12715, 3, 56, 39, 18, -46 },
  { 12736, 20, 64, 39, 11, -51 },
  { 12896, 35, 11, 39, 2, -25 },
};

const GFXfont RobotoMono_ExtraLight65pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight65pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _ROBOTOMONO_EXTRALIGHT65PT7B_H_
