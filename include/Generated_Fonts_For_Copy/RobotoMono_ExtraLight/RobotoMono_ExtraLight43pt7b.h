#ifndef _ROBOTOMONO_EXTRALIGHT43PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight43pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x00, 0x05,
  0xF8, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0xC2, 0xC2, 0xC2, 0x82, 0x00, 0x30,
  0x10, 0x00, 0x20, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x20, 0x00, 0x40, 0x20, 0x00, 0x40, 0x60, 0x00, 0xC0,
  0x60, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x80, 0x40, 0x00, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x80, 0x01, 0x80,
  0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x80, 0xFF, 0xFF, 0xFC, 0x02, 0x01, 0x00, 0x02, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x06,
  0x00, 0x04, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0x01, 0xC1,
  0xC0, 0x1C, 0x30, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0x98, 0x00, 0x33, 0x80, 0x0E, 0x38,
  0x03, 0x83, 0xC3, 0xE0, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x61, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x60, 0xC0, 0x40, 0x40, 0xC0, 0x40,
  0xC0, 0xC0, 0x40, 0x80, 0xC0, 0x41, 0x80, 0xC0, 0xC3, 0x00, 0xC0, 0xC3,
  0x00, 0x61, 0x86, 0x00, 0x3F, 0x86, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x30, 0x00, 0x20,
  0xFC, 0x00, 0x61, 0x8E, 0x00, 0xC3, 0x06, 0x00, 0xC2, 0x02, 0x01, 0x82,
  0x03, 0x01, 0x86, 0x03, 0x03, 0x06, 0x03, 0x02, 0x06, 0x03, 0x06, 0x02,
  0x03, 0x04, 0x02, 0x02, 0x00, 0x03, 0x06, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0xC0, 0x03, 0x01, 0x80,
  0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0x60, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x1C, 0x00, 0x06, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0xC0, 0x00,
  0x61, 0x80, 0x03, 0x07, 0x01, 0x98, 0x0E, 0x06, 0x60, 0x18, 0x13, 0x00,
  0x30, 0xCC, 0x00, 0x63, 0x30, 0x00, 0xCC, 0xC0, 0x03, 0xE3, 0x00, 0x07,
  0x86, 0x00, 0x0C, 0x18, 0x00, 0x78, 0x30, 0x07, 0x30, 0x78, 0x78, 0xE0,
  0xFF, 0x81, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x40, 0x38, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x60, 0x18, 0x0C, 0x0E, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x10, 0x10,
  0x37, 0xC2, 0x1F, 0x1F, 0x5F, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00, 0xD8,
  0x00, 0x31, 0x80, 0x06, 0x38, 0x01, 0x83, 0x00, 0x60, 0x30, 0x18, 0x03,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x33, 0x33, 0x33, 0x36, 0xE4, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x30, 0x1C, 0x0C,
  0x00, 0xC3, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x13, 0x00, 0x03, 0x60,
  0x00, 0x6C, 0x00, 0x1D, 0x00, 0x07, 0xA0, 0x03, 0xBC, 0x00, 0xE3, 0x80,
  0x38, 0x70, 0x0C, 0x0E, 0x03, 0x01, 0xC0, 0xC0, 0x38, 0x30, 0x07, 0x0C,
  0x00, 0xE3, 0x00, 0x14, 0xC0, 0x02, 0xF0, 0x00, 0xDC, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0xC1, 0xC0,
  0x38, 0x1E, 0x1E, 0x00, 0xFF, 0x00, 0x00, 0x40, 0x70, 0x7C, 0x7B, 0xF8,
  0xF0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xF0, 0x00,
  0xFF, 0xE0, 0x1C, 0x07, 0x03, 0x00, 0x38, 0x70, 0x01, 0x86, 0x00, 0x0C,
  0x40, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x1C, 0x1C, 0x00,
  0xC3, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03, 0x18, 0x00, 0x63, 0x80, 0x18,
  0x1E, 0x1E, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00,
  0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x20, 0xC0, 0x03, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x01, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x08,
  0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x6F, 0xF8, 0x1F, 0x9F, 0x07, 0x00,
  0xE0, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0xB0,
  0x00, 0x66, 0x00, 0x39, 0xC0, 0x1C, 0x38, 0x0F, 0x07, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0xFC, 0x04, 0x7F, 0xE0, 0x98, 0x0E, 0x36, 0x00,
  0x67, 0x00, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x18, 0xC0, 0x03, 0x1C, 0x00, 0xC1, 0xC0, 0x30, 0x1E, 0x1C,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x70, 0x1C, 0x18, 0x01, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0x98,
  0x00, 0x32, 0x00, 0x06, 0x40, 0x00, 0x48, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x63, 0x00, 0x18, 0x30, 0x0E, 0x03, 0xEF, 0x80, 0x3F, 0xC0, 0x1E,
  0x0E, 0x07, 0x00, 0x71, 0x80, 0x07, 0x30, 0x00, 0x6C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x03, 0x30, 0x00, 0x63, 0x80, 0x38, 0x3C, 0x3E, 0x01, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x70, 0x1C, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0xC0,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x03, 0x40, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x07, 0x30, 0x00, 0xE7, 0x00, 0x2C, 0x70, 0x1D, 0x87, 0xFE, 0x30, 0x3F,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x03, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x77, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0xCC, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xE0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xF8, 0x38, 0x0C, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x70, 0x07, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x30, 0x3F, 0x06,
  0x30, 0x61, 0x86, 0x60, 0xC0, 0x82, 0x60, 0x80, 0x82, 0x41, 0x81, 0x82,
  0x41, 0x01, 0x83, 0x41, 0x01, 0x83, 0xC3, 0x01, 0x03, 0xC3, 0x01, 0x02,
  0xC3, 0x01, 0x02, 0xC3, 0x01, 0x02, 0xC3, 0x03, 0x02, 0xC3, 0x03, 0x02,
  0xC3, 0x03, 0x06, 0xC1, 0x05, 0x04, 0x41, 0x8D, 0x8C, 0x61, 0xF9, 0xF8,
  0x60, 0xF0, 0xF0, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x40, 0x07, 0xC3, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x68, 0x00, 0x01,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x20, 0x00, 0x40, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x04, 0x00,
  0x30, 0x18, 0x01, 0x80, 0x60, 0x06, 0x00, 0x80, 0x18, 0x03, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x30, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0xFF,
  0xC0, 0x1F, 0xFF, 0x03, 0x00, 0x78, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80,
  0x03, 0x30, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x0E, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xC0, 0x0F, 0x18, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x79, 0xFF, 0xFC, 0x3F, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x03, 0x81, 0x80, 0x1C, 0x30,
  0x00, 0xC3, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x02, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x1C,
  0x03, 0x80, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x03,
  0x00, 0xF0, 0x60, 0x07, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x76,
  0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x0C, 0x60,
  0x03, 0x8C, 0x01, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0xFF, 0xFC, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x03, 0x81, 0x80, 0x1C, 0x30,
  0x00, 0xC7, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x03, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x07, 0x0C,
  0x00, 0xE0, 0x78, 0x7C, 0x03, 0xFF, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x0D, 0xC0, 0x03, 0x18, 0x00, 0xC1, 0x80, 0x38,
  0x1E, 0x1E, 0x01, 0xFF, 0x00, 0x80, 0x00, 0xE8, 0x00, 0x0C, 0x80, 0x01,
  0x88, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC0, 0x80, 0x18, 0x08, 0x03,
  0x80, 0x80, 0x70, 0x08, 0x0E, 0x00, 0x80, 0xC0, 0x08, 0x18, 0x00, 0x83,
  0x00, 0x08, 0x60, 0x00, 0x8E, 0x00, 0x09, 0xB0, 0x00, 0xB3, 0x80, 0x0E,
  0x18, 0x00, 0xE0, 0xC0, 0x0C, 0x06, 0x00, 0x80, 0x70, 0x08, 0x03, 0x00,
  0x80, 0x18, 0x08, 0x00, 0xC0, 0x80, 0x0E, 0x08, 0x00, 0x70, 0x80, 0x03,
  0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x0E, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xD0, 0x00, 0xFB, 0x00, 0x37, 0x60, 0x06, 0xE4,
  0x00, 0x9C, 0xC0, 0x33, 0x98, 0x06, 0x71, 0x81, 0x8E, 0x30, 0x31, 0xC6,
  0x06, 0x38, 0x61, 0x87, 0x0C, 0x30, 0xF0, 0x84, 0x1E, 0x19, 0x83, 0xC3,
  0x30, 0x78, 0x2C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x3C, 0x0C, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xB0, 0x00, 0xEC, 0x00,
  0x39, 0x80, 0x0E, 0x60, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x38, 0x60, 0x0E,
  0x0C, 0x03, 0x83, 0x00, 0xE0, 0x60, 0x38, 0x18, 0x0E, 0x03, 0x03, 0x80,
  0xC0, 0xE0, 0x18, 0x38, 0x06, 0x0E, 0x00, 0xC3, 0x80, 0x18, 0xE0, 0x06,
  0x38, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x1C, 0x03, 0x00, 0xF0, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0x00, 0x38, 0x60, 0x01,
  0xCC, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x2C, 0x00, 0x0D, 0x80, 0x01,
  0xB0, 0x00, 0x66, 0x00, 0x38, 0xC0, 0x3E, 0x1F, 0xFF, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x70,
  0x38, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x64, 0x00, 0x01, 0x90,
  0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02,
  0x40, 0x00, 0x09, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x07, 0x00, 0x38, 0x0E, 0x01,
  0xC0, 0x1E, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0xFF, 0x80, 0x1F, 0xFF,
  0x02, 0x00, 0x70, 0x40, 0x03, 0x08, 0x00, 0x31, 0x00, 0x03, 0x20, 0x00,
  0x64, 0x00, 0x0C, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00,
  0xC8, 0x00, 0x19, 0x00, 0x06, 0x20, 0x01, 0xC4, 0x00, 0x70, 0xFF, 0xF8,
  0x1F, 0xFE, 0x02, 0x00, 0xC0, 0x40, 0x18, 0x08, 0x01, 0x81, 0x00, 0x30,
  0x20, 0x03, 0x04, 0x00, 0x30, 0x80, 0x06, 0x10, 0x00, 0x62, 0x00, 0x0C,
  0x40, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x01, 0xA0, 0x00, 0x38, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x1C, 0x03, 0x83, 0x80, 0x0C, 0x30, 0x00, 0xE6, 0x00,
  0x06, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x06, 0x1C, 0x01, 0xC0, 0xF8,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00,
  0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00,
  0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00,
  0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0xD0, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x08, 0xC0, 0x03, 0x1C, 0x00,
  0xC1, 0xC0, 0x38, 0x1E, 0x1E, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x80, 0x0C, 0x02, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x02, 0x00, 0x40,
  0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x80, 0x01, 0x06, 0x00, 0x06, 0x18, 0x00, 0x18, 0x40, 0x00,
  0x63, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x07, 0x80, 0x60, 0x0F, 0x00, 0xE0, 0x16, 0x01, 0xC0, 0x24, 0x03, 0x80,
  0xC8, 0x05, 0x01, 0x98, 0x1A, 0x03, 0x30, 0x36, 0x06, 0x60, 0x6C, 0x08,
  0xC0, 0x98, 0x11, 0x81, 0x30, 0x21, 0x06, 0x20, 0xC2, 0x0C, 0x41, 0x86,
  0x18, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x43, 0x08, 0x31, 0x82, 0x10, 0x63,
  0x04, 0x60, 0x46, 0x0C, 0xC0, 0x88, 0x19, 0x81, 0x90, 0x33, 0x03, 0x60,
  0x26, 0x06, 0xC0, 0x48, 0x0D, 0x80, 0xD0, 0x0B, 0x01, 0xE0, 0x14, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x63, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x03, 0x01, 0x80, 0x0E, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x31,
  0x80, 0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x01,
  0x87, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x06, 0x00,
  0xC0, 0x30, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x39,
  0xC0, 0x00, 0x6E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD8,
  0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x03,
  0x03, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x04,
  0x06, 0x00, 0x30, 0x60, 0x00, 0x83, 0x00, 0x06, 0x30, 0x00, 0x11, 0x80,
  0x00, 0xD8, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFC, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0xFF, 0xFC, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xFC, 0x01, 0x80, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x06, 0x40, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x30,
  0x0C, 0x30, 0x18, 0x10, 0x18, 0x18, 0x10, 0x18, 0x30, 0x0C, 0x30, 0x0C,
  0x60, 0x04, 0x60, 0x06, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1,
  0x83, 0x0C, 0x18, 0x30, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0x80, 0x71, 0x80,
  0x0E, 0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x3F, 0xFC, 0x7F, 0xFF, 0x38, 0x00, 0xD8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x60, 0x0E, 0xCF, 0x0E, 0x31, 0xFF, 0x0C, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0xFE, 0x0C, 0xFF, 0xC3, 0x70, 0x18, 0xF0,
  0x03, 0x38, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1B, 0x80, 0x06, 0xF0,
  0x03, 0x36, 0x01, 0xCC, 0xE1, 0xE3, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0x80, 0x70, 0xC0, 0x0E, 0x60, 0x01, 0x98, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x18, 0xC0, 0x06, 0x38, 0x03, 0x07, 0x87, 0x80, 0x7F, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0xFE, 0x10, 0xFF,
  0xC4, 0x70, 0x1D, 0x18, 0x01, 0x4C, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x01,
  0x60, 0x00, 0x58, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x14, 0x00, 0x05, 0x80, 0x01, 0x60, 0x00, 0x58, 0x00, 0x16, 0x00,
  0x04, 0xC0, 0x03, 0x38, 0x01, 0xC7, 0x00, 0xD0, 0xF1, 0xE4, 0x0F, 0xE1,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0E, 0x03, 0x81, 0x80, 0x1C, 0x30, 0x00,
  0xC3, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00, 0x2C, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x06, 0x0C, 0x00, 0xC0, 0x78, 0x78, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xFC, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF0, 0x87, 0xFC, 0x4E, 0x03, 0xA6,
  0x00, 0x56, 0x00, 0x3B, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0x6E, 0x00, 0x73,
  0x80, 0x68, 0xF0, 0xE4, 0x1F, 0xE2, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x68, 0x00, 0x66, 0x00, 0x71, 0xC0, 0x70, 0x7F, 0xF0, 0x0F,
  0xE0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x7F, 0x0C,
  0x7F, 0xE3, 0x30, 0x0C, 0xD8, 0x01, 0xBC, 0x00, 0x6E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF9, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x73, 0xBF, 0x1F, 0xE0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0xEC, 0x00, 0x73, 0x00, 0x38, 0xC0, 0x1C, 0x30, 0x0E, 0x0C,
  0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x0C, 0xE0, 0x03, 0x78,
  0x00, 0xFB, 0x00, 0x3C, 0xE0, 0x0C, 0x1C, 0x03, 0x03, 0x80, 0xC0, 0x60,
  0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x01, 0xCC,
  0x00, 0x3B, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x83, 0xF3, 0x7F, 0x9F, 0xEE, 0x06, 0xC1,
  0xB8, 0x0E, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0,
  0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C,
  0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03,
  0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xC0, 0xC1, 0xFC, 0x31, 0xFF,
  0x8C, 0xC0, 0x73, 0x60, 0x06, 0xF0, 0x01, 0xB8, 0x00, 0x2E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0C,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1C, 0x03, 0x83, 0x80, 0x18, 0x30, 0x00,
  0xC6, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00, 0xC3,
  0x00, 0x1C, 0x1C, 0x03, 0x80, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xC3, 0xF8,
  0x33, 0xFF, 0x0D, 0x80, 0x63, 0xC0, 0x0C, 0xE0, 0x01, 0xB8, 0x00, 0x6C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x0C, 0xD8, 0x07, 0x33, 0x87, 0x8C,
  0x7F, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF0,
  0x8F, 0xFE, 0x4E, 0x03, 0xA6, 0x00, 0x56, 0x00, 0x1B, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x58, 0x00, 0x6E, 0x00, 0x73, 0x80, 0x68, 0xF0, 0xE4, 0x1F, 0xE2, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xC1, 0xFF, 0x8F, 0xFB, 0x38, 0x06,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0x80, 0x39, 0xC0, 0x06, 0x60,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x03, 0x30,
  0x01, 0x87, 0x83, 0xC0, 0x7F, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x81, 0x00, 0x7F, 0xC0,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x0F, 0x30, 0x06, 0xC7,
  0x0F, 0x30, 0xFF, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0C,
  0x60, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x20, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x84,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x03, 0x60, 0x18, 0x02, 0x60,
  0x18, 0x06, 0x60, 0x1C, 0x06, 0x60, 0x3C, 0x06, 0x20, 0x34, 0x04, 0x30,
  0x24, 0x04, 0x30, 0x26, 0x0C, 0x30, 0x66, 0x0C, 0x10, 0x66, 0x0C, 0x10,
  0x42, 0x08, 0x18, 0x43, 0x18, 0x18, 0xC3, 0x18, 0x18, 0xC1, 0x18, 0x08,
  0x81, 0x10, 0x0C, 0x81, 0x90, 0x0D, 0x81, 0xB0, 0x0D, 0x80, 0xB0, 0x05,
  0x00, 0xB0, 0x05, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xE0, 0x00, 0x37, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x18,
  0x0C, 0x03, 0x80, 0xE0, 0x30, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x9C,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x1D,
  0x80, 0x01, 0x9C, 0x00, 0x30, 0xC0, 0x06, 0x06, 0x00, 0xE0, 0x30, 0x1C,
  0x01, 0x81, 0x80, 0x1C, 0x30, 0x00, 0xC6, 0x00, 0x06, 0xE0, 0x00, 0x30,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80,
  0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x04, 0x00, 0x70, 0x07, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF0, 0x07, 0xC0, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x71,
  0xC0, 0x05, 0x80, 0xC0, 0x1B, 0x00, 0xE0, 0x34, 0x00, 0xE0, 0xD8, 0x00,
  0xFF, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoMono_ExtraLight43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 3, 31, 26, 11, -31 },
  { 13, 8, 9, 26, 9, -32 },
  { 22, 24, 31, 26, 1, -31 },
  { 115, 19, 39, 26, 4, -35 },
  { 208, 24, 31, 26, 1, -31 },
  { 301, 22, 31, 26, 3, -31 },
  { 387, 2, 9, 26, 11, -32 },
  { 390, 10, 44, 26, 8, -34 },
  { 445, 10, 44, 26, 7, -34 },
  { 500, 19, 18, 26, 4, -31 },
  { 543, 21, 22, 26, 2, -25 },
  { 601, 4, 10, 26, 8, -4 },
  { 606, 16, 2, 26, 5, -15 },
  { 610, 3, 3, 26, 12, -3 },
  { 612, 15, 34, 26, 6, -31 },
  { 676, 19, 31, 26, 3, -31 },
  { 750, 10, 31, 26, 5, -31 },
  { 789, 20, 31, 26, 2, -31 },
  { 867, 19, 31, 26, 2, -31 },
  { 941, 21, 31, 26, 2, -31 },
  { 1023, 18, 31, 26, 5, -31 },
  { 1093, 19, 31, 26, 3, -31 },
  { 1167, 20, 31, 26, 3, -31 },
  { 1245, 19, 31, 26, 4, -31 },
  { 1319, 19, 31, 26, 3, -31 },
  { 1393, 3, 21, 26, 13, -21 },
  { 1401, 4, 27, 26, 12, -21 },
  { 1415, 19, 18, 26, 3, -23 },
  { 1458, 18, 10, 26, 4, -19 },
  { 1481, 18, 18, 26, 4, -23 },
  { 1522, 16, 31, 26, 5, -31 },
  { 1584, 24, 31, 26, 1, -31 },
  { 1677, 22, 31, 26, 2, -31 },
  { 1763, 19, 31, 26, 4, -31 },
  { 1837, 20, 31, 26, 3, -31 },
  { 1915, 19, 31, 26, 4, -31 },
  { 1989, 18, 31, 26, 4, -31 },
  { 2059, 17, 31, 26, 5, -31 },
  { 2125, 20, 31, 26, 3, -31 },
  { 2203, 18, 31, 26, 4, -31 },
  { 2273, 18, 31, 26, 4, -31 },
  { 2343, 19, 31, 26, 2, -31 },
  { 2417, 20, 31, 26, 5, -31 },
  { 2495, 18, 31, 26, 5, -31 },
  { 2565, 19, 31, 26, 4, -31 },
  { 2639, 18, 31, 26, 4, -31 },
  { 2709, 20, 31, 26, 3, -31 },
  { 2787, 19, 31, 26, 5, -31 },
  { 2861, 22, 36, 26, 2, -31 },
  { 2960, 19, 31, 26, 5, -31 },
  { 3034, 20, 31, 26, 3, -31 },
  { 3112, 22, 31, 26, 2, -31 },
  { 3198, 19, 31, 26, 3, -31 },
  { 3272, 22, 31, 26, 2, -31 },
  { 3358, 23, 31, 26, 2, -31 },
  { 3448, 22, 31, 26, 2, -31 },
  { 3534, 21, 31, 26, 2, -31 },
  { 3616, 19, 31, 26, 3, -31 },
  { 3690, 7, 42, 26, 10, -35 },
  { 3727, 14, 34, 26, 6, -31 },
  { 3787, 7, 42, 26, 9, -35 },
  { 3824, 16, 17, 26, 5, -31 },
  { 3858, 18, 2, 26, 4, 0 },
  { 3863, 6, 6, 26, 10, -32 },
  { 3868, 18, 23, 26, 4, -23 },
  { 3920, 18, 32, 26, 4, -32 },
  { 3992, 18, 23, 26, 4, -23 },
  { 4044, 18, 32, 26, 3, -32 },
  { 4116, 20, 23, 26, 3, -23 },
  { 4174, 19, 33, 26, 4, -33 },
  { 4253, 17, 32, 26, 4, -23 },
  { 4321, 18, 32, 26, 4, -32 },
  { 4393, 18, 31, 26, 5, -31 },
  { 4463, 13, 40, 26, 4, -31 },
  { 4528, 18, 32, 26, 5, -32 },
  { 4600, 18, 32, 26, 5, -32 },
  { 4672, 22, 23, 26, 2, -23 },
  { 4736, 18, 23, 26, 4, -23 },
  { 4788, 20, 23, 26, 3, -23 },
  { 4846, 18, 32, 26, 4, -23 },
  { 4918, 17, 32, 26, 4, -23 },
  { 4986, 15, 23, 26, 8, -23 },
  { 5030, 18, 23, 26, 4, -23 },
  { 5082, 18, 29, 26, 4, -29 },
  { 5148, 18, 23, 26, 4, -23 },
  { 5200, 21, 23, 26, 2, -23 },
  { 5261, 24, 23, 26, 1, -23 },
  { 5330, 20, 23, 26, 3, -23 },
  { 5388, 22, 32, 26, 2, -23 },
  { 5476, 20, 23, 26, 3, -23 },
  { 5534, 14, 43, 26, 7, -34 },
  { 5610, 2, 37, 26, 12, -31 },
  { 5620, 14, 43, 26, 7, -34 },
  { 5696, 23, 7, 26, 1, -16 },
};

const GFXfont RobotoMono_ExtraLight43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight43pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_EXTRALIGHT43PT7B_H_
