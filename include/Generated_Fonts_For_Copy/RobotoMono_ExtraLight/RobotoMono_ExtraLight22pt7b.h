#ifndef _ROBOTOMONO_EXTRALIGHT22PT7B_H_
#define _ROBOTOMONO_EXTRALIGHT22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLight.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLight22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0xB6, 0xDA, 0x08, 0x40, 0x84, 0x08, 0x40, 0x88, 0x08,
  0x8F, 0xFF, 0x10, 0x81, 0x08, 0x11, 0x01, 0x10, 0x11, 0x0F, 0xFE, 0x21,
  0x02, 0x10, 0x22, 0x02, 0x20, 0x08, 0x02, 0x01, 0xE0, 0x84, 0x40, 0x90,
  0x24, 0x09, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x06,
  0x02, 0x40, 0x8F, 0xC0, 0x40, 0x10, 0x30, 0x02, 0x40, 0x21, 0x11, 0x08,
  0x88, 0x48, 0x22, 0x41, 0xE4, 0x00, 0x40, 0x02, 0x00, 0x23, 0x01, 0x24,
  0x12, 0x10, 0x90, 0x88, 0x84, 0x02, 0x40, 0x1E, 0x1C, 0x04, 0x41, 0x08,
  0x21, 0x04, 0x20, 0x88, 0x0A, 0x00, 0x80, 0x78, 0x09, 0x0A, 0x11, 0x41,
  0x28, 0x19, 0x01, 0x30, 0x63, 0xF3, 0xF8, 0x08, 0x88, 0x44, 0x21, 0x10,
  0x84, 0x21, 0x08, 0x41, 0x08, 0x42, 0x08, 0x41, 0x04, 0x82, 0x08, 0x41,
  0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x88, 0x44, 0x40, 0x08,
  0x02, 0x00, 0x82, 0x23, 0x7B, 0x03, 0x01, 0x40, 0x48, 0x61, 0x00, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x00, 0x55, 0x80, 0xFE, 0xB0, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x80,
  0x1E, 0x30, 0x90, 0x30, 0x18, 0x0C, 0x0E, 0x0B, 0x09, 0x88, 0xC8, 0x68,
  0x38, 0x18, 0x0A, 0x05, 0x04, 0x7C, 0x04, 0x76, 0x61, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x1E, 0x18, 0x44, 0x0A, 0x02, 0x80,
  0x80, 0x20, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0xFF, 0x1E, 0x08, 0x44, 0x0A, 0x02, 0x00, 0x40, 0x20, 0x08, 0x0C,
  0x1F, 0x00, 0x20, 0x04, 0x01, 0x80, 0x60, 0x14, 0x08, 0xFC, 0x01, 0x00,
  0x20, 0x0C, 0x02, 0x80, 0x50, 0x12, 0x04, 0x40, 0x88, 0x21, 0x08, 0x21,
  0x04, 0x7F, 0xF0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0x90, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x05, 0xE1, 0x84, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x80,
  0x90, 0x26, 0x18, 0xFC, 0x06, 0x0C, 0x08, 0x08, 0x08, 0x04, 0x02, 0xF9,
  0x82, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x04, 0x7C, 0xFF, 0xE0,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x1E, 0x18, 0x44, 0x0A,
  0x02, 0x80, 0xA0, 0x24, 0x08, 0xFC, 0x33, 0x10, 0x28, 0x06, 0x01, 0x80,
  0x60, 0x14, 0x08, 0xFC, 0x1C, 0x31, 0xB0, 0x50, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xA1, 0xCF, 0x20, 0x10, 0x10, 0x08, 0x18, 0x70, 0xC0, 0x60,
  0x50, 0x00, 0x15, 0xA0, 0x00, 0x80, 0xC3, 0x86, 0x0C, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x70,
  0x06, 0x00, 0xC0, 0x18, 0x0C, 0x38, 0x60, 0xC0, 0x00, 0x3C, 0x42, 0x81,
  0x81, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x0F, 0x01, 0x0C, 0x20, 0x24, 0x22, 0x8D, 0x29, 0x11, 0x91, 0x19,
  0x11, 0x91, 0x19, 0x11, 0x91, 0x29, 0x32, 0x8C, 0xC4, 0x00, 0x60, 0x81,
  0xF0, 0x04, 0x00, 0xC0, 0x18, 0x05, 0x00, 0x90, 0x12, 0x04, 0x40, 0x84,
  0x10, 0x84, 0x10, 0x81, 0x1F, 0xE4, 0x04, 0x80, 0x50, 0x0C, 0x01, 0xFC,
  0x20, 0xC8, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x1B, 0xF8, 0x83, 0x20, 0x28,
  0x06, 0x01, 0x80, 0x60, 0x28, 0x1B, 0xF8, 0x0F, 0x06, 0x10, 0x81, 0x20,
  0x24, 0x02, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x14,
  0x04, 0x80, 0x88, 0x20, 0xF8, 0xF8, 0x21, 0x88, 0x12, 0x02, 0x80, 0xA0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x33,
  0xF0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x0F, 0x06, 0x10, 0x81, 0x20, 0x24, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x7E, 0x00, 0xA0, 0x14, 0x02, 0xC0, 0x48, 0x10, 0xFC, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x80, 0x50, 0x26, 0x18, 0xFC, 0x80, 0x50, 0x12, 0x04, 0x41,
  0x08, 0x61, 0x18, 0x22, 0x04, 0x80, 0xA8, 0x18, 0x82, 0x10, 0x41, 0x08,
  0x11, 0x01, 0x20, 0x34, 0x03, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03,
  0xFF, 0x80, 0xF0, 0x3C, 0x17, 0x05, 0xA1, 0x68, 0x9A, 0x26, 0x51, 0x94,
  0x63, 0x18, 0x86, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x70,
  0x38, 0x1A, 0x0C, 0x86, 0x43, 0x11, 0x88, 0xC2, 0x61, 0x30, 0x58, 0x1C,
  0x0E, 0x03, 0x01, 0x0E, 0x06, 0x30, 0x81, 0x20, 0x24, 0x04, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x88, 0x20,
  0xF8, 0xFE, 0x20, 0x68, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x83,
  0x3F, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0F, 0x06, 0x11,
  0x81, 0x20, 0x24, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x14, 0x04, 0x80, 0x88, 0x20, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80, 0x60, 0x28, 0x0A, 0x02, 0xFF, 0x20,
  0x88, 0x22, 0x04, 0x81, 0x20, 0x28, 0x0A, 0x01, 0x1E, 0x18, 0x48, 0x0A,
  0x01, 0x80, 0x60, 0x04, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x14, 0x08, 0xFC, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x04, 0x7C, 0x80, 0x30, 0x05, 0x01,
  0x20, 0x24, 0x04, 0x41, 0x08, 0x21, 0x04, 0x11, 0x02, 0x20, 0x44, 0x04,
  0x80, 0xA0, 0x14, 0x01, 0x80, 0x20, 0x84, 0x18, 0x41, 0x86, 0x28, 0x62,
  0x46, 0x24, 0xA2, 0x4A, 0x24, 0x92, 0x49, 0x44, 0x94, 0x51, 0x43, 0x14,
  0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x08, 0xC0, 0x28, 0x08, 0x81, 0x10, 0x41,
  0x08, 0x12, 0x02, 0x80, 0x30, 0x06, 0x01, 0x40, 0x24, 0x08, 0xC3, 0x08,
  0x40, 0x90, 0x16, 0x01, 0x80, 0x38, 0x09, 0x01, 0x10, 0x42, 0x08, 0x22,
  0x04, 0x40, 0x50, 0x0A, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x7F, 0xC0, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x03, 0xFF, 0xF2, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x4E, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x81, 0x01, 0x02, 0xE4, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x9E, 0x10, 0x10, 0x28, 0x28, 0x44, 0x44, 0x42,
  0x82, 0x83, 0xFF, 0x80, 0xC8, 0x80, 0x1E, 0x30, 0xA0, 0x30, 0x10, 0x08,
  0xFD, 0x83, 0x01, 0x80, 0xC0, 0x60, 0x6F, 0xD0, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0xF2, 0x85, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x82, 0xBE, 0x00, 0x1E, 0x30, 0x90, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xA0, 0x50, 0x47, 0xC0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0xE5, 0x8A, 0x83, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x83,
  0x3E, 0x80, 0x1E, 0x08, 0x44, 0x0A, 0x02, 0x80, 0xBF, 0xF8, 0x02, 0x00,
  0x80, 0x30, 0x06, 0x08, 0xFC, 0x03, 0xC3, 0x00, 0x80, 0x40, 0x10, 0x3F,
  0xE1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x00, 0x1C, 0xB1, 0x50, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x50, 0x67, 0xD0, 0x08, 0x07, 0x04, 0xC6, 0x1C, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0xF2, 0x85, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0xFC, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x43, 0xFF, 0x06, 0x0C, 0x00, 0x07, 0xE0, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x4F, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x0A, 0x09, 0x08, 0x88, 0x58, 0x38, 0x1A, 0x08,
  0x84, 0x22, 0x19, 0x04, 0x81, 0x80, 0xFC, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0xFF, 0xC0, 0xB9, 0xD8, 0xC6, 0x10, 0xC2, 0x18, 0x43, 0x08,
  0x61, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x10, 0x9E, 0x50, 0xB0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x0E,
  0x06, 0x31, 0x81, 0x20, 0x24, 0x03, 0x00, 0x60, 0x0A, 0x01, 0x40, 0x48,
  0x08, 0x82, 0x0F, 0x80, 0x9E, 0x51, 0xB0, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x70, 0x57, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x1C, 0xB1,
  0xD0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x67, 0xD0,
  0x08, 0x04, 0x02, 0x01, 0x8F, 0xB0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x1E, 0x30, 0xD0, 0x28, 0x14, 0x01, 0xC0, 0x1C,
  0x01, 0x00, 0xC0, 0x50, 0x27, 0xE0, 0x10, 0x08, 0x04, 0x1F, 0xF1, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x3E, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x67,
  0xD0, 0x80, 0x28, 0x09, 0x01, 0x10, 0x22, 0x08, 0x41, 0x04, 0x40, 0x88,
  0x09, 0x01, 0x40, 0x28, 0x02, 0x00, 0x84, 0x18, 0x42, 0x86, 0x28, 0xA2,
  0x4A, 0x24, 0xA2, 0x49, 0x45, 0x14, 0x51, 0x43, 0x14, 0x30, 0x82, 0x08,
  0x40, 0x64, 0x08, 0xC2, 0x08, 0x80, 0xB0, 0x0C, 0x01, 0x80, 0x50, 0x11,
  0x06, 0x10, 0x81, 0x60, 0x30, 0x80, 0x30, 0x05, 0x01, 0x20, 0x22, 0x08,
  0x41, 0x04, 0x20, 0x88, 0x09, 0x01, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x60, 0x00, 0xFF, 0x80, 0x20, 0x10, 0x08, 0x04, 0x03,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x03, 0xFF, 0x06, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x43, 0x02, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0xC0, 0xC0, 0x40, 0xFF, 0xFF, 0xE0, 0x80, 0xC0, 0x80, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x30, 0x18, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x04, 0x10, 0x00, 0x78, 0x18, 0x42, 0x83, 0xE0,
};

const GFXglyph RobotoMono_ExtraLight22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 1, 16, 13, 6, -16 },
  { 3, 3, 5, 13, 5, -17 },
  { 5, 12, 16, 13, 1, -16 },
  { 29, 10, 20, 13, 2, -18 },
  { 54, 13, 16, 13, 0, -16 },
  { 80, 11, 16, 13, 2, -16 },
  { 102, 1, 5, 13, 6, -17 },
  { 103, 5, 22, 13, 4, -17 },
  { 117, 5, 22, 13, 4, -17 },
  { 131, 10, 9, 13, 2, -16 },
  { 143, 11, 11, 13, 1, -13 },
  { 159, 2, 5, 13, 4, -2 },
  { 161, 7, 1, 13, 3, -8 },
  { 162, 2, 2, 13, 6, -2 },
  { 163, 8, 17, 13, 3, -16 },
  { 180, 9, 16, 13, 2, -16 },
  { 198, 6, 16, 13, 2, -16 },
  { 210, 10, 16, 13, 1, -16 },
  { 230, 10, 16, 13, 1, -16 },
  { 250, 11, 16, 13, 1, -16 },
  { 272, 10, 16, 13, 2, -16 },
  { 292, 9, 16, 13, 2, -16 },
  { 310, 11, 16, 13, 1, -16 },
  { 332, 10, 16, 13, 2, -16 },
  { 352, 9, 16, 13, 2, -16 },
  { 370, 1, 11, 13, 7, -11 },
  { 372, 2, 14, 13, 6, -11 },
  { 376, 9, 9, 13, 2, -12 },
  { 387, 9, 6, 13, 2, -10 },
  { 394, 9, 9, 13, 2, -12 },
  { 405, 8, 16, 13, 3, -16 },
  { 421, 12, 16, 13, 1, -16 },
  { 445, 11, 16, 13, 1, -16 },
  { 467, 10, 16, 13, 2, -16 },
  { 487, 11, 16, 13, 1, -16 },
  { 509, 10, 16, 13, 2, -16 },
  { 529, 9, 16, 13, 2, -16 },
  { 547, 9, 16, 13, 2, -16 },
  { 565, 11, 16, 13, 1, -16 },
  { 587, 9, 16, 13, 2, -16 },
  { 605, 9, 16, 13, 2, -16 },
  { 623, 10, 16, 13, 1, -16 },
  { 643, 11, 16, 13, 2, -16 },
  { 665, 10, 16, 13, 2, -16 },
  { 685, 10, 16, 13, 2, -16 },
  { 705, 9, 16, 13, 2, -16 },
  { 723, 11, 16, 13, 1, -16 },
  { 745, 10, 16, 13, 2, -16 },
  { 765, 11, 19, 13, 1, -16 },
  { 792, 10, 16, 13, 2, -16 },
  { 812, 10, 16, 13, 2, -16 },
  { 832, 11, 16, 13, 1, -16 },
  { 854, 9, 16, 13, 2, -16 },
  { 872, 11, 16, 13, 1, -16 },
  { 894, 12, 16, 13, 1, -16 },
  { 918, 11, 16, 13, 1, -16 },
  { 940, 11, 16, 13, 1, -16 },
  { 962, 10, 16, 13, 1, -16 },
  { 982, 3, 21, 13, 5, -18 },
  { 990, 7, 17, 13, 3, -16 },
  { 1005, 3, 21, 13, 5, -18 },
  { 1013, 8, 9, 13, 3, -16 },
  { 1022, 9, 1, 13, 2, 0 },
  { 1024, 3, 3, 13, 5, -16 },
  { 1026, 9, 12, 13, 2, -12 },
  { 1040, 9, 17, 13, 2, -17 },
  { 1060, 9, 12, 13, 2, -12 },
  { 1074, 9, 17, 13, 2, -17 },
  { 1094, 10, 12, 13, 2, -12 },
  { 1109, 10, 17, 13, 2, -17 },
  { 1131, 9, 17, 13, 2, -12 },
  { 1151, 9, 17, 13, 2, -17 },
  { 1171, 10, 16, 13, 2, -16 },
  { 1191, 7, 21, 13, 2, -16 },
  { 1210, 9, 17, 13, 3, -17 },
  { 1230, 10, 17, 13, 2, -17 },
  { 1252, 11, 12, 13, 1, -12 },
  { 1269, 9, 12, 13, 2, -12 },
  { 1283, 11, 12, 13, 1, -12 },
  { 1300, 9, 16, 13, 2, -12 },
  { 1318, 9, 16, 13, 2, -12 },
  { 1336, 8, 12, 13, 4, -12 },
  { 1348, 9, 12, 13, 2, -12 },
  { 1362, 9, 15, 13, 2, -15 },
  { 1379, 9, 12, 13, 2, -12 },
  { 1393, 11, 12, 13, 1, -12 },
  { 1410, 12, 12, 13, 1, -12 },
  { 1428, 11, 12, 13, 1, -12 },
  { 1445, 11, 17, 13, 1, -12 },
  { 1469, 10, 12, 13, 2, -12 },
  { 1484, 7, 22, 13, 4, -17 },
  { 1504, 1, 19, 13, 6, -16 },
  { 1507, 7, 22, 13, 4, -17 },
  { 1527, 12, 3, 13, 1, -8 },
};

const GFXfont RobotoMono_ExtraLight22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLight22pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLight22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_EXTRALIGHT22PT7B_H_
