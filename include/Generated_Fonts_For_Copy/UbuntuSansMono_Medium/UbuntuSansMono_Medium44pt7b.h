#ifndef _UBUNTUSANSMONO_MEDIUM44PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x7D, 0xFF,
  0xFF, 0xFF, 0xEF, 0x84, 0x00, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDE, 0x1F,
  0x78, 0x7D, 0xE1, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83,
  0x9C, 0x0E, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x1F,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xE0,
  0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xC1,
  0xE0, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC3, 0xF0, 0x0C, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF4, 0x00, 0x1F, 0x78, 0x03, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x02, 0xFF, 0x00,
  0x79, 0xFF, 0x00, 0xF7, 0x9E, 0x03, 0xCE, 0x1C, 0x0F, 0x1C, 0x38, 0x1E,
  0x38, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE1, 0xE3, 0xC1, 0xC3, 0x8F, 0x03,
  0xC7, 0x1E, 0x07, 0x9E, 0x78, 0x07, 0xFD, 0xE0, 0x0F, 0xF3, 0xC0, 0x07,
  0xCF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0xC0, 0x01, 0xE7, 0xF0, 0x03,
  0x9F, 0xF0, 0x0F, 0x3D, 0xE0, 0x3C, 0xF1, 0xE0, 0x79, 0xE3, 0xC1, 0xE3,
  0xC7, 0x87, 0x87, 0x07, 0x0F, 0x0E, 0x0E, 0x3C, 0x1E, 0x3C, 0x70, 0x3C,
  0x79, 0xE0, 0x78, 0xF7, 0x80, 0x7B, 0xCF, 0x00, 0xFF, 0xBC, 0x00, 0xFE,
  0x00, 0x00, 0x30, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x1F,
  0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF9,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x10, 0x07, 0xF0,
  0x3C, 0x1F, 0xF0, 0x78, 0x7F, 0xF0, 0xF0, 0xFB, 0xF3, 0xE3, 0xE3, 0xF7,
  0x87, 0x83, 0xFF, 0x1F, 0x03, 0xFE, 0x3E, 0x03, 0xF8, 0x7C, 0x03, 0xF0,
  0xF8, 0x03, 0xE0, 0xF0, 0x0F, 0xE1, 0xF0, 0x3F, 0xC3, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x83, 0xFF, 0x8F, 0x81, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xBC, 0xE7, 0x00, 0x00, 0x08, 0x00, 0x70, 0x01, 0xF0,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x70, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x07, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x06, 0x1E, 0x0D, 0xF1, 0xC7, 0xBF, 0xBB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xDE, 0x00,
  0xFB, 0xE0, 0x3E, 0x7E, 0x0F, 0xC7, 0xC1, 0xF8, 0xFC, 0x0E, 0x0E, 0x00,
  0x80, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF1, 0xFC, 0x0F, 0x07, 0x83,
  0xE7, 0xF3, 0xF8, 0xFC, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x08, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xF0, 0xFC, 0x1F, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x87, 0x0F,
  0x7C, 0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7,
  0x87, 0xFE, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0xC1,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xF7, 0xC0, 0x78, 0xF8, 0x08,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xC3, 0xF8, 0xE0, 0x1F, 0x88, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0x83, 0xF8, 0x40, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFB, 0x00, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1,
  0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xD8, 0x01, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x07, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xBF, 0xC1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFC, 0x0F, 0xDE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0x1F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x07, 0xE7, 0xC0, 0x3E,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1E, 0x7C, 0x03,
  0xE7, 0xE0, 0x3E, 0x3F, 0x07, 0xC1, 0xFE, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x83, 0xF3, 0xFC, 0x3E, 0x0F, 0xE7, 0xC0, 0x3F, 0x78,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0x7E, 0x03, 0xF7, 0xFD, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x08, 0x0F,
  0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF0, 0xF8, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xF1, 0xFC, 0xFF,
  0x3F, 0xC7, 0xF0, 0xFC, 0x0F, 0x07, 0x83, 0xE7, 0xF3, 0xF8, 0xFC, 0x1C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE7, 0x03, 0xF2, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x02, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xF0, 0x1F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1F, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xE1, 0xFE, 0x3E, 0x0F, 0xF1, 0xF0, 0x7F, 0x8F,
  0x03, 0xFC, 0x78, 0x1F, 0xE3, 0xC0, 0xFF, 0x1E, 0x07, 0xF8, 0xF0, 0x3F,
  0xC7, 0xC1, 0xFE, 0x3E, 0x0F, 0xF0, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x1F,
  0xFE, 0xF0, 0x7F, 0xF7, 0xC0, 0xFF, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xF7, 0x80,
  0x01, 0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xE3, 0xE0,
  0x03, 0xC3, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0x81, 0xF0,
  0x07, 0x81, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x7F,
  0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x81, 0xFC, 0xF8, 0x07, 0xEF,
  0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFE, 0x0F, 0x0F, 0xC0, 0x08, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x0C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x03, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xF9, 0xFF, 0x8F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF,
  0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8,
  0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0x0F, 0x1F, 0xC0, 0x10,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E,
  0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xE0, 0x3E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x20, 0x07, 0xC7, 0x01, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x3F, 0xF8, 0x00, 0x70, 0x00, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0x3E, 0x01,
  0xF1, 0xF0, 0x1F, 0x8F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1F,
  0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFB,
  0xF0, 0x07, 0xCF, 0xC0, 0x3E, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xF0,
  0x7C, 0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3F, 0x3E, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x03, 0xF8, 0xFE, 0x0F, 0xE3, 0xB8, 0x3F, 0x8E, 0xE1, 0xFE, 0x3B, 0xC7,
  0x79, 0xE7, 0x1D, 0xE7, 0x9C, 0xF7, 0x9E, 0x7B, 0xDE, 0x79, 0xEE, 0x79,
  0xE3, 0xF8, 0xE7, 0x8F, 0xE3, 0xDE, 0x3F, 0x0F, 0x78, 0x7C, 0x3D, 0xE1,
  0xF0, 0xF7, 0x87, 0x83, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xF7, 0x81, 0xFE, 0xF0, 0x3F, 0xCF,
  0x07, 0xF9, 0xE0, 0xFF, 0x1E, 0x1F, 0xE3, 0xC3, 0xFC, 0x3C, 0x7F, 0x87,
  0x8F, 0xF0, 0x79, 0xFE, 0x0F, 0x3F, 0xC0, 0xF7, 0xF8, 0x1E, 0xFF, 0x01,
  0xDF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x87,
  0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE1, 0xF0,
  0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x0C, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFC, 0x7F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x81, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x87, 0xF0, 0xFC,
  0x07, 0xC3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xE0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xF8, 0xFF, 0x8F, 0x80, 0xFC,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0x87, 0xC0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x3F, 0x01, 0xC7, 0xE0, 0x04, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF4, 0x00, 0x1F, 0x70, 0x03, 0xF7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x3E, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x70, 0x00,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF3, 0xE0, 0x03, 0xE7,
  0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x1E, 0x0F,
  0x78, 0x7C, 0x3D, 0xE3, 0xF0, 0xF7, 0x8F, 0xC7, 0x9E, 0x3F, 0x9E, 0x78,
  0xEE, 0x79, 0xE7, 0xB9, 0xE7, 0x9C, 0xF7, 0x9E, 0x71, 0xDE, 0x7B, 0xC7,
  0x78, 0xEE, 0x1F, 0xE3, 0xB8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF8,
  0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x03, 0xC0, 0xFC, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8,
  0x0F, 0x81, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xCF, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xE7, 0xC0,
  0x07, 0xDF, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x7E, 0xFC, 0x01, 0xF1, 0xF0, 0x0F, 0x87,
  0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x1F, 0x0F, 0xC0, 0x7E, 0x3E, 0x00, 0xF9,
  0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xCE, 0x00, 0x1E, 0x08, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20,
  0x38, 0x3E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0E, 0x02, 0x00, 0x00, 0xC0,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x7F, 0xFC, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x40, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x20, 0x0F, 0xBF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC0, 0xFC, 0xF8,
  0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0xC0, 0x10, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x21, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x16, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0x0F, 0x83, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF0, 0x3F, 0x7C, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xF7,
  0xE0, 0x3E, 0xFE, 0x07, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x81, 0xF1, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x28, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x03,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xFC, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0xC0, 0x7D,
  0xFE, 0x3F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFC, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xB8, 0x07, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x84, 0x03, 0xFF, 0xF0,
  0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x08, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x40, 0x1F,
  0x70, 0x3F, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF0, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x07, 0xEF, 0x80, 0x7E, 0x7C, 0x07, 0xE3, 0xE0,
  0x7E, 0x1F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E, 0x7E, 0x01,
  0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x7E,
  0x00, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x3E, 0x1F, 0x81, 0xF0, 0x7E, 0x0F,
  0x81, 0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xFC, 0xF8, 0x03,
  0xF7, 0xC0, 0x0F, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x08, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xC0,
  0xFF, 0xCF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x0F,
  0x0F, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F,
  0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x7C,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xE0, 0x00, 0x40, 0x1F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x00, 0x60, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF1, 0xF0,
  0x0F, 0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFE, 0x0F, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07,
  0xEF, 0xC0, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xBF,
  0xE0, 0xF8, 0x20, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x07, 0xDF,
  0x80, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBF, 0x03, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x43, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xC0, 0x17,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xF8, 0x01, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xB0,
  0x03, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x02, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x04, 0x00, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x01,
  0xF7, 0xE0, 0x7D, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8,
  0x01, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x01, 0xE7, 0xC0,
  0x03, 0xEF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDF,
  0x07, 0x07, 0xBE, 0x1F, 0x0F, 0x3C, 0x3E, 0x1E, 0x78, 0x7C, 0x3C, 0xF1,
  0xF8, 0x79, 0xE3, 0xF8, 0xF3, 0xC7, 0xF1, 0xC7, 0x9E, 0xE7, 0x8F, 0x3D,
  0xEF, 0x0F, 0x73, 0xDE, 0x1F, 0xE3, 0xBC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x07, 0x80, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xF0, 0x1F,
  0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xF0,
  0x0F, 0xC7, 0xC0, 0x3E, 0x0F, 0x81, 0xF0, 0x3F, 0x0F, 0x80, 0x7C, 0x3E,
  0x00, 0xF9, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x00, 0xF8, 0x7C, 0x03,
  0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80,
  0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0x79, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x04, 0x1F, 0x80, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFE, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0x80,
  0x10, 0x7F, 0x80, 0xF3, 0xFF, 0x83, 0xCF, 0xFF, 0xBF, 0x7F, 0xFF, 0xF9,
  0xE0, 0xFF, 0xEF, 0x01, 0xFF, 0x04, 0x01, 0xF0,
};

const GFXglyph UbuntuSansMono_Medium44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 31, 25, 9, -30 },
  { 29, 14, 12, 25, 5, -33 },
  { 50, 23, 30, 25, 1, -30 },
  { 137, 20, 39, 25, 2, -34 },
  { 235, 23, 32, 25, 1, -31 },
  { 327, 23, 31, 25, 1, -31 },
  { 417, 5, 13, 25, 10, -33 },
  { 426, 15, 43, 25, 5, -35 },
  { 507, 14, 43, 25, 5, -35 },
  { 583, 19, 18, 25, 3, -30 },
  { 626, 21, 22, 25, 2, -24 },
  { 684, 10, 14, 25, 7, -7 },
  { 702, 12, 5, 25, 6, -15 },
  { 710, 8, 8, 25, 8, -7 },
  { 718, 19, 42, 25, 3, -34 },
  { 818, 21, 32, 25, 2, -31 },
  { 902, 19, 30, 25, 3, -30 },
  { 974, 19, 31, 25, 3, -31 },
  { 1048, 19, 32, 25, 3, -31 },
  { 1124, 21, 30, 25, 2, -30 },
  { 1203, 19, 31, 25, 3, -30 },
  { 1277, 19, 32, 25, 3, -31 },
  { 1353, 19, 30, 25, 3, -30 },
  { 1425, 20, 32, 25, 2, -31 },
  { 1505, 20, 31, 25, 2, -31 },
  { 1583, 8, 24, 25, 8, -23 },
  { 1607, 10, 30, 25, 6, -23 },
  { 1645, 21, 21, 25, 2, -23 },
  { 1701, 21, 14, 25, 2, -20 },
  { 1738, 21, 21, 25, 2, -23 },
  { 1794, 17, 32, 25, 4, -31 },
  { 1862, 21, 38, 25, 2, -31 },
  { 1962, 24, 30, 25, 0, -30 },
  { 2052, 20, 31, 25, 3, -31 },
  { 2130, 21, 32, 25, 2, -31 },
  { 2214, 20, 31, 25, 3, -31 },
  { 2292, 19, 30, 25, 4, -30 },
  { 2364, 18, 30, 25, 4, -30 },
  { 2432, 21, 32, 25, 2, -31 },
  { 2516, 20, 30, 25, 2, -30 },
  { 2591, 17, 30, 25, 4, -30 },
  { 2655, 19, 31, 25, 2, -30 },
  { 2729, 21, 30, 25, 3, -30 },
  { 2808, 19, 30, 25, 4, -30 },
  { 2880, 22, 30, 25, 1, -30 },
  { 2963, 19, 30, 25, 3, -30 },
  { 3035, 22, 32, 25, 1, -31 },
  { 3123, 20, 31, 25, 3, -31 },
  { 3201, 22, 39, 25, 1, -31 },
  { 3309, 20, 31, 25, 3, -31 },
  { 3387, 20, 32, 25, 2, -31 },
  { 3467, 21, 30, 25, 2, -30 },
  { 3546, 20, 31, 25, 2, -30 },
  { 3624, 23, 30, 25, 1, -30 },
  { 3711, 22, 30, 25, 1, -30 },
  { 3794, 23, 30, 25, 1, -30 },
  { 3881, 23, 30, 25, 1, -30 },
  { 3968, 19, 30, 25, 3, -30 },
  { 4040, 13, 42, 25, 6, -34 },
  { 4109, 19, 42, 25, 3, -34 },
  { 4209, 12, 42, 25, 6, -34 },
  { 4272, 22, 17, 25, 1, -30 },
  { 4319, 24, 4, 25, 0, 4 },
  { 4331, 9, 9, 25, 8, -34 },
  { 4342, 18, 25, 25, 3, -24 },
  { 4399, 20, 35, 25, 3, -34 },
  { 4487, 21, 25, 25, 2, -24 },
  { 4553, 19, 35, 25, 2, -34 },
  { 4637, 21, 25, 25, 2, -24 },
  { 4703, 21, 34, 25, 3, -34 },
  { 4793, 19, 32, 25, 2, -24 },
  { 4869, 18, 34, 25, 3, -34 },
  { 4946, 21, 35, 25, 2, -34 },
  { 5038, 16, 42, 25, 3, -34 },
  { 5122, 21, 34, 25, 3, -34 },
  { 5212, 21, 35, 25, 2, -34 },
  { 5304, 21, 23, 25, 2, -23 },
  { 5365, 18, 24, 25, 3, -24 },
  { 5419, 21, 25, 25, 2, -24 },
  { 5485, 20, 32, 25, 3, -24 },
  { 5565, 19, 32, 25, 2, -24 },
  { 5641, 17, 23, 25, 5, -23 },
  { 5690, 19, 25, 25, 3, -24 },
  { 5750, 20, 31, 25, 3, -30 },
  { 5828, 18, 24, 25, 3, -23 },
  { 5882, 23, 23, 25, 1, -23 },
  { 5949, 23, 23, 25, 1, -23 },
  { 6016, 22, 23, 25, 1, -23 },
  { 6080, 22, 31, 25, 1, -23 },
  { 6166, 18, 23, 25, 3, -23 },
  { 6218, 17, 42, 25, 4, -34 },
  { 6308, 5, 42, 25, 10, -34 },
  { 6335, 18, 42, 25, 3, -34 },
  { 6430, 22, 8, 25, 1, -17 },
};

const GFXfont UbuntuSansMono_Medium44pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium44pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium44pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UBUNTUSANSMONO_MEDIUM44PT7B_H_
