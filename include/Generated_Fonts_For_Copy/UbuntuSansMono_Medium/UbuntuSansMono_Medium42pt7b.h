#ifndef _UBUNTUSANSMONO_MEDIUM42PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x1E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF,
  0xFB, 0xF7, 0xC2, 0x00, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xEF, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x1E, 0xE0, 0x60,
  0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC3,
  0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x7C,
  0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78,
  0x3C, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xCF, 0xC0, 0x31, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xB8, 0x03, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xFC, 0x00, 0xF7, 0xF8, 0x07, 0xBC, 0xE0, 0x3C, 0xE3,
  0xC0, 0xE3, 0x87, 0x07, 0x8E, 0x1C, 0x1C, 0x38, 0x70, 0xF0, 0xE1, 0xC7,
  0x83, 0x87, 0x1C, 0x0E, 0x3C, 0xF0, 0x3C, 0xE7, 0x80, 0x7F, 0x9C, 0x01,
  0xFC, 0xF0, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF3, 0xE0, 0x03,
  0x9F, 0xC0, 0x1E, 0xFF, 0x80, 0xF3, 0xCE, 0x03, 0x8E, 0x3C, 0x1E, 0x38,
  0xF0, 0xF1, 0xE1, 0xC3, 0x87, 0x87, 0x1E, 0x1E, 0x1C, 0x70, 0x38, 0xF3,
  0xC0, 0xE3, 0x9E, 0x03, 0xDE, 0x70, 0x07, 0xFB, 0xC0, 0x0F, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xF1, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x3E,
  0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0x83, 0x81, 0xFC, 0x1E, 0x1F, 0xF0, 0xF1, 0xFF,
  0xC7, 0x9F, 0x3F, 0x38, 0xF0, 0xFF, 0xC7, 0x83, 0xFE, 0x7C, 0x0F, 0xF3,
  0xE0, 0x3F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x7F, 0x1F, 0xCF,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xCF, 0x87, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFD, 0xEF, 0x7B, 0xDE, 0xE7, 0x00, 0x00, 0x30, 0x01, 0xE0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x10, 0x20, 0x01, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x0F, 0x80, 0x1C, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x03, 0x0F, 0x0C, 0xF9, 0xC7, 0x9F, 0xBB, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7B,
  0xE0, 0x1F, 0x3E, 0x07, 0xC7, 0xE0, 0xF8, 0x78, 0x06, 0x0E, 0x00, 0x40,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0x7E, 0x0F, 0x07, 0x0F, 0xBF, 0x9F, 0x8F, 0x86, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7C, 0x10,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x1F, 0x83, 0xE0, 0x7C,
  0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01,
  0xEF, 0x80, 0x1E, 0xF8, 0xF1, 0xEF, 0x9F, 0x1E, 0xF1, 0xF1, 0xFF, 0x1F,
  0x1F, 0xF0, 0xF1, 0xFF, 0x8E, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8,
  0x01, 0xEF, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC3,
  0xE0, 0xFC, 0x3F, 0xBF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xF3, 0xC0, 0x70, 0xF0, 0x10,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x01, 0xF0, 0x01,
  0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF3, 0xF8, 0x70, 0x1F, 0x88,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x03,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xE3, 0xF8, 0x60, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE8, 0x01, 0xF9, 0xF9,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8,
  0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x3C, 0x0F,
  0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x80, 0x1F, 0xBF, 0x3F, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xE0, 0x3E, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xF7, 0x80, 0x1E, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x3E, 0x07, 0xC7, 0xF3, 0xF8, 0x7F, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xF0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xEF,
  0x00, 0x79, 0xF0, 0x0F, 0x3F, 0x03, 0xE3, 0xF0, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0x87, 0xC7, 0xF9, 0xF0, 0x1F, 0x3C,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xEF, 0x80, 0x7D, 0xFC, 0x3F, 0x1F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFC, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xF1, 0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xF7, 0x80, 0x1E, 0xF8,
  0x03, 0xDF, 0x80, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F,
  0xCF, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7C, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7C, 0x10, 0x0F, 0x07, 0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xE1, 0xF0,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F,
  0x8F, 0xE3, 0xFC, 0xFF, 0x3F, 0xC7, 0xE0, 0x78, 0x1E, 0x0F, 0x3F, 0x8F,
  0xC3, 0xE0, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x01, 0xE0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x70, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0x70, 0x7E, 0x40, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0x78, 0x78,
  0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x0B, 0xDE, 0x07, 0xFE,
  0xF0, 0x7F, 0xF7, 0x87, 0xFF, 0xBC, 0x7E, 0x3D, 0xE3, 0xE1, 0xEF, 0x1E,
  0x0F, 0xF1, 0xF0, 0x7F, 0x8F, 0x83, 0xFC, 0x7C, 0x1F, 0xE3, 0xE0, 0xF7,
  0x9F, 0x07, 0xBC, 0x78, 0x3D, 0xE3, 0xC1, 0xEF, 0x1F, 0x0F, 0x78, 0x7F,
  0xFB, 0xC3, 0xFF, 0xCF, 0x0F, 0xFE, 0x78, 0x1F, 0xE3, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x60, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x80, 0x0F,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x3C, 0x03, 0xE0,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0x80, 0x1E,
  0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xF3,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0x01, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x7C, 0x78, 0x3F, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xF0, 0x0F, 0x9E, 0x00,
  0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x3E, 0xF0, 0x0F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xE3, 0xE3, 0xF8, 0x06, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x06, 0x1F, 0xF7, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x1C, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x03, 0xF1, 0xE0, 0x3F, 0x3C,
  0x03, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xE0,
  0x0F, 0xBC, 0x03, 0xE7, 0x80, 0xFC, 0xF0, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xE3, 0xE3, 0xF0, 0x04, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0x3E, 0x01, 0xF3, 0xF0, 0x1F, 0x1F, 0xF7, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x58, 0x00, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x80, 0x3F, 0x30, 0x0F, 0x9F,
  0xBF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x60, 0x00, 0xF0,
  0x07, 0xEF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x01, 0xF8, 0xF0, 0x1F, 0x0F,
  0x03, 0xE0, 0xF0, 0x7E, 0x0F, 0x0F, 0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x00,
  0xF3, 0xE0, 0x0F, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0x7E, 0x00, 0xF3, 0xF0, 0x0F, 0x1F, 0x80, 0xF0, 0xFC, 0x0F, 0x07,
  0xE0, 0xF0, 0x7E, 0x0F, 0x03, 0xF0, 0xF0, 0x1F, 0x8F, 0x00, 0xF8, 0xF0,
  0x0F, 0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F,
  0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1D,
  0xC7, 0x70, 0xEE, 0x7B, 0x8F, 0x73, 0xDC, 0x73, 0x9E, 0x73, 0x9C, 0xF3,
  0xBC, 0xE7, 0x9D, 0xC7, 0x3C, 0xFE, 0x39, 0xE3, 0xF1, 0xEF, 0x1F, 0x0F,
  0x78, 0xF8, 0x7B, 0xC3, 0xC3, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0x80, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x78, 0x3F, 0xEF,
  0x07, 0xFC, 0xF0, 0xFF, 0x9E, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C, 0x7F, 0xC3,
  0xCF, 0xF8, 0x79, 0xFF, 0x07, 0xBF, 0xE0, 0xF7, 0xFC, 0x0E, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xF8, 0xFE, 0x1F, 0x81, 0xF0,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0xDE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF0, 0x01,
  0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x3E,
  0x01, 0xF1, 0xF8, 0x1F, 0x07, 0xF7, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xEF, 0x80,
  0x7D, 0xF0, 0x1F, 0xBE, 0x3F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x81, 0xFC, 0xFE, 0x1F, 0x81, 0xF0, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x00, 0xF3, 0xE0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBE, 0x00,
  0x7D, 0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x3E, 0x01, 0xF1, 0xF8, 0x1F, 0x07,
  0xF3, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x38, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x01, 0xF9, 0xE0, 0x1F, 0x3C, 0x01, 0xE7,
  0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x07, 0xCF,
  0x00, 0xF9, 0xE0, 0x7E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xE1, 0xE0, 0x3E, 0x3C,
  0x07, 0xC7, 0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x00, 0xFB, 0xC0, 0x1F, 0x78,
  0x01, 0xFF, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F,
  0xFF, 0xE3, 0xF8, 0x78, 0xFC, 0x01, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xEC, 0x00, 0xFD, 0xF8, 0x7F, 0x3F, 0xFF, 0xEF, 0xFF,
  0xF8, 0x3F, 0xFC, 0x00, 0xB8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0xF3, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0x78, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x3C,
  0x03, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x3E, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE3, 0xE0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3D, 0xF0, 0x00, 0xF7,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0xF0, 0xF7, 0x8F,
  0x87, 0xBC, 0x7C, 0x3D, 0xE3, 0xF1, 0xCF, 0x3F, 0x8E, 0x79, 0xDC, 0x73,
  0xCE, 0x73, 0x9E, 0xF3, 0x9C, 0xF7, 0x1C, 0xE7, 0xB8, 0xF7, 0x3D, 0xC3,
  0xB8, 0xFC, 0x1D, 0xC7, 0xE0, 0xFE, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x8F,
  0x80, 0xFC, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x00, 0xFC, 0x00, 0xF9, 0xF0,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x00, 0xF8, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0xCF, 0x00, 0x0F, 0x7C, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x7C, 0x00, 0x7C, 0xF8,
  0x01, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x3C, 0x1F, 0x01, 0xF0, 0x3E, 0x0F,
  0x80, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x9F, 0x00,
  0x3E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0x7F, 0xE0,
  0x03, 0xE3, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x18, 0x1E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E,
  0x06, 0x01, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x9F,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xF0, 0x3E, 0xF8, 0x07,
  0xDE, 0x00, 0xFF, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xFC, 0x1F,
  0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x18, 0x00, 0x08, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xE0, 0x7E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7B,
  0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x81, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x02, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x1F, 0xEF, 0x1F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFD, 0xF8, 0x1F, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0x7E, 0x03, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x18, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFD, 0xFC, 0x7E, 0x07, 0xE7, 0xC0,
  0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x04, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xDF, 0x01, 0xF0, 0x08,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7E, 0x03, 0xDF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0x7E,
  0x0F, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xF3, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xDC, 0x07, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFC, 0x7F, 0xFC, 0x03, 0xF8, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x02, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7D, 0x00, 0xFB, 0xC3, 0xF7, 0xFF, 0xDF, 0xFF, 0xBF, 0xFC, 0x0F, 0xF0,
  0x08, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8,
  0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F, 0x9F, 0x80, 0xFB, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xBF, 0x00,
  0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F,
  0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x02, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x04, 0x00, 0xFF, 0x9F,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF1, 0xF1, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1E, 0xF8,
  0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xC7, 0xC0, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0x7C,
  0x03, 0xE7, 0xE0, 0x7C, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x81, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3E, 0x10, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC,
  0xFF, 0xFF, 0x7E, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x7C, 0x03, 0xDF, 0x81, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFE, 0xF0, 0x08, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFE, 0xFC, 0x78, 0x01, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xD0,
  0x03, 0xEF, 0xE7, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x20, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0xC0, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x07, 0xBE, 0x03, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x03, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87,
  0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x03, 0xC1, 0xF0, 0x1F, 0x0F,
  0x00, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0x7B, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC1, 0xE1, 0xEF, 0x07, 0x87, 0x9C, 0x3E,
  0x1E, 0x78, 0xFC, 0x79, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x1E, 0x7F, 0x1C,
  0x79, 0xDE, 0x71, 0xE7, 0x3B, 0xC3, 0xBC, 0xEF, 0x0E, 0xE3, 0xFC, 0x3F,
  0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xE0, 0x78, 0x07, 0x00, 0xFC, 0x00, 0xFB, 0xF0, 0x0F, 0x8F, 0x80, 0xF8,
  0x3E, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xE7, 0xC0, 0x1F, 0x3C, 0x00, 0x7F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0x87,
  0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x03, 0xE7, 0xC0, 0x0F, 0xFC,
  0x00, 0x7C, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0x8F, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x0F,
  0x03, 0xE0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x02, 0x1F, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x30, 0xFF, 0x03, 0xCF, 0xFE, 0x1E, 0xFF, 0xFF, 0xE7,
  0x8F, 0xFF, 0x38, 0x1F, 0xF3, 0xC0, 0x3F, 0x00,
};

const GFXglyph UbuntuSansMono_Medium42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 7, 30, 24, 8, -29 },
  { 28, 13, 12, 24, 5, -32 },
  { 48, 21, 29, 24, 1, -29 },
  { 125, 19, 38, 24, 2, -33 },
  { 216, 22, 31, 24, 1, -30 },
  { 302, 21, 30, 24, 1, -30 },
  { 381, 5, 13, 24, 9, -32 },
  { 390, 14, 41, 24, 5, -33 },
  { 462, 14, 41, 24, 5, -33 },
  { 534, 19, 18, 24, 2, -29 },
  { 577, 20, 21, 24, 2, -23 },
  { 630, 9, 14, 24, 7, -7 },
  { 646, 11, 4, 24, 6, -14 },
  { 652, 8, 8, 24, 8, -7 },
  { 660, 18, 41, 24, 3, -33 },
  { 753, 20, 31, 24, 2, -30 },
  { 831, 18, 29, 24, 3, -29 },
  { 897, 19, 30, 24, 2, -30 },
  { 969, 19, 31, 24, 2, -30 },
  { 1043, 20, 29, 24, 2, -29 },
  { 1116, 18, 30, 24, 3, -29 },
  { 1184, 19, 30, 24, 2, -29 },
  { 1256, 18, 29, 24, 3, -29 },
  { 1322, 19, 31, 24, 2, -30 },
  { 1396, 19, 30, 24, 2, -30 },
  { 1468, 8, 23, 24, 8, -22 },
  { 1491, 10, 29, 24, 6, -22 },
  { 1528, 20, 20, 24, 2, -22 },
  { 1578, 20, 13, 24, 2, -19 },
  { 1611, 20, 20, 24, 2, -22 },
  { 1661, 16, 31, 24, 4, -30 },
  { 1723, 21, 36, 24, 1, -30 },
  { 1818, 23, 29, 24, 0, -29 },
  { 1902, 19, 29, 24, 3, -29 },
  { 1971, 20, 31, 24, 2, -30 },
  { 2049, 19, 29, 24, 3, -29 },
  { 2118, 18, 29, 24, 4, -29 },
  { 2184, 17, 29, 24, 4, -29 },
  { 2246, 20, 31, 24, 2, -30 },
  { 2324, 19, 29, 24, 2, -29 },
  { 2393, 16, 29, 24, 4, -29 },
  { 2451, 18, 30, 24, 2, -29 },
  { 2519, 20, 29, 24, 3, -29 },
  { 2592, 18, 29, 24, 4, -29 },
  { 2658, 21, 29, 24, 1, -29 },
  { 2735, 19, 29, 24, 2, -29 },
  { 2804, 21, 31, 24, 1, -30 },
  { 2886, 19, 29, 24, 3, -29 },
  { 2955, 21, 38, 24, 1, -30 },
  { 3055, 19, 29, 24, 3, -29 },
  { 3124, 19, 31, 24, 2, -30 },
  { 3198, 20, 29, 24, 2, -29 },
  { 3271, 19, 30, 24, 2, -29 },
  { 3343, 22, 29, 24, 1, -29 },
  { 3423, 21, 29, 24, 1, -29 },
  { 3500, 22, 29, 24, 1, -29 },
  { 3580, 22, 29, 24, 1, -29 },
  { 3660, 19, 29, 24, 2, -29 },
  { 3729, 12, 41, 24, 6, -33 },
  { 3791, 18, 41, 24, 3, -33 },
  { 3884, 12, 41, 24, 5, -33 },
  { 3946, 21, 16, 24, 1, -29 },
  { 3988, 23, 4, 24, 0, 4 },
  { 4000, 9, 9, 24, 7, -33 },
  { 4011, 19, 23, 24, 2, -22 },
  { 4066, 19, 34, 24, 3, -33 },
  { 4147, 20, 23, 24, 2, -22 },
  { 4205, 18, 34, 24, 2, -33 },
  { 4282, 20, 23, 24, 2, -22 },
  { 4340, 21, 33, 24, 2, -33 },
  { 4427, 18, 30, 24, 2, -22 },
  { 4495, 18, 33, 24, 3, -33 },
  { 4570, 20, 33, 24, 2, -32 },
  { 4653, 15, 40, 24, 3, -32 },
  { 4728, 20, 33, 24, 3, -33 },
  { 4811, 20, 33, 24, 2, -32 },
  { 4894, 20, 22, 24, 2, -22 },
  { 4949, 18, 22, 24, 3, -22 },
  { 4999, 20, 23, 24, 2, -22 },
  { 5057, 19, 30, 24, 3, -22 },
  { 5129, 18, 30, 24, 2, -22 },
  { 5197, 16, 22, 24, 5, -22 },
  { 5241, 18, 23, 24, 3, -22 },
  { 5293, 20, 30, 24, 2, -29 },
  { 5368, 17, 23, 24, 3, -22 },
  { 5417, 21, 22, 24, 1, -22 },
  { 5475, 22, 22, 24, 1, -22 },
  { 5536, 21, 22, 24, 1, -22 },
  { 5594, 21, 30, 24, 1, -22 },
  { 5673, 17, 22, 24, 3, -22 },
  { 5720, 17, 41, 24, 3, -33 },
  { 5808, 4, 41, 24, 10, -33 },
  { 5829, 17, 41, 24, 3, -33 },
  { 5917, 21, 7, 24, 1, -16 },
};

const GFXfont UbuntuSansMono_Medium42pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium42pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium42pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUSANSMONO_MEDIUM42PT7B_H_
