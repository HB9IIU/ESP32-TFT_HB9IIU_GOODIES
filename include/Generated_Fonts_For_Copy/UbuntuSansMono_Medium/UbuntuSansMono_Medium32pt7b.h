#ifndef _UBUNTUSANSMONO_MEDIUM32PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium32pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC0,
  0x00, 0x00, 0xC7, 0xBF, 0xF9, 0xE0, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE1,
  0xF8, 0x7E, 0x1D, 0x86, 0x61, 0x80, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1C,
  0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x38,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x38, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xE0,
  0x70, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0xF8, 0xFF,
  0xE7, 0xFF, 0xBE, 0x02, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x3F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFC, 0x0F, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x10, 0x00, 0x7C, 0x07, 0xFE, 0x0E, 0xC6, 0x0E, 0xC6,
  0x1C, 0xC6, 0x18, 0xC6, 0x38, 0xC6, 0x70, 0xCE, 0x70, 0xFE, 0xE0, 0x7D,
  0xC0, 0x01, 0xC0, 0x03, 0x8C, 0x03, 0x3E, 0x07, 0x7F, 0x0E, 0x63, 0x0C,
  0x63, 0x1C, 0xE3, 0x38, 0x63, 0x38, 0x63, 0x70, 0x67, 0xE0, 0x7F, 0xE0,
  0x3E, 0x03, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x3C, 0xF0, 0x38, 0x70, 0x38,
  0x70, 0x38, 0x70, 0x38, 0xF0, 0x3C, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x0E, 0x3F, 0x8E, 0x7F, 0xCE, 0x73, 0xCE, 0xF1, 0xFC, 0xE0, 0xFC, 0xE0,
  0x7C, 0xE0, 0x3C, 0xF0, 0x7C, 0x7F, 0xFE, 0x3F, 0xEE, 0x1F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xE6, 0x66, 0x01, 0x80, 0xF0, 0x7C, 0x3C, 0x1E, 0x07, 0x83,
  0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x08, 0x60, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x04, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x18, 0xC2, 0xFB, 0x3F, 0xFF, 0xF7, 0xFF, 0x81, 0xE0,
  0x0F, 0xC0, 0x7B, 0x83, 0xCF, 0x0F, 0x3E, 0x18, 0x60, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x3E, 0x3E, 0x3E, 0x3F, 0x3E, 0x0E, 0x1E, 0x7C, 0xF8, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xF7, 0xE3, 0xC3, 0xCF,
  0x03, 0xDE, 0x07, 0xB8, 0x07, 0x70, 0x0E, 0xE3, 0x1D, 0xCF, 0x3F, 0x9E,
  0x7F, 0x3C, 0xEE, 0x31, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xF0, 0x3D,
  0xE0, 0x71, 0xE1, 0xE3, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xC0,
  0x1F, 0x00, 0xFC, 0x0F, 0xF0, 0xFF, 0xC1, 0xEF, 0x06, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1F, 0xFF, 0x7F, 0xFD, 0xFF,
  0xF0, 0x07, 0x00, 0xFF, 0x8F, 0xFF, 0x3F, 0x7E, 0x60, 0x79, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x01, 0xFF, 0x8F, 0xFF, 0x1F,
  0xFC, 0x40, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x07, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x1E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xB8, 0x07,
  0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x38, 0x38, 0x38, 0x78, 0x38, 0x70,
  0x38, 0xF0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0xFF,
  0x87, 0xFF, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x07, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x00, 0xF8,
  0x1F, 0xE0, 0xFF, 0x87, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0xF7, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xE0, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x39, 0xE1, 0xE3, 0xFF, 0x07,
  0xF8, 0x3F, 0xF1, 0xE3, 0xEF, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xFC, 0x0F, 0xFF, 0xF9, 0xFF, 0xE1, 0xFE, 0x00, 0x07, 0x80, 0x7F,
  0x83, 0xFF, 0x1F, 0x3E, 0xF0, 0x7B, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x01, 0xDF, 0x3F, 0x7F, 0xFC, 0xFF, 0xF0, 0x33, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x01, 0xF8, 0x7F, 0xC1, 0xFC, 0x07,
  0xC0, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF,
  0xFF, 0xDE, 0x1E, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x3F, 0x3F, 0x3F, 0x1F, 0x06, 0x0E, 0x7C, 0xF8, 0x70, 0x00,
  0x04, 0x00, 0x70, 0x07, 0xC0, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0x3C,
  0x00, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF0,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0x00, 0x7C,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFE, 0x03, 0xE0, 0x0C, 0x00, 0x00, 0x0F,
  0x0F, 0xFC, 0xFF, 0xE7, 0x3F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xC0,
  0x07, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x07,
  0x70, 0x3F, 0x70, 0xFF, 0xE1, 0xFF, 0xE3, 0xC7, 0xE3, 0x87, 0xE7, 0x87,
  0xE7, 0x87, 0xE7, 0x87, 0xE7, 0x87, 0xE7, 0x87, 0xE3, 0x87, 0xF3, 0xE7,
  0x71, 0xFF, 0x70, 0xFF, 0x78, 0x38, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFE, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0x78, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x3C, 0xF0,
  0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE1, 0xE0, 0x70, 0x78, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1E, 0x01, 0xC7, 0x80,
  0x79, 0xE0, 0x1E, 0x70, 0x07, 0xBC, 0x00, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF,
  0xFF, 0xB8, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0xF3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xFE, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x00,
  0x70, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x02, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x02, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0xC7, 0x07, 0xCE, 0x07, 0x9C, 0x07, 0xB8, 0x0F, 0x70, 0x0E,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0x70, 0x1E, 0xE0, 0x3D, 0xC0, 0xF3, 0x83, 0xE7, 0xFF, 0x8F, 0xFE,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEE, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEE, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0xFC, 0xF3, 0xE0,
  0x27, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0xFE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x78, 0x0E, 0xF0,
  0x1C, 0xF0, 0x39, 0xF0, 0x71, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x80, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xD0, 0x3F, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0xF0,
  0x3E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3,
  0xC0, 0xF7, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xF7,
  0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7E, 0x7E, 0x76, 0x6E, 0x76,
  0x6E, 0x77, 0xEE, 0x63, 0xCE, 0x63, 0xCE, 0xE3, 0xCE, 0xE3, 0x8F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x7E, 0xE1, 0xFB, 0x87, 0xE7, 0x1F, 0x9C, 0x7E, 0x39, 0xF8, 0xE7,
  0xE1, 0xDF, 0x87, 0x7E, 0x0D, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x70, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3E, 0x7C, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x7C, 0x3C, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0x81, 0xEF,
  0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1D, 0xE0, 0x7B, 0xC1,
  0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x3E, 0x78, 0x1E, 0x70, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E,
  0x78, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0E, 0xFF, 0xC1, 0xFF, 0xE3,
  0xFF, 0xE7, 0x83, 0xCF, 0x03, 0x9E, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x3D, 0xE0, 0xF3, 0xDF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xB8, 0x3C, 0x78,
  0x78, 0x78, 0xF0, 0x71, 0xE0, 0xF3, 0xC0, 0xE7, 0x81, 0xEF, 0x01, 0xDE,
  0x03, 0xC0, 0x07, 0x80, 0x7F, 0xE3, 0xFF, 0x9F, 0x1E, 0xF0, 0x0B, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xD0,
  0x0F, 0xFF, 0xFB, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03,
  0xDF, 0xFE, 0x7F, 0xF0, 0x7F, 0x80, 0xF0, 0x03, 0xDE, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03,
  0x87, 0x00, 0xF3, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE3, 0xCE, 0xE3, 0xCE, 0xE3, 0xCE, 0x67, 0xCE, 0x67, 0xEE, 0x66, 0x6E,
  0x66, 0x6E, 0x6E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1C, 0xF0, 0x0F, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C,
  0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78,
  0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xDE, 0x01, 0xE3, 0x80, 0x70, 0xF0, 0x3C, 0x3C, 0x0F, 0x07,
  0x83, 0x81, 0xE1, 0xE0, 0x38, 0x70, 0x0F, 0x3C, 0x01, 0xCE, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0F, 0xFF, 0xFF, 0xFE, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1C, 0x38,
  0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0x70, 0x0E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x41, 0x8F, 0x1E, 0x3C, 0x70, 0x80, 0x3F,
  0xC0, 0xFF, 0xC3, 0xFF, 0x88, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC7,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x30, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF7, 0xE1, 0xFF, 0xE3,
  0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xDE, 0x0F, 0xBF, 0xFE,
  0x7F, 0xF8, 0xFF, 0xE0, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0xDF, 0x01, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x0F, 0xDC, 0x7F, 0xF3, 0xFF, 0xDF, 0x0F, 0x78, 0x1D, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x78, 0x1D, 0xF0,
  0x73, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1,
  0xE1, 0xF7, 0x81, 0xEE, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x8F, 0xFF, 0x0F, 0xFE,
  0x07, 0xFC, 0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x7C, 0x30, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xFB, 0xE0, 0xF7, 0x81, 0xEE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x7B, 0xC0, 0xF7,
  0xC1, 0xE7, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF1, 0x03, 0xE7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x30, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF,
  0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x7B, 0xC0, 0xEF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x04, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x10, 0x7F, 0xC0, 0xFF, 0x01,
  0xFC, 0x00, 0x40, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x0C, 0x00, 0x00,
  0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF6, 0x1F, 0x7F, 0xEF, 0xFC, 0x3F, 0x80,
  0x30, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x3F, 0xE0, 0xFB, 0xC1, 0xE7, 0x87, 0x8F, 0x1E,
  0x1E, 0x78, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xEF, 0x03, 0xCF, 0x07,
  0x8F, 0x0F, 0x0F, 0x1E, 0x0F, 0x3C, 0x1F, 0x78, 0x1E, 0xF0, 0x1E, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x10, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x7E, 0x7C, 0xFF, 0xFE, 0xFF,
  0xFE, 0xE3, 0x8E, 0xE3, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x3F, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E,
  0xF0, 0x7B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x1E, 0xF0,
  0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78,
  0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF,
  0xE3, 0xFF, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0x78, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0x80, 0xEF, 0x03, 0xDE, 0x0F, 0xBF,
  0xFE, 0x7F, 0xF8, 0xFF, 0xE1, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xF9, 0xE0,
  0xF7, 0x81, 0xEF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7B, 0x80, 0xF7, 0x81, 0xEF, 0x83, 0xCF, 0xFF, 0x8F, 0xFF, 0x0F,
  0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0xE7, 0xFF, 0x9E, 0x04, 0x70, 0x01,
  0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x3D, 0x00, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xE0, 0x06, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x43, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x70, 0x3D, 0xE0,
  0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38,
  0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE1, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC6, 0x67, 0xEE, 0x77, 0xEE,
  0x76, 0x6E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x3C, 0x3C, 0x3C, 0x38, 0x3C,
  0x38, 0x1C, 0xF0, 0x0F, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x38, 0x1E, 0x78,
  0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0E, 0x78, 0x1C, 0x78, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0F,
  0x70, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C,
  0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x38, 0x0E, 0x38, 0x0F, 0x78, 0x0F, 0x70,
  0x07, 0x70, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0xFC, 0x0F, 0x00,
  0xFC, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x0F, 0xF8, 0x7F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0x7F, 0x87, 0x7F, 0xFE,
  0xE1, 0xFE, 0xE0, 0xFC,
};

const GFXglyph UbuntuSansMono_Medium32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 10, 9, 18, 4, -24 },
  { 30, 16, 22, 18, 1, -22 },
  { 74, 14, 28, 18, 2, -25 },
  { 123, 16, 23, 18, 1, -23 },
  { 169, 16, 23, 18, 1, -23 },
  { 215, 4, 10, 18, 7, -24 },
  { 220, 10, 31, 18, 4, -25 },
  { 259, 10, 31, 18, 4, -25 },
  { 298, 14, 13, 18, 2, -22 },
  { 321, 14, 16, 18, 2, -17 },
  { 349, 8, 10, 18, 5, -5 },
  { 359, 8, 4, 18, 5, -11 },
  { 363, 6, 5, 18, 6, -5 },
  { 367, 14, 31, 18, 2, -25 },
  { 422, 15, 23, 18, 1, -23 },
  { 466, 14, 22, 18, 2, -22 },
  { 505, 14, 23, 18, 2, -23 },
  { 546, 14, 23, 18, 2, -23 },
  { 587, 16, 22, 18, 1, -22 },
  { 631, 14, 22, 18, 2, -22 },
  { 670, 14, 22, 18, 2, -22 },
  { 709, 14, 22, 18, 2, -22 },
  { 748, 14, 23, 18, 2, -23 },
  { 789, 14, 23, 18, 2, -23 },
  { 830, 6, 16, 18, 6, -16 },
  { 842, 8, 21, 18, 4, -16 },
  { 863, 14, 15, 18, 2, -17 },
  { 890, 14, 10, 18, 2, -14 },
  { 908, 14, 15, 18, 2, -17 },
  { 935, 12, 23, 18, 3, -23 },
  { 970, 16, 28, 18, 1, -23 },
  { 1026, 18, 22, 18, 0, -22 },
  { 1076, 14, 22, 18, 2, -22 },
  { 1115, 16, 23, 18, 1, -23 },
  { 1161, 15, 22, 18, 2, -22 },
  { 1203, 13, 22, 18, 3, -22 },
  { 1239, 13, 22, 18, 3, -22 },
  { 1275, 15, 23, 18, 1, -23 },
  { 1319, 14, 22, 18, 2, -22 },
  { 1358, 12, 22, 18, 3, -22 },
  { 1391, 13, 22, 18, 2, -22 },
  { 1427, 16, 22, 18, 2, -22 },
  { 1471, 13, 22, 18, 3, -22 },
  { 1507, 16, 22, 18, 1, -22 },
  { 1551, 14, 22, 18, 2, -22 },
  { 1590, 16, 23, 18, 1, -23 },
  { 1636, 15, 22, 18, 2, -22 },
  { 1678, 16, 29, 18, 1, -23 },
  { 1736, 15, 22, 18, 2, -22 },
  { 1778, 14, 23, 18, 2, -23 },
  { 1819, 16, 22, 18, 1, -22 },
  { 1863, 14, 22, 18, 2, -22 },
  { 1902, 18, 22, 18, 0, -22 },
  { 1952, 16, 22, 18, 1, -22 },
  { 1996, 16, 22, 18, 1, -22 },
  { 2040, 18, 22, 18, 0, -22 },
  { 2090, 14, 22, 18, 2, -22 },
  { 2129, 9, 31, 18, 5, -25 },
  { 2164, 14, 31, 18, 2, -25 },
  { 2219, 9, 31, 18, 4, -25 },
  { 2254, 16, 12, 18, 1, -22 },
  { 2278, 18, 3, 18, 0, 3 },
  { 2285, 6, 7, 18, 6, -25 },
  { 2291, 14, 17, 18, 2, -17 },
  { 2321, 15, 25, 18, 2, -25 },
  { 2368, 14, 17, 18, 2, -17 },
  { 2398, 14, 25, 18, 1, -25 },
  { 2442, 15, 17, 18, 1, -17 },
  { 2474, 15, 25, 18, 2, -25 },
  { 2521, 15, 23, 18, 1, -17 },
  { 2565, 14, 25, 18, 2, -25 },
  { 2609, 14, 25, 18, 2, -25 },
  { 2653, 12, 31, 18, 2, -25 },
  { 2700, 15, 25, 18, 2, -25 },
  { 2747, 14, 25, 18, 2, -25 },
  { 2791, 16, 17, 18, 1, -17 },
  { 2825, 14, 17, 18, 2, -17 },
  { 2855, 16, 17, 18, 1, -17 },
  { 2889, 15, 23, 18, 2, -17 },
  { 2933, 15, 23, 18, 1, -17 },
  { 2977, 12, 17, 18, 4, -17 },
  { 3003, 14, 17, 18, 2, -17 },
  { 3033, 14, 22, 18, 2, -22 },
  { 3072, 14, 17, 18, 2, -17 },
  { 3102, 16, 17, 18, 1, -17 },
  { 3136, 16, 17, 18, 1, -17 },
  { 3170, 16, 17, 18, 1, -17 },
  { 3204, 16, 23, 18, 1, -17 },
  { 3250, 12, 17, 18, 3, -17 },
  { 3276, 12, 31, 18, 3, -25 },
  { 3323, 4, 31, 18, 7, -25 },
  { 3339, 13, 31, 18, 2, -25 },
  { 3390, 16, 5, 18, 1, -12 },
};

const GFXfont UbuntuSansMono_Medium32pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium32pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUSANSMONO_MEDIUM32PT7B_H_
