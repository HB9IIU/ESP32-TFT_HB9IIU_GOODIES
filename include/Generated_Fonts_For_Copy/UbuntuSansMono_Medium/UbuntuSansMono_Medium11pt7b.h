#ifndef _UBUNTUSANSMONO_MEDIUM11PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC7, 0xDD, 0x90, 0x28, 0xAF, 0xCA, 0x4B, 0xF5, 0x14, 0x21,
  0x3D, 0x0C, 0x38, 0x73, 0xF1, 0x00, 0x46, 0xAA, 0x9C, 0x28, 0xD5, 0x63,
  0x31, 0x65, 0x1C, 0x6B, 0x6C, 0x9F, 0xD4, 0x12, 0x44, 0xC8, 0xC4, 0x42,
  0x10, 0x84, 0x22, 0x11, 0x13, 0x26, 0xC0, 0x65, 0x7E, 0xCD, 0x00, 0x21,
  0x3E, 0x42, 0x10, 0x76, 0xE0, 0xF0, 0x11, 0x12, 0x22, 0x44, 0x48, 0x80,
  0x64, 0xA5, 0x7F, 0xCE, 0x5E, 0x23, 0x28, 0x42, 0x10, 0x9F, 0x64, 0x84,
  0x22, 0x22, 0x1F, 0xE9, 0x17, 0x31, 0x1F, 0x08, 0x62, 0x92, 0x4B, 0xF0,
  0x82, 0xFC, 0x8E, 0x31, 0x1F, 0x13, 0x21, 0xC9, 0x4E, 0x5E, 0xF8, 0x84,
  0x42, 0x31, 0x08, 0x64, 0xA5, 0xAF, 0x4E, 0x7E, 0x64, 0xA5, 0x3F, 0x08,
  0xDC, 0xF0, 0xF0, 0xF0, 0xF6, 0x0B, 0xB1, 0xC3, 0x80, 0xF8, 0x3E, 0x87,
  0x0E, 0x6C, 0x00, 0xE9, 0x12, 0x60, 0x46, 0x39, 0x24, 0x77, 0xA6, 0x97,
  0x52, 0x60, 0x60, 0x30, 0xC3, 0x92, 0x49, 0xE4, 0xE1, 0xE4, 0xA5, 0x6F,
  0x4E, 0x7E, 0x39, 0x94, 0x10, 0xC1, 0x04, 0x0F, 0xE5, 0xA7, 0x39, 0xCE,
  0x5C, 0xF4, 0x21, 0xEF, 0x42, 0x1F, 0xF8, 0x88, 0xF8, 0x88, 0x39, 0x94,
  0x10, 0xCD, 0x34, 0xCF, 0x9C, 0xE7, 0xFF, 0xCE, 0x73, 0xF6, 0x66, 0x66,
  0x6F, 0xF1, 0x11, 0x11, 0x1F, 0x9C, 0xA9, 0x8E, 0x5A, 0x53, 0x84, 0x21,
  0x08, 0x42, 0x1F, 0x49, 0x27, 0x5D, 0x77, 0x1C, 0x71, 0x9C, 0xF7, 0xBB,
  0xDE, 0x73, 0x31, 0x24, 0xF1, 0xC7, 0x34, 0x9E, 0xE4, 0xA7, 0x3F, 0x42,
  0x10, 0x31, 0x24, 0xF1, 0xC7, 0x34, 0x9E, 0x10, 0x70, 0xE5, 0xA5, 0x2F,
  0x5A, 0x53, 0x74, 0xA1, 0x83, 0x0C, 0x7E, 0xFC, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x9C, 0xE7, 0x39, 0xCE, 0x5E, 0x87, 0x14, 0x92, 0x48, 0xE3, 0x0C,
  0xC7, 0x1C, 0x7D, 0x75, 0xD4, 0x92, 0xCD, 0x23, 0x8C, 0x31, 0xE4, 0xB3,
  0xC5, 0x34, 0x8E, 0x30, 0xC3, 0x0C, 0xF8, 0x8C, 0x44, 0x22, 0x1F, 0xF2,
  0x49, 0x24, 0x93, 0x80, 0x88, 0xC4, 0x46, 0x22, 0x31, 0x10, 0xF3, 0x33,
  0x33, 0x33, 0x33, 0xF0, 0x30, 0xC6, 0x93, 0xC8, 0xFC, 0xB4, 0xF1, 0x3D,
  0x9F, 0x84, 0x21, 0xE9, 0x4E, 0x72, 0xF0, 0x7E, 0x21, 0x08, 0x3C, 0x08,
  0x42, 0x74, 0xE7, 0x29, 0x78, 0x39, 0x2C, 0xFC, 0x41, 0xE0, 0x13, 0xD1,
  0xE4, 0x21, 0x08, 0x40, 0x3A, 0x73, 0x94, 0x9C, 0x2F, 0x88, 0x8F, 0x99,
  0x99, 0x90, 0x40, 0x30, 0x84, 0x21, 0x87, 0x30, 0xF1, 0x11, 0x11, 0x3E,
  0x84, 0x21, 0x3B, 0x73, 0x96, 0x98, 0xC2, 0x10, 0x84, 0x21, 0x07, 0xFB,
  0xDD, 0x75, 0xC7, 0x10, 0xF9, 0x99, 0x99, 0x31, 0x2C, 0xF3, 0x49, 0xE0,
  0xE4, 0xA7, 0x39, 0x7A, 0x10, 0x3A, 0x73, 0x94, 0xBC, 0x21, 0x7C, 0x21,
  0x08, 0x40, 0x78, 0xC3, 0x1F, 0x47, 0xD0, 0x84, 0x21, 0xE0, 0x99, 0x99,
  0x9F, 0xC5, 0x24, 0x9A, 0x30, 0xC0, 0x86, 0x1B, 0x5D, 0x69, 0x20, 0xCD,
  0xA3, 0x0C, 0x6B, 0x30, 0x4D, 0x24, 0x8A, 0x30, 0x43, 0x38, 0xF3, 0x24,
  0xCF, 0x36, 0x44, 0x4C, 0x44, 0x44, 0x30, 0xFF, 0xFF, 0xFC, 0xC6, 0x22,
  0x23, 0x22, 0x22, 0xE0, 0x76, 0x60,
};

const GFXglyph UbuntuSansMono_Medium11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 8, 6, 2, -8 },
  { 3, 4, 3, 6, 1, -8 },
  { 5, 6, 8, 6, 0, -8 },
  { 11, 5, 10, 6, 1, -9 },
  { 18, 6, 8, 6, 0, -8 },
  { 24, 6, 8, 6, 0, -8 },
  { 30, 2, 3, 6, 2, -8 },
  { 31, 4, 11, 6, 1, -9 },
  { 37, 4, 11, 6, 1, -9 },
  { 43, 5, 5, 6, 1, -8 },
  { 47, 5, 6, 6, 1, -6 },
  { 51, 2, 4, 6, 2, -2 },
  { 52, 3, 1, 6, 2, -4 },
  { 53, 2, 2, 6, 2, -2 },
  { 54, 4, 11, 6, 1, -9 },
  { 60, 5, 8, 6, 1, -8 },
  { 65, 5, 8, 6, 1, -8 },
  { 70, 5, 8, 6, 1, -8 },
  { 75, 4, 8, 6, 1, -8 },
  { 79, 6, 8, 6, 0, -8 },
  { 85, 4, 8, 6, 1, -8 },
  { 89, 5, 8, 6, 1, -8 },
  { 94, 5, 8, 6, 1, -8 },
  { 99, 5, 8, 6, 1, -8 },
  { 104, 5, 8, 6, 1, -8 },
  { 109, 2, 6, 6, 2, -6 },
  { 111, 2, 8, 6, 2, -6 },
  { 113, 5, 5, 6, 1, -6 },
  { 117, 5, 3, 6, 1, -5 },
  { 119, 5, 5, 6, 1, -6 },
  { 123, 4, 8, 6, 1, -8 },
  { 127, 6, 10, 6, 0, -8 },
  { 135, 6, 8, 6, 0, -8 },
  { 141, 5, 8, 6, 1, -8 },
  { 146, 6, 8, 6, 0, -8 },
  { 152, 5, 8, 6, 1, -8 },
  { 157, 5, 8, 6, 1, -8 },
  { 162, 4, 8, 6, 1, -8 },
  { 166, 6, 8, 6, 0, -8 },
  { 172, 5, 8, 6, 1, -8 },
  { 177, 4, 8, 6, 1, -8 },
  { 181, 4, 8, 6, 1, -8 },
  { 185, 5, 8, 6, 1, -8 },
  { 190, 5, 8, 6, 1, -8 },
  { 195, 6, 8, 6, 0, -8 },
  { 201, 5, 8, 6, 1, -8 },
  { 206, 6, 8, 6, 0, -8 },
  { 212, 5, 8, 6, 1, -8 },
  { 217, 6, 10, 6, 0, -8 },
  { 225, 5, 8, 6, 1, -8 },
  { 230, 5, 8, 6, 1, -8 },
  { 235, 6, 8, 6, 0, -8 },
  { 241, 5, 8, 6, 1, -8 },
  { 246, 6, 8, 6, 0, -8 },
  { 252, 6, 8, 6, 0, -8 },
  { 258, 6, 8, 6, 0, -8 },
  { 264, 6, 8, 6, 0, -8 },
  { 270, 5, 8, 6, 1, -8 },
  { 275, 3, 11, 6, 2, -9 },
  { 280, 4, 11, 6, 1, -9 },
  { 286, 4, 11, 6, 1, -9 },
  { 292, 6, 5, 6, 0, -8 },
  { 296, 6, 1, 6, 0, 1 },
  { 297, 2, 3, 6, 2, -9 },
  { 298, 4, 6, 6, 1, -6 },
  { 301, 5, 9, 6, 1, -9 },
  { 307, 5, 6, 6, 1, -6 },
  { 311, 5, 9, 6, 0, -9 },
  { 317, 6, 6, 6, 0, -6 },
  { 322, 5, 9, 6, 1, -9 },
  { 328, 5, 8, 6, 0, -6 },
  { 333, 4, 9, 6, 1, -9 },
  { 338, 5, 8, 6, 1, -8 },
  { 343, 4, 10, 6, 1, -8 },
  { 348, 5, 9, 6, 1, -9 },
  { 354, 5, 8, 6, 1, -8 },
  { 359, 6, 6, 6, 0, -6 },
  { 364, 4, 6, 6, 1, -6 },
  { 367, 6, 6, 6, 0, -6 },
  { 372, 5, 8, 6, 1, -6 },
  { 377, 5, 8, 6, 0, -6 },
  { 382, 5, 6, 6, 1, -6 },
  { 386, 4, 6, 6, 1, -6 },
  { 389, 5, 7, 6, 1, -7 },
  { 394, 4, 6, 6, 1, -6 },
  { 397, 6, 6, 6, 0, -6 },
  { 402, 6, 6, 6, 0, -6 },
  { 407, 6, 6, 6, 0, -6 },
  { 412, 6, 8, 6, 0, -6 },
  { 418, 4, 6, 6, 1, -6 },
  { 421, 4, 11, 6, 1, -9 },
  { 427, 2, 11, 6, 2, -9 },
  { 430, 4, 11, 6, 1, -9 },
  { 436, 6, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_Medium11pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium11pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUSANSMONO_MEDIUM11PT7B_H_
