#ifndef _UBUNTUSANSMONO_MEDIUM21PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium21pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0xEF, 0xE0, 0xCF, 0x3C, 0xF3,
  0xCF, 0x30, 0x19, 0x86, 0x61, 0x98, 0x66, 0xFF, 0xFF, 0xF3, 0x30, 0xCC,
  0x33, 0x3F, 0xFF, 0xFD, 0x98, 0x66, 0x19, 0x8C, 0x60, 0x0C, 0x03, 0x03,
  0xF9, 0xFE, 0x60, 0xB8, 0x0E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x38, 0x07,
  0x01, 0xD8, 0xEF, 0xF8, 0xF8, 0x0C, 0x03, 0x00, 0x30, 0x2F, 0x0F, 0x23,
  0x66, 0x4C, 0x98, 0x96, 0x1E, 0xC0, 0x30, 0x0D, 0xC1, 0xBC, 0x6C, 0x89,
  0x93, 0x32, 0xC6, 0xF8, 0x78, 0x1C, 0x1F, 0x86, 0x71, 0x8C, 0x66, 0x19,
  0x83, 0xC0, 0xE2, 0x7D, 0xB3, 0xEC, 0x7B, 0x0E, 0xC3, 0xBF, 0xF7, 0xCC,
  0xFF, 0xFC, 0x02, 0x0C, 0x38, 0xE3, 0x86, 0x1C, 0x30, 0x60, 0xC3, 0x83,
  0x06, 0x0C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x70, 0x20, 0x41, 0xC1, 0xC1,
  0xC1, 0xC1, 0x83, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x1C,
  0x30, 0xC7, 0x04, 0x00, 0x0C, 0x03, 0x08, 0xC9, 0xB6, 0xFF, 0xC3, 0x01,
  0xE1, 0xCE, 0x33, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x11, 0xDE, 0x71, 0x9B, 0x80, 0xFF, 0xF0,
  0x4F, 0xFE, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x1C,
  0x00, 0x1E, 0x0F, 0xC7, 0x39, 0x86, 0xE1, 0xB0, 0x7C, 0xDF, 0x33, 0xCC,
  0xF0, 0x7C, 0x1F, 0x86, 0x63, 0x9F, 0xC3, 0xE0, 0x0C, 0x0E, 0x1F, 0x1F,
  0x8D, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF,
  0xFE, 0x3E, 0x1F, 0xCE, 0x39, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0x60, 0x1F, 0xFF, 0xFC, 0x3E, 0x7F, 0x90, 0xE0,
  0x70, 0x38, 0x1C, 0x7C, 0x3E, 0x07, 0x80, 0xC0, 0x60, 0x30, 0x3F, 0xFF,
  0xFC, 0x03, 0x01, 0xC0, 0xF0, 0x3C, 0x1B, 0x0C, 0xC3, 0x31, 0x8C, 0xC3,
  0x3F, 0xFF, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x3F, 0x9F, 0xCC, 0x06,
  0x03, 0x03, 0x81, 0xF8, 0xFE, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x3B, 0xFF,
  0xF8, 0x01, 0x83, 0xE1, 0xE0, 0xE0, 0x70, 0x18, 0x0F, 0xF3, 0xFE, 0xE1,
  0xB8, 0x7E, 0x1F, 0x87, 0x61, 0x9F, 0xE3, 0xF0, 0xFF, 0xFF, 0xF0, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x03, 0x80, 0x1E, 0x1F, 0xC6, 0x3B, 0x86, 0xE1, 0x98, 0x67, 0xB0,
  0xF8, 0x77, 0x98, 0x6C, 0x1F, 0x07, 0xE1, 0xDF, 0xE3, 0xF0, 0x1E, 0x1F,
  0xC6, 0x3B, 0x86, 0xC1, 0xB8, 0x7E, 0x1D, 0xEF, 0x3F, 0x80, 0x60, 0x38,
  0x0C, 0x0F, 0x1F, 0x87, 0x80, 0x4F, 0xFE, 0x00, 0x04, 0xFF, 0xE0, 0x23,
  0xDE, 0xE0, 0x00, 0x04, 0x7B, 0xDE, 0x27, 0x70, 0x00, 0x80, 0xF0, 0xF9,
  0xF0, 0xF0, 0x3C, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x20, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x40, 0x3C, 0x07, 0xC0, 0x7E, 0x03, 0xC0,
  0xF1, 0xF9, 0xF0, 0xF0, 0x10, 0x00, 0x7C, 0xFE, 0x87, 0x07, 0x07, 0x06,
  0x0C, 0x18, 0x38, 0x30, 0x00, 0x00, 0x38, 0x38, 0x38, 0x0E, 0x0F, 0xE7,
  0x19, 0x83, 0xC0, 0xF1, 0xFC, 0xFF, 0x73, 0xD8, 0xF6, 0x3D, 0x8F, 0x73,
  0xCF, 0xF1, 0xF6, 0x01, 0xC0, 0x3F, 0x83, 0xE0, 0x06, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1B, 0x81, 0x98, 0x19, 0x83, 0x1C, 0x30, 0xC3, 0xFC, 0x7F,
  0xC6, 0x0E, 0x60, 0x66, 0x06, 0xE0, 0x70, 0x7C, 0x3F, 0xCE, 0x3B, 0x86,
  0xE1, 0xB8, 0xEF, 0xF3, 0xFC, 0xE3, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xBF,
  0xEF, 0xF0, 0x0F, 0x0F, 0xF7, 0x89, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0E, 0x03, 0x80, 0x70, 0x4F, 0xF1, 0xFC, 0x78, 0x3F, 0xCE,
  0x7B, 0x8E, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x86,
  0xE3, 0xBF, 0xCF, 0xE0, 0xFF, 0x7F, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0xFD,
  0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x0F, 0x0F, 0xF7, 0x89, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC1, 0xF0,
  0x7E, 0x1F, 0x87, 0x71, 0xCF, 0xF1, 0xFC, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1C, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3F, 0x9F, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x34, 0x3F, 0xF9, 0xF8, 0xE1, 0xDC,
  0x33, 0x8E, 0x73, 0x8E, 0x61, 0xD8, 0x3F, 0x07, 0xC0, 0xFC, 0x1D, 0xC3,
  0x9C, 0x71, 0xCE, 0x19, 0xC3, 0xB8, 0x38, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE,
  0x61, 0x98, 0x6E, 0x3B, 0xCE, 0xF2, 0xF5, 0xBD, 0xEF, 0x73, 0xCC, 0xF3,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xC1, 0xF8, 0x7E, 0x1F, 0xC7,
  0xF9, 0xF6, 0x7C, 0xDF, 0x37, 0xC5, 0xF1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0,
  0x7C, 0x1C, 0x1E, 0x1F, 0xC7, 0x3B, 0x86, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1F, 0x87, 0x61, 0x9F, 0xE3, 0xF0, 0xF8, 0x7F, 0x31,
  0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8E, 0xFF, 0x7E, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x1E, 0x0F, 0xC7, 0x3B, 0x86, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x87, 0xE1, 0x9F, 0xE3, 0xF0, 0x30, 0x0E, 0x01,
  0xF0, 0x18, 0x7C, 0x3F, 0xCE, 0x7B, 0x86, 0xE1, 0xB8, 0x6E, 0x3B, 0xFE,
  0xFF, 0x39, 0x8E, 0x73, 0x8C, 0xE1, 0xB8, 0x6E, 0x1C, 0x1F, 0x1F, 0xE7,
  0x11, 0x80, 0xE0, 0x18, 0x07, 0x80, 0xFC, 0x0F, 0x80, 0xE0, 0x1C, 0x07,
  0x81, 0xBF, 0xE7, 0xF0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x87, 0xE1, 0x9F, 0xE3, 0xF0, 0xE0, 0x6C, 0x0D, 0x81, 0xB0, 0x77,
  0x0E, 0x61, 0x8C, 0x31, 0x8E, 0x39, 0x83, 0x30, 0x66, 0x0F, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0xCF,
  0x73, 0xDE, 0xF5, 0xBD, 0x2F, 0xCE, 0xE3, 0xB8, 0x66, 0x18, 0x60, 0x6E,
  0x1C, 0xC3, 0x1C, 0xC1, 0xB8, 0x3E, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xF0,
  0x66, 0x1C, 0xE3, 0x0C, 0xE1, 0xF8, 0x18, 0xE0, 0x6C, 0x0D, 0xC3, 0x98,
  0x63, 0x1C, 0x33, 0x06, 0xE0, 0x78, 0x0F, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x7F, 0xDF, 0xF0, 0x18, 0x0E, 0x07, 0x01, 0x80,
  0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0xFF,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0F, 0xFF, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x1C,
  0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0xFC, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x7F, 0xFF, 0x0C, 0x07, 0x81, 0xE0, 0xFC, 0x33, 0x1C, 0xEE,
  0x1B, 0x07, 0x40, 0x80, 0xFF, 0xFF, 0xFF, 0xCE, 0x71, 0x7F, 0x1F, 0xC0,
  0x60, 0x31, 0xFB, 0xFF, 0x87, 0xC3, 0xE1, 0xBF, 0xCF, 0xE0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0xF3, 0xFD, 0x86, 0xC3, 0xE1, 0xF0, 0x78, 0x7C,
  0x3E, 0x1B, 0xFD, 0xFC, 0x1F, 0xCF, 0xE7, 0x03, 0x80, 0xE0, 0x30, 0x0E,
  0x03, 0x80, 0x70, 0x1F, 0xF1, 0xFC, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x19,
  0xFD, 0xFF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0D, 0xFE, 0x7F,
  0x3F, 0x1F, 0xE6, 0x1B, 0x87, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x1F,
  0xE3, 0xF8, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x3F, 0xEF, 0xF8, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x3F, 0xBF,
  0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0x7F, 0xBF, 0xC0, 0x60, 0x38,
  0x3F, 0xF9, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFF, 0xC7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x18, 0x0F, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0xFC, 0x3F, 0x07, 0x07, 0x07, 0x00, 0x00, 0x7F, 0x7F, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x47, 0x7E, 0xFC, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x1F, 0x1D, 0x9C, 0xDC, 0x7C, 0x3E, 0x1B,
  0x8C, 0xE6, 0x3B, 0x0D, 0x87, 0xFC, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xFC,
  0x3F, 0xFF, 0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x03, 0xC0,
  0xF0, 0x3C, 0x0C, 0xFE, 0xFF, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x3F, 0x1F, 0xEE, 0x1B, 0x87, 0xC1, 0xF0, 0x3C, 0x1F, 0x87,
  0xE1, 0x9F, 0xE3, 0xF0, 0xFE, 0x7F, 0xB1, 0xD8, 0x7C, 0x3E, 0x0F, 0x0F,
  0x87, 0xC3, 0x7F, 0xBF, 0x98, 0x0C, 0x06, 0x03, 0x00, 0x3F, 0xBF, 0xF8,
  0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xBF, 0xCF, 0xE0, 0x30, 0x18,
  0x0C, 0x06, 0x7F, 0xFF, 0xB8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x00, 0x3F, 0xBF, 0xD8, 0x0C, 0x07, 0x81, 0xF8, 0x1E, 0x03,
  0x81, 0xBF, 0xFF, 0xC0, 0x18, 0x06, 0x01, 0x83, 0xFF, 0xFF, 0xC6, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xC3, 0xF0, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x7F, 0xC0, 0xF0, 0x7E,
  0x19, 0x86, 0x63, 0x9C, 0xC3, 0x30, 0xF8, 0x1E, 0x07, 0x80, 0xC0, 0xE0,
  0x6C, 0x0D, 0x99, 0xB3, 0x36, 0x66, 0xDE, 0xDB, 0xDB, 0x4A, 0x39, 0xC6,
  0x38, 0xC3, 0x00, 0xE1, 0xD8, 0xE3, 0x30, 0xFC, 0x1E, 0x07, 0x81, 0xE0,
  0xDC, 0x73, 0xB8, 0x6C, 0x1C, 0xE1, 0xF8, 0x76, 0x19, 0x86, 0x73, 0x8C,
  0xC3, 0xB0, 0x6C, 0x1E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x3E, 0x0F, 0x00,
  0xFF, 0xFF, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xE0, 0xFF, 0xFF, 0x1F,
  0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0xE0, 0xF0, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x38, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0C, 0x07, 0x0F, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xF8, 0xF0, 0x78, 0xFF, 0x3C, 0xF9,
  0x0C,
};

const GFXglyph UbuntuSansMono_Medium21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 6, 6, 12, 3, -16 },
  { 14, 10, 15, 12, 1, -15 },
  { 33, 10, 18, 12, 1, -16 },
  { 56, 11, 15, 12, 0, -15 },
  { 77, 10, 15, 12, 1, -15 },
  { 96, 2, 7, 12, 5, -16 },
  { 98, 7, 21, 12, 2, -17 },
  { 117, 7, 21, 12, 2, -17 },
  { 136, 10, 9, 12, 1, -15 },
  { 148, 10, 10, 12, 1, -11 },
  { 161, 5, 7, 12, 3, -4 },
  { 166, 6, 2, 12, 3, -7 },
  { 168, 4, 4, 12, 4, -4 },
  { 170, 9, 20, 12, 1, -16 },
  { 193, 10, 15, 12, 1, -15 },
  { 212, 9, 15, 12, 2, -15 },
  { 229, 10, 15, 12, 1, -15 },
  { 248, 9, 15, 12, 1, -15 },
  { 265, 10, 15, 12, 1, -15 },
  { 284, 9, 15, 12, 1, -15 },
  { 301, 10, 15, 12, 1, -15 },
  { 320, 10, 15, 12, 1, -15 },
  { 339, 10, 15, 12, 1, -15 },
  { 358, 10, 15, 12, 1, -15 },
  { 377, 4, 11, 12, 4, -11 },
  { 383, 5, 14, 12, 3, -11 },
  { 392, 10, 10, 12, 1, -11 },
  { 405, 10, 6, 12, 1, -9 },
  { 413, 10, 10, 12, 1, -11 },
  { 426, 8, 15, 12, 2, -15 },
  { 441, 10, 18, 12, 1, -15 },
  { 464, 12, 15, 12, 0, -15 },
  { 487, 10, 15, 12, 1, -15 },
  { 506, 10, 15, 12, 1, -15 },
  { 525, 10, 15, 12, 1, -15 },
  { 544, 9, 15, 12, 2, -15 },
  { 561, 8, 15, 12, 2, -15 },
  { 576, 10, 15, 12, 1, -15 },
  { 595, 10, 15, 12, 1, -15 },
  { 614, 8, 15, 12, 2, -15 },
  { 629, 9, 15, 12, 1, -15 },
  { 646, 11, 15, 12, 1, -15 },
  { 667, 9, 15, 12, 2, -15 },
  { 684, 10, 15, 12, 1, -15 },
  { 703, 10, 15, 12, 1, -15 },
  { 722, 10, 15, 12, 1, -15 },
  { 741, 9, 15, 12, 2, -15 },
  { 758, 10, 19, 12, 1, -15 },
  { 782, 10, 15, 12, 1, -15 },
  { 801, 10, 15, 12, 1, -15 },
  { 820, 10, 15, 12, 1, -15 },
  { 839, 10, 15, 12, 1, -15 },
  { 858, 11, 15, 12, 0, -15 },
  { 879, 10, 15, 12, 1, -15 },
  { 898, 11, 15, 12, 0, -15 },
  { 919, 11, 15, 12, 0, -15 },
  { 940, 10, 15, 12, 1, -15 },
  { 959, 6, 20, 12, 3, -16 },
  { 974, 9, 20, 12, 1, -16 },
  { 997, 6, 20, 12, 3, -16 },
  { 1012, 10, 9, 12, 1, -15 },
  { 1024, 12, 2, 12, 0, 2 },
  { 1027, 4, 4, 12, 4, -16 },
  { 1029, 9, 11, 12, 1, -11 },
  { 1042, 9, 16, 12, 2, -16 },
  { 1060, 10, 11, 12, 1, -11 },
  { 1074, 9, 16, 12, 1, -16 },
  { 1092, 10, 11, 12, 1, -11 },
  { 1106, 10, 16, 12, 1, -16 },
  { 1126, 9, 15, 12, 1, -11 },
  { 1143, 8, 16, 12, 2, -16 },
  { 1159, 10, 16, 12, 1, -16 },
  { 1179, 8, 20, 12, 1, -16 },
  { 1199, 9, 16, 12, 2, -16 },
  { 1217, 10, 16, 12, 1, -16 },
  { 1237, 10, 11, 12, 1, -11 },
  { 1251, 8, 11, 12, 2, -11 },
  { 1262, 10, 11, 12, 1, -11 },
  { 1276, 9, 15, 12, 2, -11 },
  { 1293, 9, 15, 12, 1, -11 },
  { 1310, 9, 11, 12, 2, -11 },
  { 1323, 9, 11, 12, 1, -11 },
  { 1336, 10, 14, 12, 1, -14 },
  { 1354, 8, 11, 12, 2, -11 },
  { 1365, 10, 11, 12, 1, -11 },
  { 1379, 11, 11, 12, 0, -11 },
  { 1395, 10, 11, 12, 1, -11 },
  { 1409, 10, 15, 12, 1, -11 },
  { 1428, 8, 11, 12, 2, -11 },
  { 1439, 8, 20, 12, 2, -16 },
  { 1459, 2, 20, 12, 5, -16 },
  { 1464, 8, 20, 12, 2, -16 },
  { 1484, 10, 4, 12, 1, -8 },
};

const GFXfont UbuntuSansMono_Medium21pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium21pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UBUNTUSANSMONO_MEDIUM21PT7B_H_
