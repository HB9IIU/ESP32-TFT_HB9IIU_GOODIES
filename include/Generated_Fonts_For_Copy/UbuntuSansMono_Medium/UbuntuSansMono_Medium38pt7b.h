#ifndef _UBUNTUSANSMONO_MEDIUM38PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xC7, 0x8E, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x8F, 0x9F, 0xFF, 0x7E, 0xF8,
  0x40, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xEF, 0x1E, 0xF0, 0xEF,
  0x0E, 0xE0, 0xEE, 0x0E, 0x60, 0xE0, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F,
  0x0E, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFC,
  0x1E, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x80, 0x1F, 0x78,
  0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0x87, 0xFF, 0x80, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x17, 0xF0, 0x0E,
  0xFF, 0x01, 0xCE, 0x78, 0x3C, 0xE3, 0x83, 0x8E, 0x38, 0x78, 0xE3, 0x87,
  0x0E, 0x38, 0xE0, 0xE3, 0x9E, 0x0E, 0x39, 0xC0, 0xF7, 0x38, 0x07, 0xF7,
  0x80, 0x3E, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE3, 0x00, 0x1C, 0xFC, 0x03,
  0xDF, 0xE0, 0x39, 0xCE, 0x07, 0x3C, 0xE0, 0xF3, 0x87, 0x0E, 0x38, 0x71,
  0xC3, 0x87, 0x3C, 0x38, 0x73, 0x81, 0xCE, 0x78, 0x1C, 0xE7, 0x01, 0xFE,
  0xE0, 0x0F, 0xC0, 0x00, 0x20, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0,
  0x3C, 0x3C, 0x07, 0xCF, 0x80, 0x7B, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x87, 0x87, 0xF0, 0xF1, 0xEF, 0x1E, 0x79, 0xF3, 0xCF, 0x1F, 0x73,
  0xC1, 0xFE, 0x78, 0x1F, 0xCF, 0x01, 0xF1, 0xE0, 0x1E, 0x3E, 0x07, 0xE3,
  0xE1, 0xFE, 0x7F, 0xFF, 0xC7, 0xFE, 0x7C, 0x3F, 0x87, 0x80, 0xFF, 0xFF,
  0xFF, 0xBD, 0xEF, 0x73, 0x9C, 0xE0, 0x00, 0x20, 0x03, 0x80, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xE0, 0x02, 0x00, 0x20, 0x03, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x3F, 0x00, 0xF0, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x08, 0x38, 0x27, 0x9C, 0x73, 0xEE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0x01, 0xC0, 0x01, 0xF8, 0x01, 0xDE, 0x01, 0xEF, 0x81, 0xF3, 0xE1,
  0xF1, 0xF0, 0x30, 0x60, 0x08, 0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1F,
  0x1F, 0x8F, 0xE7, 0xF3, 0xF8, 0xFC, 0x1C, 0x1E, 0x1E, 0x7F, 0x3E, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C,
  0x1F, 0x1F, 0x03, 0xC7, 0x80, 0xFB, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x7B, 0xC7, 0x1E, 0xF3, 0xE7, 0xBC, 0xF9, 0xFF, 0x3E, 0x7B,
  0xC7, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0x78,
  0x07, 0x9E, 0x03, 0xC7, 0xC1, 0xF0, 0xF8, 0xFC, 0x3F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0x80, 0x02, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x1F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xF9, 0xE0, 0x61, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x0F,
  0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xC7, 0x83, 0xF1, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC3, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0xE0, 0x7E, 0x7F, 0xFE,
  0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF9, 0xC0, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x3F, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xFB, 0xF0, 0x7D, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xF0, 0x3E, 0x7C, 0x3E, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7,
  0xC1, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07,
  0x9F, 0x07, 0xC7, 0xE7, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xF8, 0x78,
  0xFE, 0x78, 0x1F, 0x3C, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x3E, 0xF8, 0x3F, 0x7F, 0xFF, 0x1F, 0xFF, 0x03, 0xFF,
  0x00, 0x10, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC7,
  0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0x7B, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x07, 0xEF, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0x80,
  0x00, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x9F, 0xFF, 0xFE, 0xFD, 0xF0, 0x1F, 0x0F, 0xCF, 0xE7, 0xF1, 0xF8,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7E, 0x7F,
  0x3F, 0x8F, 0xC7, 0xE0, 0xF0, 0x70, 0xFB, 0xF9, 0xF8, 0x70, 0x00, 0x00,
  0x00, 0x80, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7E, 0x00,
  0x07, 0x80, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x1C, 0x00, 0x0F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xE1, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE6, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xC7, 0xC1, 0xE0, 0x3C, 0x78, 0x03, 0x8F, 0x00, 0x79, 0xC0, 0x0F, 0x78,
  0x05, 0xEF, 0x07, 0xFD, 0xC3, 0xFF, 0xB8, 0x7F, 0xF7, 0x1F, 0x1F, 0xE3,
  0xC3, 0xFC, 0x78, 0x7F, 0x8E, 0x0F, 0xF1, 0xC1, 0xFE, 0x38, 0x3F, 0xC7,
  0x87, 0xF8, 0xF0, 0xF7, 0x1E, 0x1E, 0xE3, 0xE3, 0xDE, 0x3F, 0xFB, 0xC3,
  0xFF, 0x38, 0x3F, 0xE7, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1D, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x01, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF9, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x3F, 0x3E, 0x07, 0xCF, 0x80, 0xF3,
  0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xE3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0xBE, 0x01,
  0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0xFB,
  0xE1, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x01, 0x8F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x08, 0xFE, 0x0E, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x80,
  0x1E, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xF8, 0x7E, 0x3E,
  0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x0F, 0xBE,
  0x07, 0xCF, 0x83, 0xF3, 0xE7, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xF0, 0x19,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x3C,
  0xF8, 0x1E, 0x7E, 0x0F, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x04,
  0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x60, 0x1F, 0x78, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC,
  0x3F, 0xF0, 0x01, 0x00, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0x80, 0xF9,
  0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE1,
  0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7C, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x07,
  0x87, 0x80, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xE7, 0xE0, 0xFC, 0xEE, 0x1F,
  0x9D, 0xC7, 0x73, 0xB8, 0xEE, 0x73, 0x1D, 0xCE, 0x77, 0x39, 0xCE, 0xE7,
  0x39, 0xDC, 0xE7, 0x1F, 0x1C, 0xE3, 0xE3, 0xDC, 0x7C, 0x7B, 0x87, 0x8F,
  0x70, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3C,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xEE, 0x0F, 0xF7, 0x87, 0xF9, 0xC3, 0xFC, 0xF1, 0xFE,
  0x38, 0xFF, 0x1E, 0x7F, 0x87, 0x3F, 0xC3, 0xDF, 0xE0, 0xEF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xE0, 0xF8, 0x78, 0x0F, 0x9F, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0xF8, 0x0F,
  0x8F, 0x01, 0xF1, 0xF8, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x60, 0x00, 0x1F, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF,
  0x03, 0xF7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x01, 0xF7, 0x83, 0xFB, 0xFF, 0xF9, 0xFF,
  0xF8, 0xFF, 0xF0, 0x7F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xE0,
  0xF8, 0x78, 0x0F, 0x9F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01,
  0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F, 0x01, 0xF1, 0xF8, 0x7C, 0x1F, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x0F, 0x80,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x3F, 0x3E, 0x07, 0xCF,
  0x80, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF3, 0xE0,
  0x3C, 0xF8, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3E, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0xF8, 0x1E, 0x3E, 0x07, 0x8F,
  0x80, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7C, 0x03,
  0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0xC0, 0x23, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3D, 0x00, 0x3E,
  0xF0, 0x3E, 0xFF, 0xFF, 0x7F, 0xFF, 0x0F, 0xFF, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x7D,
  0xF8, 0x7C, 0x7F, 0xFE, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x20, 0x00, 0xF0,
  0x01, 0xFF, 0x00, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0x78, 0x03, 0xE7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x78,
  0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0E, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x7B,
  0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0x80, 0x0F, 0x70,
  0x01, 0xEE, 0x1C, 0x3D, 0xC3, 0xC7, 0xB8, 0xF8, 0xE7, 0x1F, 0x1C, 0xE3,
  0xF3, 0x9C, 0xEE, 0x73, 0x9D, 0xCE, 0x73, 0x9D, 0xCE, 0xE3, 0xB9, 0xDC,
  0x77, 0x3B, 0x86, 0xE7, 0x60, 0xFC, 0xFC, 0x1F, 0x8F, 0x81, 0xF1, 0xE0,
  0x3E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF8, 0x03, 0xEF, 0x80, 0x78, 0xF0,
  0x1E, 0x1F, 0x03, 0xC1, 0xE0, 0xF0, 0x3E, 0x1E, 0x03, 0xC7, 0x80, 0x3D,
  0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01, 0xE3,
  0xC0, 0x7C, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xF8, 0x78, 0x0F, 0x1F, 0x01,
  0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x3C, 0xF0, 0x01, 0xFF, 0x80,
  0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x3E,
  0x07, 0x81, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x9E, 0x00,
  0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x87, 0xC0,
  0xF0, 0xF0, 0x1F, 0x3E, 0x01, 0xEF, 0x80, 0x3E, 0x60, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x70,
  0xF8, 0x7C, 0x3F, 0x0E, 0x04, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x0F, 0xFF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0x7C, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0,
  0x08, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3D, 0xFC, 0x1F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xF3, 0xF3, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0, 0x0F,
  0x78, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x1F, 0x9F, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE7, 0xF8,
  0xE7, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x81, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x00, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xFF, 0xE1, 0xFF,
  0xF1, 0xFF, 0xF9, 0xFD, 0xFC, 0xF8, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x7C, 0x07, 0x9F, 0x03, 0xCF, 0xE1, 0xE3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0x7C,
  0x7C, 0x0F, 0xBE, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7F, 0x87, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x60, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x1F,
  0xFF, 0x3F, 0xFF, 0x7E, 0x1F, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xEF, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x40, 0x1F, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xF8, 0x3F, 0xE0, 0x08, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFE, 0xFE, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF8, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0x7F, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x90,
  0x1E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x0F, 0xF0, 0x08, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07, 0xFE, 0x03, 0xEF, 0x03, 0xE7,
  0x83, 0xE3, 0xC3, 0xE1, 0xE3, 0xE0, 0xF3, 0xE0, 0x7B, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xBF, 0x03, 0xCF, 0xC1, 0xE3, 0xF0, 0xF0,
  0xF8, 0x78, 0x3E, 0x3C, 0x0F, 0x9E, 0x03, 0xEF, 0x00, 0xFF, 0x80, 0x7C,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF9, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x3E, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xCF, 0x9E, 0xE3,
  0xC3, 0xF8, 0x70, 0xFE, 0x1E, 0x3F, 0x87, 0x8F, 0xE1, 0xE3, 0xF8, 0x78,
  0xFE, 0x1E, 0x3F, 0x87, 0x8F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0x7F,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFC, 0xFE, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFC, 0xFC,
  0x7C, 0x0F, 0xBE, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x80,
  0xF9, 0xF0, 0x3E, 0x7E, 0x3F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0x1F, 0xCF,
  0x03, 0xF7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x3E, 0xFC, 0x7E, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0x9F, 0x7C, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x7E, 0x3F, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x3F,
  0xFE, 0x7F, 0xFC, 0xFC, 0x1C, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00,
  0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F,
  0xF0, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7E, 0x18, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x7E, 0x1E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7,
  0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xF0, 0x3C, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0x7C, 0x7C, 0x07, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E,
  0xF0, 0xE0, 0xEF, 0x0F, 0x1E, 0xF0, 0xF1, 0xE7, 0x1F, 0x1E, 0x71, 0xF1,
  0xE7, 0x1F, 0x9C, 0x73, 0xB9, 0xC7, 0x3B, 0x9C, 0x7B, 0xBD, 0xC7, 0xF1,
  0xDC, 0x3F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x07, 0x81, 0xC0, 0x78, 0xF8, 0x03, 0xEF, 0x80, 0xF8, 0xF8, 0x1E, 0x0F,
  0x07, 0x80, 0xF1, 0xF0, 0x1F, 0x3C, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0x3C, 0x03, 0xC7, 0xC0, 0xF0, 0x7C, 0x3E, 0x07, 0x87, 0x80, 0xF9, 0xE0,
  0x0F, 0x7C, 0x01, 0xF0, 0x78, 0x03, 0xEF, 0x80, 0x79, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1F,
  0x0F, 0x01, 0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F,
  0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x03, 0x7F,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x83, 0xFF, 0x07, 0xFC, 0x0F,
  0xE0, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x1C, 0xFF, 0x87, 0xBF, 0xFF, 0xF7,
  0x9F, 0xFD, 0xE0, 0xFF, 0x18, 0x07, 0xC0,
};

const GFXglyph UbuntuSansMono_Medium38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 27, 21, 7, -26 },
  { 25, 12, 11, 21, 5, -29 },
  { 42, 19, 26, 21, 1, -26 },
  { 104, 17, 33, 21, 2, -29 },
  { 175, 20, 28, 21, 1, -27 },
  { 245, 19, 27, 21, 1, -27 },
  { 310, 5, 12, 21, 8, -29 },
  { 318, 13, 37, 21, 4, -30 },
  { 379, 13, 37, 21, 4, -30 },
  { 440, 17, 16, 21, 2, -26 },
  { 474, 17, 19, 21, 2, -21 },
  { 515, 9, 12, 21, 6, -6 },
  { 529, 10, 4, 21, 6, -13 },
  { 534, 7, 6, 21, 7, -6 },
  { 540, 16, 37, 21, 3, -30 },
  { 614, 18, 28, 21, 2, -27 },
  { 677, 16, 26, 21, 3, -26 },
  { 729, 17, 27, 21, 2, -27 },
  { 787, 17, 28, 21, 2, -27 },
  { 847, 19, 26, 21, 1, -26 },
  { 909, 17, 27, 21, 2, -26 },
  { 967, 17, 28, 21, 2, -27 },
  { 1027, 17, 26, 21, 2, -26 },
  { 1083, 17, 28, 21, 2, -27 },
  { 1143, 17, 27, 21, 2, -27 },
  { 1201, 7, 19, 21, 7, -19 },
  { 1218, 9, 25, 21, 5, -19 },
  { 1247, 18, 18, 21, 2, -20 },
  { 1288, 17, 12, 21, 2, -17 },
  { 1314, 18, 18, 21, 2, -20 },
  { 1355, 15, 28, 21, 3, -27 },
  { 1408, 19, 33, 21, 1, -27 },
  { 1487, 21, 26, 21, 0, -26 },
  { 1556, 18, 27, 21, 2, -27 },
  { 1617, 18, 28, 21, 2, -27 },
  { 1680, 18, 27, 21, 2, -27 },
  { 1741, 17, 26, 21, 3, -26 },
  { 1797, 16, 26, 21, 3, -26 },
  { 1849, 17, 28, 21, 2, -27 },
  { 1909, 17, 26, 21, 2, -26 },
  { 1965, 15, 26, 21, 3, -26 },
  { 2014, 16, 27, 21, 2, -26 },
  { 2068, 19, 26, 21, 2, -26 },
  { 2130, 16, 26, 21, 4, -26 },
  { 2182, 19, 26, 21, 1, -26 },
  { 2244, 17, 26, 21, 2, -26 },
  { 2300, 19, 28, 21, 1, -27 },
  { 2367, 17, 27, 21, 3, -27 },
  { 2425, 19, 34, 21, 1, -27 },
  { 2506, 18, 27, 21, 2, -27 },
  { 2567, 17, 28, 21, 2, -27 },
  { 2627, 19, 26, 21, 1, -26 },
  { 2689, 17, 27, 21, 2, -26 },
  { 2747, 20, 26, 21, 1, -26 },
  { 2812, 19, 26, 21, 1, -26 },
  { 2874, 19, 26, 21, 1, -26 },
  { 2936, 20, 26, 21, 1, -26 },
  { 3001, 17, 26, 21, 2, -26 },
  { 3057, 10, 37, 21, 6, -30 },
  { 3104, 16, 37, 21, 3, -30 },
  { 3178, 11, 37, 21, 5, -30 },
  { 3229, 19, 14, 21, 1, -26 },
  { 3263, 21, 4, 21, 0, 3 },
  { 3274, 8, 7, 21, 7, -29 },
  { 3281, 17, 20, 21, 2, -20 },
  { 3324, 17, 30, 21, 3, -30 },
  { 3388, 17, 20, 21, 2, -20 },
  { 3431, 17, 30, 21, 1, -30 },
  { 3495, 18, 20, 21, 2, -20 },
  { 3540, 19, 29, 21, 2, -29 },
  { 3609, 16, 27, 21, 2, -20 },
  { 3663, 16, 30, 21, 3, -30 },
  { 3723, 17, 29, 21, 2, -29 },
  { 3785, 14, 36, 21, 3, -29 },
  { 3848, 17, 30, 21, 3, -30 },
  { 3912, 17, 29, 21, 2, -29 },
  { 3974, 18, 20, 21, 2, -20 },
  { 4019, 16, 20, 21, 3, -20 },
  { 4059, 18, 21, 21, 2, -20 },
  { 4107, 17, 27, 21, 3, -20 },
  { 4165, 16, 27, 21, 2, -20 },
  { 4219, 15, 20, 21, 4, -20 },
  { 4257, 16, 20, 21, 3, -20 },
  { 4297, 18, 26, 21, 2, -26 },
  { 4356, 15, 20, 21, 3, -20 },
  { 4394, 19, 20, 21, 1, -20 },
  { 4442, 20, 20, 21, 1, -20 },
  { 4492, 19, 20, 21, 1, -20 },
  { 4540, 19, 27, 21, 1, -20 },
  { 4605, 15, 20, 21, 3, -20 },
  { 4643, 15, 37, 21, 3, -30 },
  { 4713, 4, 37, 21, 9, -30 },
  { 4732, 15, 37, 21, 3, -30 },
  { 4802, 19, 7, 21, 1, -15 },
};

const GFXfont UbuntuSansMono_Medium38pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium38pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium38pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUSANSMONO_MEDIUM38PT7B_H_
