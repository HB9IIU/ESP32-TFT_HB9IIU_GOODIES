#ifndef _UBUNTUSANSMONO_MEDIUM50PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium50pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x1E,
  0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03,
  0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3E, 0x00, 0x3C,
  0x0F, 0x80, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0x0F, 0xC3, 0xF0, 0x00, 0x87,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x20, 0x00, 0x7E, 0x70, 0x01, 0xFD,
  0xFE, 0x1F, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xCF,
  0xF0, 0x01, 0xE7, 0xFE, 0x00, 0xFB, 0xE7, 0x80, 0x3C, 0xF0, 0xF0, 0x1E,
  0x3C, 0x3C, 0x0F, 0x8F, 0x0F, 0x03, 0xC3, 0xC3, 0xC1, 0xF0, 0xF0, 0xF0,
  0x78, 0x3C, 0x3C, 0x3C, 0x0F, 0x0F, 0x1F, 0x03, 0xC3, 0xC7, 0x80, 0xF9,
  0xF3, 0xC0, 0x1F, 0xF9, 0xF0, 0x07, 0xFE, 0x78, 0x00, 0xFF, 0x3E, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE1, 0x80, 0x00, 0xF1,
  0xF8, 0x00, 0x78, 0xFF, 0x00, 0x3E, 0x7F, 0xE0, 0x0F, 0x3E, 0x7C, 0x07,
  0x8F, 0x0F, 0x03, 0xE3, 0xC3, 0xC0, 0xF0, 0xF0, 0xF0, 0x7C, 0x3C, 0x3C,
  0x1E, 0x0F, 0x0F, 0x0F, 0x03, 0xC3, 0xC7, 0xC0, 0xF0, 0xF1, 0xE0, 0x3C,
  0x3C, 0xF0, 0x0F, 0x9F, 0x7C, 0x01, 0xFF, 0x9E, 0x00, 0x7F, 0xEF, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x1C,
  0x01, 0xFE, 0x07, 0xC0, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x7C, 0x3F, 0x7F,
  0x1F, 0x0F, 0x8F, 0xE7, 0x87, 0xC1, 0xFF, 0xE1, 0xF0, 0x3F, 0xF8, 0x7C,
  0x07, 0xFC, 0x1F, 0x00, 0xFF, 0x0F, 0xC0, 0x1F, 0xC1, 0xF0, 0x07, 0xF0,
  0x7C, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x87, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x9F, 0x83, 0xFF, 0xC7, 0xE0, 0x7F, 0xC0, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x00,
  0x0C, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x0C, 0x30,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x81, 0xE0, 0x27, 0x87, 0x87, 0x9F, 0x9E, 0x7E, 0x7F, 0xBB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x7E, 0x1F,
  0x83, 0xF8, 0x7F, 0x03, 0xC0, 0xF0, 0x03, 0x03, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFE,
  0x03, 0xE0, 0x3E, 0x07, 0xC1, 0xF8, 0xFF, 0x8F, 0xF0, 0xFC, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x0F, 0xC7,
  0xF9, 0xFE, 0x7F, 0xFF, 0xF7, 0xF9, 0xFE, 0x3F, 0x01, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE7,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x18, 0x3E, 0xFC, 0x3C, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x3C, 0x3F, 0xFC, 0x18,
  0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0x7C, 0x07, 0xF3, 0xE0,
  0x1E, 0x1F, 0x00, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xBF, 0xF1, 0xF0, 0x1F, 0xC3, 0x00,
  0x3F, 0x08, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0x1F, 0xF0, 0xE0, 0x1F, 0xC2,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF9, 0x00, 0x0F, 0xE7, 0x80, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFD,
  0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x07, 0xE1,
  0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF9, 0x00, 0x0F, 0xE7, 0x80, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0xE0,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xE0, 0x3F, 0xBE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x8F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0x0F, 0xF0, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0x3F, 0xF1,
  0xF8, 0x1F, 0xE7, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F,
  0xC7, 0xE0, 0x3F, 0x9F, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7D, 0xFC, 0x03, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0x8F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x04,
  0x0F, 0xC7, 0xF9, 0xFE, 0x7F, 0xFF, 0xF7, 0xF9, 0xFE, 0x3F, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xFC,
  0x7F, 0x9F, 0xE7, 0xFF, 0xFF, 0x7F, 0x9F, 0xE3, 0xF0, 0x10, 0x01, 0x00,
  0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF3, 0xFF, 0x1F, 0xE1, 0xFE, 0x0F, 0xC0,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1,
  0xFE, 0x0F, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x1F, 0x8F, 0xF8, 0xFE, 0x0F,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7,
  0xC3, 0xFC, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x07, 0xFF, 0x78, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x7F, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xF8,
  0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8,
  0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7F, 0xFF, 0x7C, 0x3F, 0xFF, 0x7C, 0x1F,
  0xFF, 0x7C, 0x0F, 0xFF, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7E,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x3E, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0xFE, 0x3F, 0x0F, 0xF8, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xE0,
  0x7F, 0xCF, 0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x8F, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0xFE,
  0x1F, 0xE0, 0x0E, 0x1F, 0xC0, 0x02, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x02, 0x0F, 0xF8, 0x3E, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0x81, 0xFE, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x3F,
  0x3F, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFC, 0x7E, 0x1F, 0xE0, 0x0C, 0x1F, 0xC0, 0x02, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0x0F, 0xF0, 0x3F, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF4, 0x00, 0x3F, 0x38, 0x03, 0xF9, 0xF0, 0x3F, 0xDF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0xFC,
  0xFE, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x7B, 0x81, 0xDE, 0x7B, 0xC3, 0xDE, 0x7B, 0xC3,
  0xDE, 0x79, 0xC3, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x78, 0xFF, 0x1E, 0x78, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xBC, 0x07, 0xFE, 0xF8, 0x1F, 0xF9, 0xE0,
  0x7F, 0xE7, 0xC1, 0xFF, 0x8F, 0x07, 0xFE, 0x3E, 0x1F, 0xF8, 0x78, 0x7F,
  0xE1, 0xF1, 0xFF, 0x83, 0xC7, 0xFE, 0x0F, 0x9F, 0xF8, 0x1E, 0x7F, 0xE0,
  0x7D, 0xFF, 0x80, 0xF7, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x9F,
  0x00, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xE0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xE0, 0x1F, 0xEF,
  0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7E, 0xF8, 0x03, 0xFB, 0xE0, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFA, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81,
  0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0xFC,
  0x03, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xC3,
  0xF1, 0xFC, 0x00, 0xC7, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFD, 0x80, 0x07, 0xF7, 0xC0, 0x3F,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x0F,
  0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8,
  0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8,
  0xFF, 0x1F, 0xF8, 0xFF, 0x1E, 0x79, 0xE7, 0x1E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xC3, 0x9E, 0x7B, 0xC3, 0xDE, 0x7B, 0xC3, 0xDE, 0x7B,
  0x81, 0xDE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07,
  0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xCE,
  0x00, 0x07, 0x01, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x10, 0x0C, 0x07, 0x83, 0xF0, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0x80,
  0x60, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0C, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x78, 0x03, 0xEF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFC, 0x3F, 0xCF, 0xC0, 0x3F, 0xBE, 0x00, 0x7E, 0xF8, 0x01,
  0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x03, 0xFB, 0xE0, 0x1F,
  0xCF, 0xC1, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFC, 0x03, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x70, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0xFF, 0x0F, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF3,
  0xFE, 0x1F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x0B, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x04, 0x3F, 0xF8,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFC, 0x0E, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0xFF, 0x01, 0xF7, 0xF0, 0x07, 0xDF, 0x80, 0x1F, 0x7E,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0xC0, 0x1F, 0x3F, 0x81, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0x7C, 0x01, 0xE1,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF2,
  0x00, 0x1F, 0x8F, 0xC3, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x18, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xF0,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0,
  0xFE, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x04, 0x01, 0xFC, 0x78, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE6, 0x01, 0xF8, 0xFD, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x07, 0xFF, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0xBE, 0x00, 0xFE,
  0x7C, 0x03, 0xF8, 0xF8, 0x0F, 0xE1, 0xF0, 0x3F, 0x83, 0xE0, 0xFE, 0x07,
  0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x3F, 0x80, 0x3E, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xCF,
  0xE0, 0x0F, 0x8F, 0xE0, 0x1F, 0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0xC7, 0xC0, 0x1F,
  0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x08,
  0x03, 0xFC, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0xC0, 0x07, 0x80, 0xC0, 0x7F, 0xE7, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x7E, 0x3F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8,
  0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8,
  0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xC0, 0xFE, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x03, 0xE0,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xF0, 0x3F, 0xCF, 0x80, 0x7F, 0x3E, 0x00, 0xFE, 0xF8, 0x01, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0xF8,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xBF, 0xF0,
  0x3E, 0x0C, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0xFF, 0x83, 0xF3, 0xF8, 0x07, 0xDF, 0xC0, 0x1F, 0x7E,
  0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xFC,
  0x03, 0xF3, 0xFC, 0x7F, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x3F, 0xF7, 0xC0, 0x0E, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xCF, 0xBE, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFC,
  0x03, 0x87, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFD, 0x80, 0x03, 0xE7, 0xE0, 0x3F,
  0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00,
  0x1A, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x40, 0x7F, 0xC7, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xF7,
  0xF8, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x00, 0x70, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7,
  0x81, 0xE0, 0x79, 0xE0, 0x7C, 0x1E, 0x7C, 0x3F, 0x07, 0x9F, 0x0F, 0xC3,
  0xE7, 0xC3, 0xF0, 0xF9, 0xF1, 0xFE, 0x3E, 0x7C, 0x7F, 0x8F, 0x8F, 0x1F,
  0xE3, 0xC3, 0xCF, 0x7C, 0xF0, 0xF3, 0xCF, 0x3C, 0x3C, 0xF3, 0xCF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xF0,
  0x07, 0xE1, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xF3, 0xE0, 0x01, 0xF3, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x43, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x0C, 0x0F,
  0xF8, 0x07, 0xCF, 0xFF, 0x07, 0xCF, 0xFF, 0xE7, 0xE7, 0xFF, 0xFF, 0xE7,
  0xC3, 0xFF, 0xF3, 0xC0, 0x7F, 0xF1, 0xE0, 0x0F, 0xF0, 0x10, 0x01, 0xE0,
  0x00,
};

const GFXglyph UbuntuSansMono_Medium50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 36, 28, 10, -35 },
  { 37, 16, 15, 28, 6, -38 },
  { 67, 26, 35, 28, 1, -35 },
  { 181, 23, 44, 28, 3, -39 },
  { 308, 26, 36, 28, 1, -35 },
  { 425, 26, 35, 28, 1, -35 },
  { 539, 6, 16, 28, 11, -38 },
  { 551, 16, 48, 28, 6, -39 },
  { 647, 16, 48, 28, 6, -39 },
  { 743, 22, 21, 28, 3, -35 },
  { 801, 24, 25, 28, 2, -27 },
  { 876, 12, 16, 28, 8, -8 },
  { 900, 14, 5, 28, 7, -17 },
  { 909, 10, 10, 28, 9, -9 },
  { 922, 22, 48, 28, 3, -39 },
  { 1054, 24, 36, 28, 2, -35 },
  { 1162, 21, 35, 28, 4, -35 },
  { 1254, 22, 35, 28, 3, -35 },
  { 1351, 22, 36, 28, 3, -35 },
  { 1450, 24, 35, 28, 2, -35 },
  { 1555, 22, 36, 28, 3, -35 },
  { 1654, 22, 36, 28, 3, -35 },
  { 1753, 22, 35, 28, 3, -35 },
  { 1850, 22, 37, 28, 3, -36 },
  { 1952, 22, 36, 28, 3, -36 },
  { 2051, 10, 28, 28, 9, -27 },
  { 2086, 12, 35, 28, 7, -27 },
  { 2139, 23, 23, 28, 3, -26 },
  { 2206, 24, 15, 28, 2, -22 },
  { 2251, 23, 23, 28, 3, -26 },
  { 2318, 19, 36, 28, 5, -35 },
  { 2404, 24, 43, 28, 2, -35 },
  { 2533, 28, 35, 28, 0, -35 },
  { 2656, 23, 35, 28, 3, -35 },
  { 2757, 24, 36, 28, 2, -35 },
  { 2865, 23, 35, 28, 3, -35 },
  { 2966, 22, 35, 28, 4, -35 },
  { 3063, 21, 35, 28, 4, -35 },
  { 3155, 24, 36, 28, 2, -35 },
  { 3263, 24, 35, 28, 2, -35 },
  { 3368, 20, 35, 28, 4, -35 },
  { 3456, 21, 36, 28, 3, -35 },
  { 3551, 24, 35, 28, 3, -35 },
  { 3656, 21, 35, 28, 5, -35 },
  { 3748, 24, 35, 28, 2, -35 },
  { 3853, 22, 35, 28, 3, -35 },
  { 3950, 25, 36, 28, 2, -35 },
  { 4063, 22, 35, 28, 4, -35 },
  { 4160, 25, 44, 28, 2, -35 },
  { 4298, 24, 35, 28, 3, -35 },
  { 4403, 22, 36, 28, 3, -35 },
  { 4502, 24, 35, 28, 2, -35 },
  { 4607, 24, 36, 28, 2, -35 },
  { 4715, 26, 35, 28, 1, -35 },
  { 4829, 24, 35, 28, 2, -35 },
  { 4934, 26, 35, 28, 1, -35 },
  { 5048, 26, 35, 28, 1, -35 },
  { 5162, 22, 35, 28, 3, -35 },
  { 5259, 15, 48, 28, 7, -39 },
  { 5349, 22, 48, 28, 3, -39 },
  { 5481, 15, 48, 28, 6, -39 },
  { 5571, 25, 20, 28, 2, -35 },
  { 5634, 28, 5, 28, 0, 4 },
  { 5652, 10, 10, 28, 9, -39 },
  { 5665, 21, 28, 28, 3, -27 },
  { 5739, 22, 40, 28, 4, -39 },
  { 5849, 23, 28, 28, 3, -27 },
  { 5930, 22, 40, 28, 2, -39 },
  { 6040, 24, 28, 28, 2, -27 },
  { 6124, 24, 39, 28, 3, -39 },
  { 6241, 22, 36, 28, 2, -27 },
  { 6340, 20, 39, 28, 4, -39 },
  { 6438, 23, 39, 28, 3, -38 },
  { 6551, 19, 48, 28, 3, -38 },
  { 6665, 23, 39, 28, 4, -39 },
  { 6778, 23, 40, 28, 3, -39 },
  { 6893, 24, 27, 28, 2, -27 },
  { 6974, 20, 27, 28, 4, -27 },
  { 7042, 24, 28, 28, 2, -27 },
  { 7126, 22, 36, 28, 4, -27 },
  { 7225, 22, 36, 28, 2, -27 },
  { 7324, 19, 27, 28, 6, -27 },
  { 7389, 22, 28, 28, 3, -27 },
  { 7466, 23, 35, 28, 3, -34 },
  { 7567, 20, 27, 28, 4, -26 },
  { 7635, 26, 26, 28, 1, -26 },
  { 7720, 26, 26, 28, 1, -26 },
  { 7805, 26, 26, 28, 1, -26 },
  { 7890, 24, 35, 28, 2, -26 },
  { 7995, 20, 26, 28, 4, -26 },
  { 8060, 20, 48, 28, 4, -39 },
  { 8180, 6, 48, 28, 11, -39 },
  { 8216, 20, 48, 28, 4, -39 },
  { 8336, 25, 9, 28, 2, -19 },
};

const GFXfont UbuntuSansMono_Medium50pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium50pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium50pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _UBUNTUSANSMONO_MEDIUM50PT7B_H_
