#ifndef _UBUNTUSANSMONO_MEDIUM12PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium12pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x47, 0xD5, 0x50, 0x24, 0xBF, 0xCA, 0x6B, 0xF4, 0x94, 0x23,
  0xE1, 0x0E, 0x1C, 0x33, 0xF1, 0x00, 0x43, 0x4A, 0xA5, 0x45, 0x05, 0x8A,
  0xA5, 0xCC, 0x11, 0xE4, 0x96, 0x39, 0xDD, 0xF3, 0x74, 0xF0, 0x32, 0x44,
  0xCC, 0x44, 0x62, 0x10, 0xC2, 0x31, 0x11, 0x11, 0x36, 0xC0, 0x27, 0xC9,
  0xA5, 0x00, 0x21, 0x09, 0xF2, 0x10, 0x6D, 0x40, 0xE0, 0xF0, 0x18, 0x84,
  0x62, 0x11, 0x88, 0x46, 0x20, 0x27, 0xA3, 0x1A, 0xD6, 0x33, 0x70, 0x27,
  0x08, 0x42, 0x10, 0x9F, 0x27, 0x86, 0x33, 0x31, 0x10, 0xF8, 0x27, 0x86,
  0x27, 0x0C, 0x23, 0xF0, 0x18, 0x62, 0x92, 0x4B, 0xF0, 0x82, 0x7A, 0x31,
  0xE1, 0x84, 0x7E, 0x3A, 0x21, 0xE8, 0xC6, 0x6E, 0xF8, 0xC4, 0x42, 0x31,
  0x88, 0x27, 0xE3, 0x37, 0x4E, 0x31, 0xF0, 0x27, 0xA3, 0x18, 0xBC, 0x66,
  0xE0, 0xF0, 0xF0, 0xF0, 0xF6, 0x1B, 0xA1, 0xC1, 0x80, 0xF8, 0x3E, 0xC3,
  0x82, 0xEC, 0x00, 0x27, 0x86, 0x22, 0x30, 0x0C, 0x60, 0x10, 0xF4, 0x57,
  0xD7, 0xDF, 0x57, 0x40, 0x81, 0xC0, 0x30, 0x50, 0xA3, 0x44, 0xCF, 0x91,
  0x63, 0xF4, 0xE7, 0xE9, 0xC6, 0x7E, 0x13, 0xE1, 0x08, 0x42, 0x18, 0x78,
  0xF4, 0xE3, 0x18, 0xC6, 0x7E, 0xFC, 0x21, 0xE8, 0x42, 0x1F, 0xFC, 0x21,
  0xF8, 0x42, 0x10, 0x13, 0xE1, 0x08, 0x46, 0x39, 0x78, 0x8C, 0x63, 0xF8,
  0xC6, 0x31, 0xF9, 0x08, 0x42, 0x10, 0x9F, 0x78, 0xC6, 0x31, 0x8E, 0x7E,
  0x9A, 0x4A, 0x30, 0xA2, 0x49, 0xA3, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x4D,
  0xB6, 0xDD, 0x57, 0x1C, 0x71, 0x8E, 0x73, 0x5A, 0xCE, 0x71, 0x11, 0xF4,
  0x71, 0xC7, 0x14, 0x53, 0x38, 0xFC, 0x63, 0x3F, 0x42, 0x10, 0x79, 0x1C,
  0x71, 0xC5, 0x14, 0xCE, 0x10, 0x30, 0xF4, 0xE3, 0x3F, 0x4A, 0x71, 0x27,
  0xE1, 0x06, 0x0C, 0x31, 0xF0, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x8C,
  0x63, 0x18, 0xC6, 0x7E, 0xC6, 0x89, 0x12, 0x66, 0x85, 0x0E, 0x18, 0xC7,
  0x14, 0x55, 0x75, 0xB6, 0xD3, 0xCD, 0xA3, 0x84, 0x39, 0xA4, 0xF1, 0xC6,
  0x99, 0xA1, 0x41, 0x02, 0x04, 0x08, 0xF8, 0x8C, 0x46, 0x22, 0x1F, 0xF2,
  0x49, 0x24, 0x93, 0x80, 0x86, 0x10, 0x86, 0x10, 0x86, 0x10, 0x86, 0xE4,
  0x92, 0x49, 0x27, 0x80, 0x30, 0xA6, 0xF1, 0xFE, 0xCC, 0xF0, 0xDF, 0x18,
  0xFC, 0x84, 0x21, 0xF8, 0xC6, 0x33, 0xF0, 0x7C, 0x21, 0x0C, 0x3C, 0x0C,
  0x30, 0xDF, 0x4F, 0x34, 0xD3, 0x3C, 0x7D, 0x1F, 0xD0, 0x40, 0xF0, 0x3D,
  0x04, 0x3E, 0x41, 0x04, 0x10, 0x40, 0x7D, 0x3C, 0xD3, 0x6C, 0xF0, 0xDE,
  0x84, 0x21, 0xE9, 0xC6, 0x31, 0x88, 0x62, 0x01, 0xC6, 0x31, 0x8C, 0x38,
  0x31, 0x0F, 0x11, 0x11, 0x11, 0xF0, 0x84, 0x21, 0x3B, 0x62, 0x92, 0x88,
  0xE3, 0x18, 0xC6, 0x31, 0x8C, 0x38, 0xFF, 0x5D, 0x75, 0xC7, 0x10, 0xF4,
  0xE3, 0x18, 0xC4, 0x79, 0x1C, 0x51, 0x4C, 0xE0, 0xF4, 0x63, 0x19, 0xFA,
  0x10, 0x7D, 0x3C, 0xD3, 0x4D, 0xF0, 0xC3, 0xFE, 0x31, 0x8C, 0x60, 0xFC,
  0x38, 0x70, 0xF8, 0x42, 0x3E, 0x84, 0x21, 0x87, 0x9C, 0xE7, 0x39, 0xBC,
  0xC5, 0x36, 0x8A, 0x38, 0xC0, 0x87, 0xA9, 0x53, 0x66, 0xC9, 0x80, 0xCC,
  0xA3, 0x0E, 0x6B, 0x10, 0x45, 0x36, 0x8A, 0x38, 0x41, 0x38, 0xF9, 0x88,
  0x8C, 0x7C, 0x3B, 0x18, 0xC6, 0x61, 0x8C, 0x63, 0x0E, 0xFF, 0xE0, 0xE1,
  0x08, 0x42, 0x0C, 0x84, 0x21, 0x38, 0x25, 0xF8, 0x80,
};

const GFXglyph UbuntuSansMono_Medium12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 4, 3, 7, 1, -9 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 5, 10, 7, 1, -9 },
  { 18, 7, 9, 7, 0, -9 },
  { 26, 6, 9, 7, 0, -9 },
  { 33, 1, 4, 7, 3, -9 },
  { 34, 4, 11, 7, 1, -9 },
  { 40, 4, 11, 7, 1, -9 },
  { 46, 5, 5, 7, 1, -8 },
  { 50, 5, 6, 7, 1, -7 },
  { 54, 3, 4, 7, 2, -2 },
  { 56, 3, 1, 7, 2, -4 },
  { 57, 2, 2, 7, 2, -2 },
  { 58, 5, 11, 7, 1, -9 },
  { 65, 5, 9, 7, 1, -9 },
  { 71, 5, 8, 7, 1, -8 },
  { 76, 5, 9, 7, 1, -9 },
  { 82, 5, 9, 7, 1, -9 },
  { 88, 6, 8, 7, 0, -8 },
  { 94, 5, 8, 7, 1, -8 },
  { 99, 5, 8, 7, 1, -8 },
  { 104, 5, 8, 7, 1, -8 },
  { 109, 5, 9, 7, 1, -9 },
  { 115, 5, 9, 7, 1, -9 },
  { 121, 2, 6, 7, 2, -6 },
  { 123, 2, 8, 7, 2, -6 },
  { 125, 5, 5, 7, 1, -6 },
  { 129, 5, 3, 7, 1, -5 },
  { 131, 5, 5, 7, 1, -6 },
  { 135, 5, 9, 7, 1, -9 },
  { 141, 6, 11, 7, 0, -9 },
  { 150, 7, 8, 7, 0, -8 },
  { 157, 5, 8, 7, 1, -8 },
  { 162, 5, 9, 7, 1, -9 },
  { 168, 5, 8, 7, 1, -8 },
  { 173, 5, 8, 7, 1, -8 },
  { 178, 5, 8, 7, 1, -8 },
  { 183, 5, 9, 7, 1, -9 },
  { 189, 5, 8, 7, 1, -8 },
  { 194, 5, 8, 7, 1, -8 },
  { 199, 5, 8, 7, 1, -8 },
  { 204, 6, 8, 7, 1, -8 },
  { 210, 5, 8, 7, 1, -8 },
  { 215, 6, 8, 7, 0, -8 },
  { 221, 5, 8, 7, 1, -8 },
  { 226, 6, 9, 7, 0, -9 },
  { 233, 5, 8, 7, 1, -8 },
  { 238, 6, 10, 7, 0, -8 },
  { 246, 5, 8, 7, 1, -8 },
  { 251, 5, 9, 7, 1, -9 },
  { 257, 6, 8, 7, 0, -8 },
  { 263, 5, 8, 7, 1, -8 },
  { 268, 7, 8, 7, 0, -8 },
  { 275, 6, 8, 7, 0, -8 },
  { 281, 6, 8, 7, 0, -8 },
  { 287, 7, 8, 7, 0, -8 },
  { 294, 5, 8, 7, 1, -8 },
  { 299, 3, 11, 7, 2, -9 },
  { 304, 5, 11, 7, 1, -9 },
  { 311, 3, 11, 7, 2, -9 },
  { 316, 6, 4, 7, 0, -8 },
  { 319, 7, 1, 7, 0, 1 },
  { 320, 3, 2, 7, 2, -9 },
  { 321, 5, 6, 7, 1, -6 },
  { 325, 5, 9, 7, 1, -9 },
  { 331, 5, 6, 7, 1, -6 },
  { 335, 6, 9, 7, 0, -9 },
  { 342, 6, 6, 7, 0, -6 },
  { 347, 6, 9, 7, 1, -9 },
  { 354, 6, 8, 7, 0, -6 },
  { 360, 5, 9, 7, 1, -9 },
  { 366, 5, 9, 7, 1, -9 },
  { 372, 4, 11, 7, 1, -9 },
  { 378, 5, 9, 7, 1, -9 },
  { 384, 5, 9, 7, 1, -9 },
  { 390, 6, 6, 7, 0, -6 },
  { 395, 5, 6, 7, 1, -6 },
  { 399, 6, 6, 7, 0, -6 },
  { 404, 5, 8, 7, 1, -6 },
  { 409, 6, 8, 7, 0, -6 },
  { 415, 5, 6, 7, 1, -6 },
  { 419, 5, 6, 7, 1, -6 },
  { 423, 5, 8, 7, 1, -8 },
  { 428, 5, 6, 7, 1, -6 },
  { 432, 6, 6, 7, 0, -6 },
  { 437, 7, 6, 7, 0, -6 },
  { 443, 6, 6, 7, 0, -6 },
  { 448, 6, 8, 7, 0, -6 },
  { 454, 5, 6, 7, 1, -6 },
  { 458, 5, 11, 7, 1, -9 },
  { 465, 1, 11, 7, 3, -9 },
  { 467, 5, 11, 7, 1, -9 },
  { 474, 6, 3, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_Medium12pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium12pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUSANSMONO_MEDIUM12PT7B_H_
