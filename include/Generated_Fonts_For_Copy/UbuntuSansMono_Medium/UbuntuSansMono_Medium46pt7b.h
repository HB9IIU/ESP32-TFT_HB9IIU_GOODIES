#ifndef _UBUNTUSANSMONO_MEDIUM46PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE0, 0x00,
  0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01,
  0xF0, 0x78, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0x83, 0xE0, 0x07,
  0x83, 0xE0, 0x07, 0x83, 0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x83, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E,
  0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x0F, 0xC0, 0x18, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x90, 0x00, 0xFD, 0xF0, 0x0F, 0xEF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0x7F, 0xC0, 0x1E, 0x7F, 0xC0, 0x3C, 0xF1,
  0xE0, 0x3C, 0xF1, 0xE0, 0x78, 0xE1, 0xE0, 0xF8, 0xE0, 0xE0, 0xF0, 0xE0,
  0xE1, 0xE0, 0xE1, 0xE1, 0xE0, 0xE1, 0xE3, 0xC0, 0xF1, 0xE7, 0x80, 0xF1,
  0xE7, 0x80, 0x7F, 0xCF, 0x00, 0x7F, 0x9E, 0x00, 0x3F, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x79, 0xF8, 0x00, 0xF3, 0xFC, 0x00,
  0xF3, 0xFE, 0x01, 0xE7, 0x9E, 0x03, 0xC7, 0x8F, 0x03, 0xC7, 0x0F, 0x07,
  0x87, 0x0F, 0x0F, 0x87, 0x0F, 0x0F, 0x07, 0x0F, 0x1E, 0x07, 0x0F, 0x1E,
  0x07, 0x8F, 0x3C, 0x07, 0x8F, 0x78, 0x07, 0xFE, 0x78, 0x03, 0xFE, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x30, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x07, 0xC0, 0x1E,
  0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1F,
  0x07, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3C, 0x0F, 0xF8, 0x3C, 0x1F,
  0xF8, 0x7C, 0x3E, 0xFC, 0x7C, 0x7C, 0x7E, 0x78, 0x7C, 0x3F, 0x78, 0x78,
  0x1F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF0, 0xF8, 0x03, 0xF0, 0xF8,
  0x03, 0xF0, 0x7C, 0x03, 0xF8, 0x7E, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0x7C, 0x1F, 0xFE, 0x3E, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x0C, 0x00, 0x78, 0x01,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x30, 0x00, 0xF0, 0x01,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x0F, 0x0E,
  0x7C, 0xF3, 0xEF, 0xEE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7B, 0xE0, 0x0F, 0x9F, 0x01, 0xF9,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x06, 0x06, 0x00, 0x20, 0x40, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x01, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0x7F, 0x03, 0xC0, 0x78, 0x1E, 0x1F, 0xCF, 0xF0, 0xFC, 0x1E, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0xFE, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE1,
  0xC3, 0xEF, 0x87, 0x87, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1,
  0xFF, 0x87, 0x87, 0xFE, 0x0C, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xE7,
  0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xE0,
  0x1F, 0x0F, 0x80, 0xFC, 0x3F, 0x07, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xF7, 0xC0, 0x7E, 0x7C, 0x07, 0x87, 0xC0, 0x20, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC1, 0xFC, 0x70, 0x07, 0xE2, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0x81, 0xFC, 0x20, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0xE0, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE6, 0x00, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFD, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0x1F, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3C, 0xFC, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0xC1, 0xF0, 0x7F, 0x9F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7E, 0x1F, 0xE3, 0xE0, 0x3F, 0x3E, 0x00,
  0xFD, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x3F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83,
  0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0xC0, 0x1F, 0x3F, 0xCF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0x07, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7E,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x01, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x03, 0xE0,
  0x78, 0x1F, 0x1F, 0xCF, 0xF0, 0xFC, 0x1E, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9C, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xC7, 0xF0, 0x7C, 0x03, 0xE3,
  0xE0, 0x07, 0x8F, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0x80,
  0x07, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0x1F, 0xF0, 0xF8, 0x7F, 0xC7, 0xC1, 0xFF, 0x1F, 0x07, 0xFC,
  0x7C, 0x1F, 0xF1, 0xF0, 0x7F, 0xC7, 0xC1, 0xFF, 0x1F, 0x07, 0xFC, 0x7C,
  0x1F, 0xF1, 0xF0, 0x7F, 0xC3, 0xE1, 0xFF, 0x8F, 0xC7, 0xFE, 0x1F, 0xFF,
  0x78, 0x3F, 0xFD, 0xE0, 0x7F, 0xF7, 0xC0, 0x7F, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x04, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x3C,
  0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0x81, 0xFC, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xC3, 0xFF,
  0x3E, 0x01, 0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD,
  0xF0, 0x1F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0x81, 0xE1, 0xF8, 0x00, 0x8F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x02, 0x1F, 0xE0, 0x38, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x87, 0xFC,
  0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0x3E, 0x03, 0xF9, 0xF0, 0x7F,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF3, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0x80, 0xE1, 0xF8, 0x01, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFD, 0x00,
  0x3F, 0x38, 0x0F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x3F,
  0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x3E,
  0x0F, 0xC0, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3E, 0x7E,
  0x00, 0xFB, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xEF, 0xE0, 0x0F, 0x9F, 0xC0, 0x3E, 0x3F, 0x80, 0xF8,
  0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xF0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x7F, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xFB,
  0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0x78, 0x7E, 0x01, 0xF0, 0xFC, 0x03,
  0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7B, 0x87, 0x78, 0xF7, 0x1E, 0xF1,
  0xCF, 0x3D, 0xE7, 0x9E, 0x73, 0xCF, 0x1D, 0xE7, 0x9E, 0x3F, 0xCF, 0x3C,
  0x7F, 0x1F, 0x78, 0x7E, 0x3E, 0xF0, 0xFC, 0x7D, 0xE1, 0xF0, 0xFB, 0xC1,
  0xE1, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00,
  0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01,
  0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0x78,
  0x1F, 0xF7, 0xC1, 0xFF, 0x3C, 0x1F, 0xF3, 0xE1, 0xFF, 0x1E, 0x1F, 0xF1,
  0xF1, 0xFF, 0x0F, 0x1F, 0xF0, 0x79, 0xFF, 0x07, 0x9F, 0xF0, 0x7D, 0xFF,
  0x03, 0xDF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0xFC, 0x00,
  0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8,
  0x03, 0xF1, 0xF8, 0x07, 0xC1, 0xF8, 0x1F, 0x83, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x81, 0xFF, 0x7C,
  0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0,
  0x0F, 0xDF, 0x00, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xF0, 0x7F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0xFC, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xFC, 0x00,
  0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC1, 0xF8, 0x1F, 0x83, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x40,
  0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x08, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x83, 0xFC,
  0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xF7, 0xC0,
  0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3,
  0xE0, 0x3F, 0x9F, 0x1F, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7E, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7,
  0xE0, 0x1C, 0x7C, 0x00, 0x4F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF4, 0x00, 0x3F, 0x70, 0x07, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x80, 0x7E, 0xFE, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xEF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07,
  0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D,
  0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x83, 0xC3, 0xEF, 0x0F, 0x87, 0xDE,
  0x1F, 0x8F, 0xBC, 0x3F, 0x1F, 0x78, 0xFE, 0x3C, 0xF1, 0xFE, 0x79, 0xE3,
  0xBC, 0xF3, 0xCF, 0x39, 0xE7, 0x9E, 0x7B, 0xC7, 0x38, 0xF7, 0x8E, 0x70,
  0xEF, 0x1D, 0xE1, 0xDE, 0x3B, 0x83, 0xFC, 0x77, 0x03, 0xF8, 0xFE, 0x07,
  0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E,
  0x1F, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xEF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xC3, 0xE0,
  0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81,
  0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xEF, 0xC0,
  0x0F, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x78, 0x40, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x10, 0x0C, 0x07, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1E,
  0x03, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x40, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xEF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x0C, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x40, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFE, 0x07,
  0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x7E, 0x01, 0xFB, 0xF0,
  0x0F, 0xDF, 0x81, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0x00, 0x43, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xE0, 0x18, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x04, 0x1F,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0x07,
  0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01, 0xF3,
  0xF8, 0x1F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00,
  0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x70, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0x20, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x14, 0x00, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF0, 0x1F, 0x7E, 0x01, 0xF7,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x30, 0x07, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x38, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC1, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFD, 0xC0, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x0C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x0F,
  0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC1, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x60, 0x7F, 0xCF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xF0, 0xF8, 0x7F, 0xC3, 0xE1, 0xFF, 0x07, 0x83, 0xFC,
  0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E,
  0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x40,
  0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xE7,
  0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x07, 0xF0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7E,
  0x07, 0xF3, 0xF0, 0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0x7D,
  0xF8, 0x07, 0xEF, 0xE0, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x07, 0xE1, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF8, 0x1F, 0x7E, 0x01, 0xF7, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x1F, 0x7F, 0x03, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFD, 0xF0, 0x04, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x80, 0x6F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xE0, 0x0C, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF4, 0x00, 0x3E, 0x70, 0x07, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x0C, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0x7D, 0xF8, 0x0F, 0xBF, 0x81, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xA0, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x3C,
  0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E,
  0x1E, 0x78, 0x7E, 0x1E, 0x78, 0xFF, 0x3E, 0x78, 0xFF, 0x3C, 0x7C, 0xEF,
  0x3C, 0x3D, 0xE7, 0x3C, 0x3D, 0xE7, 0xBC, 0x3D, 0xC7, 0xBC, 0x3F, 0xC3,
  0xBC, 0x3F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x7C, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xC3,
  0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7C, 0x00,
  0xFC, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x1E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x00, 0xF9, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x20, 0x7F, 0x00, 0xF3, 0xFF,
  0x03, 0xDF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFB, 0xE3, 0xFF, 0xEF, 0x03, 0xFF,
  0x38, 0x03, 0xF8, 0x00, 0x03, 0x80,
};

const GFXglyph UbuntuSansMono_Medium46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 33, 26, 9, -32 },
  { 34, 14, 14, 26, 6, -35 },
  { 59, 24, 32, 26, 1, -32 },
  { 155, 21, 41, 26, 2, -36 },
  { 263, 24, 34, 26, 1, -33 },
  { 365, 24, 33, 26, 1, -33 },
  { 464, 6, 14, 26, 10, -35 },
  { 475, 15, 45, 26, 5, -36 },
  { 560, 15, 45, 26, 5, -36 },
  { 645, 20, 20, 26, 3, -32 },
  { 695, 22, 23, 26, 2, -25 },
  { 759, 11, 16, 26, 7, -8 },
  { 781, 12, 5, 26, 7, -16 },
  { 789, 8, 9, 26, 9, -8 },
  { 798, 20, 45, 26, 3, -36 },
  { 911, 22, 34, 26, 2, -33 },
  { 1005, 20, 32, 26, 3, -32 },
  { 1085, 20, 33, 26, 3, -33 },
  { 1168, 20, 34, 26, 3, -33 },
  { 1253, 22, 32, 26, 2, -32 },
  { 1341, 20, 33, 26, 3, -32 },
  { 1424, 20, 33, 26, 3, -32 },
  { 1507, 20, 32, 26, 3, -32 },
  { 1587, 21, 34, 26, 2, -33 },
  { 1677, 21, 33, 26, 2, -33 },
  { 1764, 8, 25, 26, 9, -24 },
  { 1789, 11, 32, 26, 6, -24 },
  { 1833, 22, 21, 26, 2, -24 },
  { 1891, 22, 15, 26, 2, -21 },
  { 1933, 22, 22, 26, 2, -24 },
  { 1994, 18, 34, 26, 4, -33 },
  { 2071, 22, 40, 26, 2, -33 },
  { 2181, 25, 32, 26, 0, -32 },
  { 2281, 21, 32, 26, 3, -32 },
  { 2365, 22, 34, 26, 2, -33 },
  { 2459, 21, 32, 26, 3, -32 },
  { 2543, 20, 32, 26, 4, -32 },
  { 2623, 19, 32, 26, 4, -32 },
  { 2699, 22, 34, 26, 2, -33 },
  { 2793, 21, 32, 26, 2, -32 },
  { 2877, 18, 32, 26, 4, -32 },
  { 2949, 19, 33, 26, 3, -32 },
  { 3028, 22, 32, 26, 3, -32 },
  { 3116, 20, 32, 26, 4, -32 },
  { 3196, 23, 32, 26, 1, -32 },
  { 3288, 20, 32, 26, 3, -32 },
  { 3368, 23, 34, 26, 1, -33 },
  { 3466, 21, 32, 26, 3, -32 },
  { 3550, 23, 42, 26, 1, -33 },
  { 3671, 21, 32, 26, 3, -32 },
  { 3755, 20, 34, 26, 3, -33 },
  { 3840, 22, 32, 26, 2, -32 },
  { 3928, 21, 33, 26, 2, -32 },
  { 4015, 24, 32, 26, 1, -32 },
  { 4111, 23, 32, 26, 1, -32 },
  { 4203, 24, 32, 26, 1, -32 },
  { 4299, 24, 32, 26, 1, -32 },
  { 4395, 20, 32, 26, 3, -32 },
  { 4475, 13, 45, 26, 7, -36 },
  { 4549, 20, 45, 26, 3, -36 },
  { 4662, 13, 45, 26, 6, -36 },
  { 4736, 22, 18, 26, 2, -32 },
  { 4786, 25, 5, 26, 0, 4 },
  { 4802, 10, 9, 26, 8, -36 },
  { 4814, 19, 26, 26, 3, -25 },
  { 4876, 21, 37, 26, 3, -36 },
  { 4974, 22, 26, 26, 2, -25 },
  { 5046, 20, 37, 26, 2, -36 },
  { 5139, 22, 26, 26, 2, -25 },
  { 5211, 22, 36, 26, 3, -36 },
  { 5310, 20, 34, 26, 2, -25 },
  { 5395, 19, 36, 26, 3, -36 },
  { 5481, 22, 36, 26, 2, -35 },
  { 5580, 17, 44, 26, 3, -35 },
  { 5674, 22, 36, 26, 3, -36 },
  { 5773, 22, 36, 26, 2, -35 },
  { 5872, 22, 24, 26, 2, -24 },
  { 5938, 19, 25, 26, 3, -25 },
  { 5998, 22, 26, 26, 2, -25 },
  { 6070, 21, 34, 26, 3, -25 },
  { 6160, 20, 34, 26, 2, -25 },
  { 6245, 18, 25, 26, 5, -25 },
  { 6302, 20, 26, 26, 3, -25 },
  { 6367, 21, 32, 26, 3, -31 },
  { 6451, 19, 25, 26, 3, -24 },
  { 6511, 24, 24, 26, 1, -24 },
  { 6583, 24, 24, 26, 1, -24 },
  { 6655, 24, 24, 26, 1, -24 },
  { 6727, 23, 33, 26, 1, -24 },
  { 6822, 18, 24, 26, 4, -24 },
  { 6876, 18, 45, 26, 4, -36 },
  { 6978, 5, 45, 26, 10, -36 },
  { 7007, 18, 45, 26, 4, -36 },
  { 7109, 22, 9, 26, 2, -18 },
};

const GFXfont UbuntuSansMono_Medium46pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium46pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium46pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _UBUNTUSANSMONO_MEDIUM46PT7B_H_
