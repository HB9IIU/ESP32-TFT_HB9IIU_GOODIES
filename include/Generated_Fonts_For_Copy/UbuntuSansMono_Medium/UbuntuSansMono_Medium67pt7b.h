#ifndef _UBUNTUSANSMONO_MEDIUM67PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium67pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x7F, 0x9F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF7, 0xFC, 0x7F, 0x03, 0xC0, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0x80, 0xFE, 0xFC,
  0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE0, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x00,
  0x3C, 0x1F, 0xF0, 0x00, 0x08, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xC0, 0x00,
  0x0F, 0xF9, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x9F, 0xFE, 0x00, 0x07, 0xE3, 0xFF, 0xE0,
  0x00, 0xF8, 0xFE, 0xFE, 0x00, 0x3F, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0,
  0xF8, 0x01, 0xF8, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x03, 0xE0, 0x1F, 0x83,
  0xE0, 0x7E, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F,
  0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x7E, 0x00, 0x3F, 0xFF, 0x1F, 0x80, 0x03, 0xFF, 0xE7, 0xE0, 0x00,
  0x3F, 0xF8, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x03, 0xF1, 0xFF, 0x80, 0x00, 0xFC, 0x7F, 0xF8, 0x00,
  0x1F, 0x8F, 0xFF, 0x80, 0x07, 0xE3, 0xFF, 0xF0, 0x00, 0xF8, 0x7C, 0x3F,
  0x00, 0x3F, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x7C, 0x01, 0xF8, 0x7C,
  0x0F, 0x80, 0x7E, 0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xF0,
  0x3E, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x07,
  0xE0, 0x1F, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0x7C, 0x3E, 0x00, 0x7E, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF3, 0xF0, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0x0F,
  0xFF, 0x9F, 0x80, 0x01, 0xFF, 0xE7, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0,
  0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0x80,
  0x7E, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xFE, 0x07, 0xE0, 0x7F, 0xFF,
  0xC1, 0xF8, 0x3F, 0xCF, 0xF0, 0x7E, 0x0F, 0xE1, 0xFE, 0x3F, 0x87, 0xF0,
  0x3F, 0xCF, 0xC1, 0xFC, 0x07, 0xFB, 0xF0, 0x7E, 0x01, 0xFF, 0xFC, 0x3F,
  0x80, 0x3F, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xE0,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x1F, 0xFC, 0x1F, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0x03, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0x00, 0xFC, 0x03, 0x0F,
  0x03, 0xF0, 0x3C, 0x7F, 0x0F, 0xC3, 0xF1, 0xFF, 0x3E, 0x3F, 0xE7, 0xFF,
  0x7B, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0xBF, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x1E, 0x07, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0xC1, 0xFE,
  0x1F, 0xFF, 0x83, 0xFC, 0x3F, 0xFF, 0x07, 0xF8, 0x7F, 0xFE, 0x0F, 0xF0,
  0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x3F, 0x07,
  0xFF, 0xE0, 0x18, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFB,
  0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1E, 0x07, 0xF8,
  0x00, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7F, 0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x7F, 0x81, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x1F, 0xF8, 0x1C, 0x00, 0x3F, 0xE0, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x40, 0x00,
  0x1F, 0xF3, 0xC0, 0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFD, 0x00,
  0x00, 0x7F, 0xCF, 0x00, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xDF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xF3, 0xFC, 0x00, 0x3F, 0xEF, 0xE0, 0x00,
  0x7F, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0,
  0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFF,
  0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0xC1, 0xFE, 0x01, 0xFF,
  0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x8F,
  0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xE0, 0x01,
  0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFF,
  0x7F, 0x80, 0x03, 0xFC, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x3F, 0xDF, 0xF8, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0x87, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFE, 0x3F, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x87, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFE, 0x3F, 0xC0, 0xE0, 0x01, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x07,
  0xFE, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFA, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x20, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7C,
  0x03, 0xFF, 0x30, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x07, 0xFF, 0x3F, 0x00, 0x3F, 0xFF, 0xBF, 0x80, 0x7F,
  0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xF7, 0xE0, 0x7F,
  0xFF, 0xFB, 0xF0, 0x3F, 0xF3, 0xFD, 0xF8, 0x3F, 0xE0, 0xFE, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0x07, 0xF0, 0x1F, 0xFF, 0x87,
  0xF0, 0x0F, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xF0,
  0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x7F, 0xFE,
  0x1F, 0xC0, 0x3F, 0xFF, 0x0F, 0xE0, 0x1F, 0xDF, 0x83, 0xF8, 0x0F, 0xEF,
  0xC1, 0xFC, 0x07, 0xF7, 0xE0, 0xFE, 0x03, 0xFB, 0xF0, 0x7F, 0x81, 0xFD,
  0xFC, 0x1F, 0xE0, 0xFE, 0xFE, 0x0F, 0xFF, 0xFF, 0x3F, 0x03, 0xFF, 0xFF,
  0x9F, 0x80, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF,
  0xF1, 0xFC, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFD, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0xFF, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFE, 0x7F, 0xFE, 0x3F, 0x80, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xF3,
  0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x03,
  0xFC, 0x3F, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0x3F, 0x80, 0x03, 0xFE, 0xFE,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFE, 0xFE, 0x00, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xFC, 0x0F, 0xFC, 0x00, 0x1C, 0x0F,
  0xF8, 0x00, 0x04, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x04, 0x0F, 0xFE, 0x00, 0x3C, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xF0, 0xFE, 0x00,
  0x3F, 0xE1, 0xFC, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0xFF, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0xFF, 0x9F, 0xC0, 0x03, 0xFE, 0x3F, 0x80, 0x0F, 0xFC, 0x7F, 0x00,
  0x3F, 0xF0, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x7E,
  0x0F, 0xFC, 0x00, 0x1C, 0x1F, 0xF0, 0x00, 0x10, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x3F,
  0x8F, 0xF8, 0x00, 0x7F, 0x1F, 0xF8, 0x00, 0xFE, 0x1F, 0xFC, 0x01, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE2, 0x00, 0x01, 0xFE, 0x38, 0x00, 0x3F,
  0xE7, 0xE0, 0x07, 0xFC, 0x7F, 0xE7, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF,
  0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xBF, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xF0, 0x03, 0xFC, 0x0F, 0xFC,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xEF, 0x87,
  0xEF, 0x81, 0xF7, 0xE3, 0xE7, 0xC0, 0xFB, 0xF1, 0xF3, 0xE0, 0xF9, 0xF8,
  0xF9, 0xF0, 0x7C, 0xFC, 0x7C, 0x7C, 0x3E, 0x7E, 0x3E, 0x3E, 0x3F, 0x3F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x8F, 0x87, 0xCF, 0x8F, 0xCF, 0xC3, 0xEF, 0xC7,
  0xE7, 0xE1, 0xF7, 0xC3, 0xF3, 0xF0, 0x7F, 0xE1, 0xF9, 0xF8, 0x3F, 0xF0,
  0xFC, 0xFC, 0x1F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF8, 0x3F, 0x3F, 0x03, 0xFC,
  0x1F, 0x9F, 0x81, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0x07, 0xF7, 0xE0, 0x3F,
  0x03, 0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFB, 0xF0, 0x07, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0x9F, 0x80, 0x7F,
  0xFE, 0x7F, 0x01, 0xFF, 0xF8, 0xFC, 0x07, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF,
  0x87, 0xE0, 0x7F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0,
  0xFE, 0x1F, 0xFF, 0x81, 0xF8, 0x7F, 0xFE, 0x07, 0xF1, 0xFF, 0xF8, 0x0F,
  0xC7, 0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0x80, 0x7E, 0x7F, 0xFE, 0x01, 0xF9,
  0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0x3F, 0x80, 0x0F, 0xFC, 0xFE, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x3F, 0xEF,
  0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xEF, 0xE0, 0x01, 0xFF,
  0x3F, 0x80, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x01, 0xF8,
  0x3F, 0xC0, 0x00, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x30, 0x00, 0x07, 0xF9, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x0F, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x07,
  0xFC, 0x1F, 0xFE, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x01, 0xF8, 0x1F, 0xDF, 0x81,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFF, 0x07, 0xE7, 0xE0, 0x7F, 0x83, 0xF3, 0xF0,
  0x7F, 0xC1, 0xF9, 0xF8, 0x3F, 0xF0, 0xFC, 0xFC, 0x1F, 0xF8, 0x7E, 0x7E,
  0x1F, 0xFC, 0x3F, 0x3F, 0x0F, 0xBE, 0x1F, 0x9F, 0x87, 0xCF, 0x8F, 0xCF,
  0xC7, 0xE7, 0xC7, 0xE3, 0xE3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF9, 0xF8,
  0xF8, 0xF8, 0x7C, 0xFC, 0x7C, 0xF8, 0x3E, 0x7E, 0x3E, 0x7C, 0x0F, 0xBF,
  0x1F, 0x3E, 0x07, 0xDF, 0x0F, 0xBE, 0x03, 0xEF, 0x87, 0xDF, 0x01, 0xF7,
  0xC3, 0xEF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFD, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x07, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x80,
  0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x00, 0x70, 0x03, 0xE0, 0x1F,
  0xC0, 0x7F, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0x80, 0x3C, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xC7, 0xFF, 0x81, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xF0, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0x03,
  0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0xFF, 0xBF, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x01, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x0C, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x61, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x83, 0xF8,
  0x07, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFE, 0x03,
  0xFF, 0x3F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x80,
  0x07, 0xF3, 0xFE, 0x00, 0x3F, 0x9F, 0xFC, 0x01, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFE, 0x7F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x70, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0x80, 0x0C,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFD,
  0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD,
  0xFF, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x7F, 0xCF, 0xFE, 0x07, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x8F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x20, 0x00, 0x1F, 0xF0,
  0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x30, 0x01, 0xFF, 0x7E, 0x03, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x8F,
  0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x3F, 0xC7, 0xFE,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC,
  0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8,
  0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0xFC,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F,
  0xE0, 0xFE, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x00,
  0x3F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFE,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0xF8, 0xFF, 0x00,
  0x3F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xDF, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x3F, 0xE0,
  0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0x00, 0x1F, 0x83, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0x00, 0x1C, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0xFF, 0x87, 0xF8, 0x00, 0x38, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x60, 0x00, 0x0F, 0xF7,
  0xC0, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x40, 0x3F, 0xE0, 0x07, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xFC, 0x00, 0xFF, 0x7F, 0xE0, 0x0F, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0x7E,
  0x01, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x01, 0xF9, 0xFC, 0x0F, 0xE0, 0x3F,
  0x3F, 0x81, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0xC0, 0xFC, 0x7E, 0x07, 0xF8,
  0x1F, 0x8F, 0xC1, 0xFF, 0x83, 0xF1, 0xF8, 0x3F, 0xF0, 0xFC, 0x3F, 0x07,
  0xFE, 0x1F, 0x87, 0xE1, 0xFF, 0xC3, 0xF0, 0xFC, 0x3E, 0xFC, 0x7E, 0x0F,
  0xC7, 0xDF, 0x8F, 0xC1, 0xF9, 0xF9, 0xF1, 0xF8, 0x3F, 0x3E, 0x3F, 0x3F,
  0x07, 0xE7, 0xC7, 0xE7, 0xC0, 0xFD, 0xF8, 0x7D, 0xF8, 0x1F, 0xBE, 0x0F,
  0xFF, 0x01, 0xF7, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x40, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x08, 0x01, 0xFF, 0x80, 0x03,
  0xC0, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0xFF, 0x80, 0x7E, 0x1F, 0xFF, 0xF0,
  0x3F, 0x8F, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x1F,
  0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0xFE, 0x1F, 0x80, 0x3F, 0xFF, 0x0F, 0xC0,
  0x03, 0xFF, 0x80, 0x30, 0x00, 0x3F, 0x80,
};

const GFXglyph UbuntuSansMono_Medium67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 11, 47, 38, 13, -46 },
  { 66, 21, 20, 38, 8, -51 },
  { 119, 34, 46, 38, 2, -46 },
  { 315, 31, 59, 38, 3, -52 },
  { 544, 35, 49, 38, 1, -48 },
  { 759, 34, 49, 38, 2, -48 },
  { 968, 8, 21, 38, 15, -51 },
  { 989, 22, 66, 38, 8, -53 },
  { 1171, 22, 66, 38, 8, -53 },
  { 1353, 30, 28, 38, 4, -46 },
  { 1458, 31, 33, 38, 3, -36 },
  { 1586, 16, 22, 38, 10, -11 },
  { 1630, 18, 7, 38, 10, -23 },
  { 1646, 12, 12, 38, 13, -11 },
  { 1664, 29, 64, 38, 4, -52 },
  { 1896, 31, 49, 38, 3, -48 },
  { 2086, 29, 46, 38, 5, -46 },
  { 2253, 30, 48, 38, 4, -48 },
  { 2433, 29, 49, 38, 4, -48 },
  { 2611, 33, 46, 38, 2, -46 },
  { 2801, 29, 47, 38, 4, -46 },
  { 2972, 30, 48, 38, 4, -47 },
  { 3152, 30, 46, 38, 4, -46 },
  { 3325, 31, 49, 38, 3, -48 },
  { 3515, 30, 48, 38, 4, -48 },
  { 3695, 12, 36, 38, 13, -35 },
  { 3749, 16, 46, 38, 9, -35 },
  { 3841, 31, 31, 38, 4, -35 },
  { 3962, 31, 21, 38, 3, -30 },
  { 4044, 31, 31, 38, 3, -35 },
  { 4165, 25, 49, 38, 6, -48 },
  { 4319, 33, 58, 38, 2, -48 },
  { 4559, 36, 46, 38, 1, -46 },
  { 4766, 30, 47, 38, 4, -47 },
  { 4943, 32, 49, 38, 3, -48 },
  { 5139, 31, 47, 38, 4, -47 },
  { 5322, 29, 46, 38, 6, -46 },
  { 5489, 27, 46, 38, 6, -46 },
  { 5645, 31, 49, 38, 3, -48 },
  { 5835, 31, 46, 38, 3, -46 },
  { 6014, 26, 46, 38, 6, -46 },
  { 6164, 28, 47, 38, 4, -46 },
  { 6329, 33, 46, 38, 4, -46 },
  { 6519, 29, 46, 38, 6, -46 },
  { 6686, 33, 46, 38, 2, -46 },
  { 6876, 30, 46, 38, 4, -46 },
  { 7049, 34, 49, 38, 2, -48 },
  { 7258, 30, 47, 38, 5, -47 },
  { 7435, 34, 60, 38, 2, -47 },
  { 7690, 32, 47, 38, 4, -47 },
  { 7878, 30, 49, 38, 4, -48 },
  { 8062, 32, 46, 38, 3, -46 },
  { 8246, 31, 47, 38, 3, -46 },
  { 8429, 36, 46, 38, 1, -46 },
  { 8636, 33, 46, 38, 2, -46 },
  { 8826, 35, 46, 38, 1, -46 },
  { 9028, 36, 46, 38, 1, -46 },
  { 9235, 30, 46, 38, 4, -46 },
  { 9408, 19, 64, 38, 10, -52 },
  { 9560, 28, 64, 38, 5, -52 },
  { 9784, 19, 64, 38, 9, -52 },
  { 9936, 34, 26, 38, 2, -46 },
  { 10047, 36, 6, 38, 1, 6 },
  { 10074, 14, 13, 38, 12, -52 },
  { 10097, 29, 37, 38, 4, -36 },
  { 10232, 30, 53, 38, 5, -52 },
  { 10431, 30, 37, 38, 4, -36 },
  { 10570, 29, 53, 38, 3, -52 },
  { 10763, 32, 37, 38, 3, -36 },
  { 10911, 33, 52, 38, 4, -52 },
  { 11126, 30, 49, 38, 3, -36 },
  { 11310, 28, 52, 38, 5, -52 },
  { 11492, 31, 52, 38, 3, -51 },
  { 11694, 24, 64, 38, 5, -51 },
  { 11886, 31, 52, 38, 5, -52 },
  { 12088, 31, 53, 38, 3, -52 },
  { 12294, 32, 36, 38, 3, -36 },
  { 12438, 28, 36, 38, 5, -36 },
  { 12564, 32, 37, 38, 3, -36 },
  { 12712, 30, 48, 38, 5, -36 },
  { 12892, 30, 48, 38, 3, -36 },
  { 13072, 27, 36, 38, 7, -36 },
  { 13194, 28, 37, 38, 5, -36 },
  { 13324, 30, 47, 38, 4, -46 },
  { 13501, 28, 36, 38, 5, -35 },
  { 13627, 34, 35, 38, 2, -35 },
  { 13776, 35, 35, 38, 1, -35 },
  { 13930, 34, 35, 38, 2, -35 },
  { 14079, 33, 48, 38, 2, -35 },
  { 14277, 27, 35, 38, 5, -35 },
  { 14396, 27, 64, 38, 5, -52 },
  { 14612, 7, 64, 38, 15, -52 },
  { 14668, 27, 64, 38, 5, -52 },
  { 14884, 34, 12, 38, 2, -26 },
};

const GFXfont UbuntuSansMono_Medium67pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium67pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium67pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _UBUNTUSANSMONO_MEDIUM67PT7B_H_
