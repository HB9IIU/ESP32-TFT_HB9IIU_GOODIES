#ifndef _UBUNTUSANSMONO_MEDIUM35PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium35pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x1C, 0x00, 0x00, 0x1E, 0xFB, 0xFF, 0xDE, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1D, 0x83, 0x00, 0x03,
  0x87, 0x01, 0xE1, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x0F, 0x01, 0xC3,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x87, 0x80, 0xE1, 0xC0,
  0x38, 0x70, 0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xC3, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xC7, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x1C,
  0x07, 0x87, 0x01, 0xE3, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFC, 0x7C, 0x0C, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x60, 0x1E, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x80, 0xFF,
  0xE0, 0x3B, 0x9C, 0x1C, 0xC7, 0x07, 0x31, 0xC3, 0x8C, 0x71, 0xC3, 0x1C,
  0x70, 0xE7, 0x38, 0x39, 0xDC, 0x07, 0xE7, 0x01, 0xF3, 0x80, 0x01, 0xE0,
  0x00, 0x71, 0x00, 0x39, 0xF8, 0x0E, 0xFE, 0x07, 0x39, 0xC3, 0x8C, 0x70,
  0xE7, 0x1C, 0x71, 0xC7, 0x3C, 0x71, 0xCE, 0x0C, 0x77, 0x03, 0x9D, 0xC0,
  0xFE, 0xE0, 0x1F, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0xF9, 0xE0, 0x3C, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0,
  0x3C, 0x78, 0x0F, 0x3C, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x87, 0x0F,
  0xF1, 0xC7, 0xFC, 0x71, 0xE7, 0x9C, 0xF0, 0xF7, 0x3C, 0x1F, 0x8F, 0x03,
  0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x1E, 0x1F, 0xC7, 0xFF, 0xF8, 0xFF, 0xDE,
  0x1F, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x60, 0x00, 0x40, 0x0E,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0C,
  0x00, 0x40, 0x40, 0x0E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x0E,
  0x00, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x43, 0x86, 0x79,
  0x9E, 0xFD, 0xBE, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x1E,
  0xF0, 0x3E, 0x78, 0x3C, 0x7C, 0x0C, 0x30, 0x08, 0x20, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x0F, 0x8F, 0xE7, 0xF1,
  0xF8, 0xFC, 0x1C, 0x1E, 0x1E, 0x7E, 0x1E, 0x08, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x0F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E, 0xF0, 0x1E, 0xF0,
  0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE3, 0x8F, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3,
  0xCF, 0xE1, 0x8F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0,
  0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x01,
  0x80, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x01, 0xFE, 0x0F, 0xFC, 0x1F, 0x78,
  0x3C, 0xF0, 0x21, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x07, 0xC0,
  0x3F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x70, 0x3C, 0x20, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE2, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFF,
  0x81, 0xFF, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE8, 0x07, 0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0xF0, 0x04,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1E, 0xF0, 0x1E, 0x78, 0x0E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x07,
  0x87, 0x83, 0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x79, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0xFF,
  0xC1, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF4, 0x07, 0xEF, 0xFF, 0xBF, 0xFE, 0x3F,
  0xF0, 0x02, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF7, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E,
  0x7C, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF8, 0x1E, 0x78,
  0x1E, 0x7E, 0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0xFC, 0x78,
  0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0x01, 0x00, 0x07, 0xC0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7E, 0xFC, 0x78, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFE, 0x07, 0xDE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x3E, 0x3F, 0x3F, 0x3F, 0x1F, 0x0F, 0x0E, 0x3C, 0xFC, 0xF0,
  0xC0, 0x00, 0x02, 0x00, 0x1E, 0x00, 0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0xF8,
  0x00, 0x40, 0x00, 0x0F, 0x83, 0xFF, 0x3F, 0xFC, 0xFF, 0xF4, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xFE,
  0x03, 0xFF, 0x83, 0xE1, 0xE3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x0E, 0xF0,
  0x07, 0x70, 0x7F, 0xB8, 0x7F, 0xDC, 0x7F, 0xFE, 0x3C, 0x7F, 0x3C, 0x3F,
  0x9E, 0x1F, 0xCF, 0x0F, 0xE7, 0x87, 0xF3, 0xC3, 0xF9, 0xE1, 0xFC, 0xF0,
  0xEE, 0x3C, 0x77, 0x1F, 0xFB, 0x87, 0xFD, 0xE1, 0xFE, 0x70, 0x10, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0xC0,
  0x07, 0x78, 0x01, 0xE7, 0x00, 0x38, 0xF0, 0x07, 0x1E, 0x01, 0xE1, 0xC0,
  0x3C, 0x3C, 0x07, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xF0, 0x0F, 0x1C, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0x04, 0x00, 0xFF,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0xF8, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xF0, 0x00,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1, 0xF0, 0x11, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x08, 0x7F, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xF8, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3E, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE1, 0xF0, 0x11, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x3D, 0xC0, 0x1E, 0xF0, 0x0F, 0x78, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0x78, 0xF8, 0x3C, 0x7F,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x18, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xFA, 0x01, 0xE6, 0x07, 0xDF, 0xFF, 0x3F, 0xFE, 0x1F, 0xF0, 0x03,
  0x00, 0xF0, 0x1F, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x0F, 0x8F, 0x07, 0x87,
  0x87, 0x83, 0xC7, 0xC1, 0xE7, 0xC0, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xBE, 0x03, 0xCF, 0x81, 0xE3, 0xE0, 0xF0,
  0xF8, 0x78, 0x3E, 0x3C, 0x0F, 0x1E, 0x07, 0xCF, 0x01, 0xF7, 0x80, 0x7B,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x38, 0x0F, 0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x83, 0xE7, 0xE1, 0xF3,
  0xF0, 0xD9, 0xD8, 0xEE, 0xEE, 0x77, 0x77, 0x33, 0xB9, 0xB9, 0xDC, 0xFC,
  0xEE, 0x7C, 0x77, 0x3E, 0x3B, 0x8F, 0x1D, 0xC7, 0x8F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xF7, 0x0F, 0xF7, 0x8F,
  0xF3, 0x8F, 0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xEF, 0xF0, 0xEF, 0xF0, 0xEF,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3C, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x1E, 0xF0, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x7C, 0x0F, 0x0F, 0x87, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8,
  0x00, 0x30, 0x00, 0x04, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xEE, 0x07,
  0xDC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFE, 0x07, 0xDF, 0xFF, 0xBF, 0xFC, 0x7F, 0xF0, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C,
  0x1F, 0x1E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x7C,
  0x0F, 0x0F, 0x07, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF0,
  0x00, 0x04, 0x04, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x07,
  0xC7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0,
  0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x80,
  0xF3, 0xC0, 0x79, 0xE0, 0x1E, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7F, 0x7C, 0x78, 0x04, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x60, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x3E, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF0, 0x01, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0x70, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x01, 0xE1, 0xC0, 0x38, 0xF0, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0x77, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0xF1, 0xDC, 0x78, 0xEE, 0x7C,
  0x77, 0x3F, 0x3B, 0x9B, 0x9D, 0xDD, 0xCE, 0xEE, 0x67, 0x77, 0x3B, 0xBB,
  0x1D, 0xDF, 0x86, 0xCF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0x78, 0xF0, 0x3C,
  0x70, 0x1E, 0xF8, 0x07, 0x9E, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x1E,
  0x1E, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x77, 0x80,
  0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x7C,
  0x0F, 0x1E, 0x01, 0xEF, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x7C, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE0,
  0x78, 0x78, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x3C, 0x1F,
  0x1F, 0x03, 0xC7, 0x80, 0x7B, 0xE0, 0x1F, 0x30, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x70, 0xF8, 0x7C, 0x1F, 0x0E,
  0x04, 0x0F, 0xC0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x0F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFF, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x7F, 0xFE, 0xFF, 0xFC, 0x7F,
  0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF3, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF,
  0x07, 0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0x78, 0x3E, 0xFF, 0xF9,
  0xFF, 0xE3, 0xFF, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x02,
  0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x01, 0x8F,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x7C, 0x0F, 0x3E, 0x0F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF,
  0x01, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0xF3, 0xC0,
  0x39, 0xE0, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x04, 0x1F, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0,
  0xF8, 0x70, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3C,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x3E, 0x1F, 0x3F, 0xFF, 0x1F,
  0xFF, 0x07, 0xEF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x20, 0x3E, 0x3F,
  0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x03, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF7, 0x83, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC2, 0x03, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x60, 0x07, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xB0, 0x7D, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x38, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3,
  0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xF7,
  0xC0, 0xF3, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x3C, 0xF0,
  0x3E, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC2, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x0C, 0x0C, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0x1C, 0x3F, 0x8E, 0x1F, 0xC7, 0x8F,
  0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1, 0xFC, 0x78, 0xFE, 0x3C, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xE0, 0x0F, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0,
  0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xF3, 0xC0,
  0x79, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xF0, 0x3C, 0x7C, 0x3E, 0x3F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF,
  0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0x7C, 0x3E, 0xFF,
  0xF9, 0xFF, 0xF3, 0xFF, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x3E, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x3E, 0x1F,
  0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x03, 0xE5, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7,
  0x80, 0x4F, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xB0, 0x0F, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x83, 0x07, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xDF, 0xFF, 0x7F, 0xFC, 0x7F, 0xF0,
  0xF0, 0x07, 0xFE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x78, 0x0F, 0x0F,
  0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x00, 0xF3,
  0xC0, 0x3C, 0xE0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE1, 0xE3, 0xBC, 0x78, 0xEF, 0x1E, 0x39, 0xCF, 0x8E, 0x73,
  0xF3, 0x9C, 0xFC, 0xE7, 0x77, 0x39, 0xDC, 0xFC, 0x77, 0x3F, 0x1F, 0x8F,
  0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F, 0x03, 0x80, 0xF8, 0x07,
  0x9F, 0x03, 0xC3, 0xC1, 0xE0, 0x78, 0x78, 0x0F, 0x3C, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3D,
  0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x83, 0xC1, 0xF1, 0xE0, 0x3C, 0x78, 0x07,
  0xBC, 0x01, 0xF0, 0x78, 0x07, 0xBC, 0x03, 0xDF, 0x01, 0xC7, 0x81, 0xE3,
  0xC0, 0xF1, 0xE0, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x0E, 0x1E, 0x07, 0x8E,
  0x03, 0xCF, 0x00, 0xF7, 0x80, 0x7B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x03,
  0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7F, 0xC1,
  0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7F,
  0x00, 0x7C, 0x07, 0xF0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0xF3, 0xFC,
  0x39, 0xFF, 0xFE, 0x71, 0xFF, 0x38, 0x1F, 0xC2, 0x01, 0xC0,
};

const GFXglyph UbuntuSansMono_Medium35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 11, 11, 20, 4, -27 },
  { 35, 18, 24, 20, 1, -24 },
  { 89, 16, 31, 20, 2, -27 },
  { 151, 18, 26, 20, 1, -25 },
  { 210, 18, 25, 20, 1, -25 },
  { 267, 4, 11, 20, 8, -27 },
  { 273, 12, 35, 20, 4, -28 },
  { 326, 11, 35, 20, 4, -28 },
  { 375, 16, 15, 20, 2, -24 },
  { 405, 16, 17, 20, 2, -19 },
  { 439, 9, 12, 20, 5, -6 },
  { 453, 10, 4, 20, 5, -12 },
  { 458, 6, 6, 20, 7, -6 },
  { 463, 15, 33, 20, 2, -27 },
  { 525, 16, 26, 20, 2, -25 },
  { 577, 15, 24, 20, 3, -24 },
  { 622, 16, 25, 20, 2, -25 },
  { 672, 15, 26, 20, 2, -25 },
  { 721, 17, 24, 20, 1, -24 },
  { 772, 15, 25, 20, 2, -24 },
  { 819, 16, 25, 20, 2, -24 },
  { 869, 16, 24, 20, 2, -24 },
  { 917, 16, 26, 20, 2, -25 },
  { 969, 16, 25, 20, 2, -25 },
  { 1019, 6, 18, 20, 7, -18 },
  { 1033, 8, 24, 20, 5, -18 },
  { 1057, 16, 16, 20, 2, -18 },
  { 1089, 16, 11, 20, 2, -16 },
  { 1111, 16, 16, 20, 2, -18 },
  { 1143, 13, 25, 20, 3, -25 },
  { 1184, 17, 30, 20, 1, -25 },
  { 1248, 19, 24, 20, 0, -24 },
  { 1305, 16, 25, 20, 2, -25 },
  { 1355, 17, 26, 20, 1, -25 },
  { 1411, 16, 25, 20, 2, -25 },
  { 1461, 15, 24, 20, 3, -24 },
  { 1506, 14, 24, 20, 3, -24 },
  { 1548, 17, 26, 20, 1, -25 },
  { 1604, 16, 24, 20, 2, -24 },
  { 1652, 14, 24, 20, 3, -24 },
  { 1694, 15, 25, 20, 2, -24 },
  { 1741, 17, 24, 20, 2, -24 },
  { 1792, 15, 24, 20, 3, -24 },
  { 1837, 17, 24, 20, 1, -24 },
  { 1888, 16, 24, 20, 2, -24 },
  { 1936, 18, 26, 20, 1, -25 },
  { 1995, 15, 25, 20, 3, -25 },
  { 2042, 18, 32, 20, 1, -25 },
  { 2114, 17, 25, 20, 2, -25 },
  { 2168, 16, 26, 20, 2, -25 },
  { 2220, 17, 24, 20, 1, -24 },
  { 2271, 16, 25, 20, 2, -24 },
  { 2321, 18, 24, 20, 1, -24 },
  { 2375, 17, 24, 20, 1, -24 },
  { 2426, 18, 24, 20, 1, -24 },
  { 2480, 18, 24, 20, 1, -24 },
  { 2534, 16, 24, 20, 2, -24 },
  { 2582, 10, 33, 20, 5, -27 },
  { 2624, 15, 33, 20, 2, -27 },
  { 2686, 10, 33, 20, 4, -27 },
  { 2728, 18, 13, 20, 1, -24 },
  { 2758, 19, 3, 20, 0, 3 },
  { 2766, 8, 7, 20, 6, -27 },
  { 2773, 15, 19, 20, 2, -19 },
  { 2809, 15, 27, 20, 3, -27 },
  { 2860, 16, 19, 20, 2, -19 },
  { 2898, 16, 27, 20, 1, -27 },
  { 2952, 17, 19, 20, 1, -19 },
  { 2993, 17, 27, 20, 2, -27 },
  { 3051, 16, 26, 20, 1, -19 },
  { 3103, 14, 27, 20, 3, -27 },
  { 3151, 16, 27, 20, 2, -27 },
  { 3205, 13, 34, 20, 2, -27 },
  { 3261, 16, 27, 20, 3, -27 },
  { 3315, 16, 27, 20, 2, -27 },
  { 3369, 17, 19, 20, 1, -19 },
  { 3410, 14, 19, 20, 3, -19 },
  { 3444, 17, 19, 20, 1, -19 },
  { 3485, 15, 25, 20, 3, -19 },
  { 3532, 16, 25, 20, 1, -19 },
  { 3582, 14, 19, 20, 4, -19 },
  { 3616, 15, 19, 20, 2, -19 },
  { 3652, 16, 24, 20, 2, -24 },
  { 3700, 14, 18, 20, 3, -18 },
  { 3732, 18, 18, 20, 1, -18 },
  { 3773, 18, 18, 20, 1, -18 },
  { 3814, 18, 18, 20, 1, -18 },
  { 3855, 17, 25, 20, 1, -18 },
  { 3909, 14, 18, 20, 3, -18 },
  { 3941, 14, 33, 20, 3, -27 },
  { 3999, 4, 33, 20, 8, -27 },
  { 4016, 14, 33, 20, 3, -27 },
  { 4074, 18, 7, 20, 1, -14 },
};

const GFXfont UbuntuSansMono_Medium35pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium35pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium35pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUSANSMONO_MEDIUM35PT7B_H_
