#ifndef _UBUNTUSANSMONO_MEDIUM43PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium43pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00,
  0x18, 0x7E, 0x7E, 0xFF, 0xFE, 0x7E, 0x7E, 0x10, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0xDE, 0x1E, 0x78, 0x79,
  0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x38, 0x01, 0xF0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0x80,
  0x3C, 0x1E, 0x00, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C,
  0x03, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80,
  0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0x87, 0xC7, 0xE0, 0x04, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF7, 0x00, 0x3E, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x81,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x3D, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xBC, 0xF0, 0x3C, 0xE1, 0xC0, 0xF3, 0x87, 0x07, 0x8E, 0x1C, 0x1C,
  0x38, 0x70, 0xF0, 0xE1, 0xC7, 0x83, 0x87, 0x1C, 0x0F, 0x3C, 0xF0, 0x3F,
  0xF7, 0x80, 0x7F, 0x9E, 0x00, 0xFC, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF3, 0xF0, 0x03, 0x9F, 0xE0, 0x1E, 0x7F, 0x80, 0xF3, 0xCF,
  0x03, 0x8E, 0x1C, 0x1E, 0x38, 0x70, 0xF0, 0xE1, 0xC3, 0xC3, 0x87, 0x1E,
  0x0E, 0x1C, 0x70, 0x38, 0x73, 0xC0, 0xF3, 0xDE, 0x03, 0xFF, 0x70, 0x07,
  0xFB, 0xC0, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xF1,
  0xE0, 0x03, 0xDF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0x07, 0xFC, 0x3C, 0x3F, 0xF8, 0xF0, 0xFB, 0xE3, 0xC7, 0xC7, 0xCF, 0x1E,
  0x0F, 0xBC, 0xF8, 0x1F, 0xE3, 0xE0, 0x7F, 0x8F, 0x80, 0xFE, 0x3E, 0x01,
  0xF0, 0x78, 0x07, 0xE1, 0xF0, 0x3F, 0xC7, 0xF3, 0xFF, 0x0F, 0xFF, 0xBE,
  0x1F, 0xFC, 0xF8, 0x3F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7,
  0xBD, 0xEF, 0x38, 0x00, 0x10, 0x00, 0xE0, 0x07, 0xC0, 0x7F, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x00, 0x38, 0x00, 0x40, 0x20, 0x01, 0xC0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0x78, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x04, 0x1E, 0x04, 0xE3, 0xC7, 0xBF, 0x39, 0xF7,
  0xF6, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xF0, 0x07, 0xC0, 0x03, 0xFC, 0x00,
  0xFB, 0xC0, 0x3E, 0x7C, 0x07, 0xCF, 0xC1, 0xF0, 0xF8, 0x1E, 0x1E, 0x01,
  0x81, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF1, 0xFC, 0x1E, 0x07, 0x83, 0xC7, 0xF3, 0xF8, 0xF8, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x3F, 0x07, 0xC3, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x86, 0x1F, 0xF8, 0xF1,
  0xFF, 0x9F, 0x9F, 0xF9, 0xF9, 0xFF, 0x9F, 0x9F, 0xF8, 0xF1, 0xFF, 0x86,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x7C, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFE, 0x03, 0xF7, 0xC0, 0x78, 0xF8, 0x0C, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x07, 0xFC,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x7C, 0x0F, 0xC3, 0x00,
  0x7C, 0x20, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0x80,
  0xFC, 0x40, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xEC, 0x00, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF1, 0x7F, 0xFC,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xDE, 0x00, 0x3C, 0xF0,
  0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x01, 0xF0,
  0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x87,
  0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC7, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF1, 0xFE,
  0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01,
  0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xE0,
  0x7E, 0x3F, 0xDF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x01,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x3F, 0x07, 0xC3, 0xF8,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xF7, 0xFC, 0x3E,
  0x1F, 0xC7, 0xC0, 0x7E, 0x78, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xF8, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x60,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xE0,
  0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01, 0xF3,
  0xF8, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1E, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7E, 0x08, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF1, 0xF8,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F,
  0x8F, 0xF3, 0xFC, 0xFF, 0x1F, 0xC7, 0xF0, 0x38, 0x1E, 0x0F, 0x1F, 0xCF,
  0xE3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xE0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x70, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFE, 0x60, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xF0, 0xFC, 0x1F, 0x00, 0xF0, 0x78, 0x03, 0xE3,
  0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x79, 0xF0, 0x3F, 0xF7, 0x81,
  0xFF, 0xDE, 0x0F, 0xFF, 0x78, 0x7F, 0xFD, 0xE3, 0xF1, 0xF7, 0x8F, 0x87,
  0xDE, 0x3C, 0x1F, 0xF8, 0xF0, 0x7F, 0xE3, 0xC1, 0xFF, 0x8F, 0x07, 0xDE,
  0x3C, 0x1F, 0x78, 0xF0, 0x7D, 0xE3, 0xC1, 0xF7, 0x8F, 0x87, 0xDE, 0x3E,
  0x1F, 0x78, 0x7F, 0xFD, 0xF1, 0xFF, 0xF3, 0xC1, 0xFF, 0xCF, 0x03, 0xFE,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x20, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x02,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7,
  0x80, 0x01, 0xE7, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x01, 0xF9, 0xE0, 0x1F, 0x3C, 0x01, 0xF7,
  0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x0F, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xF0, 0x7F, 0x9E,
  0x01, 0xFB, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xC0, 0x63, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x02,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1E,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x07,
  0xF9, 0xE0, 0x3F, 0x3C, 0x03, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xF7, 0x80, 0x7E, 0xF0, 0x1F,
  0x9E, 0x07, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F,
  0x80, 0x63, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0,
  0x1F, 0x3F, 0x01, 0xF3, 0xF8, 0x1F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x18, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x20,
  0x07, 0xC6, 0x01, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xF7, 0x80, 0x3F, 0x3C, 0x01, 0xF1,
  0xE0, 0x1F, 0x0F, 0x01, 0xF8, 0x78, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x0F,
  0xC0, 0xF0, 0xFC, 0x07, 0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xE7, 0xC0, 0x0F,
  0x7E, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xF7, 0xF0,
  0x07, 0x9F, 0xC0, 0x3C, 0x7F, 0x01, 0xE1, 0xF8, 0x0F, 0x07, 0xE0, 0x78,
  0x1F, 0x83, 0xC0, 0x7E, 0x1E, 0x03, 0xF0, 0xF0, 0x0F, 0xC7, 0x80, 0x3E,
  0x3C, 0x01, 0xF9, 0xE0, 0x07, 0xEF, 0x00, 0x3F, 0x78, 0x00, 0xFC, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF8, 0x7F, 0x0E, 0xE1, 0xFC, 0x3B, 0x87, 0x79, 0xEF, 0x1D, 0xE7, 0x9C,
  0xF7, 0x9E, 0x73, 0x9E, 0x79, 0xCE, 0x79, 0xE7, 0xF9, 0xE7, 0x8F, 0xC7,
  0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0x79, 0xE1, 0xE1, 0xE7, 0x87, 0x87, 0x9E,
  0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00,
  0x1E, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xBC, 0x1F, 0xFB, 0xC1, 0xFF, 0x9E, 0x1F,
  0xF9, 0xE1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x87, 0x9F, 0xF8, 0x79,
  0xFF, 0x83, 0xDF, 0xF8, 0x3D, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x01, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x03, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0x81, 0xFD, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x03,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF0, 0x3F, 0x8F, 0x00, 0xF8, 0xF0,
  0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF,
  0x00, 0x7C, 0xF0, 0x0F, 0xCF, 0x01, 0xF8, 0xF0, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x07, 0xC0, 0xF0, 0x3E,
  0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00,
  0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0x03,
  0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x01, 0x87,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE7, 0x00, 0x7E, 0x7F, 0x3F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x81,
  0xFF, 0xE0, 0x02, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xE0,
  0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x60, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3C, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x81, 0xE0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0x81, 0xF0,
  0x0F, 0x03, 0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00,
  0x7C, 0x78, 0x00, 0xF9, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E,
  0x1E, 0x1E, 0x78, 0x78, 0x79, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F,
  0x1E, 0x79, 0xFE, 0x79, 0xE7, 0xB9, 0xE7, 0x9C, 0xE7, 0x9E, 0x73, 0xDE,
  0x7B, 0xC7, 0x78, 0xEE, 0x1D, 0xE3, 0xB8, 0x77, 0x0F, 0xE1, 0xFC, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC0, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xE3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x07, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFF,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x3C, 0x00, 0x7C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0x7C, 0x3E,
  0x01, 0xF1, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xCE, 0x00, 0x1E, 0x08, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x20, 0x38, 0x3E, 0x1F, 0x83, 0xE0, 0xFC, 0x3C, 0x04, 0x0F, 0xF8,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x30, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFD, 0xF1, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFE, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x01, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE7, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x3F, 0xC7, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80,
  0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0xC0, 0xE3, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x11, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x01,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0xCF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xC7,
  0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xE0, 0x3E, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x0E, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x07, 0xE7, 0xE0,
  0x3E, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x43, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0x01, 0x81,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xF0,
  0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x07, 0xE7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF9, 0xC0, 0x7F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC,
  0x07, 0xFE, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xBF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xE3,
  0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x10, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x40, 0x3E, 0x70, 0x7E, 0x7F, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0xF8,
  0x0F, 0xCF, 0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F,
  0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xBF, 0x80, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x3E,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x10, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x20, 0x3F, 0x07, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF1, 0xF1, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xFC, 0x3F, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03,
  0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x83, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0xFB, 0xF0, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3E,
  0xFF, 0x07, 0xC3, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xF8, 0x3E, 0xFC, 0x07, 0xDF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x1F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFE, 0xF8, 0x02, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x07,
  0xFE, 0xBF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFD, 0xF7, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x03, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7E, 0x03, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF6, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xC3, 0xFF, 0xC0, 0x02, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x10, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF,
  0x81, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x06,
  0x00, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0x87,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF7, 0x87, 0x83, 0xDE, 0x1F, 0x1E,
  0x78, 0xFC, 0x79, 0xE3, 0xF1, 0xE7, 0x8F, 0xE7, 0x9E, 0x7F, 0x9E, 0x79,
  0xCE, 0x78, 0xE7, 0x39, 0xC3, 0xBC, 0xF7, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x78, 0x07, 0x80, 0xFC, 0x00, 0xF8, 0xF8, 0x07, 0xC1, 0xF0, 0x3E, 0x07,
  0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x7C, 0x00,
  0xFB, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC1, 0xE0,
  0x3C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x02, 0x0F, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x07,
  0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0x00, 0xE3, 0xFF, 0x03, 0xCF, 0xFF, 0x1E, 0x7F, 0xFF, 0xF9, 0xE1, 0xFF,
  0xC7, 0x01, 0xFF, 0x2C, 0x01, 0xF0,
};

const GFXglyph UbuntuSansMono_Medium43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 31, 24, 8, -30 },
  { 32, 14, 13, 24, 5, -33 },
  { 55, 22, 30, 24, 1, -30 },
  { 138, 20, 38, 24, 2, -33 },
  { 233, 22, 31, 24, 1, -30 },
  { 319, 22, 30, 24, 1, -30 },
  { 402, 5, 14, 24, 10, -33 },
  { 411, 14, 42, 24, 5, -34 },
  { 485, 14, 42, 24, 5, -34 },
  { 559, 19, 18, 24, 3, -30 },
  { 602, 20, 21, 24, 2, -23 },
  { 655, 10, 14, 24, 7, -7 },
  { 673, 12, 5, 24, 6, -15 },
  { 681, 8, 8, 24, 8, -7 },
  { 689, 18, 42, 24, 3, -34 },
  { 784, 20, 31, 24, 2, -30 },
  { 862, 19, 30, 24, 3, -30 },
  { 934, 20, 30, 24, 2, -30 },
  { 1009, 19, 31, 24, 2, -30 },
  { 1083, 21, 30, 24, 2, -30 },
  { 1162, 18, 31, 24, 3, -30 },
  { 1232, 20, 31, 24, 2, -30 },
  { 1310, 19, 30, 24, 3, -30 },
  { 1382, 20, 32, 24, 2, -31 },
  { 1462, 20, 31, 24, 2, -31 },
  { 1540, 8, 23, 24, 8, -22 },
  { 1563, 10, 29, 24, 6, -22 },
  { 1600, 20, 20, 24, 2, -22 },
  { 1650, 20, 13, 24, 2, -19 },
  { 1683, 20, 20, 24, 2, -22 },
  { 1733, 16, 31, 24, 4, -30 },
  { 1795, 22, 37, 24, 1, -30 },
  { 1897, 24, 30, 24, 0, -30 },
  { 1987, 19, 30, 24, 3, -30 },
  { 2059, 20, 31, 24, 2, -30 },
  { 2137, 19, 30, 24, 3, -30 },
  { 2209, 18, 30, 24, 4, -30 },
  { 2277, 17, 30, 24, 4, -30 },
  { 2341, 20, 31, 24, 2, -30 },
  { 2419, 20, 30, 24, 2, -30 },
  { 2494, 17, 30, 24, 4, -30 },
  { 2558, 19, 31, 24, 2, -30 },
  { 2632, 21, 30, 24, 3, -30 },
  { 2711, 18, 30, 24, 4, -30 },
  { 2779, 22, 30, 24, 1, -30 },
  { 2862, 20, 30, 24, 2, -30 },
  { 2937, 22, 31, 24, 1, -30 },
  { 3023, 19, 30, 24, 3, -30 },
  { 3095, 22, 38, 24, 1, -30 },
  { 3200, 20, 30, 24, 3, -30 },
  { 3275, 20, 31, 24, 2, -30 },
  { 3353, 20, 30, 24, 2, -30 },
  { 3428, 20, 31, 24, 2, -30 },
  { 3506, 23, 30, 24, 1, -30 },
  { 3593, 22, 30, 24, 1, -30 },
  { 3676, 22, 30, 24, 1, -30 },
  { 3759, 23, 30, 24, 1, -30 },
  { 3846, 20, 30, 24, 2, -30 },
  { 3921, 13, 42, 24, 6, -34 },
  { 3990, 18, 42, 24, 3, -34 },
  { 4085, 13, 42, 24, 5, -34 },
  { 4154, 22, 17, 24, 1, -30 },
  { 4201, 24, 4, 24, 0, 4 },
  { 4213, 9, 8, 24, 8, -33 },
  { 4222, 18, 24, 24, 3, -23 },
  { 4276, 19, 34, 24, 3, -33 },
  { 4357, 20, 24, 24, 2, -23 },
  { 4417, 19, 34, 24, 2, -33 },
  { 4498, 20, 24, 24, 2, -23 },
  { 4558, 21, 33, 24, 2, -33 },
  { 4645, 19, 31, 24, 2, -23 },
  { 4719, 18, 33, 24, 3, -33 },
  { 4794, 20, 34, 24, 2, -33 },
  { 4879, 16, 41, 24, 3, -33 },
  { 4961, 20, 33, 24, 3, -33 },
  { 5044, 20, 34, 24, 2, -33 },
  { 5129, 20, 23, 24, 2, -23 },
  { 5187, 18, 23, 24, 3, -23 },
  { 5239, 20, 24, 24, 2, -23 },
  { 5299, 19, 31, 24, 3, -23 },
  { 5373, 19, 31, 24, 2, -23 },
  { 5447, 17, 23, 24, 5, -23 },
  { 5496, 18, 24, 24, 3, -23 },
  { 5550, 20, 30, 24, 2, -29 },
  { 5625, 18, 23, 24, 3, -22 },
  { 5677, 22, 22, 24, 1, -22 },
  { 5738, 22, 22, 24, 1, -22 },
  { 5799, 22, 22, 24, 1, -22 },
  { 5860, 21, 30, 24, 1, -22 },
  { 5939, 18, 22, 24, 3, -22 },
  { 5989, 18, 42, 24, 3, -34 },
  { 6084, 4, 42, 24, 10, -34 },
  { 6105, 18, 42, 24, 3, -34 },
  { 6200, 22, 8, 24, 1, -17 },
};

const GFXfont UbuntuSansMono_Medium43pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium43pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium43pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UBUNTUSANSMONO_MEDIUM43PT7B_H_
