#ifndef _UBUNTUSANSMONO_MEDIUM57PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium57pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE7, 0xF8, 0xFC, 0x0C, 0x00, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC1, 0xF8, 0x3F, 0x80, 0x06, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFD, 0x00, 0x00, 0x7F, 0x70, 0x00, 0x3F, 0x9F,
  0xC0, 0x3F, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0xFF, 0xC0,
  0x03, 0xE3, 0xFF, 0x00, 0x0F, 0x9F, 0xFE, 0x00, 0x7C, 0x78, 0xF8, 0x03,
  0xE3, 0xE1, 0xF0, 0x0F, 0x8F, 0x87, 0xC0, 0x7C, 0x3C, 0x1F, 0x03, 0xE0,
  0xF0, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0xC1, 0xF0, 0x3C,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x7C, 0x03, 0xE1, 0xF1, 0xF0, 0x07, 0x8F,
  0x8F, 0x80, 0x1F, 0xFE, 0x7C, 0x00, 0x7F, 0xF1, 0xF0, 0x00, 0xFF, 0xCF,
  0x80, 0x01, 0xFC, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xFE, 0x00, 0x0F, 0x8F, 0xFC,
  0x00, 0x3E, 0x7F, 0xF8, 0x01, 0xF1, 0xF3, 0xE0, 0x0F, 0x8F, 0x87, 0x80,
  0x3E, 0x3E, 0x1F, 0x01, 0xF0, 0xF0, 0x7C, 0x07, 0xC3, 0xC0, 0xF0, 0x3E,
  0x0F, 0x03, 0xC1, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x3C, 0x3E, 0x03,
  0xE1, 0xF1, 0xF0, 0x0F, 0x87, 0xC7, 0xC0, 0x3E, 0x1E, 0x3E, 0x00, 0x7C,
  0xF8, 0xF8, 0x01, 0xFF, 0xE7, 0xC0, 0x03, 0xFF, 0x3E, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x01, 0xFC, 0x1F,
  0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x81,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x7C, 0x0F, 0xFE, 0x07, 0xC1, 0xFF, 0xE0, 0x7C, 0x3F, 0xFF, 0x07,
  0xC3, 0xF3, 0xF8, 0x7C, 0x7E, 0x1F, 0xCF, 0xC7, 0xE0, 0xFE, 0xFC, 0xFC,
  0x07, 0xFF, 0x8F, 0xC0, 0x7F, 0xF8, 0xFC, 0x03, 0xFF, 0x8F, 0xC0, 0x1F,
  0xF0, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xF8, 0x7F, 0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF, 0x87, 0xF0, 0x7F, 0xE0, 0x3F,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x04,
  0x10, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x03, 0xF0, 0x10,
  0xF0, 0x78, 0x3C, 0x7F, 0x1E, 0x3F, 0x9F, 0xF7, 0xBF, 0xE7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF0, 0x3F,
  0x00, 0x7C, 0x0F, 0x80, 0x06, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x3F, 0x03, 0xFC, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x7E,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0C, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x8F, 0xC0, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xF8,
  0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE7,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x30, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F,
  0xC3, 0xFF, 0xC3, 0xF8, 0xFF, 0xF1, 0xFE, 0x3F, 0xFC, 0x3F, 0x8F, 0xFF,
  0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0x30, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x3F,
  0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xEF, 0xC0,
  0x1F, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0x81, 0xF8, 0x01, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xE0, 0x0F, 0xF0, 0xE0, 0x01, 0xFC,
  0x10, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xF8, 0x1F, 0xF0, 0x60, 0x03, 0xF8, 0x20, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xA0, 0x00, 0x3F, 0xDE, 0x00, 0x7F, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xA0, 0x00, 0x3F, 0x9E,
  0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x3C, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x1F, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F,
  0xC0, 0x0F, 0xC7, 0xF8, 0x03, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xE0, 0xFE,
  0x07, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0xFF, 0xE0, 0xFE, 0x07, 0xFC, 0x7F,
  0x00, 0x7F, 0x9F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE7, 0xF8, 0x07, 0xF9, 0xFF,
  0xDF, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7E,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8, 0x01, 0xFC, 0xFF, 0xC7, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x0C, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0xC0, 0x01, 0x80, 0x3F, 0x03,
  0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF0, 0x3F,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0xF0, 0x3F, 0xC3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3E,
  0x03, 0xF0, 0x3F, 0x0F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF9, 0xF0, 0x1F, 0xE2, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0x80,
  0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0xF7, 0xC0, 0x3F, 0xFF, 0x7C, 0x07, 0xFF, 0xF7, 0xC0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0xFC, 0x3F, 0x83,
  0xFF, 0xC3, 0xF0, 0x3F, 0xFC, 0x3F, 0x03, 0xFF, 0x87, 0xE0, 0x3F, 0xF8,
  0x7E, 0x03, 0xFF, 0x87, 0xE0, 0x3F, 0xF8, 0x7E, 0x03, 0xFF, 0x87, 0xE0,
  0x3F, 0xF8, 0x7E, 0x03, 0xFF, 0xC7, 0xE0, 0x3F, 0xFC, 0x3F, 0x03, 0xFF,
  0xC3, 0xF0, 0x3F, 0xFC, 0x3F, 0x03, 0xF7, 0xC3, 0xF8, 0x3F, 0x7C, 0x1F,
  0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xF3, 0xE0, 0x7F, 0xFF,
  0x3F, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0x80, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x18, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F,
  0xE0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F,
  0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80,
  0x0F, 0xCF, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x07, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x1F, 0xFB, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFC, 0x0F,
  0xF8, 0x00, 0xC0, 0xFE, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x04, 0x0F, 0xFC, 0x01, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0x80,
  0xFF, 0x87, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00,
  0x3F, 0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F,
  0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0,
  0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x1F, 0xF8,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0x83, 0xFC, 0x00, 0x30,
  0xFF, 0x00, 0x02, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xFE, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xE3, 0xFC, 0x00, 0xFC, 0x3F, 0xE0, 0x1F, 0x83, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x20, 0x00, 0x7F, 0x30, 0x00,
  0xFE, 0x3C, 0x03, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xF3, 0xF0, 0x01, 0xFE, 0x7E, 0x00, 0x3F, 0x8F,
  0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xFC, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x1F,
  0xC0, 0xFC, 0x07, 0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7E,
  0x0F, 0xE0, 0x0F, 0xC3, 0xFC, 0x01, 0xF8, 0xFF, 0x00, 0x3F, 0x1F, 0xC0,
  0x07, 0xE7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0x7F, 0xC0, 0x07, 0xE7, 0xFC, 0x00, 0xFC, 0x7F, 0xC0, 0x1F, 0x87,
  0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x7E, 0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0x81,
  0xF8, 0x07, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xF0, 0xFC, 0x00,
  0xFF, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFE, 0x7E, 0x00, 0x1F, 0xCF,
  0xC0, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xDE, 0x07, 0xBC,
  0x7D, 0xE0, 0x7B, 0xE7, 0xDE, 0x0F, 0xBE, 0x7D, 0xF0, 0xF3, 0xE7, 0xCF,
  0x0F, 0x3E, 0x7C, 0xF1, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x79, 0xE3,
  0xE7, 0xC7, 0xBE, 0x3E, 0x7C, 0x7F, 0xE3, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C,
  0x3F, 0xC3, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8,
  0x3E, 0x7C, 0x1F, 0x83, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFD, 0xF8, 0x0F, 0xFF, 0x7E, 0x03, 0xFF, 0xCF, 0xC0, 0xFF, 0xF1, 0xF0,
  0x3F, 0xFC, 0x7E, 0x0F, 0xFF, 0x0F, 0x83, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0,
  0x7C, 0x3F, 0xFC, 0x1F, 0x0F, 0xFF, 0x03, 0xE3, 0xFF, 0xC0, 0xF8, 0xFF,
  0xF0, 0x1F, 0x3F, 0xFC, 0x07, 0xCF, 0xFF, 0x00, 0xFB, 0xFF, 0xC0, 0x3E,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xCF, 0xC0, 0x0F, 0xF3, 0xF0, 0x01, 0xFE, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xFB, 0xF0, 0x07, 0xFC,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x40, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x3F, 0x80, 0x7F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0,
  0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF9,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xFC, 0x7F, 0x0F, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xBF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xF8, 0x0F, 0x83, 0xF8, 0x00, 0x61, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC8, 0x00, 0x0F, 0xE7, 0xC0, 0x07,
  0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFE, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC1, 0xF8, 0x3E, 0xFC, 0x1F, 0x83,
  0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x3F, 0xC3, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C,
  0x3F, 0xC3, 0xE7, 0xC7, 0xFC, 0x3E, 0x7C, 0x7F, 0xE3, 0xE7, 0xC7, 0x9E,
  0x3E, 0x7C, 0xF9, 0xE3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF0, 0xF3, 0xE7,
  0xCF, 0x0F, 0x3E, 0x7D, 0xF0, 0xFB, 0xE7, 0xDE, 0x07, 0xBE, 0x7D, 0xE0,
  0x7B, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x38, 0x04, 0x00,
  0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x10, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1E, 0x00, 0x40, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x30, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xBF, 0xC0, 0x0F, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xEF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0xCF, 0xE0, 0x1F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0x30,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x61, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xF3,
  0xF8, 0x03, 0xFB, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0,
  0x03, 0xF7, 0xF8, 0x01, 0xF9, 0xFE, 0x00, 0xFC, 0xFF, 0x80, 0x7E, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xCF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF8, 0x3E, 0x01, 0xFE, 0x00, 0x20, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xF8, 0x07, 0xF3,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF,
  0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x07, 0xF3, 0xFE, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0x00,
  0x0C, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0x80, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x20, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x18, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE4, 0x00, 0x7E, 0x78, 0x0F, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF9, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xF7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x3F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x07,
  0xF8, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x18, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0xFF, 0x0F, 0xFF, 0xDF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xC3, 0xF8, 0x7E, 0xFC, 0x1F, 0x03, 0xEF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F,
  0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x04, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x03,
  0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0xFF, 0x8F, 0xE0, 0x0F, 0xF3,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xBF, 0xF8, 0x0F, 0xE0, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFC, 0x07, 0xF3, 0xFC,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xF7, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0xE0, 0x7F,
  0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF7, 0xF0, 0x01, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xBF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03,
  0xFF, 0xFA, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0x80, 0x3C, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x40, 0x00, 0x7F, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x70, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0xC0, 0x7F, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x01, 0xF0, 0x3E, 0x7C, 0x0F,
  0xC0, 0xF9, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x87, 0xF8,
  0x7E, 0x7E, 0x1F, 0xE1, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xE1, 0xFF, 0x1F,
  0x0F, 0x8F, 0xFC, 0x7C, 0x3E, 0x3D, 0xF1, 0xF0, 0xF8, 0xF3, 0xC7, 0xC3,
  0xE7, 0xCF, 0x9F, 0x07, 0xDE, 0x3E, 0xF8, 0x1F, 0x78, 0x7B, 0xE0, 0x7F,
  0xE1, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F,
  0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF1, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7E, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x40, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x80, 0xFF, 0x80, 0x1F, 0x1F, 0xFE, 0x01, 0xF3,
  0xFF, 0xF8, 0x3F, 0x7F, 0xFF, 0xE7, 0xE7, 0xFF, 0xFF, 0xFE, 0x7C, 0x1F,
  0xFF, 0xCF, 0x80, 0x7F, 0xFC, 0xF8, 0x03, 0xFF, 0x83, 0x80, 0x0F, 0xE0,
};

const GFXglyph UbuntuSansMono_Medium57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 10, 41, 32, 11, -40 },
  { 53, 18, 16, 32, 7, -43 },
  { 89, 30, 40, 32, 1, -40 },
  { 239, 26, 50, 32, 3, -44 },
  { 402, 30, 41, 32, 1, -40 },
  { 556, 28, 41, 32, 2, -40 },
  { 700, 6, 18, 32, 13, -43 },
  { 714, 18, 56, 32, 7, -45 },
  { 840, 19, 56, 32, 6, -45 },
  { 973, 26, 25, 32, 3, -40 },
  { 1055, 26, 28, 32, 3, -31 },
  { 1146, 13, 19, 32, 9, -10 },
  { 1177, 16, 6, 32, 8, -19 },
  { 1189, 10, 11, 32, 11, -10 },
  { 1203, 24, 56, 32, 4, -45 },
  { 1371, 26, 41, 32, 3, -40 },
  { 1505, 25, 40, 32, 4, -40 },
  { 1630, 26, 40, 32, 3, -40 },
  { 1760, 25, 41, 32, 3, -40 },
  { 1889, 28, 40, 32, 2, -40 },
  { 2029, 25, 41, 32, 3, -40 },
  { 2158, 26, 41, 32, 3, -40 },
  { 2292, 25, 40, 32, 4, -40 },
  { 2417, 26, 41, 32, 3, -40 },
  { 2551, 26, 40, 32, 3, -40 },
  { 2681, 10, 31, 32, 11, -30 },
  { 2720, 13, 39, 32, 8, -30 },
  { 2784, 26, 26, 32, 3, -29 },
  { 2869, 26, 18, 32, 3, -26 },
  { 2928, 26, 26, 32, 3, -29 },
  { 3013, 22, 41, 32, 5, -40 },
  { 3126, 28, 49, 32, 2, -40 },
  { 3298, 30, 40, 32, 1, -40 },
  { 3448, 26, 40, 32, 3, -40 },
  { 3578, 28, 41, 32, 2, -40 },
  { 3722, 27, 40, 32, 3, -40 },
  { 3857, 24, 40, 32, 5, -40 },
  { 3977, 23, 40, 32, 5, -40 },
  { 4092, 27, 41, 32, 2, -40 },
  { 4231, 26, 40, 32, 3, -40 },
  { 4361, 22, 40, 32, 5, -40 },
  { 4471, 24, 41, 32, 3, -40 },
  { 4594, 27, 40, 32, 4, -40 },
  { 4729, 24, 40, 32, 5, -40 },
  { 4849, 28, 40, 32, 2, -40 },
  { 4989, 26, 40, 32, 3, -40 },
  { 5119, 28, 41, 32, 2, -40 },
  { 5263, 26, 40, 32, 4, -40 },
  { 5393, 28, 51, 32, 2, -40 },
  { 5572, 27, 40, 32, 3, -40 },
  { 5707, 26, 41, 32, 3, -40 },
  { 5841, 28, 40, 32, 2, -40 },
  { 5981, 26, 41, 32, 3, -40 },
  { 6115, 30, 40, 32, 1, -40 },
  { 6265, 28, 40, 32, 2, -40 },
  { 6405, 30, 40, 32, 1, -40 },
  { 6555, 30, 40, 32, 1, -40 },
  { 6705, 26, 40, 32, 3, -40 },
  { 6835, 17, 56, 32, 8, -45 },
  { 6954, 24, 56, 32, 4, -45 },
  { 7122, 17, 56, 32, 7, -45 },
  { 7241, 28, 23, 32, 2, -40 },
  { 7322, 30, 6, 32, 1, 5 },
  { 7345, 12, 11, 32, 10, -44 },
  { 7362, 25, 32, 32, 3, -31 },
  { 7462, 26, 45, 32, 4, -44 },
  { 7609, 26, 32, 32, 3, -31 },
  { 7713, 25, 45, 32, 2, -44 },
  { 7854, 27, 32, 32, 2, -31 },
  { 7962, 28, 44, 32, 3, -44 },
  { 8116, 26, 41, 32, 2, -30 },
  { 8250, 24, 44, 32, 4, -44 },
  { 8382, 26, 45, 32, 3, -44 },
  { 8529, 21, 55, 32, 4, -44 },
  { 8674, 27, 44, 32, 4, -44 },
  { 8823, 26, 45, 32, 3, -44 },
  { 8970, 28, 30, 32, 2, -30 },
  { 9075, 24, 30, 32, 4, -30 },
  { 9165, 28, 32, 32, 2, -31 },
  { 9277, 26, 41, 32, 4, -30 },
  { 9411, 26, 41, 32, 2, -30 },
  { 9545, 23, 30, 32, 6, -30 },
  { 9632, 24, 32, 32, 4, -31 },
  { 9728, 26, 40, 32, 3, -39 },
  { 9858, 24, 31, 32, 4, -30 },
  { 9951, 29, 30, 32, 1, -30 },
  { 10060, 30, 30, 32, 1, -30 },
  { 10173, 28, 30, 32, 2, -30 },
  { 10278, 28, 41, 32, 2, -30 },
  { 10422, 23, 30, 32, 4, -30 },
  { 10509, 23, 56, 32, 5, -45 },
  { 10670, 6, 56, 32, 13, -45 },
  { 10712, 23, 56, 32, 4, -45 },
  { 10873, 28, 10, 32, 2, -22 },
};

const GFXfont UbuntuSansMono_Medium57pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium57pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium57pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _UBUNTUSANSMONO_MEDIUM57PT7B_H_
