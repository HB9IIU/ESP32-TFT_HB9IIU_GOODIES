#ifndef _UBUNTUSANSMONO_MEDIUM18PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium18pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0x1B, 0xE0, 0xCF, 0x3C, 0xF3, 0x4D, 0x20, 0x19,
  0x86, 0x61, 0x93, 0xFF, 0x13, 0x0C, 0xC3, 0x33, 0xFF, 0xFF, 0xC9, 0x86,
  0x61, 0x98, 0x18, 0x18, 0x3F, 0x7E, 0xC0, 0xC0, 0xF0, 0x7C, 0x1E, 0x03,
  0x03, 0x83, 0xFF, 0x7C, 0x18, 0x18, 0x70, 0x5C, 0x2D, 0x9B, 0x6C, 0xDA,
  0x1D, 0x82, 0xC0, 0x2E, 0x1A, 0xC5, 0xB2, 0x6D, 0x9B, 0xC3, 0x80, 0x38,
  0x3E, 0x11, 0x18, 0x84, 0xC3, 0xC1, 0xCD, 0xB6, 0xDF, 0x47, 0x31, 0x9D,
  0xE7, 0xB8, 0xFF, 0xF0, 0x0C, 0x73, 0x1C, 0x61, 0x8C, 0x30, 0xC3, 0x0C,
  0x10, 0x61, 0x83, 0x06, 0x0C, 0x43, 0x83, 0x0E, 0x18, 0x20, 0xC3, 0x0C,
  0x30, 0xC3, 0x18, 0x63, 0x18, 0xC0, 0x18, 0x99, 0xEF, 0x7E, 0x3C, 0x76,
  0x24, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x77, 0x73,
  0xEC, 0xFF, 0x6F, 0x60, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0x1C, 0x7E, 0x66,
  0xC3, 0xC3, 0xDB, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0x7E, 0x3C, 0x1C, 0x3C,
  0xEC, 0x4C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x7F, 0x7F, 0x38, 0xFE,
  0x46, 0x03, 0x06, 0x06, 0x0C, 0x1C, 0x38, 0x70, 0x60, 0xFF, 0xFF, 0x38,
  0xFE, 0x46, 0x06, 0x06, 0x0E, 0x3C, 0x06, 0x03, 0x03, 0x03, 0xEE, 0xFC,
  0x0E, 0x1E, 0x1E, 0x36, 0x66, 0x66, 0xC6, 0xFF, 0xFF, 0x06, 0x06, 0x06,
  0x7F, 0x60, 0x60, 0x60, 0x78, 0x7E, 0x07, 0x03, 0x03, 0x03, 0xEE, 0xFC,
  0x02, 0x1E, 0x38, 0x60, 0x60, 0xDC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0x76,
  0x3E, 0xFF, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30,
  0x30, 0x3C, 0x7E, 0xE3, 0xC3, 0xC3, 0x66, 0x3C, 0x6E, 0xC3, 0xC3, 0xC3,
  0xE7, 0x7E, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x03, 0x06,
  0x0E, 0x7C, 0x70, 0x6F, 0x60, 0x00, 0x6F, 0x60, 0x33, 0xCC, 0x00, 0x00,
  0xCF, 0x38, 0xBC, 0x80, 0x03, 0x1F, 0x7C, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xF8, 0x1E, 0x07, 0x0F, 0x3C, 0xF0,
  0xC0, 0x7B, 0xF8, 0xC3, 0x0C, 0x63, 0x0C, 0x20, 0x02, 0x1C, 0x70, 0x1C,
  0x3E, 0x63, 0xC1, 0xCF, 0xDF, 0x99, 0x91, 0x91, 0x99, 0xD9, 0xCF, 0xC0,
  0x60, 0x3F, 0x0F, 0x0E, 0x07, 0x81, 0xE0, 0x4C, 0x33, 0x0C, 0xC3, 0x11,
  0xFE, 0x7F, 0x98, 0x66, 0x1F, 0x03, 0x78, 0xFE, 0xC6, 0xC3, 0xC3, 0xCE,
  0xFC, 0xC7, 0xC3, 0xC3, 0xC3, 0xFF, 0xFC, 0x1E, 0x3F, 0x61, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x7F, 0x3F, 0x70, 0xFC, 0xC6, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xFF, 0x83, 0x06,
  0x0C, 0x1F, 0xB0, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xFF, 0x83, 0x06, 0x0C,
  0x1F, 0xB0, 0x60, 0xC1, 0x83, 0x06, 0x00, 0x1E, 0x3F, 0x61, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x63, 0xFF, 0xF0, 0x7F, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x06, 0xEE, 0xFC, 0xC3, 0x63, 0x33, 0x1B, 0x8F,
  0x87, 0x83, 0x61, 0x98, 0xCE, 0x63, 0xB0, 0xD8, 0x70, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xC3, 0x73, 0xB9, 0x5C,
  0xAF, 0xD6, 0xCB, 0x65, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x30, 0xC3, 0xE3,
  0xE3, 0xF3, 0xDB, 0xDB, 0xCB, 0xCF, 0xC7, 0xC7, 0xC3, 0xC3, 0x1C, 0x3F,
  0x39, 0xD8, 0x6C, 0x36, 0x1B, 0x0F, 0x87, 0xC3, 0x61, 0xB0, 0xCF, 0xC3,
  0xC0, 0x78, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xF0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x18, 0x3F, 0x39, 0xD8, 0x6C, 0x36, 0x1B, 0x0F, 0x87, 0xC3,
  0x61, 0xB0, 0xCC, 0xC3, 0xE0, 0xC0, 0x38, 0x0E, 0x78, 0x7F, 0x31, 0x98,
  0x6C, 0x36, 0x1B, 0x39, 0xF8, 0xCC, 0x63, 0x31, 0x98, 0x6C, 0x38, 0x1C,
  0x7F, 0xE2, 0xC0, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x03, 0x03, 0xE7, 0xFE,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF7, 0x7E,
  0xE0, 0xD8, 0x66, 0x19, 0x86, 0x21, 0x8C, 0xC3, 0x30, 0xCC, 0x1A, 0x07,
  0x81, 0xE0, 0x30, 0x81, 0xC0, 0xA0, 0x50, 0x29, 0x96, 0xCB, 0x75, 0xEA,
  0xE5, 0x72, 0xB9, 0xD8, 0x60, 0x61, 0xCC, 0xC3, 0x30, 0x78, 0x1E, 0x03,
  0x01, 0xE0, 0x7C, 0x33, 0x0C, 0xE6, 0x1B, 0x87, 0xE1, 0xD8, 0x63, 0x18,
  0xCC, 0x1B, 0x07, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0x07, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xFF, 0xFF, 0xFE,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xF8, 0xC0, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06,
  0x06, 0x06, 0x03, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0xF8, 0x1C, 0x1E, 0x1D, 0x8C, 0xCE, 0x36, 0x1D, 0x08, 0xFF, 0xC0,
  0x4E, 0x31, 0x38, 0x7E, 0x07, 0x03, 0x3F, 0x7F, 0xC3, 0xC3, 0xE7, 0x7F,
  0xC0, 0xC0, 0xC0, 0xC0, 0xD8, 0xFE, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xFE, 0xFC, 0x0E, 0x3F, 0x71, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7F, 0x3F,
  0x03, 0x03, 0x03, 0x03, 0x1B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x7F, 0x3F, 0x18, 0x7E, 0xE3, 0xC3, 0xFF, 0xFF, 0xC0, 0xC0, 0x7E, 0x3F,
  0x0F, 0x8F, 0xCC, 0x06, 0x03, 0x07, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x1C, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7,
  0x7F, 0x13, 0x03, 0xCE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xD8, 0xFE, 0xC6,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x30, 0x38, 0x30, 0x00, 0x00,
  0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1F, 0x0F, 0x0C, 0x1C, 0x30,
  0x00, 0x0F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xA7, 0xFC,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x3B, 0x39, 0xB8, 0xF8, 0x7C, 0x33,
  0x19, 0xCC, 0x76, 0x1C, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x1F, 0x0F, 0x66, 0xFF, 0x9B, 0x99, 0x99, 0x99,
  0x81, 0x81, 0x81, 0x81, 0x38, 0xFE, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x18, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x3C,
  0x38, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFE, 0xC0, 0xC0,
  0xC0, 0x1C, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x7F, 0x03,
  0x03, 0x03, 0x1D, 0xFF, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x1C,
  0x7E, 0x62, 0xE0, 0x78, 0x3E, 0x07, 0x03, 0xEF, 0xFE, 0x30, 0x30, 0x30,
  0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x1F, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0xE1, 0xD8, 0x66, 0x18, 0xCC, 0x33,
  0x07, 0x81, 0xE0, 0x78, 0x0C, 0x00, 0xC0, 0xD0, 0x34, 0xC9, 0x32, 0x6E,
  0x9F, 0xE7, 0x39, 0xCE, 0x31, 0x00, 0x61, 0x8C, 0xC1, 0xE0, 0x78, 0x0E,
  0x07, 0x83, 0x31, 0x86, 0xE1, 0xC0, 0xC3, 0xE3, 0x63, 0x66, 0x76, 0x36,
  0x3C, 0x1C, 0x1C, 0x18, 0xB8, 0xF0, 0x7F, 0x06, 0x0C, 0x1C, 0x18, 0x30,
  0x60, 0x7F, 0xFF, 0x0F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xE0,
  0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x07, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x18, 0xF8, 0x71, 0xFF, 0xA3, 0xC0,
};

const GFXglyph UbuntuSansMono_Medium18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 4, -12 },
  { 6, 6, 6, 10, 2, -14 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 8, 16, 10, 1, -14 },
  { 42, 10, 13, 10, 0, -13 },
  { 59, 9, 13, 10, 1, -13 },
  { 74, 2, 6, 10, 4, -14 },
  { 76, 6, 17, 10, 2, -14 },
  { 89, 6, 17, 10, 2, -14 },
  { 102, 8, 7, 10, 1, -12 },
  { 109, 8, 9, 10, 1, -10 },
  { 118, 4, 6, 10, 3, -3 },
  { 121, 4, 2, 10, 3, -6 },
  { 122, 4, 3, 10, 3, -3 },
  { 124, 8, 17, 10, 1, -14 },
  { 141, 8, 13, 10, 1, -13 },
  { 154, 8, 12, 10, 1, -12 },
  { 166, 8, 13, 10, 1, -13 },
  { 179, 8, 13, 10, 1, -13 },
  { 192, 8, 12, 10, 1, -12 },
  { 204, 8, 12, 10, 1, -12 },
  { 216, 8, 13, 10, 1, -13 },
  { 229, 8, 12, 10, 1, -12 },
  { 241, 8, 13, 10, 1, -13 },
  { 254, 8, 13, 10, 1, -13 },
  { 267, 4, 9, 10, 3, -9 },
  { 272, 5, 12, 10, 2, -9 },
  { 280, 8, 8, 10, 1, -9 },
  { 288, 8, 5, 10, 1, -8 },
  { 293, 8, 8, 10, 1, -9 },
  { 301, 6, 13, 10, 2, -13 },
  { 311, 8, 16, 10, 1, -13 },
  { 327, 10, 12, 10, 0, -12 },
  { 342, 8, 13, 10, 1, -13 },
  { 355, 8, 13, 10, 1, -13 },
  { 368, 8, 13, 10, 1, -13 },
  { 381, 7, 12, 10, 2, -12 },
  { 392, 7, 12, 10, 2, -12 },
  { 403, 8, 13, 10, 1, -13 },
  { 416, 8, 12, 10, 1, -12 },
  { 428, 7, 12, 10, 2, -12 },
  { 439, 8, 12, 10, 1, -12 },
  { 451, 9, 12, 10, 1, -12 },
  { 465, 7, 12, 10, 2, -12 },
  { 476, 9, 12, 10, 1, -12 },
  { 490, 8, 12, 10, 1, -12 },
  { 502, 9, 13, 10, 1, -13 },
  { 517, 8, 13, 10, 1, -13 },
  { 530, 9, 16, 10, 1, -13 },
  { 548, 9, 13, 10, 1, -13 },
  { 563, 8, 13, 10, 1, -13 },
  { 576, 8, 12, 10, 1, -12 },
  { 588, 8, 12, 10, 1, -12 },
  { 600, 10, 12, 10, 0, -12 },
  { 615, 9, 12, 10, 1, -12 },
  { 629, 10, 12, 10, 0, -12 },
  { 644, 10, 12, 10, 0, -12 },
  { 659, 8, 12, 10, 1, -12 },
  { 671, 5, 17, 10, 3, -14 },
  { 682, 8, 17, 10, 1, -14 },
  { 699, 5, 17, 10, 2, -14 },
  { 710, 9, 7, 10, 1, -12 },
  { 718, 10, 1, 10, 0, 2 },
  { 720, 4, 4, 10, 3, -14 },
  { 722, 8, 10, 10, 1, -10 },
  { 732, 8, 14, 10, 1, -14 },
  { 746, 8, 10, 10, 1, -10 },
  { 756, 8, 14, 10, 1, -14 },
  { 770, 8, 10, 10, 1, -10 },
  { 780, 9, 14, 10, 1, -14 },
  { 796, 8, 13, 10, 1, -10 },
  { 809, 8, 14, 10, 1, -14 },
  { 823, 8, 14, 10, 1, -14 },
  { 837, 7, 17, 10, 1, -14 },
  { 852, 9, 14, 10, 1, -14 },
  { 868, 8, 14, 10, 1, -14 },
  { 882, 8, 10, 10, 1, -10 },
  { 892, 8, 10, 10, 1, -10 },
  { 902, 8, 10, 10, 1, -10 },
  { 912, 8, 13, 10, 1, -10 },
  { 925, 8, 13, 10, 1, -10 },
  { 938, 7, 10, 10, 2, -10 },
  { 947, 8, 10, 10, 1, -10 },
  { 957, 8, 12, 10, 1, -12 },
  { 969, 8, 9, 10, 1, -9 },
  { 978, 10, 9, 10, 0, -9 },
  { 990, 10, 9, 10, 0, -9 },
  { 1002, 10, 9, 10, 0, -9 },
  { 1014, 8, 12, 10, 1, -9 },
  { 1026, 8, 9, 10, 1, -9 },
  { 1035, 8, 17, 10, 1, -14 },
  { 1052, 2, 17, 10, 4, -14 },
  { 1057, 8, 17, 10, 1, -14 },
  { 1074, 9, 3, 10, 1, -7 },
};

const GFXfont UbuntuSansMono_Medium18pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium18pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium18pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUSANSMONO_MEDIUM18PT7B_H_
