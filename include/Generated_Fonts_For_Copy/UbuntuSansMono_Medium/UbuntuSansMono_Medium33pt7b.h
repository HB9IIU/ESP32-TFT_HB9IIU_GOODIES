#ifndef _UBUNTUSANSMONO_MEDIUM33PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium33pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3,
  0x80, 0x00, 0x03, 0x9F, 0xFD, 0xF7, 0x80, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7E, 0x1D, 0x87, 0x61, 0xD8, 0x30, 0x07, 0x8E, 0x03, 0x87,
  0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x78, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0x1E, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC3, 0x80,
  0xE1, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9C, 0x38, 0x0E, 0x1C,
  0x07, 0x1E, 0x03, 0x8F, 0x03, 0xC7, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFF, 0x07, 0xFF, 0x9F, 0xFE, 0x3C, 0x0C,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE8, 0x07, 0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0xF0, 0x0F, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x7C, 0x03, 0xFF, 0x03, 0xBB, 0x83,
  0x98, 0xE1, 0xCC, 0x71, 0xC6, 0x38, 0xE3, 0x1C, 0xE1, 0x8C, 0xE0, 0xEE,
  0x70, 0x3F, 0x70, 0x1F, 0x70, 0x00, 0x38, 0x00, 0x39, 0xE0, 0x19, 0xF8,
  0x1D, 0xDC, 0x1C, 0xE7, 0x0E, 0x63, 0x8E, 0x31, 0xCE, 0x18, 0xE7, 0x0C,
  0x77, 0x07, 0x3F, 0x01, 0xFB, 0x80, 0xF8, 0x00, 0x10, 0x0F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xBC, 0x07, 0x0E, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xE1, 0xC0,
  0x71, 0xE0, 0x3D, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xE1, 0xC3, 0xF8,
  0xE3, 0xDE, 0x71, 0xC7, 0xB9, 0xE1, 0xFC, 0xE0, 0x7C, 0x70, 0x3E, 0x3C,
  0x0F, 0x1E, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0x78, 0x7F, 0x1E, 0xFF, 0xFF,
  0xF7, 0x77, 0x76, 0x00, 0x80, 0x38, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0xC0, 0x70, 0x04, 0x40,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x7C,
  0x0F, 0x07, 0xC1, 0xF0, 0x3C, 0x03, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x02, 0x1C, 0x27, 0x39, 0xDF, 0xEF, 0xBF, 0xFF, 0x8F, 0xF8, 0x07, 0xC0,
  0x1D, 0xC0, 0x7B, 0xC1, 0xE7, 0xC3, 0xC7, 0x01, 0x04, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x08, 0x1E, 0x3F, 0x3F, 0x3F, 0x1F, 0x0E, 0x0E,
  0x3C, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x11, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xC3, 0xC7, 0x03, 0xDE, 0x03, 0xBC, 0x07, 0x70, 0x0F, 0xE0,
  0x1F, 0xC7, 0x3F, 0x9E, 0x7F, 0x3C, 0xFE, 0x39, 0xFC, 0x23, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x1D, 0xE0, 0x39, 0xC0, 0xF3, 0xC3, 0xC3, 0xFF, 0x87,
  0xFE, 0x03, 0xF8, 0x00, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x1C, 0xF0, 0x21, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x03, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x80, 0x1F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE3, 0x83, 0xC4, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE3, 0xFF,
  0xC7, 0xFF, 0x98, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xD0, 0x1F, 0xFF, 0xFB, 0xFF, 0xC7,
  0xFE, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xBC, 0x07, 0xBC, 0x0F, 0x3C, 0x0E, 0x3C, 0x1C, 0x3C, 0x3C,
  0x3C, 0x38, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xF8,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xD0, 0x1F,
  0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x01, 0x80, 0x00, 0x78, 0x07, 0xF0, 0x1F,
  0xE0, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xDE, 0x03, 0xBC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0xF3, 0xC1, 0xE7, 0xFF, 0x87, 0xFF,
  0x03, 0xF8, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x1F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x03, 0xBC,
  0x07, 0x78, 0x1E, 0x78, 0x38, 0xF8, 0xF0, 0xFF, 0xC0, 0xFF, 0x03, 0xFF,
  0x8F, 0x0F, 0xBC, 0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x81, 0xE7, 0xFF, 0xCF, 0xFF, 0x07, 0xFC, 0x01, 0x80, 0x1F, 0xE0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xC3, 0xEF, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7B, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0x00, 0x00, 0x11, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x11, 0xFF, 0xFF, 0xFD, 0xE0, 0x08, 0x7D, 0xFB, 0xF7, 0xE7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x87, 0xDF, 0xBF, 0x7E, 0x7C, 0x38,
  0xE7, 0xDF, 0x38, 0x00, 0x00, 0x04, 0x00, 0x78, 0x03, 0xF8, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x01, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0xFE, 0x07, 0xF8, 0x7F,
  0xC3, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xC7, 0xFF,
  0x1F, 0xFC, 0x81, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x07,
  0xF8, 0x0F, 0xFC, 0x1F, 0x3E, 0x3C, 0x0E, 0x38, 0x07, 0x78, 0x07, 0x70,
  0x07, 0x70, 0x7F, 0x71, 0xFF, 0xF1, 0xFF, 0xE3, 0xC7, 0xE3, 0x87, 0xE3,
  0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xF3, 0xC7, 0x73,
  0xE7, 0x71, 0xFF, 0x70, 0xFF, 0x78, 0x18, 0x38, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0x73, 0xC0, 0x1C,
  0xF0, 0x0F, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xE0, 0x78, 0x38, 0x1E, 0x0E,
  0x07, 0x03, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0E, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x1E, 0x78, 0x03, 0xDC, 0x00, 0xFF, 0x00, 0x3C, 0xFF,
  0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x1E, 0xF0, 0x79, 0xE7, 0xE3, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0xDE,
  0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83,
  0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x1F,
  0xFF, 0x1F, 0x02, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x02, 0x1F,
  0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x60, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xC7, 0x87, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7B, 0xC1, 0xF7, 0x87, 0xCF, 0xFF, 0x1F, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC,
  0xFF, 0xF3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xFE,
  0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x02, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x3C, 0x0F,
  0x3E, 0x0F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x60, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0x98, 0x1E, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE,
  0x01, 0x00, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF0,
  0xF1, 0xF0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0xF7, 0xC0, 0xF3, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0,
  0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x0E, 0x78, 0x1E, 0x7C, 0x1E, 0x7C,
  0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x37, 0x76, 0x77, 0x76, 0x77, 0x77,
  0x67, 0x73, 0xE7, 0x73, 0xE7, 0x73, 0xC7, 0xF3, 0xC7, 0xF1, 0xC7, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x87, 0xF7, 0x0F, 0xE7, 0x1F, 0xCE, 0x3F, 0x8E, 0x7F,
  0x1C, 0xFE, 0x1D, 0xFC, 0x3B, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0,
  0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0x80, 0x07,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x70,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78,
  0x1E, 0x3C, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x80, 0xFF,
  0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x83, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x8F, 0xEF, 0xFF, 0x9F,
  0xFE, 0x3F, 0xE0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x1E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x0E, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0,
  0xF8, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF1, 0xE0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x38, 0xF0, 0x3C, 0xF0, 0x1C, 0xF0,
  0x1E, 0xF0, 0x1F, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF, 0xE3, 0xC0, 0x4F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7A, 0x01, 0xEF, 0xFF, 0xDF, 0xFF, 0x1F, 0xFC, 0x01, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0xC1, 0xE7,
  0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x00, 0x80, 0xF0, 0x03, 0xDE, 0x00, 0xF7,
  0x80, 0x3D, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x1C, 0x1C, 0x0F, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x78, 0x38, 0x0E, 0x1E,
  0x03, 0x87, 0x80, 0xF1, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xEE, 0x00,
  0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF3, 0xC7, 0xF3, 0xC7, 0x73, 0xE7, 0x73,
  0xE7, 0x77, 0x67, 0x76, 0x77, 0x76, 0x77, 0x7E, 0x37, 0x7E, 0x36, 0x7C,
  0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0xF0, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0x87, 0x83, 0xC1, 0xC3, 0xC0, 0xF1, 0xC0, 0x39, 0xE0,
  0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3D, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x1E, 0x1E, 0x0F,
  0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x1E, 0xF8, 0x03,
  0xDE, 0x00, 0xF7, 0x80, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0x38, 0x78, 0x0F, 0x1C, 0x01, 0xCF, 0x00, 0x7B, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0x30, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC1, 0x00, 0x0F, 0x80, 0xFF, 0xC3, 0xFF, 0x8F, 0x3E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0xE7, 0x3F, 0xFD, 0xFF, 0xFF, 0xC3, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xDF, 0xFF, 0x7F, 0xFC, 0x7F, 0xF0, 0x10, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF1, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xDE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x07, 0xBC, 0x1F, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x01,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x02, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x01, 0x1E, 0x1F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF7, 0xC1, 0xEF, 0x03, 0xDC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x81,
  0xEF, 0x03, 0xDF, 0x07, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x01, 0xC0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7E, 0x7C, 0x1E, 0x78, 0x0F, 0x70, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3E, 0x02, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x70,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xC1, 0xEF,
  0x03, 0xDC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0x80,
  0xF7, 0x81, 0xEF, 0x83, 0xCF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF2, 0x03, 0xCF, 0xFF, 0x9F, 0xFE, 0x1F, 0xF0, 0x20,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE7, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xEE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x41,
  0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF6, 0x0F, 0x7F,
  0xFF, 0xFE, 0x3F, 0x80, 0x20, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFB, 0x83,
  0xE7, 0x0F, 0x8E, 0x1E, 0x1C, 0x78, 0x39, 0xE0, 0x77, 0x80, 0xFE, 0x01,
  0xFE, 0x03, 0xBE, 0x07, 0x3E, 0x0E, 0x3E, 0x1C, 0x3E, 0x38, 0x3C, 0x70,
  0x3C, 0xE0, 0x3D, 0xC0, 0x7C, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x41, 0xFF,
  0x81, 0xFF, 0x01, 0xFE, 0x08, 0x18, 0xFF, 0x7E, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE3, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7,
  0xE1, 0xC7, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x0E, 0x07, 0xFE, 0x3F, 0xFD, 0xFF, 0xEE, 0x0F,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xC0, 0x01, 0x80,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0x1E, 0x78, 0x0F, 0x70, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F,
  0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x0E, 0x03,
  0xFF, 0x0F, 0xFF, 0x3F, 0xFC, 0xE0, 0x7B, 0x81, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0x07,
  0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7,
  0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xF7, 0x81, 0xEF, 0x03, 0xDF, 0x07, 0x9F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x07, 0xC3, 0xFF, 0xFF, 0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0xE3, 0xFF,
  0x9F, 0x9E, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0x7F,
  0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF4, 0x03, 0xDF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x08, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFC, 0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7,
  0x81, 0xE1, 0xC0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x1E, 0x3C, 0x0F, 0x3C,
  0x03, 0x9E, 0x01, 0xEE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x1C, 0x77, 0x1E, 0x3B, 0x8F, 0x1D, 0xC7, 0xCE, 0x73, 0xE7, 0x3B,
  0xB3, 0x9D, 0xDD, 0x8E, 0xCF, 0xC7, 0xE3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8,
  0x78, 0x38, 0x38, 0x1C, 0x00, 0xF8, 0x0F, 0x3C, 0x0F, 0x0F, 0x0F, 0x03,
  0xC7, 0x80, 0xF7, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xCF, 0x01, 0xE3, 0xC1, 0xE0, 0xF1, 0xE0,
  0x78, 0xF0, 0x1E, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E,
  0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x1C, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x0F, 0x38, 0x0F, 0x38, 0x07, 0x78, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x3F, 0xC3,
  0xFE, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x7F, 0x83, 0xFC, 0x1F, 0x80, 0x0C, 0x04, 0x3F, 0x07,
  0x7F, 0xC7, 0x7F, 0xFF, 0xE1, 0xFE, 0x60, 0x7C,
};

const GFXglyph UbuntuSansMono_Medium33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 23, 18, 6, -23 },
  { 19, 10, 10, 18, 4, -25 },
  { 32, 17, 23, 18, 1, -23 },
  { 81, 15, 30, 18, 2, -26 },
  { 138, 17, 24, 18, 1, -23 },
  { 189, 17, 23, 18, 1, -23 },
  { 238, 4, 10, 18, 7, -25 },
  { 243, 11, 32, 18, 4, -26 },
  { 287, 11, 32, 18, 4, -26 },
  { 331, 15, 14, 18, 2, -23 },
  { 358, 15, 16, 18, 2, -18 },
  { 388, 8, 11, 18, 5, -6 },
  { 399, 9, 3, 18, 5, -11 },
  { 403, 6, 6, 18, 6, -6 },
  { 408, 14, 32, 18, 2, -26 },
  { 464, 15, 24, 18, 2, -23 },
  { 509, 15, 23, 18, 2, -23 },
  { 553, 15, 23, 18, 2, -23 },
  { 597, 14, 24, 18, 2, -23 },
  { 639, 16, 23, 18, 1, -23 },
  { 685, 14, 24, 18, 2, -23 },
  { 727, 15, 24, 18, 2, -23 },
  { 772, 15, 23, 18, 2, -23 },
  { 816, 15, 24, 18, 2, -23 },
  { 861, 15, 23, 18, 2, -23 },
  { 905, 6, 18, 18, 6, -18 },
  { 919, 7, 23, 18, 5, -18 },
  { 940, 15, 15, 18, 2, -17 },
  { 969, 15, 10, 18, 2, -15 },
  { 988, 15, 15, 18, 2, -17 },
  { 1017, 13, 23, 18, 3, -23 },
  { 1055, 16, 28, 18, 1, -23 },
  { 1111, 18, 23, 18, 0, -23 },
  { 1163, 15, 23, 18, 2, -23 },
  { 1207, 16, 24, 18, 1, -23 },
  { 1255, 15, 23, 18, 2, -23 },
  { 1299, 14, 23, 18, 3, -23 },
  { 1340, 13, 23, 18, 3, -23 },
  { 1378, 16, 24, 18, 1, -23 },
  { 1426, 15, 23, 18, 2, -23 },
  { 1470, 13, 23, 18, 3, -23 },
  { 1508, 14, 24, 18, 2, -23 },
  { 1550, 16, 23, 18, 2, -23 },
  { 1596, 14, 23, 18, 3, -23 },
  { 1637, 16, 23, 18, 1, -23 },
  { 1683, 15, 23, 18, 2, -23 },
  { 1727, 16, 24, 18, 1, -23 },
  { 1775, 15, 23, 18, 2, -23 },
  { 1819, 16, 29, 18, 1, -23 },
  { 1877, 16, 23, 18, 2, -23 },
  { 1923, 15, 24, 18, 2, -23 },
  { 1968, 16, 23, 18, 1, -23 },
  { 2014, 15, 24, 18, 2, -23 },
  { 2059, 18, 23, 18, 0, -23 },
  { 2111, 16, 23, 18, 1, -23 },
  { 2157, 17, 23, 18, 1, -23 },
  { 2206, 18, 23, 18, 0, -23 },
  { 2258, 15, 23, 18, 2, -23 },
  { 2302, 9, 32, 18, 5, -26 },
  { 2338, 14, 32, 18, 2, -26 },
  { 2394, 10, 32, 18, 4, -26 },
  { 2434, 16, 13, 18, 1, -23 },
  { 2460, 18, 3, 18, 0, 3 },
  { 2467, 7, 7, 18, 6, -26 },
  { 2474, 14, 18, 18, 2, -18 },
  { 2506, 15, 26, 18, 2, -26 },
  { 2555, 15, 18, 18, 2, -18 },
  { 2589, 15, 26, 18, 1, -26 },
  { 2638, 16, 18, 18, 1, -18 },
  { 2674, 16, 26, 18, 2, -26 },
  { 2726, 15, 24, 18, 1, -18 },
  { 2771, 13, 26, 18, 3, -26 },
  { 2814, 15, 25, 18, 2, -25 },
  { 2861, 12, 31, 18, 2, -25 },
  { 2908, 15, 26, 18, 3, -26 },
  { 2957, 15, 25, 18, 2, -25 },
  { 3004, 16, 18, 18, 1, -18 },
  { 3040, 13, 18, 18, 3, -18 },
  { 3070, 16, 18, 18, 1, -18 },
  { 3106, 14, 24, 18, 3, -18 },
  { 3148, 15, 24, 18, 1, -18 },
  { 3193, 13, 18, 18, 4, -18 },
  { 3223, 14, 18, 18, 2, -18 },
  { 3255, 15, 22, 18, 2, -22 },
  { 3297, 14, 17, 18, 2, -17 },
  { 3327, 17, 17, 18, 1, -17 },
  { 3364, 17, 17, 18, 1, -17 },
  { 3401, 17, 17, 18, 1, -17 },
  { 3438, 16, 23, 18, 1, -17 },
  { 3484, 13, 17, 18, 3, -17 },
  { 3512, 13, 32, 18, 3, -26 },
  { 3564, 4, 32, 18, 7, -26 },
  { 3580, 13, 32, 18, 3, -26 },
  { 3632, 16, 6, 18, 1, -13 },
};

const GFXfont UbuntuSansMono_Medium33pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium33pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium33pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UBUNTUSANSMONO_MEDIUM33PT7B_H_
