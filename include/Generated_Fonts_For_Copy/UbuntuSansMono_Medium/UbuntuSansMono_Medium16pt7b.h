#ifndef _UBUNTUSANSMONO_MEDIUM16PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium16pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x64, 0x90, 0x1F, 0x80, 0xDE, 0xF7, 0xB8, 0x80, 0x1B, 0x09,
  0x84, 0x9F, 0xF3, 0x21, 0xB0, 0x99, 0xFF, 0x64, 0x32, 0x1B, 0x00, 0x10,
  0x79, 0xFE, 0x0C, 0x1E, 0x0F, 0x07, 0x06, 0x0F, 0xFB, 0xC1, 0x02, 0x00,
  0x71, 0xE9, 0xA4, 0x9A, 0x87, 0xC0, 0x40, 0x7C, 0x6B, 0x25, 0xB2, 0xF1,
  0xC0, 0x3C, 0x33, 0x19, 0x8D, 0x83, 0x81, 0xD9, 0xEC, 0x9E, 0xC6, 0x33,
  0x8E, 0x60, 0xF8, 0x08, 0xCC, 0xC4, 0x63, 0x18, 0xC6, 0x31, 0x86, 0x18,
  0xE1, 0x86, 0x18, 0x63, 0x0C, 0x63, 0x18, 0xC6, 0x23, 0x33, 0x90, 0x11,
  0x27, 0xF9, 0xC2, 0x8D, 0x8A, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04,
  0x08, 0x37, 0x33, 0xE4, 0xF8, 0x5F, 0x80, 0x06, 0x0C, 0x30, 0x60, 0xC3,
  0x06, 0x0C, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x10, 0x60, 0x7C, 0xDB, 0x1E,
  0x39, 0x77, 0xF1, 0xE3, 0xC6, 0xD9, 0xF0, 0x18, 0x73, 0xE4, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x31, 0xF8, 0x7D, 0x98, 0x18, 0x30, 0xC3, 0x0C, 0x30,
  0x61, 0x83, 0xF8, 0xFC, 0x98, 0x18, 0x23, 0xC7, 0x81, 0x83, 0x07, 0x1F,
  0xF0, 0x0C, 0x38, 0xF1, 0x66, 0xD9, 0xA3, 0x7F, 0x0C, 0x18, 0x30, 0x7E,
  0xC1, 0x82, 0x07, 0x8F, 0x81, 0x83, 0x07, 0x1F, 0xF0, 0x1C, 0x75, 0x86,
  0x0F, 0xDF, 0xF1, 0xE3, 0xC6, 0xDD, 0xF0, 0xFE, 0x0C, 0x30, 0x61, 0x83,
  0x04, 0x18, 0x30, 0x60, 0x80, 0x7D, 0x8F, 0x1E, 0x36, 0xCF, 0xB3, 0xE3,
  0xC7, 0x8D, 0xF0, 0x7D, 0x9F, 0x1E, 0x3C, 0x7F, 0xCF, 0x83, 0x0D, 0xF1,
  0xC0, 0x5F, 0x80, 0x17, 0xE0, 0x27, 0x70, 0x00, 0x27, 0x73, 0xE8, 0x06,
  0x3F, 0xC6, 0x07, 0x83, 0xC1, 0x80, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0xC1,
  0xF0, 0x78, 0x31, 0xFE, 0x30, 0x00, 0xFC, 0x98, 0x18, 0x61, 0x86, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x3C, 0xCF, 0x0C, 0x79, 0xF6, 0x6C, 0xD9, 0xB3,
  0x3F, 0x03, 0x03, 0xE0, 0x1C, 0x0E, 0x05, 0x06, 0xC3, 0x61, 0x11, 0x8C,
  0xFE, 0x63, 0x20, 0xB0, 0x60, 0xFD, 0x9B, 0x1E, 0x3F, 0xDF, 0xB1, 0xE3,
  0xC7, 0x9F, 0xF0, 0x3E, 0xC7, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xE4,
  0xF8, 0xF9, 0x9B, 0x1E, 0x3C, 0x78, 0x71, 0xE3, 0xC7, 0xBB, 0xE0, 0xFF,
  0x83, 0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xC1, 0x83, 0xF8, 0xFF, 0x83, 0x06,
  0x0C, 0x1F, 0xB0, 0x60, 0xC1, 0x83, 0x00, 0x3E, 0xC7, 0x06, 0x0C, 0x18,
  0xF1, 0xE3, 0xC6, 0xCC, 0xF8, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3,
  0xC7, 0x8F, 0x18, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23,
  0xF8, 0x7E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x9B, 0xE0, 0xC6,
  0xCC, 0xCC, 0xD8, 0xF0, 0xF0, 0xD8, 0xCC, 0xCC, 0xC6, 0xC3, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xF8, 0xC7, 0x8F, 0xBD, 0x5A,
  0xB7, 0x64, 0xC1, 0x83, 0x06, 0x08, 0xC7, 0x8F, 0x9F, 0x3F, 0x7A, 0xF7,
  0xE7, 0xCF, 0x8F, 0x18, 0x3E, 0x63, 0x63, 0x41, 0x41, 0xC1, 0x41, 0x43,
  0x63, 0x77, 0x3E, 0xFD, 0x9F, 0x1E, 0x3C, 0x7F, 0xFF, 0x60, 0xC1, 0x83,
  0x00, 0x3E, 0x67, 0x63, 0x41, 0x41, 0xC1, 0x41, 0x43, 0x63, 0x77, 0x3E,
  0x08, 0x0E, 0x03, 0xFC, 0xCC, 0xC6, 0xC6, 0xC6, 0xFC, 0xF8, 0xCC, 0xCC,
  0xC6, 0xC7, 0x7F, 0x8B, 0x06, 0x07, 0x07, 0x83, 0x83, 0x07, 0x9F, 0xF0,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xDD, 0xF0, 0xC1, 0xA0, 0x98, 0xCC,
  0x66, 0x31, 0x10, 0xD8, 0x6C, 0x14, 0x0E, 0x07, 0x00, 0x83, 0x06, 0x0C,
  0x19, 0x37, 0x6A, 0xD5, 0xEF, 0x8F, 0x18, 0x63, 0x31, 0x8D, 0x82, 0x81,
  0xC0, 0xE0, 0x50, 0x6C, 0x22, 0x31, 0xB0, 0xE0, 0xC1, 0xB1, 0x98, 0xC6,
  0xC3, 0x60, 0xE0, 0x70, 0x10, 0x08, 0x04, 0x02, 0x00, 0xFE, 0x0C, 0x30,
  0x61, 0x86, 0x0C, 0x30, 0x61, 0x83, 0xF8, 0xFF, 0xF1, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x18,
  0x10, 0x30, 0x60, 0x40, 0xC1, 0x81, 0x03, 0xFF, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x7F, 0x38, 0x71, 0xB3, 0x6C, 0x70, 0x40, 0xFF,
  0xFF, 0xC0, 0xCC, 0x80, 0x30, 0xF8, 0x18, 0x37, 0xF8, 0xF1, 0xE3, 0x7E,
  0xC1, 0x83, 0x06, 0x8F, 0xD8, 0xF1, 0xE3, 0xC7, 0x8F, 0x3F, 0xE0, 0x0C,
  0xFF, 0x86, 0x0C, 0x18, 0x30, 0x39, 0x3E, 0x06, 0x0C, 0x18, 0xB7, 0xF8,
  0xF1, 0xC3, 0x87, 0x8F, 0x9B, 0xF0, 0x10, 0xFB, 0x1E, 0x3F, 0xF0, 0x30,
  0x72, 0x7E, 0x1F, 0x31, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x18, 0xFF, 0x1E, 0x38, 0x78, 0xF1, 0xBF, 0x36, 0x0F, 0xF7,
  0xC0, 0xC1, 0x83, 0x06, 0x8F, 0xD8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x30,
  0x30, 0x60, 0x00, 0x0F, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE8, 0xF0, 0x1C,
  0x70, 0x00, 0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0x80, 0xC0,
  0xC0, 0xC0, 0xC0, 0xCE, 0xCC, 0xD8, 0xF0, 0xD8, 0xCC, 0xC6, 0xC7, 0xF0,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE8, 0xF0, 0x45, 0xFE,
  0x4C, 0x99, 0x32, 0x60, 0xC1, 0x82, 0x31, 0xFB, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC6, 0x10, 0xFB, 0x1E, 0x38, 0x30, 0xF1, 0xF7, 0x7C, 0x31, 0xFB,
  0x1E, 0x3C, 0x78, 0xF1, 0xF7, 0xFD, 0x83, 0x06, 0x00, 0x18, 0xFF, 0x1E,
  0x38, 0x78, 0xF1, 0xF7, 0x7E, 0x0C, 0x18, 0x30, 0x13, 0xFC, 0x30, 0xC3,
  0x0C, 0x30, 0xC0, 0x18, 0xFB, 0x07, 0x07, 0x83, 0x81, 0xE3, 0xFC, 0x30,
  0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x64, 0xF8, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xD9, 0xBF, 0xE3, 0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xA0, 0x70,
  0x30, 0xC1, 0xE4, 0x92, 0x4B, 0xA5, 0x52, 0xA9, 0xDC, 0xC4, 0x63, 0x1B,
  0x07, 0x03, 0x81, 0xC1, 0xB1, 0x8D, 0xC7, 0xC7, 0x8D, 0x1B, 0x26, 0xC7,
  0x8E, 0x0C, 0x11, 0xE3, 0x80, 0xFE, 0x18, 0x61, 0xC3, 0x0C, 0x30, 0x7F,
  0x06, 0x3C, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0xE0, 0x60, 0xC1, 0x83, 0x06,
  0x0E, 0x0F, 0xFF, 0xFF, 0xC1, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x0E,
  0x30, 0x60, 0xC1, 0x83, 0x0E, 0x78, 0xF3, 0xFE, 0x30,
};

const GFXglyph UbuntuSansMono_Medium16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 2, -12 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 7, 14, 9, 1, -12 },
  { 36, 9, 11, 9, 0, -11 },
  { 49, 9, 11, 9, 0, -11 },
  { 62, 1, 5, 9, 4, -12 },
  { 63, 5, 16, 9, 2, -13 },
  { 73, 5, 16, 9, 2, -13 },
  { 83, 7, 7, 9, 1, -11 },
  { 90, 7, 8, 9, 1, -9 },
  { 97, 4, 6, 9, 2, -3 },
  { 100, 5, 1, 9, 2, -5 },
  { 101, 3, 3, 9, 3, -3 },
  { 103, 7, 16, 9, 1, -13 },
  { 117, 7, 11, 9, 1, -11 },
  { 127, 7, 11, 9, 1, -11 },
  { 137, 7, 11, 9, 1, -11 },
  { 147, 7, 11, 9, 1, -11 },
  { 157, 7, 11, 9, 1, -11 },
  { 167, 7, 11, 9, 1, -11 },
  { 177, 7, 11, 9, 1, -11 },
  { 187, 7, 11, 9, 1, -11 },
  { 197, 7, 11, 9, 1, -11 },
  { 207, 7, 11, 9, 1, -11 },
  { 217, 3, 9, 9, 3, -9 },
  { 221, 4, 12, 9, 2, -9 },
  { 227, 7, 7, 9, 1, -8 },
  { 234, 7, 5, 9, 1, -7 },
  { 239, 7, 7, 9, 1, -8 },
  { 246, 7, 11, 9, 1, -11 },
  { 256, 7, 13, 9, 1, -11 },
  { 268, 9, 11, 9, 0, -11 },
  { 281, 7, 11, 9, 1, -11 },
  { 291, 7, 11, 9, 1, -11 },
  { 301, 7, 11, 9, 1, -11 },
  { 311, 7, 11, 9, 1, -11 },
  { 321, 7, 11, 9, 1, -11 },
  { 331, 7, 11, 9, 1, -11 },
  { 341, 7, 11, 9, 1, -11 },
  { 351, 7, 11, 9, 1, -11 },
  { 361, 7, 11, 9, 1, -11 },
  { 371, 8, 11, 9, 1, -11 },
  { 382, 7, 11, 9, 1, -11 },
  { 392, 7, 11, 9, 1, -11 },
  { 402, 7, 11, 9, 1, -11 },
  { 412, 8, 11, 9, 0, -11 },
  { 423, 7, 11, 9, 1, -11 },
  { 433, 8, 14, 9, 0, -11 },
  { 447, 8, 11, 9, 1, -11 },
  { 458, 7, 11, 9, 1, -11 },
  { 468, 7, 11, 9, 1, -11 },
  { 478, 7, 11, 9, 1, -11 },
  { 488, 9, 11, 9, 0, -11 },
  { 501, 7, 11, 9, 1, -11 },
  { 511, 9, 11, 9, 0, -11 },
  { 524, 9, 11, 9, 0, -11 },
  { 537, 7, 11, 9, 1, -11 },
  { 547, 5, 16, 9, 2, -13 },
  { 557, 7, 16, 9, 1, -13 },
  { 571, 5, 16, 9, 2, -13 },
  { 581, 7, 6, 9, 1, -11 },
  { 587, 9, 2, 9, 0, 1 },
  { 590, 3, 3, 9, 3, -12 },
  { 592, 7, 9, 9, 1, -9 },
  { 600, 7, 12, 9, 1, -12 },
  { 611, 7, 9, 9, 1, -9 },
  { 619, 7, 12, 9, 1, -12 },
  { 630, 7, 9, 9, 1, -9 },
  { 638, 8, 12, 9, 1, -12 },
  { 650, 7, 12, 9, 1, -9 },
  { 661, 7, 12, 9, 1, -12 },
  { 672, 7, 12, 9, 1, -12 },
  { 683, 6, 15, 9, 1, -12 },
  { 695, 8, 12, 9, 1, -12 },
  { 707, 7, 12, 9, 1, -12 },
  { 718, 7, 9, 9, 1, -9 },
  { 726, 7, 9, 9, 1, -9 },
  { 734, 7, 9, 9, 1, -9 },
  { 742, 7, 12, 9, 1, -9 },
  { 753, 7, 12, 9, 1, -9 },
  { 764, 6, 9, 9, 2, -9 },
  { 771, 7, 9, 9, 1, -9 },
  { 779, 7, 11, 9, 1, -11 },
  { 789, 7, 8, 9, 1, -8 },
  { 796, 9, 8, 9, 0, -8 },
  { 805, 9, 8, 9, 0, -8 },
  { 814, 9, 8, 9, 0, -8 },
  { 823, 7, 11, 9, 1, -8 },
  { 833, 7, 8, 9, 1, -8 },
  { 840, 7, 16, 9, 1, -13 },
  { 854, 1, 16, 9, 4, -13 },
  { 856, 7, 16, 9, 1, -13 },
  { 870, 7, 3, 9, 1, -6 },
};

const GFXfont UbuntuSansMono_Medium16pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium16pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UBUNTUSANSMONO_MEDIUM16PT7B_H_
