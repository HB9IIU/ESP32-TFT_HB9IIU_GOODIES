#ifndef _UBUNTUSANSMONO_MEDIUM40PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium40pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDF, 0x10, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x70,
  0x77, 0x07, 0x70, 0x70, 0x01, 0xE1, 0xE0, 0x1C, 0x1E, 0x03, 0xC1, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x83, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE1, 0xE0, 0x1C,
  0x1E, 0x03, 0xC1, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7E, 0x03, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xD8, 0x01,
  0xF7, 0xC3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7B,
  0xF8, 0x07, 0xBF, 0xE0, 0x39, 0xC7, 0x03, 0xCE, 0x38, 0x3C, 0x71, 0xC1,
  0xC3, 0x8F, 0x1E, 0x1C, 0x70, 0xE0, 0xE3, 0x8F, 0x07, 0x1C, 0xF0, 0x3D,
  0xE7, 0x00, 0xFE, 0x78, 0x03, 0xF7, 0x80, 0x06, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0xF8, 0x01, 0xCF, 0xE0, 0x1E, 0x7F, 0x80, 0xE7, 0x9C, 0x0F,
  0x38, 0xF0, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0x70, 0xE3, 0x83, 0x87,
  0x38, 0x1C, 0x73, 0xC0, 0xF3, 0x9C, 0x03, 0xFD, 0xC0, 0x0F, 0xC0, 0x00,
  0x10, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xF1, 0xE0,
  0x3E, 0x1E, 0x03, 0xC0, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3E, 0x1E,
  0x01, 0xE3, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC,
  0x1E, 0x1F, 0xE1, 0xE3, 0xFF, 0x1E, 0x7D, 0xF9, 0xE7, 0x8F, 0x9C, 0x78,
  0x7F, 0xCF, 0x03, 0xFC, 0xF0, 0x1F, 0x8F, 0x00, 0xF8, 0xF8, 0x0F, 0x87,
  0x81, 0xFC, 0x7C, 0x3F, 0xE3, 0xFF, 0xDE, 0x1F, 0xF9, 0xF0, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0x9C, 0xE0, 0x00, 0x20, 0x03, 0x00,
  0x3C, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x78, 0x01, 0x80,
  0x04, 0x40, 0x03, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7C, 0x01, 0x80, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x21, 0xE0, 0x9E, 0x38, 0xE7, 0xEE, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x3F, 0x00, 0x1E, 0xE0, 0x0F, 0xBC, 0x07,
  0xCF, 0x83, 0xF1, 0xF0, 0x38, 0x78, 0x04, 0x08, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x06, 0x07, 0xE1, 0xF8, 0xFF, 0x3F,
  0xC7, 0xF1, 0xF8, 0x1E, 0x07, 0x83, 0xCF, 0xE3, 0xF0, 0x78, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x39, 0xFB, 0xFF, 0xFF, 0xFF,
  0x9F, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0xF8,
  0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0xF1, 0xEF, 0x1F, 0x3D, 0xE3, 0xE7, 0xFC, 0x7C, 0xFF, 0x8F,
  0x1E, 0xF0, 0x43, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x01, 0xEF, 0x80,
  0x7C, 0xF0, 0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x7C, 0x3F, 0x1F, 0x03, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFB,
  0xE0, 0x71, 0xF0, 0x20, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF,
  0x87, 0xFF, 0xF3, 0xFF, 0xFC, 0x78, 0x1F, 0x88, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x0F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x30, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7D, 0x00, 0x3E, 0x78, 0x3F, 0x9F, 0xFF, 0xCF, 0xFF, 0xE1,
  0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x1E,
  0x78, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7D, 0x00, 0x3E, 0x7C, 0x3F, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0x40, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xEF, 0xF0,
  0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xF3, 0xFB, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xF7, 0xC0,
  0x7D, 0xF0, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFC, 0x7E,
  0x7C, 0x0F, 0x9E, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0x78, 0x07, 0xDF,
  0x01, 0xE7, 0xE0, 0xF8, 0xFC, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFB, 0xFC, 0x7C, 0x1F, 0x9E, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0x7E, 0x1F, 0xDF,
  0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF0, 0xFC, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0x7C, 0x03, 0xDF, 0xC3, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00,
  0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x7E, 0xFF, 0xFF, 0xFF, 0xE7, 0xC0, 0x07, 0x07, 0xE1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x7E, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x0F, 0xC0, 0xE0, 0x78,
  0x3C, 0xFF, 0x1F, 0x87, 0x81, 0x00, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00,
  0x3F, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x0E, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x0E,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xEF,
  0xE4, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0x20, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x7C, 0x1E, 0x01,
  0xE3, 0xE0, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x02, 0xF7, 0x83,
  0xFF, 0x78, 0x7F, 0xF7, 0x8F, 0xFF, 0x70, 0xF8, 0xF7, 0x1F, 0x0F, 0xF1,
  0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF,
  0x1E, 0x0F, 0x71, 0xE0, 0xF7, 0x8F, 0x0F, 0x78, 0xF8, 0xF7, 0x87, 0xFF,
  0x78, 0x7F, 0xF3, 0xC1, 0xFF, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xCF, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xF0, 0x07, 0x83,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF8, 0x1F, 0x01, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x01,
  0xE7, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0x81, 0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xE7, 0xC0,
  0x3C, 0xF8, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x3F, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xC3, 0xFC, 0xF8, 0x07, 0xDF, 0x00,
  0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xBE, 0x01,
  0xF7, 0xC0, 0x7E, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0,
  0x0C, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x02, 0x1F, 0xE7,
  0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0x80, 0x7F, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x83, 0xF1, 0xF0, 0x1F,
  0x3E, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0xBE, 0x03, 0xE7, 0xC0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x00,
  0x8F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x03,
  0xDF, 0x00, 0xF7, 0xE0, 0x3C, 0xFC, 0x0F, 0x3F, 0xC7, 0xC7, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x30, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x40, 0x3E, 0x78, 0x7F, 0x3F,
  0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xDE, 0x01,
  0xF3, 0xC0, 0x3E, 0x78, 0x0F, 0x8F, 0x03, 0xE1, 0xE0, 0xFC, 0x3C, 0x1F,
  0x07, 0x87, 0xC0, 0xF1, 0xF0, 0x1E, 0x7C, 0x03, 0xDF, 0x80, 0x7B, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xBF, 0x00, 0xF3, 0xF0,
  0x1E, 0x3F, 0x03, 0xC3, 0xE0, 0x78, 0x3E, 0x0F, 0x07, 0xE1, 0xE0, 0x7E,
  0x3C, 0x07, 0xC7, 0x80, 0xFC, 0xF0, 0x0F, 0x9E, 0x00, 0xFB, 0xC0, 0x1F,
  0x78, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3E, 0x03, 0xE3, 0xE0,
  0x7E, 0x3E, 0x07, 0xE3, 0xF0, 0x7E, 0x7F, 0x0E, 0xE7, 0xF0, 0xEE, 0x7B,
  0x8E, 0xE7, 0xB9, 0xEE, 0x7B, 0x9C, 0xE7, 0x9D, 0xCE, 0x79, 0xFC, 0xE7,
  0x9F, 0x8E, 0x79, 0xF8, 0xF7, 0x8F, 0x8F, 0x78, 0xF0, 0xF7, 0x8F, 0x0F,
  0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xF7, 0x83, 0xFD, 0xE0, 0xFF,
  0x3C, 0x3F, 0xCF, 0x0F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x0F, 0x3F, 0xC3,
  0xCF, 0xF0, 0x7B, 0xFC, 0x1E, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E,
  0x78, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1E, 0x3C,
  0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x8F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x20, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xF0, 0x1F, 0xBC, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x0F, 0xBC, 0x07,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01,
  0xF7, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x8F, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x81, 0xF9,
  0xF0, 0x1F, 0x3E, 0x01, 0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF1, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x0F,
  0x81, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFE, 0x7C, 0x7C, 0x01, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7D, 0x80,
  0x1F, 0x7C, 0x3F, 0x9F, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7D,
  0xF0, 0x1F, 0x7E, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3D, 0xF0, 0x01,
  0xE7, 0x80, 0x1F, 0x3C, 0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x3C,
  0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x7C,
  0x0F, 0x03, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78,
  0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0xF0, 0xF7, 0x8F, 0x0F, 0x78, 0xF8,
  0xF7, 0x9F, 0x8E, 0x79, 0xF8, 0xE7, 0x9F, 0xCE, 0x79, 0xDC, 0xE7, 0xB9,
  0xCE, 0x7B, 0x9C, 0xE7, 0xB8, 0xEE, 0x7F, 0x0E, 0xE7, 0xF0, 0xEE, 0x3F,
  0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x7C, 0x07,
  0x81, 0xE0, 0x7C, 0x0F, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xF1, 0xE0, 0x07,
  0x9F, 0x00, 0x3E, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3E,
  0xF0, 0x01, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x83, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x1E, 0x00,
  0x7D, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xBE, 0x00, 0x7C,
  0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x03, 0xC0,
  0xF8, 0x1F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xE3, 0xC0, 0x0F, 0x3E, 0x00,
  0x7D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xDF, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0x7C, 0x3E, 0x07, 0xC3,
  0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x1F, 0x78, 0x00, 0xE1, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x38, 0x1E,
  0x1F, 0x83, 0xE0, 0xFC, 0x1C, 0x04, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x70, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x03, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7C, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x81, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x7F, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xCF, 0x81, 0xFB, 0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x01, 0xFB, 0xF3, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xFD, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC3, 0xFD, 0xE3, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xFD, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDF,
  0x01, 0xEF, 0xF3, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0x7C, 0xF0, 0x0F,
  0xBE, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xFD, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xE0,
  0x20, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF,
  0xEF, 0xF3, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1E, 0xF8, 0x1F, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFC,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x78, 0x7F, 0x3F,
  0xFF, 0x9F, 0xFF, 0x9F, 0xFF, 0x00, 0x10, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF3, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3E, 0x01, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xEF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0x30, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x80, 0xF9, 0xE3, 0xF7, 0xFF, 0xCF, 0xFF, 0x8F, 0xFC, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x3F, 0x78, 0x0F, 0xCF, 0x01, 0xF1, 0xE0, 0x7C, 0x3C,
  0x1F, 0x07, 0x87, 0xC0, 0xF1, 0xF0, 0x1E, 0x7C, 0x03, 0xDF, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x01, 0xEF, 0xC0, 0x3C, 0xFC, 0x07, 0x8F, 0xC0, 0xF0,
  0xFC, 0x1E, 0x0F, 0xC3, 0xC0, 0xF8, 0x78, 0x0F, 0x8F, 0x00, 0xF9, 0xE0,
  0x1F, 0xBC, 0x01, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xEF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0xFF, 0xBF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x79, 0xFB, 0xEE,
  0x1E, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x0F, 0xE1, 0xE1, 0xFC,
  0x3C, 0x3F, 0x87, 0x87, 0xF0, 0xF0, 0xFE, 0x1E, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1E, 0x7F, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xEF, 0x01, 0xF7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xC0,
  0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0xF7, 0xC0, 0x3E, 0x7C, 0x0F, 0xCF, 0xF7, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x01, 0x80, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x1E,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xF8, 0x1F, 0xBF, 0xDF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF8, 0xF7, 0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xE0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x7C, 0x07, 0xBF, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xC3, 0xCF,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x0F, 0xFC, 0x3F, 0xBF, 0xFF, 0xDF, 0xFF, 0xC7, 0xFF, 0x80,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xDE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x0F, 0x7F, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1E, 0x7C, 0x03, 0xE3,
  0xC0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0x78,
  0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xF0, 0x07, 0xDE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1D,
  0xE0, 0x00, 0xEF, 0x00, 0x0F, 0x78, 0x78, 0x7B, 0xC3, 0xC3, 0xCE, 0x1F,
  0x1E, 0x70, 0xF8, 0xF3, 0x8F, 0xC7, 0x9E, 0x7F, 0x38, 0xF3, 0xF9, 0xC7,
  0xBD, 0xCE, 0x3D, 0xCE, 0xF0, 0xEE, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F,
  0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x38, 0x00,
  0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x3E, 0x03, 0xC1, 0xF0, 0x78, 0x0F, 0x0F,
  0x80, 0xF9, 0xF0, 0x07, 0xDE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7D, 0xF0, 0x0F,
  0x9F, 0x00, 0xF0, 0xF8, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x03, 0xE7,
  0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF7, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xF0,
  0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x87, 0x80, 0x78, 0xF8, 0x07,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xDF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x43, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0x1F, 0x80, 0x73, 0xFE, 0x0F, 0x3F, 0xF9, 0xF7, 0xFF,
  0xFE, 0x70, 0x7F, 0xEF, 0x03, 0xFC, 0x10, 0x07, 0x00,
};

const GFXglyph UbuntuSansMono_Medium40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 29, 22, 8, -28 },
  { 23, 12, 11, 22, 5, -30 },
  { 40, 20, 28, 22, 1, -28 },
  { 110, 18, 35, 22, 2, -31 },
  { 189, 21, 29, 22, 1, -28 },
  { 266, 20, 28, 22, 1, -28 },
  { 336, 5, 12, 22, 9, -30 },
  { 344, 13, 40, 22, 5, -32 },
  { 409, 13, 40, 22, 5, -32 },
  { 474, 18, 17, 22, 2, -28 },
  { 513, 18, 20, 22, 2, -22 },
  { 558, 10, 14, 22, 6, -7 },
  { 576, 11, 5, 22, 6, -14 },
  { 583, 7, 7, 22, 8, -7 },
  { 590, 17, 38, 22, 3, -31 },
  { 671, 19, 29, 22, 2, -28 },
  { 740, 17, 28, 22, 3, -28 },
  { 800, 18, 28, 22, 2, -28 },
  { 863, 18, 29, 22, 2, -28 },
  { 929, 20, 28, 22, 1, -28 },
  { 999, 18, 29, 22, 2, -28 },
  { 1065, 18, 29, 22, 2, -28 },
  { 1131, 17, 28, 22, 3, -28 },
  { 1191, 18, 29, 22, 2, -28 },
  { 1257, 18, 28, 22, 2, -28 },
  { 1320, 7, 21, 22, 8, -21 },
  { 1339, 10, 28, 22, 5, -21 },
  { 1374, 19, 19, 22, 2, -21 },
  { 1420, 18, 12, 22, 2, -18 },
  { 1447, 19, 19, 22, 2, -21 },
  { 1493, 15, 29, 22, 4, -28 },
  { 1548, 20, 34, 22, 1, -28 },
  { 1633, 22, 28, 22, 0, -28 },
  { 1710, 19, 28, 22, 2, -28 },
  { 1777, 19, 29, 22, 2, -28 },
  { 1846, 19, 28, 22, 2, -28 },
  { 1913, 17, 28, 22, 4, -28 },
  { 1973, 16, 28, 22, 4, -28 },
  { 2029, 18, 29, 22, 2, -28 },
  { 2095, 18, 28, 22, 2, -28 },
  { 2158, 16, 28, 22, 3, -28 },
  { 2214, 17, 29, 22, 2, -28 },
  { 2276, 19, 28, 22, 3, -28 },
  { 2343, 17, 28, 22, 4, -28 },
  { 2403, 20, 28, 22, 1, -28 },
  { 2473, 18, 28, 22, 2, -28 },
  { 2536, 20, 29, 22, 1, -28 },
  { 2609, 18, 28, 22, 3, -28 },
  { 2672, 20, 35, 22, 1, -28 },
  { 2760, 19, 28, 22, 2, -28 },
  { 2827, 18, 29, 22, 2, -28 },
  { 2893, 19, 28, 22, 2, -28 },
  { 2960, 18, 29, 22, 2, -28 },
  { 3026, 21, 28, 22, 1, -28 },
  { 3100, 20, 28, 22, 1, -28 },
  { 3170, 21, 28, 22, 1, -28 },
  { 3244, 21, 28, 22, 1, -28 },
  { 3318, 18, 28, 22, 2, -28 },
  { 3381, 11, 38, 22, 6, -31 },
  { 3434, 17, 38, 22, 3, -31 },
  { 3515, 12, 38, 22, 5, -31 },
  { 3572, 20, 16, 22, 1, -28 },
  { 3612, 22, 3, 22, 0, 4 },
  { 3621, 9, 8, 22, 7, -31 },
  { 3630, 18, 21, 22, 2, -21 },
  { 3678, 18, 31, 22, 3, -31 },
  { 3748, 18, 21, 22, 2, -21 },
  { 3796, 17, 31, 22, 2, -31 },
  { 3862, 19, 21, 22, 2, -21 },
  { 3912, 20, 31, 22, 2, -31 },
  { 3990, 17, 29, 22, 2, -21 },
  { 4052, 17, 31, 22, 3, -31 },
  { 4118, 18, 31, 22, 2, -31 },
  { 4188, 15, 39, 22, 3, -31 },
  { 4262, 19, 31, 22, 3, -31 },
  { 4336, 18, 31, 22, 2, -31 },
  { 4406, 19, 21, 22, 2, -21 },
  { 4456, 17, 21, 22, 3, -21 },
  { 4501, 19, 22, 22, 2, -21 },
  { 4554, 18, 28, 22, 3, -21 },
  { 4617, 17, 28, 22, 2, -21 },
  { 4677, 16, 21, 22, 4, -21 },
  { 4719, 17, 21, 22, 3, -21 },
  { 4764, 19, 27, 22, 2, -27 },
  { 4829, 16, 21, 22, 3, -21 },
  { 4871, 20, 21, 22, 1, -21 },
  { 4924, 21, 21, 22, 1, -21 },
  { 4980, 20, 21, 22, 1, -21 },
  { 5033, 20, 29, 22, 1, -21 },
  { 5106, 16, 21, 22, 3, -21 },
  { 5148, 16, 38, 22, 3, -31 },
  { 5224, 4, 38, 22, 9, -31 },
  { 5243, 16, 38, 22, 3, -31 },
  { 5319, 20, 7, 22, 1, -15 },
};

const GFXfont UbuntuSansMono_Medium40pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium40pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium40pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUSANSMONO_MEDIUM40PT7B_H_
