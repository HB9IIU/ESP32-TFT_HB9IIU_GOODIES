#ifndef _UBUNTUSANSMONO_MEDIUM31PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium31pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x37,
  0xFF, 0xF7, 0x80, 0xE3, 0xF8, 0xFE, 0x3F, 0x8E, 0xE3, 0xB8, 0xEE, 0x3B,
  0x86, 0xE1, 0x98, 0x60, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x38, 0x1C, 0x78,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x71, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xF0, 0x3F, 0xF9, 0xFF, 0xE7, 0x83, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0xFB, 0xFF,
  0xEF, 0xFE, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0xBF, 0x03, 0x9D, 0xC1, 0xCC, 0x61, 0xC6, 0x30, 0xC7, 0x18, 0xE1, 0x8C,
  0xE0, 0xCE, 0x60, 0x77, 0x70, 0x1F, 0x70, 0x07, 0x30, 0x00, 0x38, 0x00,
  0x19, 0xE0, 0x1D, 0xF8, 0x1C, 0xCE, 0x0C, 0xE7, 0x0E, 0x73, 0x8E, 0x39,
  0xC6, 0x1C, 0xE7, 0x0E, 0x77, 0x03, 0xF3, 0x80, 0xF0, 0x07, 0x80, 0x1F,
  0xE0, 0x3F, 0xE0, 0x38, 0xF0, 0x78, 0x70, 0x78, 0x70, 0x38, 0xE0, 0x38,
  0xE0, 0x3D, 0xC0, 0x1F, 0x80, 0x1F, 0x08, 0x3F, 0x0C, 0x7F, 0x9C, 0x73,
  0xDC, 0xF1, 0xFC, 0xE0, 0xFC, 0xE0, 0x78, 0xE0, 0x78, 0xF0, 0x7C, 0x7F,
  0xFC, 0x7F, 0xDE, 0x1F, 0x8F, 0xFF, 0xFE, 0xEE, 0xEE, 0xE6, 0x01, 0x80,
  0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0x80, 0x40,
  0x60, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38,
  0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0,
  0x10, 0x00, 0x07, 0x00, 0x1C, 0x08, 0x70, 0x19, 0xCE, 0xFB, 0xFB, 0xFF,
  0xF1, 0xFC, 0x03, 0xE0, 0x1D, 0xC0, 0xF7, 0x87, 0xCF, 0x06, 0x38, 0x08,
  0x40, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x3C, 0x7C, 0xF9, 0xF3, 0xE1, 0xC7, 0x3E,
  0xF9, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xEF, 0xFE, 0x78, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xE3, 0xC3, 0x83, 0xCF, 0x03, 0x9C,
  0x07, 0x38, 0x0F, 0x70, 0x1F, 0xE7, 0x1F, 0xCF, 0x3F, 0x9E, 0x7F, 0x38,
  0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1C, 0xF0, 0x38, 0xF0, 0xF1,
  0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x1E, 0x01, 0xF8, 0x1F,
  0xE0, 0xFF, 0x81, 0xCE, 0x04, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x07, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x1F, 0x81, 0xFF, 0x8F, 0xFF,
  0x3C, 0x3C, 0x40, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x83,
  0xFF, 0x3F, 0xFC, 0xC1, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x1F, 0xFF, 0xEF, 0xFF, 0x7F, 0xE0, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0x9E, 0x0F,
  0x3C, 0x1C, 0x78, 0x70, 0xF0, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x3F, 0xF9, 0xFF, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3F, 0x83, 0xFF, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0xFF, 0xFD, 0xFF, 0xEF, 0xFC,
  0x00, 0x00, 0x10, 0x0F, 0xC0, 0x7F, 0x07, 0xFA, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xFF, 0x8F, 0xFF, 0x3F, 0x7E, 0xE0, 0x7B,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xE7, 0x87, 0x9F, 0xFE,
  0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x1E,
  0xF0, 0x3B, 0x80, 0xEE, 0x03, 0xBC, 0x0E, 0x78, 0x79, 0xF3, 0xC3, 0xFE,
  0x0F, 0xF8, 0x7B, 0xF3, 0xC1, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x03, 0xBF, 0x7E, 0x7F, 0xF0, 0xFF, 0x80, 0x0F, 0x80, 0xFF, 0x87,
  0xFF, 0x1E, 0x3C, 0xF0, 0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x83, 0xDF, 0xFF, 0x3F, 0xF8, 0x3E, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7E, 0x1F, 0xE0, 0x7F, 0x01, 0xE0, 0x00, 0x7B,
  0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFB, 0xFF, 0x9E, 0x1E,
  0x3E, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3E,
  0x3E, 0x3F, 0x1E, 0x0E, 0x0E, 0x7C, 0xF8, 0x60, 0x00, 0x08, 0x01, 0xF0,
  0x1F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0x01, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x80,
  0xF8, 0x03, 0x80, 0x00, 0x3F, 0x0F, 0xFC, 0xFF, 0xE4, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x3E, 0x01,
  0xE0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xE3, 0x80, 0xEE, 0x01,
  0xDC, 0x03, 0xB8, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x8E, 0x3F, 0x3C, 0x7E,
  0x70, 0xFC, 0xE1, 0xF9, 0xC3, 0xF3, 0x87, 0xE7, 0x8F, 0xC7, 0x9D, 0xCF,
  0xFB, 0x8F, 0xF7, 0x07, 0x87, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xFC,
  0x0F, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x39, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x3C, 0x0F,
  0x0E, 0x07, 0x07, 0x03, 0x83, 0xC1, 0xC1, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x78, 0x0F, 0x3C, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xFF, 0x00,
  0x78, 0x3E, 0x03, 0xFF, 0x8F, 0xFF, 0x38, 0x7C, 0xE0, 0x7B, 0x81, 0xEE,
  0x03, 0xB8, 0x1E, 0xE0, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xFC, 0xE0, 0xFB,
  0x80, 0xEE, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xBF, 0xFE,
  0xFF, 0xF3, 0xFF, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x7F, 0xF8, 0xF8, 0x63,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x08, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x03,
  0xFF, 0x0F, 0xFE, 0x38, 0xFC, 0xE0, 0xFB, 0x81, 0xEE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3B, 0x81, 0xEE, 0x0F, 0x3F, 0xFC, 0xFF, 0xC3, 0xFC,
  0x00, 0xFF, 0xF7, 0xFF, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xFC,
  0x7F, 0xF9, 0xF0, 0x63, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x07,
  0xB8, 0x0F, 0x78, 0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF9, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7A, 0x07, 0xBF, 0xFD, 0xFF, 0xC7, 0xFC, 0x00, 0xE0, 0x3D,
  0xC0, 0xF3, 0x83, 0xC7, 0x07, 0x8E, 0x1E, 0x1C, 0x78, 0x39, 0xE0, 0x73,
  0xC0, 0xEF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0x7C, 0x0E, 0x7C, 0x1C, 0x7C,
  0x38, 0x78, 0x70, 0x78, 0xE0, 0x79, 0xC0, 0xF3, 0x80, 0xF7, 0x01, 0xEE,
  0x01, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x78, 0x1C, 0xF0, 0x79, 0xE0, 0xF3, 0xE1, 0xE6, 0xC7, 0xCD, 0x8D,
  0xDB, 0x9B, 0xB3, 0x77, 0x66, 0xCE, 0xCF, 0x9F, 0x8F, 0x3F, 0x1E, 0x7E,
  0x38, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xE0, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFE, 0xE3, 0xFB, 0x8F, 0xE7, 0x3F, 0x9C, 0xFE, 0x3B,
  0xF8, 0xEF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3C, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1,
  0xE3, 0xE7, 0x81, 0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0x70, 0x1E, 0xF0, 0x39, 0xE0, 0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x00,
  0x3F, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE3, 0xE7, 0x83,
  0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0x70, 0x1E, 0xF0,
  0x39, 0xE0, 0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x20, 0x3E, 0x03, 0xFF, 0x0F,
  0xFF, 0x38, 0x7C, 0xE0, 0x7B, 0x81, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B,
  0x81, 0xEE, 0x0F, 0x3F, 0xFC, 0xFF, 0xC3, 0xFF, 0x0E, 0x1E, 0x38, 0x38,
  0xE0, 0xF3, 0x81, 0xCE, 0x07, 0xB8, 0x0E, 0xE0, 0x3F, 0x80, 0x70, 0x0F,
  0xE0, 0xFF, 0xE7, 0xFF, 0x1E, 0x0C, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF4, 0x07, 0xBF, 0xFE, 0xFF, 0xF1,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B,
  0xC1, 0xE7, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0xF0, 0x07, 0xB8, 0x03, 0x9E,
  0x01, 0xCF, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x78, 0xF0, 0x38, 0x78, 0x1C,
  0x1C, 0x1E, 0x0E, 0x0E, 0x07, 0x87, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0x71,
  0xC0, 0x1C, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x9F, 0x9F,
  0x3B, 0x36, 0x76, 0x6E, 0xED, 0xCD, 0xDB, 0x1B, 0xB6, 0x3E, 0x6C, 0x7C,
  0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x81, 0xC0, 0xF0, 0x1E, 0x78, 0x1C,
  0x38, 0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xE0, 0x0F, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xF0, 0x1E, 0xF0,
  0x1C, 0x78, 0x3C, 0x78, 0x38, 0x3C, 0x78, 0x3C, 0x70, 0x1E, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0x8E, 0x03, 0xC7, 0x81, 0xC1, 0xC1,
  0xE0, 0xF0, 0xE0, 0x78, 0xF0, 0x1C, 0x70, 0x07, 0x38, 0x03, 0xB8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0xFF, 0xFF, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x7F,
  0x81, 0xEF, 0x03, 0xCF, 0x0F, 0x0E, 0x1C, 0x1E, 0x78, 0x1D, 0xE0, 0x3D,
  0xC0, 0x39, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x43,
  0x8F, 0x1E, 0x3C, 0x20, 0x06, 0x01, 0xFF, 0x0F, 0xFC, 0x61, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xE1, 0xFF, 0x7F, 0xFB, 0xFF, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x1F, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x40, 0xFF, 0xE3,
  0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xFF, 0xCF, 0xFF,
  0x3F, 0xF0, 0x01, 0xC0, 0x3F, 0xF3, 0xFF, 0x9F, 0xCE, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x8F, 0x1F, 0xFC,
  0xFF, 0xF7, 0xEF, 0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x0F, 0x78, 0x3C, 0xFF, 0xF1, 0xFF,
  0xC3, 0xFF, 0x01, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xF3, 0xE7, 0x81, 0xCE,
  0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF8, 0x78, 0x21, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xC0, 0x3F, 0xF3, 0xFF,
  0xCF, 0x8F, 0x78, 0x1D, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xDC, 0x07, 0x78, 0x3C, 0xFF, 0xF3, 0xFF, 0xC3, 0xF7, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xD8, 0x3E, 0x7F, 0xF9, 0xFF, 0xC1, 0xF8, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x40, 0xFF, 0xE7, 0xFF, 0xBF, 0xFD, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0x0C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xC0, 0x1E,
  0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x61, 0xE7, 0xFE, 0xFF, 0xC3, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7D, 0xE0,
  0xF3, 0xC3, 0xC7, 0x8F, 0x0F, 0x3C, 0x1E, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x81, 0xEF, 0x83, 0xCF, 0x87, 0x8F, 0x0F, 0x0F, 0x1E, 0x0F, 0x3C,
  0x0F, 0x78, 0x1F, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFB, 0xDF, 0x7F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7,
  0xE3, 0x8F, 0xC7, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0x07, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x07, 0xF8,
  0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x38, 0x01, 0x00, 0x1F, 0xE0, 0x7F,
  0xE1, 0xF7, 0xE7, 0x83, 0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7B, 0x80, 0xF7, 0x81, 0xEF, 0x07, 0x8F, 0xFF, 0x0F,
  0xFC, 0x0F, 0xE0, 0x02, 0x03, 0xFF, 0x8F, 0xFF, 0x3E, 0x7E, 0xF0, 0x7B,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xF1,
  0xFF, 0xCF, 0xDF, 0x78, 0x1D, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x78, 0x1D, 0xE0, 0xF3, 0xFF, 0xCF, 0xFF,
  0x0F, 0xDC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x01, 0x83, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0x00, 0xFF, 0x9F, 0xFC, 0xF8, 0xE7,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00,
  0xF0, 0x03, 0xA0, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x83, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF,
  0xF0, 0x0F, 0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x38, 0x3C,
  0x3C, 0x38, 0x3C, 0x78, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE3, 0x86, 0xE3, 0x8E, 0xE3, 0xCE, 0xE3, 0xCE, 0xE7, 0xCE,
  0x66, 0xCE, 0x76, 0xEE, 0x7E, 0x6C, 0x7C, 0x6C, 0x7C, 0x7C, 0x3C, 0x3C,
  0x38, 0x3C, 0x38, 0x38, 0xF0, 0x1E, 0x78, 0x3C, 0x3C, 0x38, 0x1E, 0x78,
  0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1E, 0xF0, 0x1C, 0x78, 0x3C, 0x38, 0x78, 0x3C, 0x70, 0x1E, 0xF0, 0x0F,
  0x70, 0x1E, 0xF0, 0x3D, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x87, 0x87,
  0x0E, 0x0E, 0x1C, 0x1E, 0x78, 0x1C, 0xE0, 0x3D, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x02, 0x1E, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x0F, 0xC0, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x1C,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E,
  0x00, 0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF8, 0x03, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE1, 0xFE, 0x0F, 0xF0, 0x7E, 0x00, 0x1E, 0x04, 0x7E, 0x1D, 0xFF, 0xFF,
  0x9F, 0xFE, 0x0F, 0xC0, 0x06, 0x00,
};

const GFXglyph UbuntuSansMono_Medium31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 10, 10, 17, 4, -24 },
  { 28, 16, 21, 17, 1, -21 },
  { 70, 14, 27, 17, 2, -24 },
  { 118, 17, 22, 17, 0, -22 },
  { 165, 16, 22, 17, 1, -22 },
  { 209, 4, 10, 17, 7, -24 },
  { 214, 10, 30, 17, 4, -24 },
  { 252, 10, 30, 17, 4, -24 },
  { 290, 14, 13, 17, 2, -21 },
  { 313, 14, 16, 17, 2, -17 },
  { 341, 7, 10, 17, 5, -5 },
  { 350, 9, 4, 17, 4, -11 },
  { 355, 6, 5, 17, 6, -5 },
  { 359, 13, 30, 17, 2, -24 },
  { 408, 15, 22, 17, 1, -22 },
  { 450, 14, 21, 17, 2, -21 },
  { 487, 14, 22, 17, 2, -22 },
  { 526, 13, 22, 17, 2, -22 },
  { 562, 15, 21, 17, 1, -21 },
  { 602, 13, 21, 17, 2, -21 },
  { 637, 14, 22, 17, 2, -22 },
  { 676, 14, 21, 17, 2, -21 },
  { 713, 14, 22, 17, 2, -22 },
  { 752, 14, 22, 17, 2, -22 },
  { 791, 6, 16, 17, 6, -16 },
  { 803, 8, 21, 17, 4, -16 },
  { 824, 14, 14, 17, 2, -16 },
  { 849, 14, 10, 17, 2, -14 },
  { 867, 14, 14, 17, 2, -16 },
  { 892, 12, 22, 17, 3, -22 },
  { 925, 15, 27, 17, 1, -22 },
  { 976, 17, 21, 17, 0, -21 },
  { 1021, 14, 22, 17, 2, -22 },
  { 1060, 15, 22, 17, 1, -22 },
  { 1102, 14, 22, 17, 2, -22 },
  { 1141, 13, 21, 17, 3, -21 },
  { 1176, 12, 21, 17, 3, -21 },
  { 1208, 15, 22, 17, 1, -22 },
  { 1250, 14, 21, 17, 2, -21 },
  { 1287, 12, 21, 17, 3, -21 },
  { 1319, 13, 21, 17, 2, -21 },
  { 1354, 15, 21, 17, 2, -21 },
  { 1394, 13, 21, 17, 3, -21 },
  { 1429, 15, 21, 17, 1, -21 },
  { 1469, 14, 21, 17, 2, -21 },
  { 1506, 15, 22, 17, 1, -22 },
  { 1548, 14, 22, 17, 2, -22 },
  { 1587, 15, 28, 17, 1, -22 },
  { 1640, 14, 22, 17, 2, -22 },
  { 1679, 14, 22, 17, 2, -22 },
  { 1718, 15, 21, 17, 1, -21 },
  { 1758, 14, 21, 17, 2, -21 },
  { 1795, 17, 21, 17, 0, -21 },
  { 1840, 15, 21, 17, 1, -21 },
  { 1880, 16, 21, 17, 1, -21 },
  { 1922, 17, 21, 17, 0, -21 },
  { 1967, 14, 21, 17, 2, -21 },
  { 2004, 8, 30, 17, 5, -24 },
  { 2034, 13, 30, 17, 2, -24 },
  { 2083, 9, 30, 17, 4, -24 },
  { 2117, 15, 12, 17, 1, -21 },
  { 2140, 17, 3, 17, 0, 3 },
  { 2147, 6, 6, 17, 6, -24 },
  { 2152, 13, 17, 17, 2, -17 },
  { 2180, 14, 24, 17, 2, -24 },
  { 2222, 14, 17, 17, 2, -17 },
  { 2252, 14, 24, 17, 1, -24 },
  { 2294, 15, 17, 17, 1, -17 },
  { 2326, 15, 24, 17, 2, -24 },
  { 2371, 14, 23, 17, 1, -17 },
  { 2412, 13, 24, 17, 2, -24 },
  { 2451, 14, 24, 17, 2, -24 },
  { 2493, 12, 30, 17, 2, -24 },
  { 2538, 15, 24, 17, 2, -24 },
  { 2583, 14, 24, 17, 2, -24 },
  { 2625, 15, 16, 17, 1, -16 },
  { 2655, 13, 17, 17, 2, -17 },
  { 2683, 15, 17, 17, 1, -17 },
  { 2715, 14, 23, 17, 2, -17 },
  { 2756, 14, 23, 17, 1, -17 },
  { 2797, 13, 17, 17, 3, -17 },
  { 2825, 13, 17, 17, 2, -17 },
  { 2853, 14, 21, 17, 2, -21 },
  { 2890, 13, 16, 17, 2, -16 },
  { 2916, 16, 16, 17, 1, -16 },
  { 2948, 16, 16, 17, 1, -16 },
  { 2980, 16, 16, 17, 1, -16 },
  { 3012, 15, 22, 17, 1, -16 },
  { 3054, 13, 16, 17, 2, -16 },
  { 3080, 12, 30, 17, 3, -24 },
  { 3125, 3, 30, 17, 7, -24 },
  { 3137, 13, 30, 17, 2, -24 },
  { 3186, 15, 6, 17, 1, -12 },
};

const GFXfont UbuntuSansMono_Medium31pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium31pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium31pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUSANSMONO_MEDIUM31PT7B_H_
