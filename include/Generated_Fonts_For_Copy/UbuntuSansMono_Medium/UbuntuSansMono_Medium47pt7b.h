#ifndef _UBUNTUSANSMONO_MEDIUM47PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium47pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xF7, 0x03, 0xDC, 0x0F, 0x70, 0x3D, 0xC0, 0xE0,
  0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0xF8,
  0x01, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0,
  0x07, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x0F, 0x83, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80,
  0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFE, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x80,
  0x03, 0xF7, 0xC0, 0x3F, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x1F,
  0xE0, 0x07, 0x9F, 0xF0, 0x07, 0x9F, 0x3C, 0x07, 0xCF, 0x1E, 0x03, 0xC7,
  0x87, 0x03, 0xC3, 0x83, 0x83, 0xE1, 0xC1, 0xC1, 0xE0, 0xE0, 0xE1, 0xE0,
  0x70, 0x70, 0xF0, 0x3C, 0x78, 0xF0, 0x1E, 0x3C, 0xF0, 0x0F, 0xBE, 0x78,
  0x03, 0xFE, 0x78, 0x00, 0xFE, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x7F, 0x00, 0x1E, 0x7F, 0xC0, 0x0F,
  0x3F, 0xF0, 0x0F, 0x3C, 0x78, 0x0F, 0x9E, 0x3C, 0x07, 0x8F, 0x0E, 0x07,
  0x87, 0x87, 0x83, 0xC3, 0xC3, 0xC3, 0xC1, 0xE1, 0xE3, 0xC0, 0xF0, 0xE1,
  0xE0, 0x78, 0x71, 0xE0, 0x3C, 0x79, 0xE0, 0x0F, 0xFC, 0xF0, 0x07, 0xFC,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0x87, 0xC0, 0x1F, 0x03,
  0xC0, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x30, 0x0F, 0xF0, 0x3C, 0x1F, 0xF8,
  0x3C, 0x1F, 0xFC, 0x3C, 0x3E, 0x7E, 0x3C, 0x7C, 0x3F, 0x7C, 0x7C, 0x1F,
  0xFC, 0x7C, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF8, 0xF8, 0x03,
  0xF0, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF8, 0x7E, 0x07, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0x3E, 0x1F, 0xFE, 0x3E, 0x07, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE3, 0x80, 0x00, 0x18,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0x80, 0x01,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x30, 0x78,
  0x11, 0xE3, 0xC3, 0xCF, 0xCE, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xEF, 0x00, 0x3F, 0x7C,
  0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x03, 0xC1, 0xE0, 0x0C,
  0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x03, 0xE0, 0x78, 0x1F, 0x0F, 0xCF, 0xF0,
  0xFC, 0x1E, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x1F,
  0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0xC7, 0xFE, 0x3F,
  0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x87, 0x87, 0xFE, 0x04, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x7C,
  0x00, 0xF9, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x87,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0x7C, 0x03, 0xE3, 0xE0, 0x0C, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xE1, 0xFE, 0x3C, 0x03, 0xF0, 0x80, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7C, 0x3F, 0xC3, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x01,
  0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x78,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x60, 0x0F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xE0, 0x3F, 0xBE, 0x00, 0xFD,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xFC, 0x07, 0xE7,
  0xF0, 0x7E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF0, 0xF8, 0x07, 0xE7,
  0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xE0,
  0x0F, 0x8F, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0xFF, 0x0F, 0x81, 0xFF, 0x7E,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xF9, 0xFF, 0x0F,
  0x81, 0xFC, 0x7E, 0x01, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3E,
  0x7F, 0x01, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x87, 0xF0, 0xFE, 0x3E, 0x03, 0xF3, 0xF0, 0x0F, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x06, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x07, 0x81,
  0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7E, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F,
  0x0F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE0, 0x7C, 0x0F, 0x03,
  0xE1, 0xF9, 0xFE, 0x1F, 0x83, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x78, 0x3F, 0xC8, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x1E, 0x7C,
  0x00, 0x3C, 0xF0, 0x00, 0x7D, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0x8F, 0xF8, 0x7E, 0x1F, 0xF0, 0xF8,
  0x3F, 0xE1, 0xE0, 0x7F, 0xC7, 0xC0, 0xFF, 0x8F, 0x81, 0xFF, 0x1F, 0x03,
  0xFE, 0x3E, 0x07, 0xFC, 0x7C, 0x0F, 0xF8, 0x78, 0x1F, 0xF0, 0xF8, 0x3F,
  0xF1, 0xF0, 0x7F, 0xE3, 0xF8, 0xFF, 0xC3, 0xFF, 0xF7, 0x83, 0xFF, 0xEF,
  0x83, 0xFF, 0xDF, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x40, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7C, 0x03, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x1F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3E, 0x03, 0xFD, 0xF0, 0x07, 0xEF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0x80, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xF8, 0xF8,
  0x7F, 0x00, 0x63, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x02, 0x1F, 0xE0, 0x38, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7C, 0x0F, 0xF3,
  0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xFD, 0xF0, 0x1F, 0xCF, 0x83, 0xFC,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF0, 0x78, 0x7F, 0x00, 0x63, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7E,
  0x00, 0x7D, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xE0, 0x1F, 0x1F, 0xE0,
  0x7C, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE6, 0x00, 0x7E, 0x78,
  0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x5C, 0x00, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0,
  0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC7, 0xE0,
  0x0F, 0x9F, 0x80, 0x1F, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xEF, 0xE0, 0x07, 0xCF, 0xE0, 0x0F,
  0x8F, 0xE0, 0x1F, 0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x8F, 0x80,
  0x1F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC1, 0xDC,
  0x3F, 0xC3, 0xDC, 0x3D, 0xC3, 0xDE, 0x3D, 0xC3, 0x9E, 0x3D, 0xE3, 0x9E,
  0x3D, 0xE7, 0x9E, 0x7C, 0xE7, 0x9E, 0x7C, 0xF7, 0x1E, 0x7C, 0xFF, 0x1E,
  0x7C, 0x7F, 0x1E, 0x7C, 0x7E, 0x1E, 0x7C, 0x7E, 0x1E, 0x7C, 0x3E, 0x1E,
  0x7C, 0x3C, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xBC, 0x07, 0xFD, 0xF0, 0x3F, 0xE7, 0x81, 0xFF, 0x3E,
  0x0F, 0xF8, 0xF0, 0x7F, 0xC7, 0xC3, 0xFE, 0x1E, 0x1F, 0xF0, 0xF8, 0xFF,
  0x83, 0xC7, 0xFC, 0x1F, 0x3F, 0xE0, 0x79, 0xFF, 0x03, 0xEF, 0xF8, 0x0F,
  0x7F, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x80, 0xFC,
  0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7E, 0x03, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0C, 0x3F, 0xF0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xE0,
  0x3F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF,
  0x80, 0x7E, 0x3E, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xF0, 0x3C, 0x3F, 0x00, 0x23, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x80, 0x03, 0xE7, 0x00, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F,
  0x80, 0x7E, 0x3F, 0x03, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0,
  0x01, 0xF9, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0x80, 0x03, 0xE7,
  0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x7D, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x7C, 0x3C, 0x1E, 0x7C, 0x3E, 0x1E, 0x7C, 0x7E, 0x1E,
  0x7C, 0x7E, 0x1E, 0x7C, 0x7E, 0x1E, 0x7C, 0xFF, 0x1E, 0x7C, 0xFF, 0x1E,
  0x7C, 0xF7, 0x1E, 0x7C, 0xE7, 0x9E, 0x3D, 0xE7, 0x9E, 0x3D, 0xE3, 0x9E,
  0x3D, 0xC3, 0xDE, 0x3F, 0xC3, 0xDC, 0x3F, 0xC1, 0xDC, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xF8,
  0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xE0,
  0x03, 0xE7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xE7, 0xE0,
  0x07, 0xE3, 0xE0, 0x07, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0x81, 0xF8,
  0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7E,
  0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xE0, 0x03,
  0xE1, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF0, 0x00,
  0x70, 0x40, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x0E, 0x07,
  0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0x7C, 0x0E, 0x01, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1C, 0x1F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x02, 0x80, 0x08, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFB, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xBF, 0xCF, 0xC0, 0x7E, 0xF8,
  0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x1F,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x18,
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xFC, 0xF8, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x08, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xDF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xF8, 0x0F,
  0xDF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xE0,
  0x3F, 0x3F, 0x81, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xC7, 0xF0, 0xFC, 0x07, 0xE7, 0xE0, 0x0F,
  0x9F, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x70, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x81, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3,
  0xFC, 0x3F, 0xBF, 0x80, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xF0, 0x07,
  0xDF, 0xC0, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE2, 0x00, 0x7F, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xBF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF,
  0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x06, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF9, 0xC0, 0x7E, 0x7F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x08,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0x7C, 0x03, 0xFB,
  0xE0, 0x1F, 0x9F, 0x01, 0xF8, 0xF8, 0x1F, 0x87, 0xC1, 0xF8, 0x3E, 0x1F,
  0x81, 0xF1, 0xF8, 0x0F, 0x9F, 0x80, 0x7D, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3E, 0xFE, 0x01, 0xF3, 0xF8,
  0x0F, 0x8F, 0xE0, 0x7C, 0x3F, 0x83, 0xE0, 0xFE, 0x1F, 0x03, 0xF0, 0xF8,
  0x0F, 0xC7, 0xC0, 0x3F, 0x3E, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x1F,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x06, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0x80, 0x3F, 0x83, 0xE1, 0xFF, 0xDF,
  0xE3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0x9F, 0xEF, 0xDE, 0x1F, 0x0F,
  0xBC, 0x1E, 0x0F, 0x78, 0x3C, 0x1F, 0xF0, 0x7C, 0x3F, 0xE0, 0xF8, 0x7F,
  0xC1, 0xF0, 0xFF, 0x83, 0xE1, 0xFF, 0x07, 0xC3, 0xFE, 0x0F, 0x87, 0xFC,
  0x1F, 0x0F, 0xF8, 0x3E, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x1F, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xEF, 0xF0, 0xFC, 0x0F, 0xE7,
  0xE0, 0x1F, 0x9F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0x9F,
  0x80, 0x7E, 0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x7F, 0xCF, 0x80, 0xFE, 0xF8, 0x07,
  0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xFE, 0x0F, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0x83, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFE, 0xFF, 0x9F, 0x80, 0x7D,
  0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01,
  0xF3, 0xF8, 0x3F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07,
  0xFE, 0xF8, 0x01, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xAF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xF0, 0x00, 0xBE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0x03, 0xC7, 0xC0, 0x04, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF4, 0x00, 0x1F, 0x78, 0x03, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x70, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x06, 0x00, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x1F,
  0x7F, 0x01, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x0A, 0x80, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00,
  0x7B, 0xE0, 0xF0, 0x7C, 0xF0, 0x7C, 0x3E, 0x78, 0x3E, 0x1F, 0x3C, 0x3F,
  0x0F, 0x1E, 0x1F, 0x87, 0x8F, 0x0F, 0xE3, 0xC7, 0xCF, 0xF1, 0xE3, 0xE7,
  0xF8, 0xF0, 0xF3, 0xDE, 0x78, 0x7B, 0xCF, 0x7C, 0x3D, 0xE7, 0xBC, 0x1E,
  0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xF8, 0x1F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x80,
  0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE7,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xE3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x81,
  0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xE0, 0x1F,
  0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x18, 0x7F, 0xC0, 0x3D, 0xFF, 0xE0, 0xFB,
  0xFF, 0xF3, 0xEF, 0xFF, 0xFF, 0xDF, 0x0F, 0xFF, 0x3C, 0x07, 0xFC, 0x38,
  0x03, 0xF0,
};

const GFXglyph UbuntuSansMono_Medium47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 34, 26, 9, -33 },
  { 35, 14, 14, 26, 6, -36 },
  { 60, 24, 33, 26, 1, -33 },
  { 159, 22, 41, 26, 2, -36 },
  { 272, 25, 34, 26, 1, -33 },
  { 379, 24, 33, 26, 1, -33 },
  { 478, 6, 15, 26, 10, -36 },
  { 490, 15, 46, 26, 6, -37 },
  { 577, 16, 46, 26, 5, -37 },
  { 669, 21, 20, 26, 3, -33 },
  { 722, 22, 23, 26, 2, -25 },
  { 786, 11, 16, 26, 7, -8 },
  { 808, 13, 5, 26, 7, -16 },
  { 817, 8, 9, 26, 9, -8 },
  { 826, 20, 46, 26, 3, -37 },
  { 941, 22, 34, 26, 2, -33 },
  { 1035, 21, 33, 26, 3, -33 },
  { 1122, 21, 33, 26, 3, -33 },
  { 1209, 20, 34, 26, 3, -33 },
  { 1294, 23, 33, 26, 2, -33 },
  { 1389, 20, 34, 26, 3, -33 },
  { 1474, 21, 34, 26, 3, -33 },
  { 1564, 21, 33, 26, 3, -33 },
  { 1651, 22, 34, 26, 2, -33 },
  { 1745, 21, 33, 26, 3, -33 },
  { 1832, 8, 26, 26, 9, -25 },
  { 1858, 11, 33, 26, 6, -25 },
  { 1904, 22, 21, 26, 2, -24 },
  { 1962, 22, 14, 26, 2, -21 },
  { 2001, 22, 21, 26, 2, -24 },
  { 2059, 18, 34, 26, 4, -33 },
  { 2136, 23, 40, 26, 2, -33 },
  { 2251, 26, 33, 26, 0, -33 },
  { 2359, 21, 33, 26, 3, -33 },
  { 2446, 22, 34, 26, 2, -33 },
  { 2540, 21, 33, 26, 3, -33 },
  { 2627, 20, 33, 26, 4, -33 },
  { 2710, 19, 33, 26, 4, -33 },
  { 2789, 22, 34, 26, 2, -33 },
  { 2883, 22, 33, 26, 2, -33 },
  { 2974, 18, 33, 26, 4, -33 },
  { 3049, 20, 34, 26, 3, -33 },
  { 3134, 23, 33, 26, 3, -33 },
  { 3229, 20, 33, 26, 4, -33 },
  { 3312, 24, 33, 26, 1, -33 },
  { 3411, 21, 33, 26, 3, -33 },
  { 3498, 24, 34, 26, 1, -33 },
  { 3600, 21, 33, 26, 3, -33 },
  { 3687, 24, 42, 26, 1, -33 },
  { 3813, 22, 33, 26, 3, -33 },
  { 3904, 21, 34, 26, 3, -33 },
  { 3994, 23, 33, 26, 2, -33 },
  { 4089, 22, 34, 26, 2, -33 },
  { 4183, 25, 33, 26, 1, -33 },
  { 4287, 24, 33, 26, 1, -33 },
  { 4386, 24, 33, 26, 1, -33 },
  { 4485, 25, 33, 26, 1, -33 },
  { 4589, 21, 33, 26, 3, -33 },
  { 4676, 13, 46, 26, 7, -37 },
  { 4751, 20, 46, 26, 3, -37 },
  { 4866, 13, 46, 26, 6, -37 },
  { 4941, 23, 19, 26, 2, -33 },
  { 4996, 26, 5, 26, 0, 4 },
  { 5013, 10, 9, 26, 8, -36 },
  { 5025, 20, 26, 26, 3, -25 },
  { 5090, 20, 38, 26, 4, -37 },
  { 5185, 22, 26, 26, 2, -25 },
  { 5257, 21, 38, 26, 2, -37 },
  { 5357, 22, 26, 26, 2, -25 },
  { 5429, 23, 36, 26, 3, -36 },
  { 5533, 21, 34, 26, 2, -25 },
  { 5623, 19, 37, 26, 4, -37 },
  { 5711, 22, 37, 26, 2, -36 },
  { 5813, 18, 45, 26, 3, -36 },
  { 5915, 21, 37, 26, 4, -37 },
  { 6013, 22, 37, 26, 2, -36 },
  { 6115, 23, 25, 26, 2, -25 },
  { 6187, 19, 25, 26, 4, -25 },
  { 6247, 22, 26, 26, 2, -25 },
  { 6319, 20, 34, 26, 4, -25 },
  { 6404, 21, 34, 26, 2, -25 },
  { 6494, 19, 25, 26, 5, -25 },
  { 6554, 20, 26, 26, 3, -25 },
  { 6619, 21, 33, 26, 3, -32 },
  { 6706, 20, 26, 26, 3, -25 },
  { 6771, 24, 25, 26, 1, -25 },
  { 6846, 25, 25, 26, 1, -25 },
  { 6925, 24, 25, 26, 1, -25 },
  { 7000, 23, 34, 26, 1, -25 },
  { 7098, 19, 25, 26, 4, -25 },
  { 7158, 19, 46, 26, 4, -37 },
  { 7268, 5, 46, 26, 11, -37 },
  { 7297, 19, 46, 26, 4, -37 },
  { 7407, 23, 8, 26, 2, -18 },
};

const GFXfont UbuntuSansMono_Medium47pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium47pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium47pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _UBUNTUSANSMONO_MEDIUM47PT7B_H_
