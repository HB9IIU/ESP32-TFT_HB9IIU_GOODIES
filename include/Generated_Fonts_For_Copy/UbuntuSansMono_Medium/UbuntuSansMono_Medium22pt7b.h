#ifndef _UBUNTUSANSMONO_MEDIUM22PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium22pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x66, 0x66, 0x66, 0x00, 0x7F, 0x70, 0xCF, 0x9F, 0x3E,
  0x6C, 0xD8, 0xB1, 0x00, 0x18, 0xC3, 0x38, 0x66, 0x0C, 0xCF, 0xFF, 0xFF,
  0xCC, 0x61, 0x98, 0x33, 0x1F, 0xFF, 0xFF, 0xB1, 0x86, 0x60, 0xCC, 0x39,
  0x80, 0x0C, 0x03, 0x00, 0xF0, 0xFF, 0x71, 0x98, 0x0E, 0x01, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x00, 0xC0, 0x36, 0x3F, 0xFE, 0x3E, 0x03, 0x00,
  0xC0, 0x30, 0x07, 0x83, 0x4C, 0x6C, 0xCC, 0xCC, 0xCC, 0xD8, 0x7B, 0x07,
  0xB0, 0x06, 0x00, 0xDE, 0x0D, 0xB1, 0x93, 0x11, 0x33, 0x13, 0x61, 0xBE,
  0x1E, 0x08, 0x07, 0xC1, 0xDC, 0x31, 0x86, 0x30, 0xCE, 0x1F, 0x81, 0xE0,
  0x78, 0xDF, 0x9B, 0x3B, 0x63, 0xCC, 0x39, 0x87, 0x3F, 0xF3, 0xE7, 0xFF,
  0xFC, 0x0C, 0x3C, 0xE1, 0x87, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x38, 0x30, 0x70, 0x70, 0x70, 0xF0, 0x40, 0xC1, 0xC1, 0xC1, 0xC1,
  0x83, 0x83, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x18, 0x71,
  0xC7, 0x0C, 0x00, 0x0C, 0x03, 0x06, 0xCF, 0xDF, 0x7F, 0x87, 0x83, 0xB1,
  0xCE, 0x11, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0xE3, 0xCF, 0x18, 0xEF, 0x10, 0xFF,
  0xF0, 0x6F, 0xF7, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0x0C, 0x0F, 0xC7, 0xF9, 0x87, 0xE1,
  0xF8, 0x3C, 0x4F, 0x33, 0xCE, 0xF3, 0x3E, 0x0F, 0x83, 0x61, 0xDC, 0x63,
  0xF8, 0xFC, 0x0C, 0x1E, 0x1F, 0x1D, 0x88, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x0C, 0x1F, 0xCF, 0xF9, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18,
  0x07, 0xFD, 0xFF, 0x1C, 0x1F, 0xC7, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x7C, 0x1F, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x77, 0xFB, 0xFC, 0x03,
  0x80, 0xF0, 0x3E, 0x0F, 0xC1, 0xB8, 0x67, 0x1C, 0xE3, 0x1C, 0xC3, 0x9F,
  0xFF, 0xFF, 0x81, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3F, 0x8F, 0xE3, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0xF0, 0x7E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x81,
  0xDF, 0xEF, 0xF0, 0x07, 0x87, 0xE3, 0xC0, 0xC0, 0x70, 0x19, 0x0F, 0xFB,
  0xFE, 0xE1, 0xF8, 0x3E, 0x0D, 0x87, 0x71, 0xDF, 0xE3, 0xF0, 0xFF, 0xFF,
  0xF0, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x0C, 0x0F, 0xE7, 0x39, 0x87, 0xE1, 0xD8,
  0x77, 0x18, 0xFC, 0x3F, 0x1C, 0xEE, 0x1F, 0x03, 0xE0, 0xF8, 0x77, 0xF8,
  0xFC, 0x0C, 0x0F, 0xC7, 0x39, 0x87, 0xE1, 0xF8, 0x3E, 0x0D, 0x83, 0x7F,
  0xCF, 0xF0, 0x1C, 0x06, 0x03, 0x83, 0xC7, 0xE1, 0xE0, 0x6F, 0xF7, 0x00,
  0x00, 0x6F, 0xF7, 0x33, 0xDE, 0x70, 0x00, 0x00, 0x33, 0xDE, 0x71, 0x9B,
  0x90, 0x00, 0xC1, 0xF1, 0xF3, 0xF0, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x01,
  0xC0, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x60,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xC0, 0xF1, 0xF9, 0xF0, 0xF0, 0x10, 0x00,
  0x18, 0xFE, 0xEF, 0x03, 0x03, 0x07, 0x06, 0x1C, 0x18, 0x38, 0x38, 0x00,
  0x00, 0x38, 0x38, 0x38, 0x06, 0x03, 0xF0, 0xE7, 0x30, 0x66, 0x0D, 0x87,
  0xF3, 0xFE, 0x77, 0xCC, 0xFB, 0x9F, 0x73, 0xEE, 0x7C, 0xCF, 0x9F, 0xF9,
  0xFB, 0x00, 0x70, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x80,
  0xD8, 0x19, 0x81, 0x9C, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0xFE, 0x7F, 0xE6,
  0x06, 0x60, 0x66, 0x07, 0xE0, 0x70, 0xFF, 0x3F, 0xEE, 0x1B, 0x87, 0xE1,
  0xB8, 0xEF, 0xF3, 0xFE, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xFF, 0xEF,
  0xF0, 0x07, 0x07, 0xF3, 0xFD, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x13, 0xFC, 0x7F, 0xFE, 0x3F, 0xEE,
  0x3B, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xE3, 0xBF, 0xCF, 0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD,
  0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x07, 0x07, 0xF3, 0xFD, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0x60, 0xDC, 0x33, 0xFC, 0x7F, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0C, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x87, 0xFF, 0xFE, 0x3F, 0xCF,
  0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x43, 0xBF, 0xE7, 0xF0, 0xE1, 0xFC, 0x33, 0x8E, 0x73, 0x8E, 0xE1,
  0xD8, 0x3F, 0x07, 0xE0, 0xEE, 0x1C, 0xE3, 0x8E, 0x71, 0xCE, 0x1D, 0xC1,
  0xB8, 0x38, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0x61, 0xCC, 0x3B, 0xC7, 0x79,
  0xED, 0x3D, 0xB5, 0xB7, 0xB6, 0x76, 0xCC, 0xD8, 0x1B, 0x03, 0x60, 0x6C,
  0x0F, 0x81, 0xF0, 0x38, 0xE0, 0xF8, 0x3F, 0x0F, 0xE3, 0xD8, 0xF7, 0x3C,
  0xCF, 0x3B, 0xC6, 0xF1, 0xBC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x0C, 0x0C,
  0x07, 0xE1, 0xFE, 0x30, 0xEE, 0x0D, 0x81, 0xB0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x6E, 0x0C, 0xC3, 0x9F, 0xE1, 0xF8, 0xFE, 0x7F, 0xF0,
  0xF8, 0x3C, 0x1E, 0x0F, 0x0F, 0xFF, 0xFF, 0x78, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x0C, 0x07, 0xE1, 0xFE, 0x30, 0xEE, 0x0D, 0x81, 0xB0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x6E, 0x0C, 0xC3, 0x9F, 0xE1, 0xF8,
  0x0C, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0xFF, 0x1F, 0xF3, 0x86, 0x70, 0xEE,
  0x1D, 0xC3, 0xB8, 0xE7, 0xFC, 0xFE, 0x1C, 0xE3, 0x8C, 0x71, 0xCE, 0x19,
  0xC3, 0xB8, 0x38, 0x0E, 0x0F, 0xF7, 0xB9, 0x80, 0x60, 0x18, 0x07, 0x00,
  0xF8, 0x1F, 0x01, 0xE0, 0x1C, 0x03, 0x00, 0xD0, 0x7F, 0xF9, 0xFC, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x61, 0xDF, 0xE3,
  0xF0, 0xE0, 0x76, 0x07, 0x60, 0x67, 0x06, 0x30, 0xE3, 0x0E, 0x30, 0xC3,
  0x8C, 0x19, 0xC1, 0x98, 0x1D, 0x80, 0xD8, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x6C, 0x0D, 0x99, 0xB3, 0x36, 0x76, 0xDE,
  0xDB, 0x5B, 0x4F, 0x79, 0xEF, 0x1C, 0xC3, 0x98, 0x70, 0x70, 0x73, 0x0E,
  0x38, 0xC1, 0x9C, 0x1D, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xD8,
  0x19, 0xC3, 0x8C, 0x30, 0xE7, 0x06, 0xE0, 0x70, 0xE0, 0x77, 0x06, 0x70,
  0xE3, 0x0C, 0x38, 0xC1, 0x98, 0x1D, 0x80, 0xF0, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x7F, 0xDF, 0xF0, 0x18, 0x0E,
  0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xC0, 0x70, 0x38,
  0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0xFF, 0xF0, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF,
  0xFC, 0x0E, 0x03, 0xC0, 0x7C, 0x1D, 0x87, 0x38, 0xC3, 0xB8, 0x36, 0x07,
  0xFF, 0xFF, 0xFF, 0x47, 0x1C, 0x70, 0x7E, 0x0F, 0xE2, 0x38, 0x07, 0x01,
  0xCF, 0xF7, 0xFF, 0x87, 0xE1, 0xF8, 0x77, 0xFC, 0xFF, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0xE3, 0xFD, 0xCF, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x0F, 0xFE, 0xFE, 0x00, 0x0F, 0x8F, 0xF7, 0x8D, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0xFC, 0x7F, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC7, 0x77, 0xFD, 0xCF, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1,
  0xF8, 0x77, 0x1D, 0xFF, 0x3F, 0xC0, 0x0E, 0x0F, 0xE7, 0x3F, 0x83, 0xE0,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x07, 0xF8, 0x7F, 0x07, 0xE1, 0xFC,
  0x70, 0x8C, 0x01, 0x80, 0x30, 0x3F, 0xF7, 0xFE, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x0F, 0x0F, 0xF7,
  0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xDF, 0xF3, 0xFC, 0x07,
  0x01, 0xE0, 0xE7, 0xFB, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xE3,
  0xFD, 0xCE, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0x80, 0x18, 0x0F, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x3F, 0x07, 0xC0, 0x06,
  0x0E, 0x0E, 0x04, 0x00, 0x00, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x86, 0xFE, 0xFC, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x3B, 0x1C, 0xCE, 0x37, 0x0F, 0x03, 0xE0, 0xDC,
  0x33, 0x8C, 0x73, 0x0E, 0xC1, 0xC0, 0xFC, 0x3F, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0xC0, 0x3F, 0x07, 0xC0, 0x73, 0x9F, 0xFB, 0x33, 0x66, 0x6C, 0xCF, 0x99,
  0xF3, 0x3E, 0x67, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x70, 0x7C, 0x7F, 0xB9,
  0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x70, 0x1E,
  0x0F, 0xE7, 0x3B, 0x87, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xD8, 0x77,
  0xF8, 0xFC, 0x7C, 0x7F, 0xB1, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE1, 0xFF, 0xDF, 0xCC, 0x06, 0x03, 0x01, 0x80, 0x0F, 0x0F, 0xF7, 0x9F,
  0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xD8, 0x77, 0xFC, 0xFF, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x1F, 0x7F, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x80, 0x70,
  0x1F, 0x01, 0xF0, 0x0E, 0x01, 0xD0, 0x77, 0xFB, 0xFC, 0x18, 0x06, 0x01,
  0x80, 0x60, 0xFF, 0xFF, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x07, 0xF0, 0xFC, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xE3, 0xFF, 0xDF, 0xE0, 0xC0, 0xFC, 0x19, 0x87, 0x30, 0xC7, 0x18,
  0x67, 0x0C, 0xC1, 0xF8, 0x1E, 0x03, 0xC0, 0x30, 0x00, 0xE0, 0x36, 0x03,
  0x66, 0x36, 0x76, 0x67, 0x66, 0xF6, 0x6D, 0x66, 0x9E, 0x39, 0xE3, 0x8C,
  0x30, 0xC0, 0xE1, 0xCE, 0x30, 0xEC, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0xC1,
  0x9C, 0x71, 0x8C, 0x3B, 0x03, 0x80, 0xE0, 0xD8, 0x77, 0x1D, 0xC6, 0x31,
  0x8E, 0xE3, 0xB0, 0x6C, 0x1F, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x3E, 0x0F,
  0x00, 0xFF, 0x7F, 0x81, 0x81, 0xC1, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x7F,
  0xFF, 0xE0, 0x0F, 0x8F, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38,
  0x78, 0x38, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x07, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xC1, 0xE1, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x1F, 0x0F, 0x80, 0x7C, 0x7F, 0xFB, 0x1F,
  0x00, 0x80,
};

const GFXglyph UbuntuSansMono_Medium22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 7, 7, 12, 3, -17 },
  { 16, 11, 15, 12, 1, -15 },
  { 37, 10, 19, 12, 1, -17 },
  { 61, 12, 16, 12, 0, -16 },
  { 85, 11, 16, 12, 1, -16 },
  { 107, 2, 7, 12, 5, -17 },
  { 109, 7, 21, 12, 3, -17 },
  { 128, 7, 21, 12, 3, -17 },
  { 147, 10, 9, 12, 1, -15 },
  { 159, 10, 11, 12, 1, -12 },
  { 173, 6, 8, 12, 3, -4 },
  { 179, 6, 2, 12, 3, -7 },
  { 181, 4, 4, 12, 4, -4 },
  { 183, 10, 21, 12, 1, -17 },
  { 210, 10, 16, 12, 1, -16 },
  { 230, 9, 15, 12, 2, -15 },
  { 247, 10, 16, 12, 1, -16 },
  { 267, 10, 16, 12, 1, -16 },
  { 287, 11, 15, 12, 1, -15 },
  { 308, 10, 15, 12, 1, -15 },
  { 327, 10, 15, 12, 1, -15 },
  { 346, 10, 15, 12, 1, -15 },
  { 365, 10, 16, 12, 1, -16 },
  { 385, 10, 16, 12, 1, -16 },
  { 405, 4, 12, 12, 4, -12 },
  { 411, 5, 16, 12, 3, -12 },
  { 421, 10, 10, 12, 1, -11 },
  { 434, 10, 7, 12, 1, -10 },
  { 443, 10, 10, 12, 1, -11 },
  { 456, 8, 16, 12, 2, -16 },
  { 472, 11, 19, 12, 1, -16 },
  { 499, 12, 15, 12, 0, -15 },
  { 522, 10, 15, 12, 1, -15 },
  { 541, 10, 16, 12, 1, -16 },
  { 561, 10, 15, 12, 1, -15 },
  { 580, 9, 15, 12, 2, -15 },
  { 597, 9, 15, 12, 2, -15 },
  { 614, 10, 16, 12, 1, -16 },
  { 634, 10, 15, 12, 1, -15 },
  { 653, 9, 15, 12, 2, -15 },
  { 670, 10, 15, 12, 1, -15 },
  { 689, 11, 15, 12, 1, -15 },
  { 710, 9, 15, 12, 2, -15 },
  { 727, 11, 15, 12, 1, -15 },
  { 748, 10, 15, 12, 1, -15 },
  { 767, 11, 16, 12, 1, -16 },
  { 789, 9, 15, 12, 2, -15 },
  { 806, 11, 20, 12, 1, -16 },
  { 834, 11, 15, 12, 1, -15 },
  { 855, 10, 16, 12, 1, -16 },
  { 875, 10, 15, 12, 1, -15 },
  { 894, 10, 15, 12, 1, -15 },
  { 913, 12, 15, 12, 0, -15 },
  { 936, 11, 15, 12, 1, -15 },
  { 957, 12, 15, 12, 0, -15 },
  { 980, 12, 15, 12, 0, -15 },
  { 1003, 10, 15, 12, 1, -15 },
  { 1022, 7, 21, 12, 3, -17 },
  { 1041, 9, 21, 12, 2, -17 },
  { 1065, 6, 21, 12, 3, -17 },
  { 1081, 11, 8, 12, 1, -15 },
  { 1092, 12, 2, 12, 0, 2 },
  { 1095, 5, 4, 12, 4, -17 },
  { 1098, 10, 12, 12, 1, -12 },
  { 1113, 9, 17, 12, 2, -17 },
  { 1133, 10, 12, 12, 1, -12 },
  { 1148, 10, 17, 12, 1, -17 },
  { 1170, 10, 12, 12, 1, -12 },
  { 1185, 11, 17, 12, 1, -17 },
  { 1209, 10, 16, 12, 1, -12 },
  { 1229, 9, 17, 12, 2, -17 },
  { 1249, 10, 17, 12, 1, -17 },
  { 1271, 8, 21, 12, 2, -17 },
  { 1292, 10, 17, 12, 2, -17 },
  { 1314, 10, 17, 12, 1, -17 },
  { 1336, 11, 12, 12, 1, -12 },
  { 1353, 9, 12, 12, 2, -12 },
  { 1367, 10, 12, 12, 1, -12 },
  { 1382, 9, 16, 12, 2, -12 },
  { 1400, 10, 16, 12, 1, -12 },
  { 1420, 9, 12, 12, 2, -12 },
  { 1434, 10, 12, 12, 1, -12 },
  { 1449, 10, 15, 12, 1, -15 },
  { 1468, 9, 11, 12, 2, -11 },
  { 1481, 11, 11, 12, 1, -11 },
  { 1497, 12, 11, 12, 0, -11 },
  { 1514, 11, 11, 12, 1, -11 },
  { 1530, 10, 15, 12, 1, -11 },
  { 1549, 9, 11, 12, 2, -11 },
  { 1562, 9, 21, 12, 2, -17 },
  { 1586, 2, 21, 12, 5, -17 },
  { 1592, 9, 21, 12, 2, -17 },
  { 1616, 11, 4, 12, 1, -8 },
};

const GFXfont UbuntuSansMono_Medium22pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium22pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUSANSMONO_MEDIUM22PT7B_H_
