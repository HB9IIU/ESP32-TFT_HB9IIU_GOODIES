#ifndef _UBUNTUSANSMONO_MEDIUM17PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium17pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x0B, 0xB0, 0xCE, 0x73, 0x9C, 0x80, 0x19, 0x0C,
  0x86, 0xDF, 0xFF, 0xF9, 0x90, 0xC9, 0xFF, 0xFF, 0x93, 0x19, 0x0C, 0x80,
  0x18, 0x18, 0x7E, 0xE2, 0xC0, 0xE0, 0x78, 0x3E, 0x06, 0x03, 0x87, 0xFE,
  0x7C, 0x18, 0x18, 0x70, 0xE8, 0xB4, 0xDA, 0x45, 0x63, 0xE0, 0x2C, 0x3F,
  0x34, 0x92, 0x59, 0xB8, 0x70, 0x78, 0x6C, 0xCC, 0xCC, 0x78, 0x70, 0x72,
  0xDA, 0x8E, 0x86, 0xCE, 0x7B, 0xFF, 0x80, 0x1C, 0xE3, 0x18, 0x43, 0x0C,
  0x30, 0xC3, 0x0C, 0x18, 0x60, 0xC1, 0xC2, 0xC1, 0x83, 0x0E, 0x18, 0x60,
  0x83, 0x0C, 0x21, 0x86, 0x30, 0xC6, 0x30, 0x18, 0x18, 0xD2, 0xFF, 0x18,
  0x2C, 0x66, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x67, 0x72,
  0xE8, 0xFF, 0xC0, 0x7F, 0x80, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x86, 0x0C,
  0x18, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0x3C, 0x7E, 0xC6, 0xC2, 0xC3,
  0xDB, 0xDB, 0xC3, 0xC3, 0xC6, 0x6E, 0x3C, 0x08, 0x38, 0xF8, 0x58, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x7F, 0x7F, 0x7C, 0xFE, 0x86, 0x06, 0x06,
  0x0C, 0x18, 0x38, 0x70, 0x60, 0xFF, 0xFF, 0x7D, 0xFC, 0x18, 0x30, 0xE7,
  0x8F, 0x83, 0x02, 0x0F, 0x3F, 0xE0, 0x06, 0x0E, 0x1E, 0x36, 0x66, 0x66,
  0xC6, 0x86, 0xFF, 0x06, 0x06, 0x06, 0x7E, 0xFD, 0x83, 0x06, 0x0F, 0x83,
  0x83, 0x02, 0x0F, 0x3F, 0xE0, 0x0E, 0x3E, 0x70, 0x60, 0xC0, 0xFE, 0xC6,
  0xC3, 0xC3, 0xC6, 0x66, 0x3C, 0xFF, 0xFF, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x30, 0x30, 0x3C, 0x7E, 0xC6, 0xC2, 0xE6, 0x7C, 0x7E,
  0xC6, 0xC3, 0xC3, 0xE6, 0x7C, 0x3C, 0x7E, 0xC6, 0xC2, 0xC3, 0xC3, 0x7F,
  0x16, 0x06, 0x0C, 0x78, 0x70, 0x7F, 0x80, 0x1F, 0xE0, 0x37, 0x70, 0x00,
  0x37, 0x73, 0xE4, 0x02, 0x0F, 0x3C, 0xF0, 0xE0, 0x78, 0x0F, 0x02, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x0F, 0x07, 0x3C, 0xF0,
  0xC0, 0xFB, 0xF0, 0xC3, 0x18, 0xC3, 0x18, 0x00, 0x87, 0x1C, 0x3C, 0x76,
  0xC3, 0xC3, 0x9F, 0x9B, 0xB3, 0xB3, 0xB3, 0x9B, 0xDF, 0xC0, 0x60, 0x3E,
  0x0C, 0x0C, 0x0E, 0x07, 0x82, 0xC3, 0x21, 0x98, 0x8C, 0xC6, 0x7F, 0x30,
  0xD0, 0x78, 0x30, 0xF8, 0xFE, 0xC6, 0xC6, 0xC6, 0xFC, 0xFE, 0xC3, 0xC3,
  0xC3, 0xFE, 0xFC, 0x1E, 0x7F, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xE0, 0x73, 0x3F, 0xF8, 0xFC, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC6, 0xFE, 0xF8, 0xFD, 0xFA, 0x04, 0x08, 0x1F, 0xBF, 0x40, 0x81, 0x03,
  0xFF, 0xF0, 0xFF, 0xF8, 0x20, 0x83, 0xFF, 0xE0, 0x82, 0x08, 0x20, 0x3E,
  0x7F, 0x60, 0xC0, 0xC0, 0xC0, 0xC3, 0xC3, 0xC3, 0xC3, 0x73, 0x3F, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF,
  0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x7E, 0xFC,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0x3F, 0xE0, 0xC3, 0xC6, 0xCC,
  0xDC, 0xD8, 0xF0, 0xF8, 0xDC, 0xCC, 0xC6, 0xC7, 0xC3, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xFF, 0xF0, 0xC6, 0xC6, 0xE6, 0xAF,
  0xAB, 0xBB, 0x9B, 0x9B, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xC3, 0xE3, 0xE3,
  0xF3, 0xD3, 0xDB, 0xCB, 0xCF, 0xC7, 0xC7, 0xC3, 0x3C, 0x7E, 0xC6, 0xC3,
  0xC3, 0x83, 0x83, 0xC3, 0xC3, 0xC6, 0x6E, 0x7C, 0xFC, 0xFE, 0xC7, 0xC3,
  0xC3, 0xC7, 0xFE, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xC6, 0xC3,
  0xC3, 0x83, 0x83, 0xC3, 0xC3, 0xC2, 0x66, 0x7C, 0x18, 0x1C, 0x07, 0xF8,
  0xFE, 0xC6, 0xC6, 0xC6, 0xC6, 0xFC, 0xEC, 0xCC, 0xC6, 0xC6, 0xC3, 0x3E,
  0x7E, 0xC0, 0xC0, 0xE0, 0x78, 0x1E, 0x06, 0x03, 0x03, 0xC6, 0xFC, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE6, 0x7C, 0xC1,
  0xB0, 0xD8, 0x6C, 0x36, 0x31, 0x18, 0xCC, 0x64, 0x16, 0x0F, 0x07, 0x01,
  0x80, 0x83, 0x83, 0x83, 0x83, 0x83, 0x9B, 0xBB, 0xAB, 0xAF, 0xE6, 0xC6,
  0xC6, 0x61, 0xB1, 0x8C, 0xC6, 0xC1, 0xE0, 0xE0, 0x70, 0x3C, 0x33, 0x19,
  0x98, 0xDC, 0x30, 0xC1, 0xB0, 0xD8, 0xC6, 0x63, 0x20, 0xF0, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0x06, 0x0C, 0x0C, 0x18, 0x30,
  0x30, 0x60, 0x60, 0xFF, 0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x1F, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30,
  0x30, 0x60, 0xC0, 0xC1, 0x83, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x7F, 0x18, 0x38, 0x3C, 0x6E, 0xE6, 0xC3, 0x82, 0xFF, 0x80,
  0x4E, 0x30, 0x7C, 0xDC, 0x18, 0x37, 0xF8, 0xF1, 0xF3, 0x7E, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC7, 0xEE, 0xFC, 0x3F,
  0x7E, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x7A, 0x3F, 0x06, 0x0C, 0x18, 0x37,
  0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xB7, 0xE0, 0x3C, 0x7E, 0xC3, 0xC3,
  0xFF, 0xC0, 0xC0, 0x76, 0x3E, 0x1F, 0x3B, 0x30, 0x30, 0xFE, 0xFE, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E, 0xFF, 0x1E, 0x3C, 0x78, 0xF1,
  0xBF, 0x16, 0x0F, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x0F, 0xDF, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x60, 0x30, 0x30, 0x30, 0x00, 0xF0, 0xF0, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x1B, 0x1F, 0x0C, 0x30, 0xC0, 0x7D, 0xF0, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x34, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xCE,
  0xDC, 0xF8, 0xF0, 0xD8, 0xCC, 0xC6, 0xC3, 0xF0, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1B, 0x1F, 0xFE, 0xFF, 0x9B, 0x9B,
  0x9B, 0x9B, 0x83, 0x83, 0x83, 0xFD, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC6, 0x3C, 0x7E, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xEE, 0x7C, 0xFC, 0xFE,
  0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xEE, 0xFC, 0xC0, 0xC0, 0xC0, 0x3E, 0xFF,
  0x1E, 0x3C, 0x78, 0xF1, 0xF7, 0x7E, 0x0C, 0x18, 0x30, 0xFF, 0xFB, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0x7E, 0xFF, 0x03, 0x03, 0xC1, 0xC1, 0xE3,
  0xFC, 0x10, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3B,
  0x1F, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xBF, 0x7E, 0xE1, 0xB0, 0xD8,
  0xC4, 0x63, 0x31, 0xB0, 0x78, 0x38, 0x0C, 0x00, 0xC0, 0xE0, 0xD3, 0x69,
  0xB5, 0xDA, 0xAD, 0xDC, 0xE6, 0x23, 0x00, 0x61, 0x99, 0x8D, 0x83, 0x80,
  0xC0, 0xF0, 0xDC, 0xC6, 0xE1, 0x80, 0xC3, 0xC2, 0x66, 0x66, 0x66, 0x34,
  0x3C, 0x1C, 0x18, 0x18, 0xB0, 0xE0, 0x7E, 0xFC, 0x30, 0xC3, 0x86, 0x18,
  0x3F, 0xFE, 0x1E, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x70, 0xF0, 0x60, 0xC1,
  0x83, 0x06, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x07, 0x0E, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x78, 0x20, 0xFB,
  0x9E, 0x04,
};

const GFXglyph UbuntuSansMono_Medium17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 3, -12 },
  { 6, 5, 5, 10, 2, -13 },
  { 10, 9, 12, 10, 0, -12 },
  { 24, 8, 15, 10, 1, -13 },
  { 39, 9, 12, 10, 0, -12 },
  { 53, 8, 12, 10, 1, -12 },
  { 65, 2, 5, 10, 4, -13 },
  { 67, 6, 16, 10, 2, -13 },
  { 79, 6, 16, 10, 2, -13 },
  { 91, 8, 7, 10, 1, -12 },
  { 98, 8, 8, 10, 1, -9 },
  { 106, 4, 6, 10, 3, -3 },
  { 109, 5, 2, 10, 2, -6 },
  { 111, 3, 3, 10, 3, -3 },
  { 113, 7, 16, 10, 1, -13 },
  { 127, 8, 12, 10, 1, -12 },
  { 139, 8, 12, 10, 1, -12 },
  { 151, 8, 12, 10, 1, -12 },
  { 163, 7, 12, 10, 1, -12 },
  { 174, 8, 12, 10, 1, -12 },
  { 186, 7, 12, 10, 1, -12 },
  { 197, 8, 12, 10, 1, -12 },
  { 209, 8, 12, 10, 1, -12 },
  { 221, 8, 12, 10, 1, -12 },
  { 233, 8, 12, 10, 1, -12 },
  { 245, 3, 9, 10, 3, -9 },
  { 249, 4, 12, 10, 2, -9 },
  { 255, 8, 8, 10, 1, -9 },
  { 263, 8, 6, 10, 1, -8 },
  { 269, 8, 8, 10, 1, -9 },
  { 277, 6, 12, 10, 2, -12 },
  { 286, 8, 15, 10, 1, -12 },
  { 301, 9, 12, 10, 0, -12 },
  { 315, 8, 12, 10, 1, -12 },
  { 327, 8, 12, 10, 1, -12 },
  { 339, 8, 12, 10, 1, -12 },
  { 351, 7, 12, 10, 2, -12 },
  { 362, 6, 12, 10, 2, -12 },
  { 371, 8, 12, 10, 1, -12 },
  { 383, 8, 12, 10, 1, -12 },
  { 395, 7, 12, 10, 1, -12 },
  { 406, 7, 12, 10, 1, -12 },
  { 417, 8, 12, 10, 1, -12 },
  { 429, 7, 12, 10, 2, -12 },
  { 440, 8, 12, 10, 1, -12 },
  { 452, 8, 12, 10, 1, -12 },
  { 464, 8, 12, 10, 1, -12 },
  { 476, 8, 12, 10, 1, -12 },
  { 488, 8, 15, 10, 1, -12 },
  { 503, 8, 12, 10, 1, -12 },
  { 515, 8, 12, 10, 1, -12 },
  { 527, 8, 12, 10, 1, -12 },
  { 539, 8, 12, 10, 1, -12 },
  { 551, 9, 12, 10, 0, -12 },
  { 565, 8, 12, 10, 1, -12 },
  { 577, 9, 12, 10, 0, -12 },
  { 591, 9, 12, 10, 0, -12 },
  { 605, 8, 12, 10, 1, -12 },
  { 617, 5, 16, 10, 2, -13 },
  { 627, 7, 16, 10, 1, -13 },
  { 641, 5, 16, 10, 2, -13 },
  { 651, 8, 7, 10, 1, -12 },
  { 658, 9, 1, 10, 0, 2 },
  { 660, 4, 3, 10, 3, -13 },
  { 662, 7, 9, 10, 1, -9 },
  { 670, 8, 13, 10, 1, -13 },
  { 683, 8, 9, 10, 1, -9 },
  { 692, 7, 13, 10, 1, -13 },
  { 704, 8, 9, 10, 1, -9 },
  { 713, 8, 13, 10, 1, -13 },
  { 726, 7, 12, 10, 1, -9 },
  { 737, 7, 13, 10, 1, -13 },
  { 749, 8, 13, 10, 1, -13 },
  { 762, 6, 16, 10, 1, -13 },
  { 774, 8, 13, 10, 1, -13 },
  { 787, 8, 13, 10, 1, -13 },
  { 800, 8, 9, 10, 1, -9 },
  { 809, 7, 9, 10, 1, -9 },
  { 817, 8, 9, 10, 1, -9 },
  { 826, 8, 12, 10, 1, -9 },
  { 838, 7, 12, 10, 1, -9 },
  { 849, 7, 9, 10, 2, -9 },
  { 857, 7, 9, 10, 1, -9 },
  { 865, 8, 12, 10, 1, -12 },
  { 877, 7, 9, 10, 1, -9 },
  { 885, 9, 9, 10, 0, -9 },
  { 896, 9, 9, 10, 0, -9 },
  { 907, 9, 9, 10, 0, -9 },
  { 918, 8, 12, 10, 1, -9 },
  { 930, 7, 9, 10, 1, -9 },
  { 938, 7, 16, 10, 1, -13 },
  { 952, 2, 16, 10, 4, -13 },
  { 956, 7, 16, 10, 1, -13 },
  { 970, 8, 4, 10, 1, -7 },
};

const GFXfont UbuntuSansMono_Medium17pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium17pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUSANSMONO_MEDIUM17PT7B_H_
