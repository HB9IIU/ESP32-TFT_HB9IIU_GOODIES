#ifndef _UBUNTUSANSMONO_MEDIUM39PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x01, 0xCF, 0xFF, 0xFF, 0xF7, 0x88, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0E, 0x60, 0xE6, 0x06, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x38, 0x38, 0x07, 0x87, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x1C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x83, 0xC0, 0x78, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0xFE, 0x07,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7C, 0x01, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x40, 0x07, 0xDE, 0x07, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x0F, 0x7F, 0x00,
  0xEF, 0x78, 0x1E, 0xE3, 0x83, 0xCE, 0x38, 0x38, 0xE3, 0x87, 0x8E, 0x38,
  0x70, 0xE3, 0x8E, 0x0E, 0x39, 0xE0, 0xE7, 0x9C, 0x0F, 0xF3, 0xC0, 0x7F,
  0x78, 0x03, 0xC7, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x78, 0x01, 0xCF, 0xE0,
  0x3D, 0xFE, 0x03, 0x9C, 0xF0, 0x71, 0xC7, 0x0F, 0x1C, 0x70, 0xE1, 0xC7,
  0x1E, 0x1C, 0x73, 0xC1, 0xC7, 0x38, 0x1C, 0x77, 0x81, 0xEF, 0x70, 0x0F,
  0xEE, 0x00, 0xFC, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03,
  0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0x7C, 0x18, 0x1F, 0xC1, 0xC3, 0xFE, 0x1C, 0x3D, 0xF1,
  0xC7, 0x8F, 0xBC, 0x78, 0x7F, 0xCF, 0x03, 0xF8, 0xF0, 0x3F, 0x8F, 0x01,
  0xF8, 0xF0, 0x0F, 0x87, 0x81, 0xF8, 0x7C, 0x3F, 0xC3, 0xFF, 0xFE, 0x3F,
  0xF9, 0xE0, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x00,
  0x20, 0x0E, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x06, 0x20, 0x01, 0x80, 0x1F,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x18, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x71, 0xE3, 0x9F, 0x33, 0xE7,
  0xED, 0xFB, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x3D,
  0xF0, 0x1F, 0x3E, 0x0F, 0xCF, 0xC1, 0xE1, 0xE0, 0x30, 0x60, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x04, 0x0F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC,
  0x7E, 0x0F, 0x07, 0x0F, 0xBF, 0x9F, 0x87, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x18, 0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x1F, 0x1F,
  0x03, 0xC7, 0x80, 0xF9, 0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x01, 0xFF, 0x00,
  0x3F, 0xC3, 0x0F, 0xF1, 0xE3, 0xFC, 0xF8, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F,
  0xF0, 0xC3, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0xF9, 0xF0, 0x3C, 0x3E, 0x3F, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x03, 0xF7, 0x80, 0xF3, 0xC0, 0x41,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7C, 0x3F, 0x1C, 0x07, 0xC2, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x03, 0xC0, 0x0F, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC3, 0x83, 0xF1, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x80, 0x1F, 0x70, 0x3F,
  0x3F, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7D, 0x00, 0x3E, 0xF0, 0x7E, 0x7F, 0xFF, 0x7F, 0xFF,
  0x1F, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x9F, 0x81, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xE7, 0xC0, 0xF8, 0xF8, 0x7C, 0x3F,
  0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9E, 0x03, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x01, 0xE7, 0xC0, 0xF9, 0xF8, 0x7C, 0x3F, 0xBE, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x3F, 0x1E, 0x03, 0xEF, 0x80,
  0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1E,
  0x7E, 0x1F, 0x9F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0x1F, 0x1F,
  0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x01, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x79, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0xF8, 0x00, 0x18, 0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x3F, 0x7F, 0xFF, 0xFB, 0xF7, 0xC0, 0x06, 0x07,
  0xE1, 0xF8, 0xFE, 0x3F, 0x87, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x7E, 0x1F, 0x8F, 0xE3, 0xFC, 0x7E, 0x1F,
  0x81, 0xE0, 0x78, 0x3C, 0xFE, 0x1F, 0x07, 0x00, 0x00, 0x01, 0x80, 0x01,
  0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x81, 0xFF,
  0x8F, 0xFF, 0xBF, 0xFE, 0xE0, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x3C,
  0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x78, 0x00, 0xEF, 0x03, 0xFD,
  0xE1, 0xFF, 0xB8, 0x7F, 0xF7, 0x0F, 0xFF, 0xE3, 0xE1, 0xFC, 0x78, 0x3F,
  0x8F, 0x07, 0xF1, 0xE0, 0xFE, 0x3C, 0x1F, 0xC7, 0x83, 0xF8, 0xF0, 0x77,
  0x1E, 0x0E, 0xE3, 0xE1, 0xDE, 0x3E, 0x3B, 0xC7, 0xFF, 0x78, 0x7F, 0xE7,
  0x87, 0xFC, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xFE, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xEF,
  0x00, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x03, 0xE0, 0x78, 0x1E, 0x03, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xC0, 0x1F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1F,
  0x78, 0x00, 0xFB, 0xC0, 0x07, 0xFE, 0x00, 0x1E, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xE3, 0xFC, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xCF, 0x83, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFB,
  0xF3, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x38, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0x83, 0x8F, 0x80, 0x27, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x01, 0x3F, 0xC3, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0x70, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xE7, 0xF8,
  0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x83, 0xF3, 0xF7, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x7F, 0xFF, 0x1F, 0x83, 0x8F, 0x80, 0x27, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x3C,
  0xF8, 0x0F, 0x3F, 0x87, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00,
  0x20, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x79, 0x80, 0x7C, 0xF0, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0x20, 0x00, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x3E,
  0x1F, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xDF, 0x80, 0xF9,
  0xF8, 0x1F, 0x1F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xF1, 0xF0,
  0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xE0,
  0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xF0, 0xFC, 0x7F,
  0x0F, 0xC7, 0xF0, 0xFE, 0x7B, 0x9D, 0xE7, 0xB9, 0xDE, 0x73, 0x9D, 0xE7,
  0x3F, 0x9E, 0x71, 0xF9, 0xE7, 0x1F, 0x9E, 0x71, 0xF1, 0xE7, 0x0F, 0x1E,
  0x70, 0xF1, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xF7, 0x83,
  0xFD, 0xE0, 0xFF, 0x3C, 0x3F, 0xC7, 0x0F, 0xF1, 0xE3, 0xFC, 0x38, 0xFF,
  0x0F, 0x3F, 0xC1, 0xCF, 0xF0, 0x7B, 0xFC, 0x1E, 0xFF, 0x03, 0xBF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0x7C, 0x7C, 0x03, 0xC7, 0xC0,
  0x3E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0x1F, 0xEF, 0x01, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0x87, 0xFB,
  0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0x7C, 0x7C, 0x03, 0xC7, 0xC0, 0x3E,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7E, 0x7F, 0x8F, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x01,
  0xE7, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0x83, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xE1, 0xF0, 0x1E,
  0x3E, 0x03, 0xE7, 0xC0, 0x3C, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xFC, 0x7E, 0x07,
  0x1F, 0x00, 0x47, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7D, 0x00, 0x3E, 0x78, 0x1F, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x00, 0x1E,
  0x70, 0xF1, 0xE7, 0x0F, 0x1E, 0x71, 0xF1, 0xE7, 0x1F, 0x9E, 0x71, 0xF9,
  0xE7, 0x3B, 0x9E, 0x73, 0x9D, 0xE7, 0x39, 0xDE, 0x73, 0x9D, 0xE7, 0x70,
  0xFE, 0x77, 0x0F, 0xC7, 0x70, 0xFC, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0xF8, 0x01, 0xF7, 0xC0, 0x3E,
  0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F,
  0x00, 0xF9, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x1F, 0x01, 0xF0, 0xF8, 0x1E, 0x0F, 0x83,
  0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xF0, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1F,
  0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F,
  0x81, 0xE0, 0x78, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80,
  0x1F, 0x10, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x20, 0x70, 0xF8, 0x7C, 0x3E, 0x0F, 0x06, 0x0F, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE2, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBF, 0x03,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x79, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE1,
  0xFB, 0xC0, 0x7D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xBE, 0x3F, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0x80, 0x00,
  0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x00, 0x9F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xE7, 0xC7, 0xFF, 0xE7, 0xFF,
  0xF7, 0xFF, 0xFB, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0xDF, 0xE3, 0xE7, 0xFF, 0xF1, 0xFF,
  0xF8, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7E, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xF3, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFD,
  0xF0, 0x7C, 0x02, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7,
  0xE0, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1E, 0xF8,
  0x1F, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFC, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x80, 0x3E, 0x7C, 0x7F, 0x3F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x03, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0xBC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x70, 0x03, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x40, 0x7D, 0xF7, 0xEF, 0xFF,
  0xBF, 0xFC, 0x7F, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x01, 0xFB, 0xC0, 0x7C, 0xF0, 0x3E, 0x3C, 0x1F, 0x0F,
  0x0F, 0x83, 0xC7, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0xF7, 0xC0, 0x3C, 0xF8, 0x0F, 0x1F, 0x03, 0xC3, 0xE0, 0xF0, 0x7C,
  0x3C, 0x0F, 0x8F, 0x01, 0xF3, 0xC0, 0x7C, 0xF0, 0x0F, 0xBC, 0x01, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0xBC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x1E, 0x0E, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE3, 0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x1F,
  0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE1,
  0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x0F, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E,
  0x1F, 0x9E, 0x03, 0xEF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0x7C, 0x0F, 0x9F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07,
  0xF8, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0x03, 0xF7, 0x80, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0x7F, 0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0x7F,
  0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF,
  0xF7, 0xE0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0x7C, 0x0F, 0xBF, 0x9F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x03, 0xFD, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFC, 0x06, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xF8, 0x04, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xCF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0xF8, 0x01, 0xF7,
  0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x7C,
  0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF1, 0xF0, 0x0F, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xE7, 0x1F, 0x8E, 0x71, 0xF8, 0xE7, 0x1F, 0x9E,
  0x79, 0xF9, 0xE7, 0xBB, 0xDE, 0x7B, 0x9D, 0xC3, 0xB9, 0xDC, 0x3F, 0x1F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0x78, 0xFC, 0x03, 0xE3, 0xC0, 0x7C, 0x3E, 0x07, 0x81, 0xF0, 0xF8, 0x0F,
  0x9F, 0x00, 0x79, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xF9, 0xF0,
  0x0F, 0x0F, 0x01, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x78, 0x03,
  0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xEF, 0x80, 0x7C, 0xF0, 0x0F, 0x9F, 0x01,
  0xE3, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x07,
  0x81, 0xE1, 0xF0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x7C, 0xF0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x02, 0x3F, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0x0F, 0x00, 0xC3, 0xFC, 0x0F, 0x3F, 0xF1, 0xE7, 0xFF,
  0xFE, 0x78, 0xFF, 0xCF, 0x03, 0xFC, 0x30, 0x0F, 0x00,
};

const GFXglyph UbuntuSansMono_Medium39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 28, 22, 8, -27 },
  { 22, 12, 12, 22, 5, -30 },
  { 40, 20, 27, 22, 1, -27 },
  { 108, 18, 34, 22, 2, -30 },
  { 185, 20, 29, 22, 1, -28 },
  { 258, 20, 28, 22, 1, -28 },
  { 328, 4, 13, 22, 9, -30 },
  { 335, 12, 38, 22, 5, -31 },
  { 392, 13, 38, 22, 4, -31 },
  { 454, 18, 16, 22, 2, -27 },
  { 490, 18, 19, 22, 2, -21 },
  { 533, 9, 13, 22, 6, -7 },
  { 548, 10, 4, 22, 6, -13 },
  { 553, 7, 7, 22, 7, -7 },
  { 560, 16, 38, 22, 3, -31 },
  { 636, 18, 29, 22, 2, -28 },
  { 702, 17, 27, 22, 3, -27 },
  { 760, 18, 28, 22, 2, -28 },
  { 823, 17, 29, 22, 2, -28 },
  { 885, 20, 27, 22, 1, -27 },
  { 953, 17, 28, 22, 2, -27 },
  { 1013, 18, 28, 22, 2, -27 },
  { 1076, 17, 27, 22, 3, -27 },
  { 1134, 18, 29, 22, 2, -28 },
  { 1200, 18, 28, 22, 2, -28 },
  { 1263, 7, 21, 22, 7, -21 },
  { 1282, 10, 27, 22, 5, -21 },
  { 1316, 18, 18, 22, 2, -20 },
  { 1357, 18, 12, 22, 2, -17 },
  { 1384, 18, 18, 22, 2, -20 },
  { 1425, 14, 29, 22, 4, -28 },
  { 1476, 19, 34, 22, 1, -28 },
  { 1557, 21, 27, 22, 0, -27 },
  { 1628, 18, 27, 22, 2, -27 },
  { 1689, 18, 29, 22, 2, -28 },
  { 1755, 18, 27, 22, 2, -27 },
  { 1816, 17, 27, 22, 3, -27 },
  { 1874, 16, 27, 22, 3, -27 },
  { 1928, 18, 29, 22, 2, -28 },
  { 1994, 18, 27, 22, 2, -27 },
  { 2055, 16, 27, 22, 3, -27 },
  { 2109, 17, 28, 22, 2, -27 },
  { 2169, 19, 27, 22, 2, -27 },
  { 2234, 16, 27, 22, 4, -27 },
  { 2288, 20, 27, 22, 1, -27 },
  { 2356, 18, 27, 22, 2, -27 },
  { 2417, 20, 29, 22, 1, -28 },
  { 2490, 17, 27, 22, 3, -27 },
  { 2548, 20, 35, 22, 1, -28 },
  { 2636, 19, 27, 22, 2, -27 },
  { 2701, 18, 29, 22, 2, -28 },
  { 2767, 19, 27, 22, 1, -27 },
  { 2832, 18, 28, 22, 2, -27 },
  { 2895, 20, 27, 22, 1, -27 },
  { 2963, 20, 27, 22, 1, -27 },
  { 3031, 20, 27, 22, 1, -27 },
  { 3099, 20, 27, 22, 1, -27 },
  { 3167, 18, 27, 22, 2, -27 },
  { 3228, 11, 38, 22, 6, -31 },
  { 3281, 16, 38, 22, 3, -31 },
  { 3357, 11, 38, 22, 5, -31 },
  { 3410, 20, 15, 22, 1, -27 },
  { 3448, 21, 4, 22, 0, 3 },
  { 3459, 8, 7, 22, 7, -30 },
  { 3466, 17, 21, 22, 2, -21 },
  { 3511, 17, 30, 22, 3, -30 },
  { 3575, 18, 21, 22, 2, -21 },
  { 3623, 17, 30, 22, 2, -30 },
  { 3687, 18, 21, 22, 2, -21 },
  { 3735, 19, 30, 22, 2, -30 },
  { 3807, 17, 28, 22, 2, -21 },
  { 3867, 16, 30, 22, 3, -30 },
  { 3927, 18, 30, 22, 2, -30 },
  { 3995, 14, 37, 22, 3, -30 },
  { 4060, 18, 30, 22, 3, -30 },
  { 4128, 18, 30, 22, 2, -30 },
  { 4196, 18, 21, 22, 2, -21 },
  { 4244, 16, 21, 22, 3, -21 },
  { 4286, 18, 22, 22, 2, -21 },
  { 4336, 17, 28, 22, 3, -21 },
  { 4396, 17, 28, 22, 2, -21 },
  { 4456, 16, 21, 22, 4, -21 },
  { 4498, 16, 21, 22, 3, -21 },
  { 4540, 18, 27, 22, 2, -27 },
  { 4601, 16, 20, 22, 3, -20 },
  { 4641, 20, 20, 22, 1, -20 },
  { 4691, 20, 20, 22, 1, -20 },
  { 4741, 20, 20, 22, 1, -20 },
  { 4791, 19, 27, 22, 1, -20 },
  { 4856, 16, 20, 22, 3, -20 },
  { 4896, 16, 38, 22, 3, -31 },
  { 4972, 4, 38, 22, 9, -31 },
  { 4991, 16, 38, 22, 3, -31 },
  { 5067, 20, 7, 22, 1, -15 },
};

const GFXfont UbuntuSansMono_Medium39pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium39pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium39pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUSANSMONO_MEDIUM39PT7B_H_
