#ifndef _UBUNTUSANSMONO_MEDIUM9PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x37, 0xD5, 0xF5, 0x30, 0x23, 0x90, 0xC1, 0x07,
  0xC4, 0xCE, 0x98, 0x75, 0xCC, 0x72, 0x99, 0x69, 0x34, 0xE0, 0x2A, 0x49,
  0x12, 0x20, 0x88, 0x92, 0x5A, 0x80, 0x4F, 0xAA, 0x21, 0x3E, 0x42, 0x00,
  0x4F, 0x00, 0xE0, 0xC0, 0x24, 0xA4, 0xA4, 0x80, 0x72, 0xAB, 0x15, 0x38,
  0x4C, 0x44, 0x4F, 0xE2, 0x24, 0x8F, 0xE5, 0x93, 0xC0, 0x31, 0x95, 0x27,
  0x88, 0xF3, 0x93, 0xC0, 0x68, 0xEA, 0xBE, 0xF2, 0x44, 0x4C, 0x72, 0x9C,
  0xA8, 0xB8, 0x74, 0x92, 0x61, 0x30, 0xD8, 0x51, 0x70, 0x09, 0xB0, 0x60,
  0x80, 0xF8, 0x3E, 0x83, 0x06, 0xC8, 0x00, 0xE5, 0x20, 0x80, 0x74, 0x6F,
  0x5A, 0xA9, 0xE0, 0x22, 0x94, 0xAA, 0xC4, 0xEA, 0xEA, 0x9E, 0x7A, 0x21,
  0x04, 0x3C, 0xEB, 0x99, 0xAE, 0xE8, 0xE8, 0x8F, 0xF3, 0xC9, 0x00, 0x7A,
  0x21, 0x14, 0xBC, 0x8C, 0x7F, 0x18, 0xC4, 0xE9, 0x25, 0xC0, 0x71, 0x11,
  0x1F, 0xBE, 0xCC, 0xA9, 0x88, 0x88, 0x8F, 0x52, 0xEB, 0x58, 0xC4, 0x99,
  0xDD, 0xBB, 0x74, 0x63, 0x1C, 0xB8, 0xE9, 0xBE, 0x88, 0x74, 0x63, 0x1C,
  0xB8, 0x83, 0xEA, 0xAC, 0xAB, 0x72, 0x18, 0x20, 0xF8, 0xF9, 0x08, 0x42,
  0x10, 0x8C, 0x63, 0x14, 0xB8, 0x8A, 0x54, 0xA5, 0x10, 0x8C, 0x6B, 0x55,
  0x28, 0xDA, 0x88, 0xA5, 0x44, 0x8A, 0x94, 0x42, 0x10, 0xF2, 0x44, 0x8F,
  0xF2, 0x49, 0x24, 0xE0, 0x92, 0x24, 0x89, 0x20, 0xE4, 0x92, 0x49, 0xE0,
  0x22, 0xB6, 0xF8, 0xB0, 0xE7, 0xDE, 0x88, 0xEB, 0x99, 0xE0, 0x3A, 0x30,
  0x87, 0x80, 0x11, 0x75, 0x9D, 0x70, 0x72, 0xBF, 0x87, 0x00, 0x74, 0xE4,
  0x44, 0x40, 0x75, 0x95, 0x71, 0x60, 0x93, 0xDB, 0x68, 0x61, 0x38, 0x42,
  0x10, 0xE0, 0x67, 0x92, 0x4D, 0xC0, 0x88, 0xBE, 0xCA, 0xB0, 0xE1, 0x08,
  0x42, 0x10, 0xE0, 0xF5, 0x6B, 0x18, 0x80, 0xF6, 0xDA, 0x72, 0xA3, 0x97,
  0x00, 0xEA, 0x99, 0xE8, 0x80, 0x75, 0x9D, 0x71, 0x10, 0xF8, 0x88, 0x80,
  0xF3, 0x1E, 0x4F, 0x44, 0x47, 0xB6, 0xDE, 0x8A, 0x94, 0xA2, 0x00, 0x8D,
  0x6B, 0xA5, 0x00, 0xCA, 0x88, 0xAD, 0x80, 0xCA, 0x94, 0x62, 0x13, 0x00,
  0xE5, 0x4E, 0x69, 0x28, 0x92, 0x60, 0xFF, 0x80, 0xC9, 0x22, 0x92, 0xC0,
  0xF8,
};

const GFXglyph UbuntuSansMono_Medium9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 5, 6, 5, 0, -6 },
  { 17, 5, 6, 5, 0, -6 },
  { 21, 1, 3, 5, 2, -7 },
  { 22, 3, 9, 5, 1, -7 },
  { 26, 3, 9, 5, 1, -7 },
  { 30, 4, 4, 5, 1, -6 },
  { 32, 5, 5, 5, 0, -5 },
  { 36, 3, 3, 5, 1, -2 },
  { 38, 3, 1, 5, 1, -3 },
  { 39, 1, 2, 5, 2, -2 },
  { 40, 3, 9, 5, 1, -7 },
  { 44, 5, 6, 5, 0, -6 },
  { 48, 4, 6, 5, 1, -6 },
  { 51, 4, 6, 5, 1, -6 },
  { 54, 3, 6, 5, 1, -6 },
  { 57, 5, 6, 5, 0, -6 },
  { 61, 3, 6, 5, 1, -6 },
  { 64, 4, 6, 5, 1, -6 },
  { 67, 4, 6, 5, 1, -6 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 5, 6, 5, 0, -6 },
  { 78, 1, 5, 5, 2, -5 },
  { 79, 2, 6, 5, 1, -5 },
  { 81, 5, 5, 5, 0, -5 },
  { 85, 5, 3, 5, 0, -4 },
  { 87, 5, 5, 5, 0, -5 },
  { 91, 3, 6, 5, 1, -6 },
  { 94, 5, 7, 5, 0, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 4, 6, 5, 1, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 4, 6, 5, 1, -6 },
  { 113, 4, 6, 5, 1, -6 },
  { 116, 3, 6, 5, 1, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 3, 6, 5, 1, -6 },
  { 130, 4, 6, 5, 0, -6 },
  { 133, 4, 6, 5, 1, -6 },
  { 136, 4, 6, 5, 1, -6 },
  { 139, 5, 6, 5, 0, -6 },
  { 143, 4, 6, 5, 1, -6 },
  { 146, 5, 6, 5, 0, -6 },
  { 150, 4, 6, 5, 1, -6 },
  { 153, 5, 8, 5, 0, -6 },
  { 158, 4, 6, 5, 1, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 5, 6, 5, 0, -6 },
  { 185, 5, 6, 5, 0, -6 },
  { 189, 4, 6, 5, 1, -6 },
  { 192, 3, 9, 5, 1, -7 },
  { 196, 3, 9, 5, 1, -7 },
  { 200, 3, 9, 5, 1, -7 },
  { 204, 5, 3, 5, 0, -6 },
  { 206, 5, 1, 5, 0, 1 },
  { 207, 2, 2, 5, 2, -7 },
  { 208, 3, 5, 5, 1, -5 },
  { 210, 4, 7, 5, 1, -7 },
  { 214, 5, 5, 5, 0, -5 },
  { 218, 4, 7, 5, 0, -7 },
  { 222, 5, 5, 5, 0, -5 },
  { 226, 4, 7, 5, 1, -7 },
  { 230, 4, 7, 5, 0, -5 },
  { 234, 3, 7, 5, 1, -7 },
  { 237, 5, 7, 5, 0, -7 },
  { 242, 3, 9, 5, 1, -7 },
  { 246, 4, 7, 5, 1, -7 },
  { 250, 5, 7, 5, 0, -7 },
  { 255, 5, 5, 5, 0, -5 },
  { 259, 3, 5, 5, 1, -5 },
  { 261, 5, 5, 5, 0, -5 },
  { 265, 4, 7, 5, 1, -5 },
  { 269, 4, 7, 5, 0, -5 },
  { 273, 4, 5, 5, 1, -5 },
  { 276, 3, 5, 5, 1, -5 },
  { 278, 4, 6, 5, 1, -6 },
  { 281, 3, 5, 5, 1, -5 },
  { 283, 5, 5, 5, 0, -5 },
  { 287, 5, 5, 5, 0, -5 },
  { 291, 5, 5, 5, 0, -5 },
  { 295, 5, 7, 5, 0, -5 },
  { 300, 3, 5, 5, 1, -5 },
  { 302, 3, 9, 5, 1, -7 },
  { 306, 1, 9, 5, 2, -7 },
  { 308, 3, 9, 5, 1, -7 },
  { 312, 5, 1, 5, 0, -3 },
};

const GFXfont UbuntuSansMono_Medium9pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium9pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UBUNTUSANSMONO_MEDIUM9PT7B_H_
