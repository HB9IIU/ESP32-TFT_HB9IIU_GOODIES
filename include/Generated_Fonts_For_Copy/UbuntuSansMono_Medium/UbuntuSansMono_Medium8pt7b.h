#ifndef _UBUNTUSANSMONO_MEDIUM8PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x55, 0xF6, 0xFA, 0x25, 0x43, 0x1F, 0x20, 0x5D, 0xE3,
  0x7B, 0x66, 0x67, 0xB7, 0xC0, 0x72, 0x49, 0x11, 0x89, 0x12, 0xB4, 0x27,
  0xA5, 0x2F, 0x22, 0x70, 0xC0, 0x80, 0x29, 0x29, 0x20, 0x65, 0x9B, 0x97,
  0x59, 0x25, 0xC0, 0x69, 0x12, 0x47, 0x61, 0x17, 0x1F, 0x13, 0x59, 0xF1,
  0x74, 0x43, 0x1F, 0x16, 0x69, 0x97, 0xE5, 0x25, 0x00, 0x65, 0x57, 0x97,
  0x69, 0x97, 0x16, 0x90, 0x41, 0xC0, 0x3C, 0x61, 0xF0, 0xF0, 0xC3, 0x68,
  0xC5, 0x21, 0x80, 0x25, 0xBB, 0xBB, 0x70, 0x26, 0x55, 0xF9, 0x69, 0x9F,
  0x9F, 0x34, 0x88, 0x87, 0x69, 0x99, 0x9E, 0xF2, 0x79, 0xC0, 0xF2, 0x79,
  0x00, 0x34, 0x89, 0x97, 0x99, 0x9F, 0x99, 0xE9, 0x25, 0xC0, 0x71, 0x11,
  0x1E, 0x9B, 0xAE, 0xB9, 0x92, 0x49, 0xC0, 0x55, 0xFB, 0x99, 0x9D, 0xDB,
  0x99, 0x65, 0x99, 0x97, 0xD6, 0xF9, 0x00, 0x65, 0x99, 0x97, 0x21, 0x69,
  0x9E, 0x99, 0x74, 0x43, 0x1F, 0xF2, 0x22, 0x22, 0x99, 0x99, 0x97, 0x99,
  0x55, 0x62, 0x99, 0xBB, 0xD5, 0x95, 0x66, 0x59, 0x95, 0x52, 0x22, 0x71,
  0x24, 0x4F, 0xEA, 0xAC, 0x92, 0x24, 0x88, 0xD5, 0x5C, 0x26, 0x59, 0xF0,
  0xC0, 0x77, 0x97, 0x93, 0xDB, 0xC0, 0x78, 0x87, 0x11, 0x79, 0x97, 0x7F,
  0x87, 0x34, 0xF4, 0x44, 0x79, 0x97, 0x96, 0x93, 0xDB, 0x40, 0x60, 0xC2,
  0x23, 0x43, 0x92, 0x74, 0x92, 0xED, 0x40, 0xC2, 0x22, 0x23, 0xFB, 0x99,
  0xF6, 0xD0, 0x79, 0x97, 0xF6, 0xF8, 0x79, 0x97, 0x10, 0xF2, 0x40, 0xF8,
  0xF0, 0x4F, 0x44, 0x30, 0xB6, 0xF0, 0x95, 0x62, 0x9B, 0xF5, 0xD2, 0x69,
  0xD5, 0x62, 0x2C, 0xEA, 0x70, 0x69, 0x44, 0x98, 0xFE, 0xC9, 0x14, 0xB0,
  0xF0,
};

const GFXglyph UbuntuSansMono_Medium8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 6, 4, 2, -6 },
  { 2, 2, 2, 4, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 6, 4, 0, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 4, 2, -6 },
  { 17, 3, 8, 4, 1, -6 },
  { 20, 3, 8, 4, 1, -6 },
  { 23, 4, 4, 4, 0, -6 },
  { 25, 4, 4, 4, 0, -4 },
  { 27, 2, 2, 4, 1, -1 },
  { 28, 2, 1, 4, 1, -3 },
  { 29, 1, 1, 4, 2, -1 },
  { 30, 3, 7, 4, 1, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 3, 6, 4, 1, -6 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 3, 6, 4, 1, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 1, 4, 4, 2, -4 },
  { 64, 2, 5, 4, 1, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 4, 3, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 3, 6, 4, 1, -6 },
  { 75, 4, 7, 4, 0, -6 },
  { 79, 4, 6, 4, 0, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 3, 6, 4, 1, -6 },
  { 94, 3, 6, 4, 1, -6 },
  { 97, 4, 6, 4, 0, -6 },
  { 100, 4, 6, 4, 0, -6 },
  { 103, 3, 6, 4, 1, -6 },
  { 106, 4, 6, 4, 0, -6 },
  { 109, 4, 6, 4, 0, -6 },
  { 112, 3, 6, 4, 1, -6 },
  { 115, 4, 6, 4, 0, -6 },
  { 118, 4, 6, 4, 0, -6 },
  { 121, 4, 6, 4, 0, -6 },
  { 124, 3, 6, 4, 1, -6 },
  { 127, 4, 8, 4, 0, -6 },
  { 131, 4, 6, 4, 0, -6 },
  { 134, 4, 6, 4, 0, -6 },
  { 137, 4, 6, 4, 0, -6 },
  { 140, 4, 6, 4, 0, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 4, 6, 4, 0, -6 },
  { 152, 4, 6, 4, 0, -6 },
  { 155, 4, 6, 4, 0, -6 },
  { 158, 2, 7, 4, 1, -6 },
  { 160, 3, 7, 4, 1, -6 },
  { 163, 2, 7, 4, 1, -6 },
  { 165, 4, 4, 4, 0, -6 },
  { 167, 4, 1, 4, 0, 1 },
  { 168, 2, 1, 4, 1, -6 },
  { 169, 4, 4, 4, 0, -4 },
  { 171, 3, 6, 4, 1, -6 },
  { 174, 4, 4, 4, 0, -4 },
  { 176, 4, 6, 4, 0, -6 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 4, 6, 4, 0, -6 },
  { 184, 4, 6, 4, 0, -4 },
  { 187, 3, 6, 4, 1, -6 },
  { 190, 4, 6, 4, 0, -6 },
  { 193, 3, 8, 4, 1, -6 },
  { 196, 3, 6, 4, 1, -6 },
  { 199, 4, 6, 4, 0, -6 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 3, 4, 4, 1, -4 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 3, 5, 4, 1, -4 },
  { 210, 4, 5, 4, 0, -4 },
  { 213, 3, 4, 4, 1, -4 },
  { 215, 3, 4, 4, 1, -4 },
  { 217, 4, 5, 4, 0, -5 },
  { 220, 3, 4, 4, 1, -4 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 4, 4, 4, 0, -4 },
  { 228, 4, 6, 4, 0, -4 },
  { 231, 3, 4, 4, 1, -4 },
  { 233, 3, 7, 4, 1, -6 },
  { 236, 1, 7, 4, 2, -6 },
  { 237, 3, 7, 4, 1, -6 },
  { 240, 4, 1, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_Medium8pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium8pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUSANSMONO_MEDIUM8PT7B_H_
