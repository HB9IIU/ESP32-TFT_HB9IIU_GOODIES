#ifndef _UBUNTUSANSMONO_MEDIUM48PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x08, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xE7, 0x01, 0xCE,
  0x03, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x0F, 0x00,
  0x1E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF,
  0xDF, 0xC3, 0xF0, 0x01, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF3, 0x00, 0x0F, 0xDF,
  0x81, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x07,
  0xDF, 0xF0, 0x03, 0xCF, 0x7C, 0x03, 0xCF, 0x1E, 0x03, 0xE7, 0x87, 0x01,
  0xE3, 0xC3, 0xC1, 0xE1, 0xC1, 0xE0, 0xF0, 0xE0, 0xF0, 0xF0, 0x78, 0x78,
  0xF0, 0x3C, 0x38, 0x78, 0x1E, 0x3C, 0x78, 0x0F, 0x1E, 0x7C, 0x03, 0xFF,
  0x3C, 0x01, 0xFF, 0x3C, 0x00, 0x7F, 0x3E, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3F, 0xC0, 0x0F, 0x9F, 0xF0,
  0x07, 0x9F, 0xF8, 0x07, 0x8F, 0x1E, 0x07, 0xCF, 0x0F, 0x03, 0xC7, 0x87,
  0x83, 0xC3, 0xC3, 0xC1, 0xE1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF1, 0xE0, 0x78,
  0x78, 0xF0, 0x1C, 0x3C, 0xF0, 0x0F, 0x3E, 0xF8, 0x07, 0xFE, 0x78, 0x01,
  0xFF, 0x78, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x3E, 0x07, 0xFC, 0x1F, 0x07, 0xFF, 0x0F, 0x87, 0xEF, 0xC7, 0xC3, 0xE7,
  0xE3, 0xC3, 0xE1, 0xF9, 0xE1, 0xF0, 0x7E, 0xF0, 0xF8, 0x1F, 0xF8, 0xF8,
  0x07, 0xF8, 0x7C, 0x01, 0xFC, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x07,
  0xC0, 0x3F, 0xC3, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7E,
  0x0F, 0xFE, 0x1F, 0x03, 0xFE, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0x39, 0xC0, 0x00, 0x08, 0x00, 0x38, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x38, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x04, 0x0F, 0x81, 0x3C, 0x7C, 0x39,
  0xF1, 0xC7, 0xDF, 0xEE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x80, 0x3F, 0x7E, 0x03,
  0xF1, 0xF8, 0x3F, 0x8F, 0xE0, 0xF8, 0x3E, 0x03, 0xC1, 0xE0, 0x04, 0x04,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFE, 0x03, 0xE0,
  0x3E, 0x07, 0xC1, 0xFC, 0xFF, 0x87, 0xF0, 0x7C, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xFC,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF,
  0x87, 0x0F, 0xBE, 0x1F, 0x1F, 0xFC, 0x3E, 0x3F, 0xF8, 0xFE, 0x7F, 0xF0,
  0xF8, 0xFF, 0xE1, 0xF1, 0xFF, 0xC1, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01,
  0xF9, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7E, 0x7E, 0x01, 0xC3, 0xF0, 0x08, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3E, 0x07, 0xF1, 0xC0, 0x0F,
  0xC4, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1C, 0x07, 0xF0, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x38, 0x07, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7,
  0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7D, 0x00, 0x07, 0xE7, 0x00, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xFF, 0x88, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x7E, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xBF, 0x00, 0xFD, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7E,
  0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0x1F, 0x83, 0xF8, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xCF, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3F, 0x7C, 0x00,
  0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x3F, 0x00, 0xF8,
  0xFE, 0x07, 0xC1, 0xFE, 0x3F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC3, 0xFC, 0x3E, 0x03, 0xF9, 0xF8, 0x03,
  0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xF3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7F, 0x03, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xDF, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x2F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x0C,
  0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF0, 0xFC,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x7F, 0x0F, 0xE3, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0x1F, 0xE0,
  0x78, 0x1F, 0x07, 0xC3, 0xF9, 0xFE, 0x3F, 0x87, 0xC0, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x40, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x1F, 0xF0, 0xFC,
  0x3F, 0xE1, 0xF0, 0x7F, 0xC3, 0xE0, 0xFF, 0x87, 0xC1, 0xFF, 0x1F, 0x03,
  0xFE, 0x3E, 0x07, 0xFC, 0x3C, 0x0F, 0xF8, 0x7C, 0x1F, 0xF0, 0xF8, 0x3F,
  0xF1, 0xF0, 0x7F, 0xE3, 0xF0, 0xFF, 0xC3, 0xF9, 0xF7, 0x87, 0xFF, 0xEF,
  0x07, 0xFF, 0xDF, 0x07, 0xFF, 0xBE, 0x01, 0xFC, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x80, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xCF, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x3E, 0x00, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xC0, 0x07, 0xC3, 0xE0,
  0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xE0, 0x3F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x1F,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3E, 0x01, 0xFC, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xBE, 0x00, 0x7E, 0xF8, 0x03, 0xFB, 0xE0, 0x7F, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC,
  0x03, 0x87, 0xE0, 0x01, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x43, 0xFE, 0x07, 0x83, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xE0, 0x7F, 0x8F, 0x80, 0x7F, 0x3E, 0x00, 0xFC, 0xF8,
  0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xFB, 0xE0, 0x07,
  0xEF, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x0F, 0xE3, 0xE1, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0x03, 0x07, 0xE0, 0x02, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xFC, 0x0F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE6, 0x00, 0x7E, 0x78, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0xFD,
  0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F,
  0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0,
  0xFC, 0x03, 0xE3, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0x7E,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xF7, 0xF0,
  0x03, 0xE7, 0xF0, 0x07, 0xC7, 0xF0, 0x0F, 0x87, 0xF0, 0x1F, 0x07, 0xF0,
  0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xE0, 0xF8, 0x0F, 0xE1, 0xF0, 0x0F, 0xC3,
  0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x1F, 0xBE,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0,
  0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7B, 0x83,
  0xBC, 0xF7, 0x8F, 0x79, 0xEF, 0x1E, 0xF3, 0xDE, 0x39, 0xE7, 0x9C, 0xF3,
  0xCF, 0x3D, 0xE7, 0xBE, 0x7B, 0xCF, 0x7C, 0x7F, 0x1F, 0xF8, 0xFE, 0x3F,
  0xF1, 0xFC, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07,
  0xFE, 0xF0, 0x3F, 0xF7, 0xC1, 0xFF, 0x9E, 0x0F, 0xFC, 0xF8, 0x7F, 0xE3,
  0xC3, 0xFF, 0x1F, 0x1F, 0xF8, 0x78, 0xFF, 0xC3, 0xE7, 0xFE, 0x0F, 0x3F,
  0xF0, 0x7D, 0xFF, 0x81, 0xEF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x00, 0x7C, 0x3F, 0x00,
  0x7E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xE0,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3,
  0xF0, 0x1F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F,
  0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F,
  0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF9, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0C, 0x07, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xE0, 0x3F, 0x8F, 0x80, 0x7F,
  0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xBE,
  0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x01,
  0xFC, 0xF8, 0x1F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xF8,
  0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x00, 0x71, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF4, 0x00, 0x1F, 0xBC, 0x03, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x3F, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x01,
  0xE3, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x3F, 0x0F, 0xFC,
  0x7F, 0x1F, 0xF8, 0xFE, 0x3F, 0xF1, 0xDC, 0x7B, 0xE7, 0xBC, 0xF7, 0xCF,
  0x79, 0xE7, 0x9C, 0x73, 0xCF, 0x78, 0xE7, 0x9E, 0xF1, 0xEF, 0x3D, 0xC3,
  0xDE, 0x7F, 0x83, 0xBC, 0xFF, 0x07, 0xF9, 0xFC, 0x0F, 0xF3, 0xF8, 0x0F,
  0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x1F,
  0x83, 0xE0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x07,
  0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x8F, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF0, 0x01,
  0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0xC0, 0x07, 0xE3,
  0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3E,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xE0, 0x0F,
  0xC7, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xF8, 0x00,
  0x3E, 0x70, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x1C, 0x0F,
  0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x1E, 0x03, 0x00, 0x00, 0xF0, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0xB0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x40,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFE,
  0x0F, 0xE7, 0xC0, 0x3F, 0xBE, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB,
  0xE0, 0x0F, 0xDF, 0x00, 0xFC, 0xF8, 0x1F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0x00, 0xC7, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x61, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0x60, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xC1, 0xF0, 0x3F, 0xEF, 0x87, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0x83, 0xFB, 0xF0, 0x07, 0xDF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xE0, 0x1F,
  0x3F, 0xC0, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x14, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xE7,
  0xC0, 0x7E, 0x00, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xC0,
  0x7D, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x3E, 0xFE,
  0x03, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x90, 0x01, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x70, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFC, 0x1F, 0xDF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x0C, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x30, 0x1F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFE, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xFB, 0xE0, 0x1F, 0xCF, 0x80, 0xFE,
  0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E,
  0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0x9F, 0x80, 0x3E, 0x3F, 0x00,
  0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0xF8,
  0x0F, 0xE3, 0xE0, 0x1F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xF8, 0x01,
  0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x1C,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x80, 0xFF, 0xCF, 0xE3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0x1F, 0x8F, 0xFE, 0x1F, 0x0F, 0xFC,
  0x3E, 0x1F, 0xF8, 0x7C, 0x1F, 0xF0, 0xF8, 0x3F, 0xE1, 0xF0, 0x7F, 0xC3,
  0xE0, 0xFF, 0x87, 0xC1, 0xFF, 0x0F, 0x83, 0xFE, 0x1F, 0x07, 0xFC, 0x3E,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x02, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0x3F, 0xBE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD,
  0xF0, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0x87, 0xF0, 0x7F, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7C, 0x0F, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0xF8,
  0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x7F, 0x7F, 0x07, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xDF, 0xF0, 0x3E, 0x08,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F,
  0xE0, 0x7D, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xFC, 0x01, 0xF7, 0xF0, 0x0F, 0x9F, 0xC3, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xF7, 0xC0, 0x08, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x03, 0xBF, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x00, 0x71,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF4, 0x00, 0x1F, 0x3C, 0x01, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF8, 0x38, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x2A, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0x7E, 0x01, 0xF7, 0xE0, 0x1F, 0x3F, 0x81, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x02, 0x00, 0xFC, 0x00,
  0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xE0,
  0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE7, 0xE0, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xF0, 0x79,
  0xE0, 0xF8, 0x3C, 0xF0, 0x7C, 0x1E, 0x78, 0x3E, 0x0F, 0x3C, 0x3F, 0x87,
  0x9E, 0x1F, 0xC7, 0xCF, 0x8F, 0xE3, 0xE7, 0xC7, 0xF1, 0xE1, 0xE7, 0xBC,
  0xF0, 0xF3, 0xDE, 0x78, 0x79, 0xCF, 0x3C, 0x3D, 0xE3, 0xDE, 0x1E, 0xF1,
  0xEF, 0x0F, 0x70, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x1F,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0x80, 0x07, 0xEF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x7E, 0x01,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0xF8, 0x00,
  0xFD, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xFC, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xEF, 0x80, 0x07,
  0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x07,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0x80, 0x38, 0xFF, 0xC0, 0x7B, 0xFF, 0xE1, 0xF7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xBC, 0x0F, 0xFF, 0x78, 0x07, 0xFC, 0x30, 0x07,
  0xE0,
};

const GFXglyph UbuntuSansMono_Medium48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 8, 34, 27, 9, -33 },
  { 35, 15, 14, 27, 6, -36 },
  { 62, 25, 33, 27, 1, -33 },
  { 166, 22, 42, 27, 2, -37 },
  { 282, 25, 35, 27, 1, -34 },
  { 392, 25, 34, 27, 1, -34 },
  { 499, 5, 15, 27, 11, -36 },
  { 509, 15, 47, 27, 6, -38 },
  { 598, 16, 47, 27, 5, -38 },
  { 692, 21, 20, 27, 3, -33 },
  { 745, 23, 24, 27, 2, -26 },
  { 814, 12, 16, 27, 7, -8 },
  { 838, 13, 5, 27, 7, -16 },
  { 847, 9, 9, 27, 9, -8 },
  { 858, 21, 47, 27, 3, -38 },
  { 982, 23, 35, 27, 2, -34 },
  { 1083, 21, 33, 27, 3, -33 },
  { 1170, 21, 34, 27, 3, -34 },
  { 1260, 21, 35, 27, 3, -34 },
  { 1352, 23, 33, 27, 2, -33 },
  { 1447, 21, 34, 27, 3, -33 },
  { 1537, 21, 35, 27, 3, -34 },
  { 1629, 21, 33, 27, 3, -33 },
  { 1716, 22, 35, 27, 2, -34 },
  { 1813, 21, 34, 27, 3, -34 },
  { 1903, 9, 26, 27, 9, -25 },
  { 1933, 11, 33, 27, 7, -25 },
  { 1979, 22, 22, 27, 3, -25 },
  { 2040, 23, 15, 27, 2, -22 },
  { 2084, 23, 22, 27, 2, -25 },
  { 2148, 19, 35, 27, 4, -34 },
  { 2232, 23, 41, 27, 2, -34 },
  { 2350, 26, 33, 27, 0, -33 },
  { 2458, 22, 34, 27, 3, -34 },
  { 2552, 23, 35, 27, 2, -34 },
  { 2653, 22, 34, 27, 3, -34 },
  { 2747, 21, 33, 27, 4, -33 },
  { 2834, 20, 33, 27, 4, -33 },
  { 2917, 23, 35, 27, 2, -34 },
  { 3018, 22, 33, 27, 2, -33 },
  { 3109, 19, 33, 27, 4, -33 },
  { 3188, 20, 34, 27, 3, -33 },
  { 3273, 23, 33, 27, 3, -33 },
  { 3368, 21, 33, 27, 4, -33 },
  { 3455, 23, 33, 27, 2, -33 },
  { 3550, 21, 33, 27, 3, -33 },
  { 3637, 24, 35, 27, 1, -34 },
  { 3742, 22, 34, 27, 3, -34 },
  { 3836, 24, 43, 27, 1, -34 },
  { 3965, 22, 34, 27, 3, -34 },
  { 4059, 21, 35, 27, 3, -34 },
  { 4151, 23, 33, 27, 2, -33 },
  { 4246, 22, 34, 27, 2, -33 },
  { 4340, 25, 33, 27, 1, -33 },
  { 4444, 23, 33, 27, 2, -33 },
  { 4539, 25, 33, 27, 1, -33 },
  { 4643, 25, 33, 27, 1, -33 },
  { 4747, 21, 33, 27, 3, -33 },
  { 4834, 14, 47, 27, 7, -38 },
  { 4917, 21, 47, 27, 3, -38 },
  { 5041, 14, 47, 27, 6, -38 },
  { 5124, 23, 18, 27, 2, -33 },
  { 5176, 26, 5, 27, 0, 4 },
  { 5193, 10, 9, 27, 9, -37 },
  { 5205, 20, 27, 27, 3, -26 },
  { 5273, 21, 38, 27, 4, -37 },
  { 5373, 22, 27, 27, 3, -26 },
  { 5448, 21, 38, 27, 2, -37 },
  { 5548, 23, 27, 27, 2, -26 },
  { 5626, 23, 37, 27, 3, -37 },
  { 5733, 21, 35, 27, 2, -26 },
  { 5825, 19, 37, 27, 4, -37 },
  { 5913, 23, 38, 27, 2, -37 },
  { 6023, 18, 46, 27, 3, -37 },
  { 6127, 22, 37, 27, 4, -37 },
  { 6229, 23, 38, 27, 2, -37 },
  { 6339, 23, 26, 27, 2, -26 },
  { 6414, 19, 26, 27, 4, -26 },
  { 6476, 23, 27, 27, 2, -26 },
  { 6554, 21, 35, 27, 4, -26 },
  { 6646, 21, 35, 27, 2, -26 },
  { 6738, 19, 26, 27, 5, -26 },
  { 6800, 21, 27, 27, 3, -26 },
  { 6871, 22, 34, 27, 3, -33 },
  { 6965, 20, 26, 27, 3, -25 },
  { 7030, 25, 25, 27, 1, -25 },
  { 7109, 25, 25, 27, 1, -25 },
  { 7188, 25, 25, 27, 1, -25 },
  { 7267, 23, 34, 27, 2, -25 },
  { 7365, 19, 25, 27, 4, -25 },
  { 7425, 19, 47, 27, 4, -38 },
  { 7537, 5, 47, 27, 11, -38 },
  { 7567, 19, 47, 27, 4, -38 },
  { 7679, 23, 9, 27, 2, -19 },
};

const GFXfont UbuntuSansMono_Medium48pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium48pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium48pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _UBUNTUSANSMONO_MEDIUM48PT7B_H_
