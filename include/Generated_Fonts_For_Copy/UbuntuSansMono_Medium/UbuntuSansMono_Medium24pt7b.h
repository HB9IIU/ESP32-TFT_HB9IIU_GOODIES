#ifndef _UBUNTUSANSMONO_MEDIUM24PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium24pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x60, 0x04, 0xFF, 0xE0, 0xE7, 0xCF,
  0x9F, 0x3C, 0x78, 0xD1, 0x80, 0x0C, 0x61, 0xCE, 0x1C, 0xE1, 0x8C, 0x18,
  0xCF, 0xFF, 0xFF, 0xF3, 0x9C, 0x31, 0x83, 0x18, 0x31, 0x8F, 0xFF, 0xFF,
  0xF6, 0x30, 0x63, 0x06, 0x30, 0xE7, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x0F,
  0xF3, 0xFC, 0xF1, 0x9C, 0x03, 0x00, 0x70, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x1E, 0x01, 0xC0, 0x3A, 0x07, 0x7F, 0xFF, 0xF8, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x38, 0x1B, 0xE1, 0x93, 0x0D, 0x98, 0xCC, 0xCC, 0x66, 0x61,
  0xB6, 0x0F, 0x70, 0x03, 0x00, 0x37, 0x83, 0xBE, 0x1B, 0x31, 0x99, 0x8C,
  0xCC, 0xC6, 0x6C, 0x3B, 0xE0, 0xF0, 0x1E, 0x03, 0xF0, 0x73, 0x86, 0x18,
  0x63, 0x87, 0x30, 0x77, 0x03, 0xE0, 0x3C, 0x67, 0xE6, 0xEE, 0xEC, 0x7C,
  0xC3, 0xCC, 0x1C, 0xE3, 0xE7, 0xFE, 0x3E, 0x70, 0xFF, 0xF6, 0xD8, 0x02,
  0x0F, 0x1E, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x1C, 0x0F, 0x06, 0x02, 0x40,
  0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07,
  0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x78, 0xF0, 0xE0, 0x40, 0x0E,
  0x01, 0xC0, 0x18, 0x33, 0x77, 0xDF, 0xFF, 0x83, 0xC0, 0xDC, 0x3B, 0xC7,
  0x30, 0x44, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF,
  0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x3B, 0xDE, 0xF1, 0x9B,
  0xD8, 0xFF, 0xFC, 0xEF, 0xFE, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x00, 0x1F, 0x07,
  0xF1, 0xEF, 0x38, 0x76, 0x0F, 0xC1, 0xF8, 0x1F, 0x73, 0xEE, 0x7C, 0xCF,
  0x81, 0xF0, 0x36, 0x0E, 0xE1, 0xDC, 0x71, 0xFE, 0x1F, 0x80, 0x06, 0x03,
  0x83, 0xE3, 0xF8, 0xFE, 0x33, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE1, 0xFF, 0x7F, 0xC0, 0x1F, 0x0F, 0xF3, 0xCF,
  0x20, 0xE0, 0x0C, 0x01, 0x80, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0x0F, 0xF1, 0xCF,
  0x00, 0xE0, 0x0C, 0x03, 0x80, 0x70, 0xFC, 0x1F, 0x80, 0x78, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xD0, 0x73, 0xFE, 0xFF, 0x80, 0x01, 0xC0, 0x3C, 0x07,
  0xC0, 0xFC, 0x0D, 0xC1, 0xDC, 0x39, 0xC3, 0x1C, 0x71, 0xC6, 0x1C, 0xE1,
  0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xC7,
  0xF8, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xF8, 0x3F, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xD0, 0x73, 0xFE, 0xFF, 0x80, 0x00, 0xC0,
  0xF8, 0x7F, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0xFC, 0xFF, 0xDC, 0x1F,
  0x83, 0xF0, 0x76, 0x0E, 0xE1, 0xDC, 0x79, 0xFE, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x1F, 0x07, 0xF9, 0xC7,
  0x30, 0x76, 0x0E, 0xC1, 0xDC, 0x31, 0xFE, 0x1F, 0x87, 0xF9, 0xC7, 0xF0,
  0x7E, 0x07, 0xC0, 0xDC, 0x3B, 0xFE, 0x3F, 0x80, 0x1F, 0x07, 0xF1, 0xE7,
  0x30, 0x7E, 0x0F, 0xC1, 0xF8, 0x3B, 0x87, 0x7F, 0xE7, 0xFC, 0x3B, 0x80,
  0x60, 0x1C, 0x07, 0x03, 0xE3, 0xF0, 0x78, 0x00, 0xEF, 0xFE, 0x00, 0x00,
  0xEF, 0xFE, 0x38, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x38, 0xF3, 0xCF, 0x1C,
  0xEF, 0x18, 0x00, 0xE0, 0x7C, 0x3F, 0x3F, 0x0F, 0x81, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1C, 0x00, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1E,
  0x03, 0xC1, 0xF9, 0xFC, 0xFC, 0x0E, 0x01, 0x00, 0x00, 0x7E, 0x7F, 0x91,
  0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0xF0, 0x78, 0x1C, 0x00, 0x0F, 0x81, 0xFC, 0x38, 0xE7, 0x06, 0x60,
  0x6E, 0x1F, 0xC7, 0xFC, 0xF7, 0xCE, 0x7C, 0xC7, 0xCC, 0x7C, 0xC7, 0xCC,
  0x7C, 0xE7, 0xE7, 0xF6, 0x3E, 0x70, 0x03, 0x80, 0x3E, 0x40, 0xFE, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x03, 0xE0, 0x1B, 0x00, 0xDC, 0x0E, 0x60, 0x73,
  0x03, 0x1C, 0x18, 0xE1, 0xC3, 0x0C, 0x18, 0x7F, 0xE7, 0xFF, 0x38, 0x19,
  0xC0, 0xEC, 0x07, 0xE0, 0x38, 0x7E, 0x1F, 0xF3, 0xFF, 0x70, 0x6E, 0x0F,
  0xC1, 0xB8, 0x77, 0xFC, 0xFF, 0x9C, 0x7B, 0x83, 0xF0, 0x3E, 0x07, 0xC1,
  0xF8, 0x7F, 0xFE, 0xFF, 0x80, 0x07, 0xC3, 0xFC, 0xF3, 0xB8, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0,
  0x1E, 0x09, 0xFF, 0x0F, 0xE0, 0x7C, 0x0F, 0xF8, 0xFF, 0xCE, 0x1C, 0xE0,
  0xEE, 0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0x7E, 0x06, 0xE0, 0x6E, 0x0E, 0xE0,
  0xEE, 0x1E, 0xE3, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0xF1, 0xB8, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x0F, 0x81, 0xF0, 0x36, 0x06, 0xE0, 0xDE, 0x19,
  0xFF, 0x1F, 0xE0, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x60, 0xFF, 0xFF, 0xFF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x71, 0xFF, 0xFF, 0x80, 0x3F,
  0xE7, 0xFC, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x98, 0x77, 0xFC, 0x7F, 0x00, 0xC1,
  0xF8, 0x3B, 0x0E, 0x63, 0xCC, 0x71, 0x9C, 0x37, 0x07, 0xC0, 0xF8, 0x1B,
  0x83, 0x38, 0x63, 0x8C, 0x79, 0x87, 0x30, 0x76, 0x0F, 0xC0, 0xE0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x60, 0xE7, 0x0E,
  0x70, 0xE7, 0x1E, 0xD9, 0xED, 0x96, 0xDB, 0x6C, 0xB6, 0xCF, 0x6C, 0xE6,
  0xC6, 0x6C, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x70, 0xE0,
  0x7C, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0xFB, 0x1F, 0x73, 0xE6, 0x7C,
  0xEF, 0x8D, 0xF1, 0xBE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xE0, 0x1F,
  0x03, 0xFC, 0x79, 0xC7, 0x0E, 0xE0, 0xEE, 0x06, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0x71, 0xE3, 0xFC, 0x1F,
  0x80, 0xFE, 0x3F, 0xEF, 0xFF, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC3,
  0xFF, 0xEF, 0xE3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F,
  0x03, 0xFC, 0x79, 0xC7, 0x0E, 0xE0, 0xEE, 0x06, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0x71, 0xE3, 0xFC, 0x1F,
  0x80, 0xE0, 0x07, 0x00, 0x3E, 0x01, 0xE0, 0x7E, 0x0F, 0xF8, 0xFF, 0xCE,
  0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xFF, 0xCF, 0xF8, 0xFF, 0x0E,
  0x38, 0xE1, 0x8E, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0, 0x70, 0x1F, 0x87, 0xF9,
  0xE3, 0x38, 0x06, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xD0, 0x3F, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xDC, 0x3B, 0xFE, 0x3F, 0x80, 0xE0,
  0x3B, 0x01, 0xDC, 0x0E, 0xE0, 0x67, 0x07, 0x18, 0x38, 0xE1, 0xC7, 0x0C,
  0x38, 0xE0, 0xC7, 0x07, 0x30, 0x39, 0x80, 0xDC, 0x06, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0x00, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x6C, 0x06,
  0xC6, 0x6C, 0xE6, 0xCE, 0x6C, 0xF6, 0xDB, 0x6D, 0xB6, 0xD9, 0xEF, 0x1E,
  0x71, 0xE7, 0x0E, 0x60, 0xE0, 0xE0, 0x7E, 0x0E, 0x70, 0xE3, 0x1C, 0x39,
  0x81, 0xB8, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1B, 0x83, 0xB8, 0x31,
  0xC7, 0x1C, 0x70, 0xEE, 0x0E, 0xE0, 0x70, 0xE0, 0x3B, 0x81, 0xDC, 0x1C,
  0x60, 0xE3, 0x86, 0x0C, 0x70, 0x73, 0x01, 0xB8, 0x0F, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7F,
  0xEF, 0xFD, 0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0x80, 0xC0, 0x38, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0,
  0x1C, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0xF0, 0x1F, 0x01, 0xF8, 0x3B, 0x83, 0x9C, 0x70, 0xEE, 0x0E, 0xE0, 0x74,
  0x04, 0xFF, 0xFF, 0xFF, 0xC0, 0x43, 0x3C, 0x71, 0x80, 0x1F, 0x07, 0xF8,
  0xCF, 0x00, 0x70, 0x0E, 0x1F, 0xCF, 0xFB, 0xC7, 0xE0, 0xFC, 0x1D, 0xC3,
  0xBF, 0xF3, 0xFE, 0x20, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xE3,
  0xFE, 0xFF, 0xB0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC3,
  0xFF, 0xEF, 0xF0, 0x07, 0xC3, 0xFC, 0xFF, 0xB8, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x9F, 0xF1, 0xFE, 0x00, 0x20, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0xB9, 0xFF, 0x7F, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x70, 0xEF, 0xFC, 0x7F, 0x80,
  0x0F, 0x07, 0xF9, 0xFF, 0x38, 0x7E, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1C, 0x01, 0xE1, 0x1F, 0xE1, 0xFE, 0x01, 0x80, 0x7F, 0x0F, 0xF1, 0xC0,
  0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0xFF, 0xE1, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x0F,
  0x87, 0xFD, 0xF7, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEE,
  0x1D, 0xFF, 0x9F, 0xF0, 0x0E, 0x01, 0x80, 0x73, 0xFE, 0xFF, 0x81, 0x00,
  0x20, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xE3, 0xFC, 0xFF, 0xB0,
  0x6C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1C,
  0x1C, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x71, 0x0F, 0xE0,
  0xFC, 0x07, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0xFF, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xD0, 0xEF,
  0xF7, 0xF0, 0x40, 0x20, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x76, 0x1E, 0xC3, 0x98, 0xE3, 0x38, 0x6E, 0x0F, 0x81, 0xB8, 0x33, 0x86,
  0x38, 0xC3, 0x98, 0x3B, 0x03, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x0E, 0x21, 0xFC, 0x1F, 0x80, 0x79, 0xCF, 0xFE,
  0xEF, 0xEC, 0xE6, 0xC6, 0x7C, 0x67, 0xC6, 0x7C, 0x67, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x7E, 0x3F, 0xCF, 0xFB, 0x0E, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xC0, 0x0F, 0x03,
  0xF8, 0x7F, 0xC7, 0x0E, 0xE0, 0xEE, 0x06, 0xE0, 0x7E, 0x06, 0xE0, 0x6E,
  0x0E, 0x71, 0xE3, 0xFC, 0x1F, 0x80, 0x7E, 0x3F, 0xCF, 0xFB, 0x07, 0xC1,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x3F, 0xFE, 0xFF, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x00, 0x0F, 0x87, 0xFD, 0xFF, 0xB8, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D, 0xC7, 0xBF, 0xF3, 0xFE, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x1F, 0x1F, 0xEF, 0xBB, 0x80,
  0xE0, 0x3E, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x78, 0x1F, 0xFE, 0xFF, 0x00,
  0x1C, 0x03, 0x80, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x43, 0xF8, 0x3F, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1D,
  0xFF, 0x3F, 0xC0, 0xC0, 0x7E, 0x06, 0xE0, 0xE6, 0x0E, 0x70, 0xC7, 0x1C,
  0x31, 0xC3, 0x98, 0x3B, 0x81, 0xF0, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x1B, 0x00, 0xD8, 0x06, 0xC6, 0x76, 0x73, 0xB3, 0x99, 0x9E, 0xCC, 0xB6,
  0x7D, 0xB1, 0xE7, 0x8E, 0x3C, 0x71, 0xC3, 0x86, 0x00, 0xE0, 0x66, 0x0E,
  0x71, 0xC3, 0x98, 0x1F, 0x80, 0xF0, 0x0E, 0x01, 0xF0, 0x1B, 0x83, 0x9C,
  0x71, 0xC6, 0x0E, 0xE0, 0x70, 0xE0, 0x7E, 0x06, 0x70, 0xE7, 0x0E, 0x70,
  0xC3, 0x1C, 0x39, 0xC3, 0x9C, 0x1D, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x60, 0x0E, 0x0F, 0xC0, 0xF8, 0x06, 0x00, 0xFF, 0xBF, 0xEF, 0xF8,
  0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xC3, 0xF1, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x83, 0xC0, 0xF0, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x1C, 0x07, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x3F, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x60, 0x0F, 0x07, 0xC3, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x3F, 0x0F, 0xC0, 0x7C, 0x37, 0xF6, 0xCF,
  0xEC, 0x3C,
};

const GFXglyph UbuntuSansMono_Medium24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 17, 13, 5, -17 },
  { 10, 7, 7, 13, 3, -18 },
  { 17, 12, 17, 13, 1, -17 },
  { 43, 11, 22, 13, 1, -19 },
  { 74, 13, 17, 13, 0, -17 },
  { 102, 12, 17, 13, 1, -17 },
  { 128, 3, 7, 13, 5, -18 },
  { 131, 8, 24, 13, 3, -19 },
  { 155, 8, 24, 13, 3, -19 },
  { 179, 11, 11, 13, 1, -17 },
  { 195, 11, 12, 13, 1, -13 },
  { 212, 5, 8, 13, 4, -4 },
  { 217, 7, 2, 13, 3, -8 },
  { 219, 4, 4, 13, 5, -4 },
  { 221, 10, 23, 13, 2, -19 },
  { 250, 11, 17, 13, 1, -17 },
  { 274, 10, 17, 13, 2, -17 },
  { 296, 11, 17, 13, 1, -17 },
  { 320, 11, 17, 13, 1, -17 },
  { 344, 12, 17, 13, 1, -17 },
  { 370, 11, 17, 13, 1, -17 },
  { 394, 11, 17, 13, 1, -17 },
  { 418, 10, 17, 13, 2, -17 },
  { 440, 11, 17, 13, 1, -17 },
  { 464, 11, 17, 13, 1, -17 },
  { 488, 4, 12, 13, 5, -12 },
  { 494, 6, 16, 13, 3, -12 },
  { 506, 11, 11, 13, 1, -12 },
  { 522, 11, 8, 13, 1, -11 },
  { 533, 11, 11, 13, 1, -12 },
  { 549, 9, 17, 13, 2, -17 },
  { 569, 12, 21, 13, 1, -17 },
  { 601, 13, 17, 13, 0, -17 },
  { 629, 11, 17, 13, 1, -17 },
  { 653, 11, 17, 13, 1, -17 },
  { 677, 12, 17, 13, 1, -17 },
  { 703, 10, 17, 13, 2, -17 },
  { 725, 10, 17, 13, 2, -17 },
  { 747, 11, 17, 13, 1, -17 },
  { 771, 11, 17, 13, 1, -17 },
  { 795, 9, 17, 13, 2, -17 },
  { 815, 11, 17, 13, 1, -17 },
  { 839, 11, 17, 13, 2, -17 },
  { 863, 10, 17, 13, 2, -17 },
  { 885, 12, 17, 13, 1, -17 },
  { 911, 11, 17, 13, 1, -17 },
  { 935, 12, 17, 13, 1, -17 },
  { 961, 10, 17, 13, 2, -17 },
  { 983, 12, 21, 13, 1, -17 },
  { 1015, 12, 17, 13, 1, -17 },
  { 1041, 11, 17, 13, 1, -17 },
  { 1065, 12, 17, 13, 1, -17 },
  { 1091, 11, 17, 13, 1, -17 },
  { 1115, 13, 17, 13, 0, -17 },
  { 1143, 12, 17, 13, 1, -17 },
  { 1169, 12, 17, 13, 1, -17 },
  { 1195, 13, 17, 13, 0, -17 },
  { 1223, 11, 17, 13, 1, -17 },
  { 1247, 7, 23, 13, 3, -19 },
  { 1268, 10, 23, 13, 2, -19 },
  { 1297, 7, 23, 13, 3, -19 },
  { 1318, 12, 10, 13, 1, -17 },
  { 1333, 13, 2, 13, 0, 2 },
  { 1337, 5, 5, 13, 4, -19 },
  { 1341, 11, 13, 13, 1, -13 },
  { 1359, 10, 19, 13, 2, -19 },
  { 1383, 11, 13, 13, 1, -13 },
  { 1401, 11, 19, 13, 1, -19 },
  { 1428, 11, 13, 13, 1, -13 },
  { 1446, 12, 19, 13, 1, -19 },
  { 1475, 11, 18, 13, 1, -13 },
  { 1500, 10, 19, 13, 2, -19 },
  { 1524, 11, 18, 13, 1, -18 },
  { 1549, 9, 23, 13, 2, -18 },
  { 1575, 11, 19, 13, 2, -19 },
  { 1602, 11, 19, 13, 1, -19 },
  { 1629, 12, 13, 13, 1, -13 },
  { 1649, 10, 13, 13, 2, -13 },
  { 1666, 12, 13, 13, 1, -13 },
  { 1686, 10, 17, 13, 2, -13 },
  { 1708, 11, 17, 13, 1, -13 },
  { 1732, 9, 13, 13, 3, -13 },
  { 1747, 10, 13, 13, 2, -13 },
  { 1764, 11, 16, 13, 1, -16 },
  { 1786, 10, 13, 13, 2, -13 },
  { 1803, 12, 13, 13, 1, -13 },
  { 1823, 13, 13, 13, 0, -13 },
  { 1845, 12, 13, 13, 1, -13 },
  { 1865, 12, 18, 13, 1, -13 },
  { 1892, 10, 13, 13, 2, -13 },
  { 1909, 10, 23, 13, 2, -19 },
  { 1938, 3, 23, 13, 5, -19 },
  { 1947, 10, 23, 13, 2, -19 },
  { 1976, 12, 4, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_Medium24pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium24pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium24pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UBUNTUSANSMONO_MEDIUM24PT7B_H_
