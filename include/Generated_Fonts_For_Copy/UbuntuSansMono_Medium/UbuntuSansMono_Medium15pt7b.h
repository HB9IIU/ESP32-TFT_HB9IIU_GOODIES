#ifndef _UBUNTUSANSMONO_MEDIUM15PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF0, 0xF0, 0xDC, 0xA5, 0x20, 0x12, 0x12, 0xFF, 0xFF, 0x26,
  0x24, 0xFF, 0x6C, 0x6C, 0x4C, 0x30, 0x61, 0xF7, 0x2C, 0x18, 0x1E, 0x0E,
  0x06, 0x0F, 0xF3, 0xC3, 0x06, 0x00, 0x60, 0xF3, 0x92, 0x94, 0xFC, 0x28,
  0x17, 0x35, 0x2D, 0x65, 0xC7, 0x18, 0x3C, 0x64, 0x64, 0x28, 0x32, 0x7A,
  0x4E, 0xC6, 0x6E, 0x7B, 0xFD, 0x11, 0xD8, 0x8C, 0x62, 0x10, 0x86, 0x30,
  0xC6, 0x1C, 0x40, 0x86, 0x18, 0x63, 0x08, 0x63, 0x18, 0x8C, 0x66, 0x62,
  0x00, 0x31, 0xAB, 0xF9, 0x86, 0xC9, 0x00, 0x30, 0x60, 0xC7, 0xF3, 0x06,
  0x0C, 0x00, 0x27, 0x73, 0xE0, 0xFF, 0x5F, 0x00, 0x04, 0x30, 0xC2, 0x18,
  0x61, 0x0C, 0x30, 0x86, 0x18, 0x43, 0x0C, 0x00, 0x30, 0xFB, 0x36, 0x29,
  0x76, 0xE5, 0xC3, 0xC5, 0x99, 0xE0, 0x30, 0xE3, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0xFC, 0x31, 0xFA, 0x30, 0x60, 0xC3, 0x0C, 0x30, 0x41, 0x83,
  0xF8, 0x33, 0xF0, 0xC3, 0x0C, 0xE0, 0xC1, 0x06, 0x3F, 0x80, 0x1C, 0x38,
  0xB3, 0x6C, 0xD1, 0xBF, 0x86, 0x0C, 0x18, 0x7D, 0x04, 0x10, 0x78, 0x30,
  0x41, 0x8F, 0xE0, 0x3C, 0xE1, 0x06, 0x8F, 0xD8, 0xB1, 0xE3, 0xCC, 0xF0,
  0xFE, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x18, 0x20, 0xC0, 0x30, 0xFB, 0x16,
  0x2C, 0xCF, 0x37, 0x43, 0x87, 0x99, 0xF0, 0x30, 0xFB, 0x34, 0x2C, 0x79,
  0xDF, 0x06, 0x0C, 0x73, 0x80, 0x5F, 0x00, 0xBE, 0x27, 0x60, 0x02, 0x77,
  0x2E, 0x04, 0x3D, 0xE6, 0x0F, 0x07, 0x81, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x81, 0xC0, 0xF0, 0x71, 0xFE, 0x30, 0x00, 0x33, 0xF0, 0xC3, 0x18,
  0x43, 0x00, 0x00, 0xC3, 0x00, 0x18, 0xFB, 0x1C, 0x39, 0xF6, 0xED, 0xDB,
  0xB7, 0x3F, 0x03, 0x03, 0xC0, 0x1C, 0x1C, 0x34, 0x24, 0x26, 0x66, 0x7E,
  0x43, 0x43, 0xC3, 0x21, 0xFB, 0x36, 0x2C, 0xDF, 0x33, 0x63, 0xC7, 0x9B,
  0xE0, 0x18, 0xFF, 0x06, 0x08, 0x10, 0x20, 0x60, 0xC0, 0xC4, 0xF8, 0x21,
  0xF3, 0x36, 0x3C, 0x78, 0xF1, 0xE3, 0xC5, 0xBB, 0xE0, 0xFD, 0x83, 0x06,
  0x0F, 0xD8, 0x30, 0x60, 0xC1, 0xFC, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30,
  0xC3, 0x00, 0x18, 0xFF, 0x06, 0x08, 0x10, 0x21, 0xE3, 0xC6, 0xCD, 0xF8,
  0x87, 0x0E, 0x1C, 0x3F, 0xF0, 0xE1, 0xC3, 0x87, 0x0C, 0xFC, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x43, 0x8F,
  0xE0, 0xCF, 0x9B, 0x67, 0x8E, 0x1E, 0x36, 0x66, 0xC7, 0x8C, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFC, 0x66, 0x66, 0x77, 0x57, 0x5B,
  0x5B, 0x43, 0x43, 0x43, 0xC3, 0xC7, 0x8F, 0x9D, 0x39, 0x72, 0xE3, 0xC7,
  0x8F, 0x0C, 0x18, 0x3E, 0x62, 0x43, 0x43, 0xC3, 0xC3, 0x43, 0x63, 0x66,
  0x3C, 0x21, 0xFB, 0x1E, 0x3C, 0x79, 0xBF, 0x60, 0xC1, 0x83, 0x00, 0x18,
  0x3E, 0x62, 0x43, 0x43, 0xC3, 0xC3, 0x43, 0x63, 0x66, 0x3C, 0x18, 0x0F,
  0x02, 0x21, 0xFB, 0x36, 0x2C, 0x5B, 0xBE, 0x6C, 0xCD, 0x8B, 0x18, 0x38,
  0xFB, 0x06, 0x0E, 0x0F, 0x07, 0x03, 0x07, 0x1B, 0xF0, 0xFE, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xE3, 0xCC, 0xF8, 0xC3, 0x43, 0x62, 0x62, 0x66, 0x26, 0x34, 0x34, 0x1C,
  0x18, 0xC3, 0x43, 0x43, 0x4B, 0x5B, 0x5B, 0x57, 0x66, 0x66, 0x62, 0xE3,
  0x26, 0x34, 0x1C, 0x18, 0x1C, 0x34, 0x26, 0x62, 0xC3, 0xC3, 0x62, 0x66,
  0x34, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFE, 0x18, 0x20, 0xC3, 0x06,
  0x18, 0x20, 0xC1, 0xFC, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0,
  0xC3, 0x04, 0x18, 0x60, 0x83, 0x0C, 0x10, 0x61, 0x82, 0x0C, 0x30, 0x40,
  0xFF, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0xF0, 0x30, 0xF1, 0xB6, 0x68,
  0x60, 0xFF, 0xFF, 0x99, 0x80, 0x79, 0x30, 0x5F, 0xEF, 0x1C, 0x5F, 0x41,
  0x83, 0x06, 0x0F, 0x9D, 0xB1, 0xE3, 0xC7, 0x8F, 0x37, 0xC0, 0x3E, 0xEB,
  0x06, 0x0C, 0x18, 0x38, 0xBF, 0x04, 0x10, 0x41, 0x7F, 0xBC, 0x61, 0x87,
  0x1C, 0x5F, 0x79, 0xDB, 0x1F, 0xFF, 0xF8, 0x39, 0x3E, 0x0C, 0x7C, 0x81,
  0x0F, 0xDF, 0x88, 0x10, 0x20, 0x40, 0x81, 0x00, 0x7F, 0xBC, 0x61, 0x87,
  0x1F, 0xCD, 0x0F, 0xFF, 0x00, 0x43, 0x0C, 0x30, 0xFB, 0xFC, 0x71, 0xC7,
  0x1C, 0x71, 0x70, 0x40, 0x07, 0x8F, 0x06, 0x0C, 0x18, 0x30, 0x64, 0x78,
  0x18, 0x60, 0x1F, 0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xF9, 0xC0, 0x41,
  0x83, 0x06, 0x0C, 0x79, 0xB6, 0x78, 0xF1, 0xB3, 0x36, 0x30, 0xF1, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC8, 0xF0, 0xFD, 0x6E, 0x5C,
  0xB9, 0x70, 0xE1, 0xC3, 0xFB, 0x7C, 0x71, 0xC7, 0x1C, 0x71, 0x79, 0xDB,
  0x1C, 0x38, 0x78, 0xF3, 0x3C, 0xF9, 0x9B, 0x1E, 0x3C, 0x78, 0xF3, 0x7E,
  0xC1, 0x83, 0x00, 0x7F, 0xBC, 0x61, 0x87, 0x1C, 0xDF, 0x04, 0x10, 0x40,
  0xFF, 0xE8, 0x20, 0x82, 0x08, 0x20, 0x7F, 0x1C, 0x1C, 0x3C, 0x18, 0xFF,
  0x20, 0x43, 0xFF, 0xF2, 0x04, 0x08, 0x10, 0x32, 0x7C, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x5F, 0xC3, 0x63, 0x62, 0x66, 0x34, 0x3C, 0x1C, 0x18, 0xC1,
  0xC1, 0x59, 0x5B, 0x5F, 0x56, 0x66, 0x66, 0x63, 0x66, 0x3C, 0x18, 0x1C,
  0x34, 0x66, 0xC3, 0x63, 0x62, 0x62, 0x26, 0x36, 0x14, 0x1C, 0x0C, 0x18,
  0x70, 0xE0, 0xFF, 0xF1, 0x8C, 0x31, 0x8C, 0x3F, 0x1C, 0xF3, 0x0C, 0x30,
  0xC2, 0x30, 0x20, 0xC3, 0x0C, 0x30, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE3, 0xC1, 0x04, 0x10, 0x41, 0x83, 0x18, 0x41, 0x04, 0x13, 0xCE, 0x00,
  0x63, 0xFE, 0x70,
};

const GFXglyph UbuntuSansMono_Medium15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 5, 4, 8, 2, -11 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 7, 14, 8, 1, -12 },
  { 30, 8, 11, 8, 0, -11 },
  { 41, 8, 11, 8, 0, -11 },
  { 52, 2, 4, 8, 3, -11 },
  { 53, 5, 15, 8, 2, -12 },
  { 63, 5, 15, 8, 2, -12 },
  { 73, 7, 6, 8, 1, -10 },
  { 79, 7, 7, 8, 1, -8 },
  { 86, 4, 5, 8, 2, -3 },
  { 89, 4, 2, 8, 2, -5 },
  { 90, 3, 3, 8, 3, -3 },
  { 92, 6, 15, 8, 1, -12 },
  { 104, 7, 11, 8, 1, -11 },
  { 114, 7, 10, 8, 1, -10 },
  { 123, 7, 11, 8, 1, -11 },
  { 133, 6, 11, 8, 1, -11 },
  { 142, 7, 10, 8, 1, -10 },
  { 151, 6, 10, 8, 1, -10 },
  { 159, 7, 10, 8, 1, -10 },
  { 168, 7, 10, 8, 1, -10 },
  { 177, 7, 11, 8, 1, -11 },
  { 187, 7, 11, 8, 1, -11 },
  { 197, 3, 8, 8, 3, -8 },
  { 200, 4, 10, 8, 2, -8 },
  { 205, 7, 7, 8, 1, -8 },
  { 212, 7, 5, 8, 1, -7 },
  { 217, 7, 7, 8, 1, -8 },
  { 224, 6, 11, 8, 1, -11 },
  { 233, 7, 13, 8, 1, -11 },
  { 245, 8, 10, 8, 0, -10 },
  { 255, 7, 11, 8, 1, -11 },
  { 265, 7, 11, 8, 1, -11 },
  { 275, 7, 11, 8, 1, -11 },
  { 285, 7, 10, 8, 1, -10 },
  { 294, 6, 10, 8, 1, -10 },
  { 302, 7, 11, 8, 1, -11 },
  { 312, 7, 10, 8, 1, -10 },
  { 321, 6, 10, 8, 1, -10 },
  { 329, 6, 10, 8, 1, -10 },
  { 337, 7, 10, 8, 1, -10 },
  { 346, 7, 10, 8, 1, -10 },
  { 355, 8, 10, 8, 0, -10 },
  { 365, 7, 10, 8, 1, -10 },
  { 374, 8, 11, 8, 0, -11 },
  { 385, 7, 11, 8, 1, -11 },
  { 395, 8, 14, 8, 0, -11 },
  { 409, 7, 11, 8, 1, -11 },
  { 419, 7, 11, 8, 1, -11 },
  { 429, 7, 10, 8, 1, -10 },
  { 438, 7, 10, 8, 1, -10 },
  { 447, 8, 10, 8, 0, -10 },
  { 457, 8, 10, 8, 0, -10 },
  { 467, 8, 10, 8, 0, -10 },
  { 477, 8, 10, 8, 0, -10 },
  { 487, 7, 10, 8, 1, -10 },
  { 496, 4, 15, 8, 2, -12 },
  { 504, 6, 15, 8, 1, -12 },
  { 516, 4, 15, 8, 2, -12 },
  { 524, 7, 5, 8, 1, -10 },
  { 529, 8, 2, 8, 0, 1 },
  { 531, 3, 3, 8, 3, -12 },
  { 533, 6, 8, 8, 1, -8 },
  { 539, 7, 12, 8, 1, -12 },
  { 550, 7, 8, 8, 1, -8 },
  { 557, 6, 12, 8, 1, -12 },
  { 566, 7, 8, 8, 1, -8 },
  { 573, 7, 12, 8, 1, -12 },
  { 584, 6, 11, 8, 1, -8 },
  { 593, 6, 12, 8, 1, -12 },
  { 602, 7, 11, 8, 1, -11 },
  { 612, 6, 14, 8, 1, -11 },
  { 623, 7, 12, 8, 1, -12 },
  { 634, 7, 12, 8, 1, -12 },
  { 645, 7, 8, 8, 1, -8 },
  { 652, 6, 8, 8, 1, -8 },
  { 658, 7, 8, 8, 1, -8 },
  { 665, 7, 11, 8, 1, -8 },
  { 675, 6, 11, 8, 1, -8 },
  { 684, 6, 8, 8, 2, -8 },
  { 690, 6, 8, 8, 1, -8 },
  { 696, 7, 10, 8, 1, -10 },
  { 705, 6, 8, 8, 1, -8 },
  { 711, 8, 8, 8, 0, -8 },
  { 719, 8, 8, 8, 0, -8 },
  { 727, 8, 8, 8, 0, -8 },
  { 735, 8, 11, 8, 0, -8 },
  { 746, 6, 8, 8, 1, -8 },
  { 752, 6, 15, 8, 1, -12 },
  { 764, 2, 15, 8, 3, -12 },
  { 768, 6, 15, 8, 1, -12 },
  { 780, 7, 3, 8, 1, -6 },
};

const GFXfont UbuntuSansMono_Medium15pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium15pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUSANSMONO_MEDIUM15PT7B_H_
