#ifndef _UBUNTUSANSMONO_MEDIUM36PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium36pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xF8, 0xFF, 0x8F, 0x70,
  0xF7, 0x0F, 0x70, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x03,
  0x87, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x1E, 0x1C, 0x07, 0x87, 0x01, 0xC3,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xE0,
  0x38, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x01, 0xE1, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xE0, 0x3C, 0x78, 0x0E, 0x1E,
  0x03, 0x87, 0x80, 0xE1, 0xC0, 0x78, 0x70, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3E,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x60, 0x1F, 0xFF, 0xFE, 0xFF, 0xFE,
  0x7F, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x08, 0x00, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0x73, 0x81, 0xCE, 0x70, 0x71,
  0x86, 0x0E, 0x30, 0xC3, 0x86, 0x18, 0xE0, 0xC3, 0x1C, 0x1C, 0xE7, 0x03,
  0xFD, 0xE0, 0x3F, 0x38, 0x03, 0xCE, 0x00, 0x03, 0xC0, 0x00, 0x73, 0xC0,
  0x1C, 0xFC, 0x03, 0xBF, 0xC0, 0xE7, 0x38, 0x3C, 0xE3, 0x07, 0x18, 0x71,
  0xC3, 0x0E, 0x78, 0x71, 0xCE, 0x0E, 0x33, 0x81, 0xCE, 0x70, 0x1F, 0xDC,
  0x03, 0xF0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0x83, 0xC0, 0xE0, 0xF0, 0x3C,
  0x38, 0x0F, 0x1E, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x0F, 0xC4, 0x07, 0xE0,
  0xE3, 0xFC, 0x79, 0xEF, 0x9E, 0x79, 0xF7, 0x3C, 0x3F, 0xCF, 0x07, 0xF3,
  0xC0, 0xFC, 0xF0, 0x1E, 0x3C, 0x07, 0xC7, 0x87, 0xF1, 0xFF, 0xFE, 0x3F,
  0xF7, 0xC7, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x60, 0x00, 0x60,
  0x1E, 0x03, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0E, 0x00, 0x40, 0x60, 0x07, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x07, 0x00, 0x20, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x71, 0xC6, 0x7D, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0x70, 0x1E, 0x78, 0x3E, 0x7C, 0x1C, 0x3C,
  0x0C, 0x30, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x0F, 0x0E, 0x3C, 0xFC,
  0xF0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0x80,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x8F, 0xF3, 0xC7, 0xF3, 0xC7,
  0xF3, 0xC7, 0xF3, 0xC7, 0xF1, 0x87, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF0, 0x00, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0x3E, 0xF0, 0x71, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1F, 0xFF, 0xBF,
  0xFF, 0x7F, 0xFE, 0x01, 0x00, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x78,
  0x7E, 0x60, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x03, 0x00, 0x3F, 0xF0, 0x7F,
  0xF8, 0x7F, 0xFC, 0x30, 0x7C, 0x20, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x60, 0x3E, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF0, 0x02,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x1E, 0x03, 0xC7, 0x81,
  0xE1, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x87, 0x81, 0xE1, 0xC0,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x60, 0x3E, 0x7F, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0,
  0x02, 0x00, 0x00, 0x3E, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0xC0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x0F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x1E, 0x7C, 0x1E, 0x3F, 0x3C, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xFC, 0x78, 0x7E, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x01, 0x80, 0x01, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E,
  0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0x7C, 0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x01, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x1E, 0x3F, 0x3F,
  0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3F,
  0x3F, 0x3F, 0x3F, 0x1F, 0x07, 0x0E, 0x3E, 0xFC, 0xF8, 0xE0, 0x00, 0x01,
  0x00, 0x03, 0x80, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x38,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x07, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x60, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1E, 0x07, 0x8F, 0x00, 0xE3, 0x80, 0x3D,
  0xE0, 0x0F, 0x78, 0x0F, 0xDC, 0x1F, 0xF7, 0x0F, 0xFD, 0xC7, 0xFF, 0xF1,
  0xE3, 0xFC, 0xF0, 0xFF, 0x3C, 0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC, 0xF0,
  0xFF, 0x3C, 0x3F, 0xCF, 0x0F, 0x71, 0xE3, 0xDC, 0x7F, 0xF7, 0x8F, 0xFD,
  0xE1, 0xFF, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x39, 0xC0, 0x03, 0x9E, 0x00,
  0x79, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0E, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xC0, 0x3C, 0x38, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xF0, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x00,
  0x20, 0x01, 0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xE3, 0xF0, 0x73, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x0C,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1E, 0x1F, 0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x3D,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x03, 0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x87, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF,
  0x3F, 0x07, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x7C, 0x0F,
  0x3F, 0x0F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xC0, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF4, 0x03, 0xEE,
  0x0F, 0xBF, 0xFF, 0x7F, 0xFC, 0x3F, 0xF0, 0x04, 0x00, 0xF0, 0x0F, 0xBC,
  0x07, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F,
  0x83, 0xC7, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0x78, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0x3E, 0x03, 0xC7, 0xC0, 0xF0, 0xF8, 0x3C,
  0x1F, 0x0F, 0x07, 0xC3, 0xC0, 0xF8, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x00,
  0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0x07, 0x0F, 0x03,
  0xE3, 0xC0, 0xF9, 0xF0, 0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0x61, 0xF9,
  0xDC, 0xEE, 0x77, 0x3B, 0x9C, 0xCE, 0xE7, 0x3F, 0x39, 0xCF, 0xCE, 0x73,
  0xF3, 0x9C, 0x78, 0xE7, 0x1E, 0x3D, 0xC7, 0x8F, 0x70, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xF7, 0x0F, 0xF7,
  0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xEF, 0xF0, 0xEF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xC0, 0x01, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x1F, 0x1F, 0x03, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7,
  0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x07, 0x9F, 0x03, 0xE3, 0xE1, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xF0, 0xFE, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF1, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF0, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xF8, 0x7C, 0x3C, 0x0F, 0x9E, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xDE, 0x00, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0x87, 0xC1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x06, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1E, 0x1F, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF,
  0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C,
  0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x07, 0x80, 0x00, 0xC0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE,
  0x7C, 0x0C, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x40, 0x0F,
  0x70, 0x1F, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF8, 0x01, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0x7C, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0x80, 0xF0,
  0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xF0,
  0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0x70,
  0xF0, 0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0xDC, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDC, 0x78, 0xF7, 0x1E, 0x3D,
  0xC7, 0x8E, 0x73, 0xF3, 0x9C, 0xFC, 0xE7, 0x3B, 0x39, 0xCC, 0xEE, 0x77,
  0x3B, 0x9D, 0xCE, 0xE7, 0x61, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF8, 0xF0, 0x3E, 0x38, 0x07, 0x00, 0xF8, 0x03, 0xDE, 0x01,
  0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0x80, 0xF3, 0xC0,
  0x3C, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x0F, 0x3C, 0x07, 0xC7,
  0x81, 0xE1, 0xE0, 0xF8, 0x3C, 0x3C, 0x0F, 0x1F, 0x01, 0xE7, 0x80, 0x7B,
  0xE0, 0x1F, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xE0, 0x0F,
  0x3C, 0x03, 0xC7, 0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0xF8,
  0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0xDC, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xEF, 0x00, 0xF3, 0xE0, 0x78, 0x78, 0x3E, 0x1F, 0x0F, 0x03,
  0xC7, 0xC0, 0x79, 0xE0, 0x1F, 0xF8, 0x03, 0xCC, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x30, 0xF8, 0x7C,
  0x1E, 0x0F, 0x06, 0x3F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x8F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFC, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x06, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x01, 0x3F, 0xFF, 0x1F,
  0xFF, 0x07, 0xFF, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3E, 0x3F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x7C, 0x0F, 0x3E, 0x0F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x7C, 0x3C, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x0C, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x07, 0x80, 0x83, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x3F,
  0xFC, 0xFF, 0xFB, 0xF0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xDF,
  0x9F, 0xBF, 0xFF, 0x3F, 0xFE, 0x1F, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE8, 0x07, 0xDF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF0, 0x1F, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x8F, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xF0, 0x02, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC1, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x40, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7D,
  0x03, 0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x07, 0xC0, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF1, 0xF0,
  0xF3, 0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xF7, 0xC0, 0xF1, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC1, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x7F, 0x3E, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xC7, 0x9E, 0xF1, 0xE3, 0xFC,
  0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E,
  0x3F, 0xC7, 0x8F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF,
  0xE7, 0x87, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x78, 0x07, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFC, 0x7C, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1F, 0x78, 0x07,
  0x9E, 0x01, 0xE7, 0xC0, 0xF8, 0xF8, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0, 0xFC, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF,
  0x3F, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x0F,
  0x3E, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7C, 0x0C, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x70, 0x1E, 0x7F, 0xFE, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x08, 0x1F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0x0F, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xC0, 0xF0, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x78,
  0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x1E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xFC,
  0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEF, 0x0E, 0x1D, 0xE3, 0xC3, 0xBC,
  0x78, 0xF7, 0x8F, 0x1E, 0x71, 0xF3, 0xCE, 0x7E, 0x71, 0xCF, 0xCE, 0x39,
  0x9D, 0xC7, 0x73, 0xB8, 0xFE, 0x77, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E,
  0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x00, 0xF8, 0x07, 0xDF, 0x01, 0xE3,
  0xC0, 0xF0, 0x78, 0x78, 0x1F, 0x1E, 0x03, 0xEF, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xBC,
  0x03, 0xCF, 0x81, 0xE1, 0xE0, 0xF0, 0x3C, 0x7C, 0x0F, 0x9E, 0x01, 0xEF,
  0x00, 0x3C, 0x78, 0x03, 0xDE, 0x01, 0xE7, 0xC0, 0x78, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xF0, 0x1F, 0xC0, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xC0, 0x00, 0x0E, 0x01, 0x0F,
  0xE0, 0x77, 0xFE, 0x3D, 0xFF, 0xFE, 0x70, 0xFF, 0xB8, 0x1F, 0xC0, 0x00,
  0xC0,
};

const GFXglyph UbuntuSansMono_Medium36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 25, 20, 7, -25 },
  { 20, 12, 10, 20, 4, -27 },
  { 35, 18, 25, 20, 1, -25 },
  { 92, 16, 32, 20, 2, -28 },
  { 156, 19, 27, 20, 1, -26 },
  { 221, 18, 26, 20, 1, -26 },
  { 280, 4, 11, 20, 8, -27 },
  { 286, 12, 35, 20, 4, -28 },
  { 339, 12, 35, 20, 4, -28 },
  { 392, 16, 15, 20, 2, -25 },
  { 422, 16, 18, 20, 2, -20 },
  { 458, 8, 12, 20, 6, -6 },
  { 470, 10, 4, 20, 5, -12 },
  { 475, 6, 6, 20, 7, -6 },
  { 480, 16, 35, 20, 2, -28 },
  { 550, 16, 27, 20, 2, -26 },
  { 604, 15, 25, 20, 3, -25 },
  { 651, 16, 26, 20, 2, -26 },
  { 703, 16, 27, 20, 2, -26 },
  { 757, 18, 25, 20, 1, -25 },
  { 814, 16, 26, 20, 2, -25 },
  { 866, 16, 26, 20, 2, -25 },
  { 918, 16, 25, 20, 2, -25 },
  { 968, 16, 27, 20, 2, -26 },
  { 1022, 16, 26, 20, 2, -26 },
  { 1074, 6, 19, 20, 7, -19 },
  { 1089, 8, 25, 20, 5, -19 },
  { 1114, 17, 17, 20, 2, -19 },
  { 1151, 16, 11, 20, 2, -16 },
  { 1173, 17, 17, 20, 2, -19 },
  { 1210, 14, 26, 20, 3, -26 },
  { 1256, 18, 31, 20, 1, -26 },
  { 1326, 20, 25, 20, 0, -25 },
  { 1389, 16, 25, 20, 2, -25 },
  { 1439, 17, 27, 20, 2, -26 },
  { 1497, 17, 25, 20, 2, -25 },
  { 1551, 16, 25, 20, 3, -25 },
  { 1601, 15, 25, 20, 3, -25 },
  { 1648, 16, 27, 20, 2, -26 },
  { 1702, 16, 25, 20, 2, -25 },
  { 1752, 14, 25, 20, 3, -25 },
  { 1796, 15, 26, 20, 2, -25 },
  { 1845, 18, 25, 20, 2, -25 },
  { 1902, 16, 25, 20, 3, -25 },
  { 1952, 18, 25, 20, 1, -25 },
  { 2009, 16, 25, 20, 2, -25 },
  { 2059, 18, 27, 20, 1, -26 },
  { 2120, 16, 25, 20, 3, -25 },
  { 2170, 18, 32, 20, 1, -25 },
  { 2242, 17, 25, 20, 2, -25 },
  { 2296, 16, 27, 20, 2, -26 },
  { 2350, 18, 25, 20, 1, -25 },
  { 2407, 16, 26, 20, 2, -25 },
  { 2459, 19, 25, 20, 1, -25 },
  { 2519, 18, 25, 20, 1, -25 },
  { 2576, 18, 25, 20, 1, -25 },
  { 2633, 19, 25, 20, 1, -25 },
  { 2693, 16, 25, 20, 2, -25 },
  { 2743, 11, 35, 20, 5, -28 },
  { 2792, 16, 35, 20, 2, -28 },
  { 2862, 10, 35, 20, 5, -28 },
  { 2906, 18, 14, 20, 1, -25 },
  { 2938, 20, 4, 20, 0, 3 },
  { 2948, 8, 7, 20, 6, -28 },
  { 2955, 16, 19, 20, 2, -19 },
  { 2993, 16, 28, 20, 3, -28 },
  { 3049, 16, 19, 20, 2, -19 },
  { 3087, 16, 28, 20, 1, -28 },
  { 3143, 18, 19, 20, 1, -19 },
  { 3186, 18, 28, 20, 2, -28 },
  { 3249, 15, 26, 20, 2, -19 },
  { 3298, 15, 28, 20, 3, -28 },
  { 3351, 16, 28, 20, 2, -28 },
  { 3407, 13, 35, 20, 3, -28 },
  { 3464, 16, 28, 20, 3, -28 },
  { 3520, 16, 28, 20, 2, -28 },
  { 3576, 18, 19, 20, 1, -19 },
  { 3619, 15, 19, 20, 3, -19 },
  { 3655, 18, 19, 20, 1, -19 },
  { 3698, 16, 26, 20, 3, -19 },
  { 3750, 16, 26, 20, 1, -19 },
  { 3802, 14, 19, 20, 4, -19 },
  { 3836, 16, 19, 20, 2, -19 },
  { 3874, 17, 25, 20, 2, -25 },
  { 3928, 14, 19, 20, 3, -19 },
  { 3962, 18, 19, 20, 1, -19 },
  { 4005, 19, 19, 20, 1, -19 },
  { 4051, 18, 19, 20, 1, -19 },
  { 4094, 18, 26, 20, 1, -19 },
  { 4153, 14, 19, 20, 3, -19 },
  { 4187, 14, 35, 20, 3, -28 },
  { 4249, 4, 35, 20, 8, -28 },
  { 4267, 14, 35, 20, 3, -28 },
  { 4329, 18, 7, 20, 1, -14 },
};

const GFXfont UbuntuSansMono_Medium36pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium36pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium36pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUSANSMONO_MEDIUM36PT7B_H_
