#ifndef _UBUNTUSANSMONO_MEDIUM45PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x38, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07,
  0x9C, 0x0E, 0x70, 0x38, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0xF8, 0x3C,
  0x01, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7C, 0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x1F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x87,
  0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78,
  0x03, 0xE0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFC, 0x1F,
  0x1F, 0x80, 0x08, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF4,
  0x00, 0x1F, 0xBC, 0x01, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00,
  0x3D, 0xFF, 0x00, 0xF7, 0xDE, 0x01, 0xEF, 0x1C, 0x07, 0x9C, 0x3C, 0x1E,
  0x38, 0x78, 0x3C, 0x70, 0xF0, 0xF0, 0xE1, 0xE1, 0xE1, 0xC3, 0xC7, 0x83,
  0x87, 0x9E, 0x07, 0x8E, 0x3C, 0x0F, 0xFC, 0xF0, 0x0F, 0xFB, 0xC0, 0x0F,
  0xE7, 0x80, 0x07, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x03,
  0xCF, 0xF0, 0x07, 0xBF, 0xE0, 0x1E, 0x79, 0xE0, 0x78, 0xE3, 0xC0, 0xF3,
  0xC3, 0x83, 0xC7, 0x87, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x78, 0x3C,
  0x38, 0xF0, 0x38, 0x73, 0xC0, 0x71, 0xEF, 0x00, 0xFF, 0xDE, 0x00, 0xFF,
  0x78, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0x07,
  0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x3C, 0x0F, 0xF0, 0x78, 0x3F, 0xF0, 0xF0, 0xFB, 0xF1,
  0xE1, 0xF3, 0xF3, 0xC7, 0xC3, 0xE7, 0x8F, 0x03, 0xFE, 0x3E, 0x03, 0xFC,
  0x7C, 0x07, 0xF8, 0xF8, 0x07, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0xC3,
  0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xEF, 0x87, 0xFF, 0x9F, 0x03,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xE7, 0x38, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x20, 0x00,
  0x60, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x40, 0xF0, 0x47, 0x8F, 0x1E,
  0xFC, 0xE7, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFC, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0xFB, 0xE0, 0x1F, 0x9F, 0x03, 0xF1,
  0xF8, 0x1F, 0x0F, 0x80, 0xE0, 0xE0, 0x04, 0x04, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x02, 0x01, 0xF0, 0x7F, 0x0F,
  0xE3, 0xFE, 0x3F, 0xC7, 0xF0, 0x7E, 0x03, 0xC0, 0xF8, 0x3E, 0x1F, 0x8F,
  0xE1, 0xF8, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0xFD, 0xFE, 0x1F, 0x83, 0xF0, 0xF8, 0x0F, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x82, 0x0F, 0xFC, 0x3C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8,
  0xFF, 0xC7, 0xC7, 0xFE, 0x1C, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xE7, 0x80, 0x7C, 0x78, 0x03, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0x80, 0xFC, 0x60, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x07,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF7, 0xF8, 0x60, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0xF0, 0x07, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0,
  0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFD, 0x00, 0x3F, 0x7F, 0xFF,
  0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC6, 0x00, 0xFB, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF8,
  0xFE, 0x1F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xFC, 0x03, 0xC3, 0xF0, 0x3E, 0x1F, 0xC3,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xC7, 0xF8, 0x7C, 0x0F, 0xE7, 0xC0, 0x1F, 0x3C, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x7E, 0xFC,
  0x07, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x03, 0xE7, 0xE0, 0x7F, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7C, 0x10, 0x07, 0x01, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF0, 0x7C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0x7E, 0x03, 0xC0, 0x78, 0x3E, 0x1F, 0xCF, 0xF0, 0xF8, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xC7, 0xFB, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x03, 0xC3, 0xE0, 0x0F, 0x8F, 0x00,
  0x1E, 0x7C, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xC7, 0xFC, 0x3E, 0x1F, 0xF1,
  0xF0, 0x7F, 0xC7, 0xC1, 0xFF, 0x1F, 0x07, 0xFC, 0x7C, 0x1F, 0xF1, 0xF0,
  0x7F, 0xC7, 0xC1, 0xFF, 0x1F, 0x07, 0xFC, 0x7C, 0x1F, 0xF0, 0xF0, 0x7F,
  0xC3, 0xE1, 0xFF, 0x8F, 0xFF, 0xDE, 0x1F, 0xFF, 0x78, 0x3F, 0xFD, 0xF0,
  0x3F, 0xC3, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x02, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xE7, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1E,
  0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xC0, 0x1E, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0x7E, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x0F,
  0xCF, 0x87, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF,
  0x80, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xE0, 0x18, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x61, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x0F, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0x83, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8,
  0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x83,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xBF,
  0x0F, 0xC0, 0x18, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0x7E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0xC0, 0x3E, 0x3F, 0x81,
  0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE2, 0x00, 0x7E, 0x38,
  0x0F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x1F, 0x00, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3E, 0x01,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0x80,
  0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0xFC, 0x00, 0xFB,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xEF, 0xE0, 0x0F, 0x9F, 0xC0, 0x3E, 0x3F, 0x80, 0xF8, 0x7F, 0x03,
  0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0,
  0x1F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xE0, 0x07,
  0xEF, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xF0, 0x7F, 0x0E,
  0xE0, 0xFE, 0x1D, 0xC1, 0xDC, 0x3B, 0xC7, 0xBC, 0x73, 0x8F, 0x78, 0xE7,
  0x1C, 0xF3, 0xCF, 0x39, 0xE7, 0x9E, 0xF3, 0xCF, 0x1D, 0xC7, 0x9E, 0x3F,
  0x8F, 0x3C, 0x7F, 0x1E, 0x78, 0x7E, 0x3C, 0xF0, 0xF8, 0x79, 0xE1, 0xF0,
  0xF3, 0xC1, 0xE1, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB,
  0xC0, 0x01, 0xF7, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0x78,
  0x1F, 0xF7, 0xC1, 0xFF, 0x3C, 0x1F, 0xF1, 0xE1, 0xFF, 0x1E, 0x1F, 0xF0,
  0xF1, 0xFF, 0x0F, 0x1F, 0xF0, 0x79, 0xFF, 0x07, 0x9F, 0xF0, 0x3D, 0xFF,
  0x03, 0xDF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xE0, 0x3F, 0x0F,
  0xC0, 0x3E, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F,
  0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xFC, 0x07, 0xE0,
  0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x80, 0xFE, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x7F, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7E,
  0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xF7,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7E, 0x00,
  0x7C, 0x7C, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7C, 0x0F, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xFC, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x1F,
  0x07, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFC, 0x7E, 0x1F, 0x00, 0x21,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC8, 0x00, 0x7C, 0x70, 0x07, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0xC7, 0xC0,
  0x03, 0xC7, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xEF, 0x80,
  0x01, 0xEF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D,
  0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC1, 0xE1, 0xE7, 0x87, 0xC3, 0xCF, 0x0F, 0x87, 0x9E, 0x1F,
  0x8F, 0x3C, 0x7F, 0x1E, 0x78, 0xEE, 0x3C, 0xF1, 0xDE, 0x79, 0xE7, 0xBC,
  0xF3, 0xCF, 0x39, 0xE7, 0x9C, 0x73, 0xC7, 0x78, 0xF7, 0x8E, 0xF0, 0xEF,
  0x1D, 0xC1, 0xDC, 0x3B, 0x83, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0x80,
  0x03, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7D, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x83, 0xF0,
  0x3E, 0x0F, 0x80, 0xFC, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x1F, 0x30, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x0C, 0x07, 0x83, 0xF0,
  0x7E, 0x07, 0xE0, 0xFC, 0x1E, 0x01, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0x81, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x3F, 0xFF, 0x9F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x40, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x9F,
  0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF9, 0xFE, 0xFC,
  0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x0F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0x07, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x21, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x3F,
  0x9F, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF9, 0xFF, 0x7E,
  0x03, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x1F, 0x7F, 0x01,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x05,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xF8, 0x7F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFC, 0xF8, 0x1F, 0x80, 0x20,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0x83, 0xF7, 0xE0, 0x1F, 0x7C,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xE0, 0x1F, 0x7F, 0xDF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE3, 0x00, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xC0, 0x18, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7D, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xF9, 0xFE, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x08, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x40,
  0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF4, 0x01, 0xF3, 0x81, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x20, 0x00, 0x18, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x1F,
  0x03, 0xF0, 0xF8, 0x3F, 0x07, 0xC3, 0xF0, 0x3E, 0x3F, 0x01, 0xF3, 0xF0,
  0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFB,
  0xF8, 0x07, 0xCF, 0xE0, 0x3E, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0x83, 0xF8,
  0x7C, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xF8, 0x03, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x7E, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x40, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x0E, 0x00, 0x3F, 0x87, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0xF1, 0xF8, 0xFB, 0xC3, 0xE1, 0xEF, 0x0F, 0x87, 0xBC, 0x3E,
  0x1F, 0xF0, 0x78, 0x7F, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F,
  0xF0, 0x78, 0x7F, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x0F, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xE3, 0xFD, 0xF0, 0x1F, 0xBE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0xFE, 0x3F, 0x01, 0xF9, 0xF0, 0x07,
  0xDF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0xFC, 0x7E, 0x0F, 0xE3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00,
  0x0F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFE, 0x1F,
  0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF,
  0xE0, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xBF, 0xE0,
  0xF8, 0x20, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xC3, 0xF7, 0xF0, 0x1F, 0x7E,
  0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01, 0xF7, 0xF0, 0x7F, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xDF, 0x00, 0xC1, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x07, 0xFF, 0x5F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xE0, 0x38, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0x00, 0x7D, 0x00, 0x0F, 0xB8, 0x03, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x30, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x40, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0x7D, 0xF8, 0x0F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x02, 0x80, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0xC0, 0x3E, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x07, 0x83, 0xDE, 0x1F, 0x0F, 0xBC, 0x3E, 0x1F, 0x78, 0x7E, 0x3C,
  0xF0, 0xFC, 0x79, 0xE3, 0xF8, 0xF3, 0xC7, 0x71, 0xE7, 0x8E, 0xF3, 0xC7,
  0xBD, 0xE7, 0x8F, 0x71, 0xCE, 0x1E, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0x80, 0x3C, 0x00, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0x7C,
  0x07, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0xFB,
  0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xE0, 0x7C, 0x07, 0xC1,
  0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xE0,
  0x0F, 0x8F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x38, 0xFF, 0x80, 0xF7, 0xFF,
  0x87, 0x9F, 0xFF, 0xFE, 0xF8, 0xFF, 0xFB, 0xC1, 0xFF, 0xCE, 0x01, 0xFE,
  0x08, 0x01, 0xE0,
};

const GFXglyph UbuntuSansMono_Medium45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 32, 25, 9, -31 },
  { 29, 14, 13, 25, 6, -34 },
  { 52, 23, 31, 25, 1, -31 },
  { 142, 21, 40, 25, 2, -35 },
  { 247, 23, 33, 25, 1, -32 },
  { 342, 23, 32, 25, 1, -32 },
  { 434, 5, 14, 25, 10, -34 },
  { 443, 15, 44, 25, 5, -36 },
  { 526, 15, 44, 25, 5, -36 },
  { 609, 20, 19, 25, 3, -31 },
  { 657, 21, 22, 25, 2, -24 },
  { 715, 11, 15, 25, 7, -8 },
  { 736, 12, 5, 25, 7, -15 },
  { 744, 8, 9, 25, 9, -8 },
  { 753, 19, 43, 25, 3, -35 },
  { 856, 21, 33, 25, 2, -32 },
  { 943, 20, 31, 25, 3, -31 },
  { 1021, 20, 32, 25, 3, -32 },
  { 1101, 19, 33, 25, 3, -32 },
  { 1180, 22, 31, 25, 2, -31 },
  { 1266, 19, 32, 25, 3, -31 },
  { 1342, 20, 32, 25, 3, -31 },
  { 1422, 20, 31, 25, 3, -31 },
  { 1500, 21, 33, 25, 2, -32 },
  { 1587, 21, 32, 25, 2, -32 },
  { 1671, 8, 25, 25, 9, -24 },
  { 1696, 11, 31, 25, 6, -24 },
  { 1739, 21, 21, 25, 2, -23 },
  { 1795, 21, 14, 25, 2, -20 },
  { 1832, 21, 21, 25, 2, -23 },
  { 1888, 17, 33, 25, 4, -32 },
  { 1959, 22, 39, 25, 2, -32 },
  { 2067, 25, 31, 25, 0, -31 },
  { 2164, 20, 32, 25, 3, -32 },
  { 2244, 21, 33, 25, 2, -32 },
  { 2331, 20, 32, 25, 3, -32 },
  { 2411, 19, 31, 25, 4, -31 },
  { 2485, 18, 31, 25, 4, -31 },
  { 2555, 21, 33, 25, 2, -32 },
  { 2642, 21, 31, 25, 2, -31 },
  { 2724, 17, 31, 25, 4, -31 },
  { 2790, 20, 32, 25, 2, -31 },
  { 2870, 22, 31, 25, 3, -31 },
  { 2956, 19, 31, 25, 4, -31 },
  { 3030, 23, 31, 25, 1, -31 },
  { 3120, 20, 31, 25, 3, -31 },
  { 3198, 23, 33, 25, 1, -32 },
  { 3293, 20, 32, 25, 3, -32 },
  { 3373, 23, 40, 25, 1, -32 },
  { 3488, 21, 32, 25, 3, -32 },
  { 3572, 21, 33, 25, 2, -32 },
  { 3659, 21, 31, 25, 2, -31 },
  { 3741, 21, 32, 25, 2, -31 },
  { 3825, 24, 31, 25, 1, -31 },
  { 3918, 23, 31, 25, 1, -31 },
  { 4008, 23, 31, 25, 1, -31 },
  { 4098, 24, 31, 25, 1, -31 },
  { 4191, 20, 31, 25, 3, -31 },
  { 4269, 12, 43, 25, 7, -35 },
  { 4334, 19, 43, 25, 3, -35 },
  { 4437, 13, 43, 25, 6, -35 },
  { 4507, 22, 17, 25, 2, -31 },
  { 4554, 25, 4, 25, 0, 4 },
  { 4567, 10, 9, 25, 8, -35 },
  { 4579, 19, 25, 25, 3, -24 },
  { 4639, 20, 36, 25, 3, -35 },
  { 4729, 21, 25, 25, 2, -24 },
  { 4795, 20, 36, 25, 2, -35 },
  { 4885, 21, 25, 25, 2, -24 },
  { 4951, 22, 35, 25, 3, -35 },
  { 5048, 20, 32, 25, 2, -24 },
  { 5128, 19, 35, 25, 3, -35 },
  { 5212, 21, 35, 25, 2, -34 },
  { 5304, 17, 43, 25, 3, -34 },
  { 5396, 21, 35, 25, 3, -35 },
  { 5488, 21, 36, 25, 2, -35 },
  { 5583, 22, 24, 25, 2, -24 },
  { 5649, 19, 24, 25, 3, -24 },
  { 5706, 21, 25, 25, 2, -24 },
  { 5772, 20, 32, 25, 3, -24 },
  { 5852, 20, 32, 25, 2, -24 },
  { 5932, 18, 24, 25, 5, -24 },
  { 5986, 19, 25, 25, 3, -24 },
  { 6046, 20, 32, 25, 3, -31 },
  { 6126, 19, 24, 25, 3, -23 },
  { 6183, 23, 23, 25, 1, -23 },
  { 6250, 23, 23, 25, 1, -23 },
  { 6317, 23, 23, 25, 1, -23 },
  { 6384, 22, 31, 25, 1, -23 },
  { 6470, 18, 23, 25, 4, -23 },
  { 6522, 18, 43, 25, 4, -35 },
  { 6619, 5, 43, 25, 10, -35 },
  { 6646, 19, 43, 25, 3, -35 },
  { 6749, 22, 8, 25, 2, -17 },
};

const GFXfont UbuntuSansMono_Medium45pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium45pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium45pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UBUNTUSANSMONO_MEDIUM45PT7B_H_
