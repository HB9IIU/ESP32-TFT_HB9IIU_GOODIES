#ifndef _UBUNTUSANSMONO_MEDIUM27PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium27pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x00, 0x0E, 0xFF,
  0xDC, 0xE3, 0xF1, 0xF8, 0xFC, 0x76, 0x3B, 0x1D, 0x8C, 0xC6, 0x0E, 0x30,
  0x71, 0x83, 0x1C, 0x18, 0xE1, 0xC7, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x18,
  0xE1, 0xC7, 0x0E, 0x30, 0x71, 0x8F, 0xFF, 0xFF, 0xFC, 0xC7, 0x0E, 0x38,
  0x71, 0x83, 0x8C, 0x18, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0xC3,
  0xFF, 0x3F, 0xF9, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x7B, 0x03, 0x9F, 0xFD,
  0xFF, 0xC0, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x3C, 0x0E, 0xF8, 0x39,
  0x98, 0x67, 0x31, 0xCE, 0x63, 0x1C, 0xCC, 0x19, 0xB8, 0x3F, 0x60, 0x3D,
  0x80, 0x07, 0x00, 0x0C, 0xE0, 0x3B, 0xE0, 0x6E, 0xC1, 0x98, 0xC7, 0x31,
  0x8C, 0x63, 0x30, 0xCE, 0xE1, 0xFB, 0x81, 0xF0, 0x1F, 0x01, 0xFC, 0x0E,
  0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xCE, 0x07, 0xF0, 0x1F, 0x01, 0xF1,
  0x9F, 0x8C, 0xEE, 0x6E, 0x3F, 0x70, 0xFB, 0x83, 0x9C, 0x1E, 0xF1, 0xF3,
  0xFD, 0xCF, 0xCE, 0xFF, 0xFF, 0xFF, 0x60, 0x03, 0x03, 0xC3, 0xC3, 0xC1,
  0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0x80, 0x60, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xE0,
  0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0x20, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x0C,
  0xE6, 0xF7, 0xEF, 0xFF, 0x0E, 0x01, 0xF0, 0x3B, 0x87, 0xBC, 0x31, 0x81,
  0x10, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x08, 0x78, 0xF1, 0xF3, 0xC1, 0x87, 0x7C, 0xF0, 0xFF, 0xFF, 0xF8, 0x23,
  0xFF, 0xF7, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x00, 0x0F, 0x80, 0xFF, 0x0F, 0x78, 0xF0, 0xE7, 0x07, 0x38,
  0x1B, 0x80, 0xFC, 0x47, 0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xC0, 0x7E, 0x03,
  0xB8, 0x19, 0xC1, 0xCE, 0x0E, 0x38, 0xE1, 0xFF, 0x07, 0xF0, 0x03, 0x00,
  0x70, 0x1F, 0x07, 0xF0, 0xFF, 0x0E, 0x70, 0x87, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF0, 0x3F, 0x0F, 0xFC, 0xFF, 0xCC, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xF3, 0xFF,
  0x20, 0xF0, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x1F, 0x83, 0xF0, 0x1F, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xC3, 0xFF, 0xFB, 0xFE, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0x70, 0x73, 0x83, 0x1C,
  0x38, 0xE3, 0x87, 0x1C, 0x39, 0xC1, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x3F, 0xE7, 0xFD, 0xFF, 0xB8, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0xC3, 0xFF, 0xFB, 0xFE, 0x00, 0x01, 0xC0, 0x7E,
  0x1F, 0xE3, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0xF0, 0xFF, 0xCF, 0xFE,
  0xE0, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0x71, 0xE7, 0xFC,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0x7C,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCF, 0x1C, 0x3F, 0xE0, 0xFE, 0x0E,
  0xF8, 0xE1, 0xE7, 0x07, 0xF0, 0x1F, 0x80, 0xEE, 0x07, 0x78, 0xF3, 0xFF,
  0x87, 0xF0, 0x0F, 0x81, 0xFF, 0x1E, 0x78, 0xE0, 0xE7, 0x07, 0x70, 0x3B,
  0x80, 0xEE, 0x07, 0x70, 0x3B, 0xFF, 0xCF, 0xFC, 0x1F, 0xE0, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x3F, 0x81, 0xF8, 0x0F, 0x00, 0x23, 0xFF, 0xF7,
  0x00, 0x00, 0x00, 0x08, 0xFF, 0xFD, 0xC0, 0x10, 0xF7, 0xDF, 0x38, 0x00,
  0x00, 0x00, 0x01, 0x0F, 0x7D, 0xF3, 0xC7, 0x3B, 0xCE, 0x00, 0x00, 0x10,
  0x03, 0xC0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7E, 0x03, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x7E, 0x00, 0x60, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x40, 0x03, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7C, 0x01, 0xE0, 0x7F, 0x0F, 0xE3,
  0xF8, 0x3F, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x3F, 0x1F, 0xF9, 0xCF, 0x00,
  0xF0, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0xC0,
  0xFF, 0x0F, 0x1C, 0x60, 0x77, 0x03, 0xB0, 0x1F, 0x87, 0xFC, 0x7F, 0xE7,
  0xBF, 0x39, 0xFB, 0x8F, 0xDC, 0x7E, 0xE3, 0xF7, 0x1F, 0x9C, 0xFC, 0xFF,
  0x63, 0xFB, 0x87, 0x9C, 0x00, 0x70, 0x01, 0xE1, 0x07, 0xF8, 0x0F, 0xC0,
  0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x36, 0x00, 0xEE, 0x01, 0xDC, 0x03,
  0x18, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x60, 0xE1, 0xC1, 0xC3, 0xFF,
  0x87, 0xFF, 0x1C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x3B, 0x80, 0x38,
  0xFF, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C,
  0xFF, 0x8F, 0xFC, 0xE7, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xE3, 0xEF, 0xFC, 0xFF, 0x80, 0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0x70, 0x17,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x3E, 0x30, 0xFF, 0xC3, 0xFC,
  0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x1E,
  0xE7, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xCF, 0xFC, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB,
  0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xDC, 0x70, 0x27, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x1D,
  0xC0, 0xEF, 0x07, 0x3C, 0x38, 0xFF, 0xC3, 0xFE, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x74, 0x0F, 0x71, 0xEF, 0xFE, 0x3F, 0x80, 0xE0,
  0x77, 0x07, 0x38, 0x79, 0xC3, 0x8E, 0x38, 0x73, 0xC3, 0xBC, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xDE, 0x0E, 0x78, 0x71, 0xE3, 0x87, 0x1C,
  0x3C, 0xE0, 0xF7, 0x03, 0xB8, 0x1E, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0xF1, 0xE7, 0x8F, 0x3C, 0x7D, 0xB6, 0xFD, 0xB7, 0xED, 0xBF,
  0x3D, 0xF9, 0xCF, 0xCE, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7F,
  0x87, 0xDC, 0x7C, 0xC7, 0xCE, 0x7C, 0x67, 0xC7, 0x7C, 0x37, 0xC3, 0x7C,
  0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x70, 0x0F, 0x81, 0xFF,
  0x1F, 0x7C, 0xE0, 0xE7, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xEE, 0x0E, 0x78,
  0xF1, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x3E, 0xFF, 0xCF, 0xF8, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x81, 0xFF,
  0x0F, 0xFC, 0xE0, 0xE7, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xEE, 0x0E, 0x78,
  0xF1, 0xFF, 0x07, 0xF0, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x06,
  0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE1, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x0E,
  0xE0, 0xEE, 0x0F, 0xE0, 0x70, 0x0F, 0xE1, 0xFF, 0x9F, 0x38, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x70, 0xF3, 0xFF, 0xBF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xEE, 0x0E, 0x78, 0xF1, 0xFF,
  0x07, 0xF0, 0xF0, 0x0E, 0xE0, 0x3D, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xC7,
  0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x60, 0x71, 0xC0, 0xE3,
  0x80, 0xC6, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x60, 0x07, 0xC0, 0x0F, 0x80,
  0x0E, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xFB, 0x6F, 0xDB, 0x7E, 0xDB, 0xBC,
  0x7D, 0xE3, 0xCF, 0x1E, 0x78, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0x39, 0xC1,
  0xE7, 0x07, 0x0E, 0x38, 0x38, 0xE0, 0x77, 0x01, 0xDC, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0xF8, 0x07, 0x70, 0x1D, 0xC0, 0xE3, 0x83, 0x8E, 0x1C,
  0x1C, 0x70, 0x73, 0x80, 0xEE, 0x03, 0xC0, 0xF0, 0x1E, 0xE0, 0x39, 0xC0,
  0x71, 0xC1, 0xC3, 0x83, 0x83, 0x87, 0x07, 0x1C, 0x07, 0x38, 0x0E, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x3C, 0x03, 0xE0, 0x3F, 0x81, 0xDC,
  0x1E, 0x70, 0xE3, 0xCE, 0x0E, 0x70, 0x7F, 0x01, 0xC8, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x43, 0x8F, 0x0F, 0x18, 0x7F, 0x8F, 0xF9, 0x07,
  0x80, 0x70, 0x0E, 0x0F, 0xDF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xF8,
  0x7F, 0xFE, 0x7F, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xF8, 0xFF, 0xCF, 0x1E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xE3, 0xEF, 0xFC, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x8F, 0x04, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0x21, 0xFF, 0x87, 0xFC, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x71, 0xFF, 0x3F,
  0xF7, 0x8F, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x77, 0x07, 0x7C, 0x73, 0xFF, 0x1F, 0xF0, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C,
  0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xFC, 0x63, 0xFF, 0x07, 0xF8, 0x03, 0xF0, 0x7F, 0xC7, 0xFC, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1F, 0xFC, 0xFF, 0xE0, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x1F, 0xF3, 0xFF, 0x78, 0x77, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x78, 0xF3, 0xFF, 0x1F,
  0xF0, 0x07, 0x00, 0x70, 0x0F, 0x7F, 0xE7, 0xFC, 0x7F, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFC, 0xFF, 0xDE, 0x7F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0E, 0x0C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE6, 0x0F, 0xF0,
  0x3F, 0x80, 0x03, 0x01, 0xE0, 0x78, 0x1E, 0x01, 0x00, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x3F, 0xFE, 0xFF, 0x9F, 0x80, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1E,
  0xE1, 0xE7, 0x1E, 0x39, 0xE1, 0xDE, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x1D,
  0xE0, 0xE7, 0x87, 0x1E, 0x38, 0x79, 0xC1, 0xEE, 0x07, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE6, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0xF7, 0xFF,
  0xF9, 0xCF, 0xCE, 0x7E, 0x71, 0xF3, 0x8F, 0x9C, 0x7C, 0xE3, 0xE7, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0C, 0xFF, 0x9F, 0xFB, 0x8F,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xC0, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xEF, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xDC, 0x1C, 0xF1, 0xE3,
  0xFE, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEF, 0x9E, 0xFF, 0xCF, 0xF8,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x78,
  0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x70,
  0x77, 0x9F, 0x3F, 0xF1, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x7F, 0xFF, 0xFB, 0xE3, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x3F, 0xEF, 0xFB,
  0xC1, 0x70, 0x0F, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xE0, 0x1C, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xE3, 0x1F, 0xF0, 0xFF, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xBC,
  0x77, 0xFE, 0x7F, 0xC0, 0xE0, 0x3F, 0x01, 0xFC, 0x0E, 0xE0, 0xE7, 0x07,
  0x1C, 0x78, 0xE3, 0x87, 0x1C, 0x1D, 0xC0, 0xEE, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0x80, 0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x33, 0x1C, 0x67, 0x38,
  0xCE, 0x71, 0x9C, 0xF7, 0x3B, 0x6E, 0x36, 0xDC, 0x6D, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x83, 0x07, 0x00, 0xF0, 0x7B, 0x83, 0x8E, 0x38, 0x3B,
  0xC1, 0xFC, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x1F, 0xC0, 0xEF, 0x0E, 0x38,
  0xE0, 0xE7, 0x07, 0xF0, 0x1C, 0xF0, 0x3B, 0x81, 0xDC, 0x1C, 0xF0, 0xE3,
  0x87, 0x1C, 0x38, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x78, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0xFE, 0x07, 0xE0, 0x3E, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE1, 0xFC, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x1E,
  0x0F, 0x81, 0xF0, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x78, 0x0F, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x3E,
  0x07, 0xC1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0xFE, 0x1F, 0x80, 0x3E, 0x1B, 0xF9, 0xF9, 0xFF, 0x83,
  0xE0,
};

const GFXglyph UbuntuSansMono_Medium27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 19, 15, 5, -19 },
  { 13, 9, 8, 15, 3, -21 },
  { 22, 13, 19, 15, 1, -19 },
  { 53, 13, 24, 15, 1, -21 },
  { 92, 15, 19, 15, 0, -19 },
  { 128, 13, 19, 15, 1, -19 },
  { 159, 3, 9, 15, 6, -21 },
  { 163, 9, 26, 15, 3, -21 },
  { 193, 9, 26, 15, 3, -21 },
  { 223, 12, 12, 15, 2, -19 },
  { 241, 13, 14, 15, 1, -15 },
  { 264, 7, 9, 15, 4, -5 },
  { 272, 7, 3, 15, 4, -9 },
  { 275, 5, 5, 15, 5, -5 },
  { 279, 11, 26, 15, 2, -21 },
  { 315, 13, 19, 15, 1, -19 },
  { 346, 12, 19, 15, 2, -19 },
  { 375, 12, 19, 15, 2, -19 },
  { 404, 11, 19, 15, 2, -19 },
  { 431, 13, 19, 15, 1, -19 },
  { 462, 11, 19, 15, 2, -19 },
  { 489, 12, 19, 15, 2, -19 },
  { 518, 12, 19, 15, 2, -19 },
  { 547, 13, 19, 15, 1, -19 },
  { 578, 13, 19, 15, 1, -19 },
  { 609, 5, 15, 15, 5, -15 },
  { 619, 6, 19, 15, 4, -15 },
  { 634, 13, 13, 15, 1, -14 },
  { 656, 13, 8, 15, 1, -12 },
  { 669, 13, 13, 15, 1, -14 },
  { 691, 11, 19, 15, 2, -19 },
  { 718, 13, 23, 15, 1, -19 },
  { 756, 15, 19, 15, 0, -19 },
  { 792, 12, 19, 15, 2, -19 },
  { 821, 13, 19, 15, 1, -19 },
  { 852, 12, 19, 15, 2, -19 },
  { 881, 12, 19, 15, 2, -19 },
  { 910, 11, 19, 15, 2, -19 },
  { 937, 13, 19, 15, 1, -19 },
  { 968, 13, 19, 15, 1, -19 },
  { 999, 11, 19, 15, 2, -19 },
  { 1026, 12, 19, 15, 1, -19 },
  { 1055, 13, 19, 15, 2, -19 },
  { 1086, 11, 19, 15, 3, -19 },
  { 1113, 13, 19, 15, 1, -19 },
  { 1144, 12, 19, 15, 2, -19 },
  { 1173, 13, 19, 15, 1, -19 },
  { 1204, 12, 19, 15, 2, -19 },
  { 1233, 13, 24, 15, 1, -19 },
  { 1272, 12, 19, 15, 2, -19 },
  { 1301, 13, 19, 15, 1, -19 },
  { 1332, 13, 19, 15, 1, -19 },
  { 1363, 13, 19, 15, 1, -19 },
  { 1394, 15, 19, 15, 0, -19 },
  { 1430, 13, 19, 15, 1, -19 },
  { 1461, 14, 19, 15, 1, -19 },
  { 1495, 15, 19, 15, 0, -19 },
  { 1531, 12, 19, 15, 2, -19 },
  { 1560, 8, 26, 15, 4, -21 },
  { 1586, 11, 26, 15, 2, -21 },
  { 1622, 8, 26, 15, 3, -21 },
  { 1648, 13, 11, 15, 1, -19 },
  { 1666, 15, 3, 15, 0, 2 },
  { 1672, 6, 5, 15, 5, -21 },
  { 1676, 11, 14, 15, 2, -14 },
  { 1696, 12, 21, 15, 2, -21 },
  { 1728, 13, 14, 15, 1, -14 },
  { 1751, 12, 21, 15, 1, -21 },
  { 1783, 13, 14, 15, 1, -14 },
  { 1806, 13, 21, 15, 2, -21 },
  { 1841, 12, 19, 15, 1, -14 },
  { 1870, 11, 21, 15, 2, -21 },
  { 1899, 13, 21, 15, 1, -21 },
  { 1934, 10, 26, 15, 2, -21 },
  { 1967, 13, 21, 15, 2, -21 },
  { 2002, 13, 21, 15, 1, -21 },
  { 2037, 13, 14, 15, 1, -14 },
  { 2060, 11, 14, 15, 2, -14 },
  { 2080, 13, 14, 15, 1, -14 },
  { 2103, 12, 19, 15, 2, -14 },
  { 2132, 12, 19, 15, 1, -14 },
  { 2161, 11, 14, 15, 3, -14 },
  { 2181, 11, 14, 15, 2, -14 },
  { 2201, 12, 18, 15, 2, -18 },
  { 2228, 11, 14, 15, 2, -14 },
  { 2248, 13, 14, 15, 1, -14 },
  { 2271, 15, 14, 15, 0, -14 },
  { 2298, 13, 14, 15, 1, -14 },
  { 2321, 13, 19, 15, 1, -14 },
  { 2352, 11, 14, 15, 2, -14 },
  { 2372, 11, 26, 15, 2, -21 },
  { 2408, 3, 26, 15, 6, -21 },
  { 2418, 11, 26, 15, 2, -21 },
  { 2454, 13, 4, 15, 1, -10 },
};

const GFXfont UbuntuSansMono_Medium27pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium27pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUSANSMONO_MEDIUM27PT7B_H_
