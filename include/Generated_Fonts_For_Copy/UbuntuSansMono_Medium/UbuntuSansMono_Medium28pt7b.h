#ifndef _UBUNTUSANSMONO_MEDIUM28PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xE6, 0x00, 0x0F, 0xFF, 0xF0, 0xF3,
  0xF9, 0xDC, 0xEC, 0x76, 0x3B, 0x1D, 0x86, 0xC3, 0x0E, 0x38, 0x38, 0xE0,
  0xE3, 0x03, 0x1C, 0x0C, 0x73, 0xFF, 0xFF, 0xFF, 0xC7, 0x18, 0x18, 0xE0,
  0xE3, 0x83, 0x8E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0x1C, 0x1C, 0x70,
  0x71, 0xC1, 0xC7, 0x07, 0x38, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x81, 0xFF, 0x1F, 0xF9, 0xE0, 0x4E, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xD8,
  0x1E, 0xFF, 0xEF, 0xFE, 0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xFC, 0x1D, 0x98, 0x73, 0x30, 0xCE, 0x63, 0x9C, 0xC6, 0x19, 0x98,
  0x33, 0x70, 0x7E, 0xC0, 0x73, 0x80, 0x0E, 0x00, 0x19, 0xE0, 0x77, 0xE0,
  0xCC, 0xC3, 0x39, 0x8E, 0x63, 0x18, 0xE6, 0x61, 0xCD, 0xC1, 0xFF, 0x01,
  0xE0, 0x0F, 0x00, 0x7E, 0x03, 0xFC, 0x1C, 0x30, 0x70, 0xE1, 0xC3, 0x07,
  0x1C, 0x0E, 0xE0, 0x3F, 0x80, 0x78, 0x83, 0xE3, 0x9D, 0xCE, 0xE7, 0xBB,
  0x8F, 0xCE, 0x1F, 0x38, 0x3C, 0xE0, 0xF3, 0xCF, 0xE7, 0xFB, 0x8F, 0xC7,
  0xFF, 0xFF, 0xDB, 0x01, 0x01, 0xC1, 0xE1, 0xE1, 0xE1, 0xE0, 0xE0, 0xF0,
  0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C,
  0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x40, 0x60, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x78,
  0x78, 0x78, 0x78, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0x86, 0x2E, 0x6F, 0xFF,
  0xF7, 0xFE, 0x0F, 0x01, 0xF8, 0x3B, 0xC7, 0x9E, 0x31, 0x80, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x7C, 0xF9,
  0xF3, 0xE1, 0xC7, 0x7C, 0x70, 0x80, 0xFF, 0xFF, 0xFF, 0x33, 0xFF, 0xF7,
  0x80, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xFF, 0x0F, 0xFC, 0x70,
  0xE7, 0x07, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE3, 0x3F, 0x3D, 0xF9, 0xEF,
  0xC6, 0x7E, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x78, 0x71, 0xE7, 0x8F,
  0xF8, 0x1F, 0x80, 0x07, 0x00, 0xF0, 0x3F, 0x0F, 0xF0, 0xF7, 0x04, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1F, 0x07, 0xFC, 0xFF,
  0xEE, 0x1E, 0x40, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0x0F, 0xFC, 0xFF, 0xC4, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xFE, 0x3E, 0xFF, 0xCF, 0xF8, 0x00, 0xF0, 0x07, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3B, 0xC1, 0xCF, 0x0E, 0x3C, 0x38, 0xF1,
  0xC3, 0xC7, 0x0F, 0x38, 0x3C, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xE3, 0xFE, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xF0, 0x7F, 0xC1, 0xFE, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0xE3, 0xEF, 0xFC, 0xFF, 0x80, 0x00,
  0x20, 0x3E, 0x0F, 0xE1, 0xF0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xFF,
  0x8F, 0xFE, 0xFB, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0xF7, 0x9E, 0x7F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x80,
  0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x03, 0xB8, 0x1D, 0xC0, 0xEF, 0x0E, 0x3C,
  0xF0, 0xFF, 0x07, 0xF8, 0x73, 0xE7, 0x07, 0xB8, 0x1F, 0x80, 0xFC, 0x07,
  0x70, 0x3B, 0xC7, 0xCF, 0xFC, 0x3F, 0xC0, 0x1F, 0x03, 0xFC, 0x7F, 0xEF,
  0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x7F, 0xF3,
  0xFF, 0x06, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x07, 0xC7, 0xF8, 0x7E, 0x07,
  0x80, 0x33, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x0C, 0xFF, 0xFD, 0xE0, 0x18,
  0xF7, 0xDF, 0x3C, 0x00, 0x00, 0x00, 0x01, 0x8F, 0x7D, 0xF3, 0xC7, 0x1F,
  0xEF, 0x20, 0x00, 0x38, 0x07, 0xC1, 0xFE, 0x3F, 0x87, 0xF0, 0x7C, 0x03,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x70, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3C, 0x01,
  0xE0, 0x7F, 0x0F, 0xE7, 0xF8, 0x1F, 0x00, 0xE0, 0x00, 0x3E, 0x3F, 0xEF,
  0xFE, 0x0F, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x70,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x07, 0xC0,
  0x3F, 0xC1, 0xFF, 0x0E, 0x0E, 0x70, 0x19, 0xC0, 0x76, 0x0F, 0xF8, 0xFF,
  0xE7, 0xFF, 0x9C, 0x7E, 0x71, 0xF9, 0x87, 0xE6, 0x1F, 0x98, 0x7E, 0x71,
  0xF9, 0xC7, 0xE7, 0xFD, 0x8F, 0xF7, 0x0F, 0x9C, 0x00, 0x38, 0x00, 0x78,
  0x20, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x37, 0x00,
  0xEE, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x38, 0x38, 0x70, 0x60,
  0xE1, 0xC1, 0xC3, 0xFF, 0xC7, 0xFF, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x0E,
  0xE0, 0x1F, 0xC0, 0x38, 0x3C, 0x0F, 0xF8, 0xFF, 0xEE, 0x1E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE7, 0xCF, 0xF8, 0xFF, 0xEE, 0x1F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x7F, 0xFF, 0xEF, 0xF8, 0x03, 0xE0,
  0x3F, 0xE1, 0xFF, 0x8F, 0x06, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xFC, 0xE1, 0xFF, 0x83, 0xFF, 0x3C, 0x07, 0xFC,
  0x3F, 0xF1, 0xC7, 0xCE, 0x0E, 0x70, 0x7B, 0x81, 0xDC, 0x0E, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xE1,
  0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x78, 0x37, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x0F, 0xC0, 0x7F,
  0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x78, 0x39, 0xF1, 0xC7, 0xFE, 0x1F,
  0xF0, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xFF, 0xFF, 0xFC, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xE7, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0xF3, 0xFF, 0xF9,
  0xFE, 0x00, 0xE0, 0x7F, 0x07, 0x38, 0x79, 0xC7, 0x8E, 0x38, 0x73, 0xC3,
  0xBC, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3B, 0xC1, 0xCF, 0x0E, 0x3C, 0x71,
  0xE3, 0x87, 0x9C, 0x1E, 0xE0, 0x77, 0x03, 0xF8, 0x0E, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x3E, 0x78, 0xD9, 0xB3, 0x66, 0xCD,
  0xBB, 0x66, 0xE7, 0x9B, 0x9E, 0x6E, 0x79, 0xB9, 0xC6, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7D, 0xC7, 0xDC, 0x7C, 0xE7, 0xCE, 0x7C,
  0x77, 0xC7, 0x7C, 0x37, 0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x70, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1C, 0x70, 0x3B,
  0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0x9C, 0x0E, 0x70, 0x79, 0xF3, 0xC3, 0xFE,
  0x07, 0xF0, 0x1E, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3B,
  0x81, 0xFC, 0x0E, 0xE0, 0x77, 0x07, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1C, 0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x03, 0x9C, 0x0E, 0x70, 0x79, 0xE3, 0xC3, 0xFF, 0x07, 0xF0, 0x07, 0x00,
  0x0E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x78, 0x3C, 0x07, 0xFC, 0x3F, 0xF1,
  0xC3, 0xCE, 0x0E, 0x70, 0x7B, 0x81, 0xDC, 0x1E, 0xE0, 0xE7, 0x0F, 0x3F,
  0xF1, 0xFF, 0x0F, 0xF8, 0x71, 0xC3, 0x87, 0x1C, 0x3C, 0xE0, 0xE7, 0x07,
  0xB8, 0x1D, 0xC0, 0xF0, 0x0F, 0x83, 0xFE, 0x7F, 0xEF, 0x02, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x7F, 0x1F, 0xFF, 0xE7, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x0F, 0x7C, 0xF1,
  0xFF, 0x87, 0xF8, 0xF0, 0x0E, 0xE0, 0x1D, 0xC0, 0x7B, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xC0,
  0x73, 0x80, 0xE7, 0x01, 0xCC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xB9, 0xC6, 0xE7, 0x9B, 0x9E, 0x6E, 0xF9, 0xBB, 0x76,
  0x6C, 0xD9, 0xF3, 0x67, 0x8D, 0x9E, 0x1E, 0x78, 0x79, 0xC1, 0xE7, 0x03,
  0x80, 0xF0, 0x3D, 0xC1, 0xE3, 0x87, 0x0E, 0x3C, 0x1C, 0xE0, 0x77, 0x00,
  0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x1C, 0xE0,
  0xF3, 0xC3, 0x87, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xC0, 0xF0,
  0x0E, 0xE0, 0x3C, 0xE0, 0x71, 0xC0, 0xE3, 0xC3, 0x83, 0x87, 0x07, 0x9C,
  0x07, 0x38, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0xFF, 0xFF, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF8, 0x1C, 0xE0,
  0xF3, 0xC3, 0x87, 0x1C, 0x1E, 0xF0, 0x3D, 0x80, 0x62, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x41, 0x8F, 0x1E, 0x1C, 0x20, 0x3F, 0x87,
  0xFC, 0x7F, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x1F, 0xF7, 0xFF, 0xF8, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xF8, 0x77, 0xFF, 0x3F, 0xF0, 0x20, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1D, 0xF0, 0xFF, 0xC7,
  0xFF, 0x38, 0x3D, 0xC0, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x77, 0x03, 0xB8, 0x3D, 0xE7, 0xCF, 0xFC, 0x7F, 0xC0, 0x07, 0xF0, 0xFF,
  0xCF, 0xFE, 0xF8, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xF1, 0x8F, 0xFC, 0x3F, 0xE0, 0x00, 0x10,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0x3F, 0xF7,
  0xFF, 0x78, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0x07, 0x70, 0x77, 0xE7, 0x3F, 0xF1, 0xFF, 0x07, 0xC0, 0xFF, 0x0F, 0xFC,
  0xF0, 0xF7, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xE7, 0x1F, 0xF8, 0x3F, 0xC0, 0x01, 0xE0, 0x3F, 0xC3,
  0xFE, 0x3C, 0x11, 0xC0, 0x0E, 0x00, 0x70, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF,
  0x87, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0xE0, 0xFF, 0xCF,
  0xFE, 0xF0, 0xF7, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83,
  0xDC, 0x1E, 0xF9, 0xF3, 0xFF, 0x8F, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0x73,
  0xDF, 0x9F, 0xF8, 0xFF, 0x80, 0x20, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0xE0, 0xEE, 0x0E, 0xE0,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x0E, 0x00, 0xF8, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xF6, 0x0F, 0xF0, 0x3F,
  0x80, 0x03, 0x81, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1D, 0xDF, 0xFF, 0x9F, 0xC0, 0x20, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F, 0xE0,
  0xF7, 0x0F, 0x38, 0xF1, 0xCF, 0x0E, 0xF0, 0x7F, 0x03, 0xF8, 0x1D, 0xE0,
  0xE7, 0x87, 0x1E, 0x38, 0x79, 0xC1, 0xCE, 0x07, 0x70, 0x3C, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xB0, 0x7F, 0x81, 0xFC, 0x7C, 0xE3,
  0xFF, 0xEF, 0xFF, 0xB9, 0xC6, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7,
  0xE3, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xC0, 0x7F, 0x8F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70,
  0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xEE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xEF, 0x03, 0x9C, 0x1E, 0x7C, 0xF0, 0xFF,
  0x81, 0xFC, 0x00, 0x7F, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x0F, 0xE0, 0x7F, 0x03, 0xB8, 0x1D, 0xC1, 0xEF, 0x9E,
  0x7F, 0xF3, 0xFF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x07, 0xE0, 0xFF, 0xCF, 0xFE, 0xF0, 0xF7, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1E, 0xE0, 0xF7, 0xDF, 0x9F, 0xFC, 0x7F,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1F, 0xC7, 0xFE, 0x7F, 0xEF, 0x00,
  0xE0, 0x0F, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0xF1, 0xEF, 0xFE, 0x7F, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0x30, 0xFF, 0x07, 0xF0, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFF, 0x0F, 0x7C, 0xF7, 0xFF, 0x3F, 0xF0, 0xE0, 0x1F, 0x80,
  0xFF, 0x03, 0x9C, 0x0E, 0x70, 0x79, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x3C,
  0xE0, 0x73, 0x81, 0xDC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0xC0, 0x1D, 0x80, 0x3B, 0x80, 0x77, 0x18, 0xEE, 0x79, 0xDC,
  0xF3, 0x39, 0xE6, 0x77, 0xCC, 0x6D, 0xD8, 0xD9, 0xF1, 0xF3, 0xE3, 0xC7,
  0x87, 0x87, 0x06, 0x0E, 0x00, 0xE0, 0x3D, 0xC0, 0xE7, 0x87, 0x0F, 0x38,
  0x1D, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xCE,
  0x0E, 0x3C, 0x78, 0x71, 0xC0, 0xEE, 0x03, 0xC0, 0xF0, 0x3D, 0xC0, 0xE7,
  0x03, 0x9E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x07, 0x1C, 0x1C, 0xE0,
  0x7B, 0x80, 0xEE, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x02, 0x7C, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0xFC, 0x0F, 0x80, 0xFC, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xFF, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x1F,
  0xC3, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x3E, 0x03, 0xC0, 0xF8, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x1F, 0xC3, 0xF0, 0x00,
  0x18, 0x11, 0xF8, 0x77, 0xFF, 0xB8, 0xFE, 0xC1, 0xF0,
};

const GFXglyph UbuntuSansMono_Medium28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 9, 8, 16, 3, -21 },
  { 20, 14, 19, 16, 1, -19 },
  { 54, 13, 25, 16, 1, -22 },
  { 95, 15, 20, 16, 0, -20 },
  { 133, 14, 20, 16, 1, -20 },
  { 168, 3, 8, 16, 6, -21 },
  { 171, 9, 27, 16, 3, -22 },
  { 202, 9, 27, 16, 3, -22 },
  { 233, 12, 11, 16, 2, -19 },
  { 250, 13, 14, 16, 1, -15 },
  { 273, 7, 10, 16, 4, -5 },
  { 282, 8, 3, 16, 4, -9 },
  { 285, 5, 5, 16, 5, -5 },
  { 289, 12, 27, 16, 2, -22 },
  { 330, 13, 20, 16, 1, -20 },
  { 363, 12, 19, 16, 2, -19 },
  { 392, 12, 20, 16, 2, -20 },
  { 422, 12, 20, 16, 2, -20 },
  { 452, 14, 19, 16, 1, -19 },
  { 486, 12, 19, 16, 2, -19 },
  { 515, 12, 20, 16, 2, -20 },
  { 545, 12, 19, 16, 2, -19 },
  { 574, 13, 20, 16, 1, -20 },
  { 607, 12, 20, 16, 2, -20 },
  { 637, 5, 15, 16, 5, -15 },
  { 647, 6, 20, 16, 4, -15 },
  { 662, 13, 12, 16, 1, -14 },
  { 682, 13, 9, 16, 1, -13 },
  { 697, 13, 12, 16, 1, -14 },
  { 717, 10, 20, 16, 3, -20 },
  { 742, 14, 24, 16, 1, -20 },
  { 784, 15, 19, 16, 0, -19 },
  { 820, 12, 20, 16, 2, -20 },
  { 850, 14, 20, 16, 1, -20 },
  { 885, 13, 20, 16, 2, -20 },
  { 918, 12, 19, 16, 2, -19 },
  { 947, 12, 19, 16, 2, -19 },
  { 976, 13, 20, 16, 1, -20 },
  { 1009, 13, 19, 16, 1, -19 },
  { 1040, 11, 19, 16, 2, -19 },
  { 1067, 11, 19, 16, 2, -19 },
  { 1094, 13, 19, 16, 2, -19 },
  { 1125, 11, 19, 16, 3, -19 },
  { 1152, 14, 19, 16, 1, -19 },
  { 1186, 12, 19, 16, 2, -19 },
  { 1215, 14, 20, 16, 1, -20 },
  { 1250, 13, 20, 16, 2, -20 },
  { 1283, 14, 25, 16, 1, -20 },
  { 1327, 13, 20, 16, 2, -20 },
  { 1360, 12, 20, 16, 2, -20 },
  { 1390, 14, 19, 16, 1, -19 },
  { 1424, 13, 19, 16, 1, -19 },
  { 1455, 15, 19, 16, 0, -19 },
  { 1491, 14, 19, 16, 1, -19 },
  { 1525, 14, 19, 16, 1, -19 },
  { 1559, 15, 19, 16, 0, -19 },
  { 1595, 12, 19, 16, 2, -19 },
  { 1624, 8, 27, 16, 4, -22 },
  { 1651, 12, 27, 16, 2, -22 },
  { 1692, 8, 27, 16, 4, -22 },
  { 1719, 14, 11, 16, 1, -19 },
  { 1739, 15, 3, 16, 0, 2 },
  { 1745, 6, 6, 16, 5, -22 },
  { 1750, 12, 15, 16, 2, -15 },
  { 1773, 13, 22, 16, 2, -22 },
  { 1809, 13, 15, 16, 1, -15 },
  { 1834, 12, 22, 16, 1, -22 },
  { 1867, 13, 15, 16, 1, -15 },
  { 1892, 13, 22, 16, 2, -22 },
  { 1928, 13, 20, 16, 1, -15 },
  { 1961, 12, 22, 16, 2, -22 },
  { 1994, 13, 21, 16, 1, -21 },
  { 2029, 10, 26, 16, 2, -21 },
  { 2062, 13, 22, 16, 2, -22 },
  { 2098, 13, 22, 16, 1, -22 },
  { 2134, 14, 15, 16, 1, -15 },
  { 2161, 12, 15, 16, 2, -15 },
  { 2184, 14, 15, 16, 1, -15 },
  { 2211, 13, 20, 16, 2, -15 },
  { 2244, 13, 20, 16, 1, -15 },
  { 2277, 11, 15, 16, 3, -15 },
  { 2298, 12, 15, 16, 2, -15 },
  { 2321, 12, 19, 16, 2, -19 },
  { 2350, 12, 15, 16, 2, -15 },
  { 2373, 14, 15, 16, 1, -15 },
  { 2400, 15, 15, 16, 0, -15 },
  { 2429, 14, 15, 16, 1, -15 },
  { 2456, 14, 20, 16, 1, -15 },
  { 2491, 12, 15, 16, 2, -15 },
  { 2514, 12, 27, 16, 2, -22 },
  { 2555, 3, 27, 16, 6, -22 },
  { 2566, 11, 27, 16, 2, -22 },
  { 2604, 14, 5, 16, 1, -11 },
};

const GFXfont UbuntuSansMono_Medium28pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium28pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium28pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUSANSMONO_MEDIUM28PT7B_H_
