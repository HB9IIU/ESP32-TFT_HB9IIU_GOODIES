#ifndef _UBUNTUSANSMONO_MEDIUM41PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x7E, 0xFF, 0xFF,
  0xFB, 0xE1, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xC1, 0xFE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE0, 0x01,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0,
  0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x0F, 0x00, 0x78, 0x78, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xDF, 0x8F, 0xC0,
  0x11, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7D, 0x80, 0x1F, 0xBF, 0x1F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x03, 0xDF, 0xE0, 0x3D, 0xE7,
  0x01, 0xCE, 0x3C, 0x1E, 0x70, 0xE1, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xF0,
  0xE1, 0xC7, 0x07, 0x1E, 0x78, 0x3C, 0xE7, 0x81, 0xFF, 0x38, 0x07, 0xF3,
  0xC0, 0x1F, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x10, 0x00, 0xE7, 0xE0,
  0x0F, 0x7F, 0x80, 0xF3, 0xDE, 0x07, 0x3C, 0x70, 0x79, 0xC3, 0x87, 0x8E,
  0x1C, 0x38, 0x70, 0xE3, 0xC3, 0x87, 0x1C, 0x1C, 0x39, 0xC0, 0xF1, 0xDE,
  0x03, 0xDE, 0xE0, 0x1F, 0xEF, 0x00, 0x7E, 0x00, 0x00, 0x40, 0x03, 0xF0,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xE1, 0xF0, 0x1F,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3E, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x8F, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x83, 0x83, 0xFC, 0x1C, 0x3F, 0xF1, 0xE3, 0xE7, 0xCF, 0x1E, 0x1F, 0x78,
  0xF0, 0x7F, 0xCF, 0x81, 0xFC, 0x78, 0x0F, 0xE3, 0xE0, 0x3E, 0x1F, 0x00,
  0xF8, 0x78, 0x0F, 0xE3, 0xF1, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xF1, 0xE0,
  0xFF, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0x9C, 0xE7, 0x00,
  0x00, 0x30, 0x07, 0x80, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xC0, 0x04, 0x60, 0x03, 0x80, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x01, 0xC0, 0x04, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x07, 0x0E, 0x1C, 0xF9, 0xCF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x03, 0xDE, 0x00, 0xFB, 0xE0, 0x3E, 0x3E, 0x07, 0xC7, 0xE0, 0x70, 0x70,
  0x02, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x07, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC,
  0x0E, 0x07, 0x83, 0xCF, 0xF1, 0xF8, 0x78, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xE0, 0xF8, 0xF8,
  0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x71, 0xFF, 0x1F, 0x1F, 0xE3, 0xE3, 0xFC, 0x7C, 0x7F, 0x8F,
  0x8F, 0xF0, 0xE1, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3E, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x0F, 0x87, 0xF7,
  0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x01, 0xE7, 0xC0, 0x61, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0xC1, 0xF8, 0x60, 0x1F, 0x08, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x07,
  0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x1F, 0x88, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x40, 0x0F, 0xDF, 0x0F, 0xE7, 0xFF, 0xF3,
  0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xDE, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x78, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7D, 0x00, 0x3F, 0x7E, 0x3F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x7C, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xE0, 0x0F,
  0xFC, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x3E,
  0x3E, 0x07, 0xC7, 0xE3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x07, 0xC3, 0xF9,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x3E, 0x7F, 0x8F, 0x81,
  0xF9, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0x7C, 0x07, 0xCF, 0xE3, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xF8, 0xF8, 0x0F, 0x9E, 0x01, 0xF7, 0xC0,
  0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x07, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0,
  0x03, 0xE0, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x3E, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x0E, 0x0F,
  0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x3E, 0x3F, 0x9F, 0xCF, 0xE7, 0xF1, 0xF8, 0x3C, 0x3C,
  0x3E, 0xFE, 0x7E, 0x3E, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x38, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x0F,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7E,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF7, 0xFF, 0xE6, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0x40, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFE, 0xFE, 0x1F, 0x01, 0xE1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF7, 0x80, 0xFF, 0x78, 0x3F, 0xF7, 0x87, 0xFF, 0x78, 0xFF,
  0xF7, 0x0F, 0x8F, 0x70, 0xF0, 0xFF, 0x1F, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E,
  0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0x71, 0xF0, 0xF7, 0x9F, 0x0F, 0x78,
  0xF0, 0xF7, 0x8F, 0xDF, 0x78, 0x7F, 0xF7, 0xC3, 0xFF, 0x3C, 0x1F, 0xF3,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x06,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x7C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0x80, 0x1F, 0x0F,
  0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xE0,
  0x01, 0xF7, 0xC0, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8F, 0x83, 0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0xFF, 0xF1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xF8, 0x0F, 0xDF, 0x00, 0xFB,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x0F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1,
  0xF8, 0x1C, 0x7E, 0x00, 0x9F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x43, 0xFE, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x30, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F,
  0x87, 0xF9, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7E, 0xF8,
  0x1F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xF8, 0x1C, 0x7E, 0x00, 0x9F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xF0, 0x1F, 0x3F, 0x03, 0xE3, 0xFC, 0xFC, 0x7F, 0xFF, 0x83,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x60, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0xC0, 0x7E, 0x7C, 0x7F, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0xF0, 0x07, 0xEF, 0x00,
  0xF8, 0xF0, 0x1F, 0x8F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xE0, 0xF0,
  0x7C, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x3E, 0x00, 0xF7, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x7E, 0x00,
  0xF3, 0xF0, 0x0F, 0x1F, 0x80, 0xF0, 0xFC, 0x0F, 0x07, 0xE0, 0xF0, 0x3E,
  0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x8F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00,
  0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x3F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F,
  0x8F, 0x71, 0xDE, 0x7B, 0x8E, 0xF3, 0xDC, 0x77, 0x9E, 0x77, 0x3C, 0xF3,
  0xB9, 0xE7, 0x9D, 0xCF, 0x3C, 0xFE, 0x79, 0xE3, 0xE3, 0xCF, 0x1F, 0x1E,
  0x78, 0xF8, 0xF3, 0xC3, 0x87, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xBC, 0x1F, 0xF7, 0x83, 0xFE, 0x78, 0x7F, 0xCF, 0x0F, 0xF8, 0xF1,
  0xFF, 0x1E, 0x3F, 0xE1, 0xE7, 0xFC, 0x3C, 0xFF, 0x83, 0xDF, 0xF0, 0x7B,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x01, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3E,
  0x7C, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xFE, 0xFE, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0x1F, 0xC0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0xBE, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFE, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x01, 0xF0, 0xF0, 0x07, 0x8F, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xFC, 0x7E,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x02, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x81, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x0F, 0x81,
  0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0x38, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x60, 0x07, 0xCF, 0x87, 0xF9, 0xFF, 0xFE, 0x7F,
  0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xE0, 0x3E, 0x7F,
  0x1F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0x80, 0x0F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x83, 0xE0,
  0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x7C, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00,
  0x7B, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xEF,
  0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x3C, 0x3C, 0xF1, 0xF1, 0xE7, 0x8F, 0x8F, 0x3C,
  0x7C, 0x79, 0xE7, 0xF3, 0xCF, 0x3B, 0x9E, 0x79, 0xDC, 0xF3, 0xDC, 0xF7,
  0x9E, 0xE3, 0xBC, 0xF7, 0x1D, 0xE7, 0xF8, 0xFE, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x78, 0x03, 0xC0, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x3C,
  0x07, 0x81, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0,
  0x07, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00,
  0x3E, 0xF8, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E,
  0x00, 0x7D, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00,
  0x7C, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0x78, 0x0F, 0x83,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x0F, 0x9E,
  0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x01, 0xF1, 0xF0,
  0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0,
  0x1F, 0x7C, 0x00, 0x7C, 0xE0, 0x03, 0x81, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x18, 0x1E,
  0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x06, 0x0F, 0xF8, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFE, 0x10, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC1, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x8F, 0xDF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDF, 0x00, 0xF7, 0xF0,
  0x7D, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x18, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x9F, 0x03, 0xFF, 0xF0, 0xFF,
  0xFE, 0x3F, 0xFF, 0xCF, 0xC1, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x7E, 0xFE,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF8, 0x0C, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x7C, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE1, 0xFD, 0xF0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x7D, 0xF8, 0x1F, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F,
  0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0,
  0xFC, 0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x08, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF0, 0x70, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7E,
  0x07, 0xDF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0x7E, 0x0F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07,
  0xF7, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x9E, 0x0F,
  0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xF8, 0x00, 0x18, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xFC, 0x1F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x78, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x80, 0x7D,
  0xE3, 0xF7, 0xFF, 0xEF, 0xFF, 0x8F, 0xFE, 0x01, 0xE0, 0x00, 0x18, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x07, 0xEF, 0x81, 0xF9, 0xF0, 0x7E, 0x3E, 0x0F, 0x87, 0xC3, 0xE0,
  0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7,
  0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x10, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x3E, 0x0F, 0x1F, 0xF7, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x1F, 0x1F, 0xE3, 0xC3, 0xFC, 0x38, 0x7F, 0x87,
  0x87, 0xF0, 0xF0, 0xFE, 0x1E, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F,
  0x0F, 0xE1, 0xE1, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x0F,
  0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83, 0xF7, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7C, 0x01, 0xF0,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F,
  0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0x7C, 0x07, 0xCF, 0x81, 0xF8, 0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xF8, 0x3F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x07,
  0xDF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xFD, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x0E, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xC0, 0x27, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x01, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7C, 0x0F, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xF0, 0xF8, 0x00, 0xFB, 0xC0,
  0x07, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x83, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xC3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0x07, 0xF8, 0x3C, 0x3F, 0xC3, 0xE1, 0xCE, 0x1F,
  0x0E, 0x70, 0xF8, 0xF3, 0xCF, 0xE7, 0x9E, 0x77, 0x3C, 0xF3, 0xB9, 0xE7,
  0xBD, 0xEF, 0x1D, 0xC7, 0x70, 0xEE, 0x3B, 0x87, 0xF1, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x00,
  0xFC, 0x01, 0xF1, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x80, 0xF8,
  0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xEF,
  0x80, 0x3E, 0x3E, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x1F, 0x0F,
  0x00, 0x78, 0xF8, 0x03, 0xEF, 0x80, 0x0F, 0x80, 0x7C, 0x01, 0xF3, 0xC0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x03, 0xE1, 0xE0, 0x3E, 0x1F,
  0x03, 0xE1, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0x87, 0x80,
  0x7C, 0x78, 0x07, 0xCF, 0x80, 0x3C, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x43, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x40,
  0xFE, 0x03, 0xCF, 0xFC, 0x1C, 0xFF, 0xFF, 0xE7, 0xDF, 0xFF, 0x38, 0x3F,
  0xF3, 0xC0, 0x7F, 0x00, 0x00, 0x60,
};

const GFXglyph UbuntuSansMono_Medium41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 29, 23, 8, -28 },
  { 27, 13, 12, 23, 5, -31 },
  { 47, 21, 28, 23, 1, -28 },
  { 121, 19, 36, 23, 2, -32 },
  { 207, 21, 30, 23, 1, -29 },
  { 286, 21, 29, 23, 1, -29 },
  { 363, 5, 13, 23, 9, -31 },
  { 372, 13, 40, 23, 5, -32 },
  { 437, 13, 40, 23, 5, -32 },
  { 502, 19, 17, 23, 2, -28 },
  { 543, 19, 20, 23, 2, -22 },
  { 591, 10, 14, 23, 6, -7 },
  { 609, 11, 4, 23, 6, -14 },
  { 615, 7, 7, 23, 8, -7 },
  { 622, 17, 40, 23, 3, -32 },
  { 707, 19, 30, 23, 2, -29 },
  { 779, 18, 28, 23, 3, -28 },
  { 842, 19, 29, 23, 2, -29 },
  { 911, 18, 30, 23, 2, -29 },
  { 979, 21, 28, 23, 1, -28 },
  { 1053, 18, 29, 23, 2, -28 },
  { 1119, 19, 30, 23, 2, -29 },
  { 1191, 18, 28, 23, 3, -28 },
  { 1254, 19, 30, 23, 2, -29 },
  { 1326, 19, 29, 23, 2, -29 },
  { 1395, 7, 21, 23, 8, -21 },
  { 1414, 9, 28, 23, 6, -21 },
  { 1446, 19, 19, 23, 2, -21 },
  { 1492, 19, 12, 23, 2, -18 },
  { 1521, 19, 19, 23, 2, -21 },
  { 1567, 15, 30, 23, 4, -29 },
  { 1624, 20, 35, 23, 1, -29 },
  { 1712, 23, 28, 23, 0, -28 },
  { 1793, 19, 29, 23, 2, -29 },
  { 1862, 19, 30, 23, 2, -29 },
  { 1934, 19, 29, 23, 2, -29 },
  { 2003, 17, 28, 23, 4, -28 },
  { 2063, 16, 28, 23, 4, -28 },
  { 2119, 19, 30, 23, 2, -29 },
  { 2191, 19, 28, 23, 2, -28 },
  { 2258, 17, 28, 23, 3, -28 },
  { 2318, 18, 29, 23, 2, -28 },
  { 2384, 20, 28, 23, 3, -28 },
  { 2454, 17, 28, 23, 4, -28 },
  { 2514, 21, 28, 23, 1, -28 },
  { 2588, 19, 28, 23, 2, -28 },
  { 2655, 21, 30, 23, 1, -29 },
  { 2734, 18, 29, 23, 3, -29 },
  { 2800, 21, 37, 23, 1, -29 },
  { 2898, 20, 29, 23, 2, -29 },
  { 2971, 19, 30, 23, 2, -29 },
  { 3043, 19, 28, 23, 2, -28 },
  { 3110, 19, 29, 23, 2, -28 },
  { 3179, 21, 28, 23, 1, -28 },
  { 3253, 21, 28, 23, 1, -28 },
  { 3327, 21, 28, 23, 1, -28 },
  { 3401, 21, 28, 23, 1, -28 },
  { 3475, 19, 28, 23, 2, -28 },
  { 3542, 12, 40, 23, 6, -32 },
  { 3602, 17, 40, 23, 3, -32 },
  { 3687, 12, 40, 23, 5, -32 },
  { 3747, 21, 16, 23, 1, -28 },
  { 3789, 23, 4, 23, 0, 4 },
  { 3801, 9, 8, 23, 7, -32 },
  { 3810, 18, 22, 23, 2, -22 },
  { 3860, 18, 32, 23, 3, -32 },
  { 3932, 19, 22, 23, 2, -22 },
  { 3985, 18, 32, 23, 2, -32 },
  { 4057, 19, 22, 23, 2, -22 },
  { 4110, 20, 32, 23, 2, -32 },
  { 4190, 18, 30, 23, 2, -22 },
  { 4258, 17, 32, 23, 3, -32 },
  { 4326, 19, 31, 23, 2, -31 },
  { 4400, 15, 39, 23, 3, -31 },
  { 4474, 19, 32, 23, 3, -32 },
  { 4550, 19, 32, 23, 2, -32 },
  { 4626, 19, 22, 23, 2, -22 },
  { 4679, 17, 22, 23, 3, -22 },
  { 4726, 19, 23, 23, 2, -22 },
  { 4781, 18, 30, 23, 3, -22 },
  { 4849, 18, 30, 23, 2, -22 },
  { 4917, 16, 22, 23, 5, -22 },
  { 4961, 17, 22, 23, 3, -22 },
  { 5008, 19, 28, 23, 2, -28 },
  { 5075, 17, 21, 23, 3, -21 },
  { 5120, 21, 21, 23, 1, -21 },
  { 5176, 21, 21, 23, 1, -21 },
  { 5232, 21, 21, 23, 1, -21 },
  { 5288, 20, 29, 23, 1, -21 },
  { 5361, 17, 21, 23, 3, -21 },
  { 5406, 17, 40, 23, 3, -32 },
  { 5491, 5, 40, 23, 9, -32 },
  { 5516, 17, 40, 23, 3, -32 },
  { 5601, 21, 8, 23, 1, -16 },
};

const GFXfont UbuntuSansMono_Medium41pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium41pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium41pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUSANSMONO_MEDIUM41PT7B_H_
