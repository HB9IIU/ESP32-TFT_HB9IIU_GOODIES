#ifndef _UBUNTUSANSMONO_MEDIUM37PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium37pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7,
  0x8E, 0x38, 0x00, 0x00, 0x31, 0xFF, 0xFF, 0xFD, 0xF0, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x19, 0x83,
  0x00, 0x03, 0xC3, 0x80, 0x78, 0x70, 0x0E, 0x1E, 0x01, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x0E, 0x01, 0xE1, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3C, 0x38, 0x07, 0x87, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x78,
  0x0F, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3F, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0x7C, 0x02, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x80, 0x1F, 0x70, 0x1F, 0x7F, 0xFF, 0xBF, 0xFF,
  0x8F, 0xFF, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0xEF, 0xE0, 0x3B, 0xFC, 0x0F, 0x73, 0x81, 0xCE,
  0x38, 0x71, 0x87, 0x0E, 0x30, 0xE3, 0x86, 0x1C, 0xF0, 0xE3, 0x9C, 0x1C,
  0xE7, 0x03, 0xFD, 0xE0, 0x3F, 0x38, 0x00, 0x8E, 0x00, 0x03, 0xC0, 0x00,
  0x73, 0xE0, 0x1C, 0xFE, 0x03, 0x9D, 0xE0, 0xE7, 0x1C, 0x3C, 0xE3, 0x87,
  0x1C, 0x71, 0xC3, 0x8E, 0x78, 0x71, 0xCE, 0x0E, 0x3B, 0x81, 0xEF, 0x70,
  0x1F, 0xDC, 0x01, 0xF0, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x38, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x3C, 0x38, 0x03, 0xCF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x38, 0x3F, 0x87, 0x0F, 0xF8, 0xE3, 0xCF, 0x9C, 0x78, 0xFF, 0x9E,
  0x0F, 0xF3, 0xC0, 0xFC, 0x78, 0x1F, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x1E,
  0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xF3, 0xC1, 0xFC, 0x7C, 0xFF, 0xFF, 0xFF,
  0x7B, 0xCE, 0x73, 0x9C, 0x00, 0x60, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x02, 0x20, 0x07,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F,
  0xC0, 0x70, 0x02, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x06, 0x1C, 0x33, 0xCE, 0x79, 0xFF, 0xFD, 0xFF, 0xFF, 0x1F, 0xFC, 0x01,
  0xF0, 0x01, 0xDC, 0x01, 0xEF, 0x01, 0xE7, 0xC1, 0xF1, 0xF0, 0x70, 0xE0,
  0x08, 0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1F, 0x07,
  0x0F, 0x3E, 0xFC, 0xF8, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xFB,
  0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xCF,
  0xC7, 0xC1, 0xE3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x71, 0xFE, 0x78, 0xFF, 0x3E, 0x7F, 0x9F, 0x3F, 0xC7, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xE7, 0x80,
  0xF3, 0xE0, 0xF8, 0xF8, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xF3, 0xE0, 0x43, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF,
  0x1F, 0xDF, 0xC7, 0x03, 0xE1, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7C, 0xFE, 0x20, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x60, 0x3F,
  0x7F, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0x7C, 0x07, 0x9F, 0x03, 0xC7, 0xC0, 0xF1, 0xF0, 0x78, 0x7C, 0x1C,
  0x1F, 0x0F, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x60, 0x3E, 0x7F, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x02,
  0x00, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0xFC,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xF3, 0xFB, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0x80, 0xF3, 0xE0, 0x79,
  0xF8, 0x7C, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xC7, 0xC7, 0x81, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E,
  0x78, 0x0F, 0x3E, 0x0F, 0x9F, 0x87, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xE0, 0xF3, 0xF8, 0xF0, 0x7E, 0x78, 0x0F, 0x78, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x7D, 0xF0, 0x7C, 0xFF, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFC, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xC7, 0xC7, 0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x01, 0xEF, 0x00, 0xF7, 0xC1, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0x00,
  0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xBF, 0x7F, 0xFF, 0xF9, 0xF0, 0x1F, 0x1F, 0x8F, 0xE7, 0xF3, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xFC, 0x7F,
  0x3F, 0x9F, 0xC7, 0xE0, 0xE0, 0xF0, 0xF3, 0xF1, 0xF0, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83,
  0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x60, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0x1F, 0xE3, 0xFF, 0xE7, 0xFF, 0x9E, 0x3F, 0x40, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x1E, 0x1E, 0x03,
  0xCF, 0x00, 0xF3, 0x80, 0x1D, 0xE0, 0x07, 0x78, 0x3F, 0xDC, 0x1F, 0xF7,
  0x0F, 0xFD, 0xC7, 0xC7, 0xF1, 0xE1, 0xFC, 0x70, 0x7F, 0x3C, 0x1F, 0xCF,
  0x07, 0xF3, 0xC1, 0xFC, 0xF0, 0x7F, 0x1C, 0x1D, 0xC7, 0x87, 0x71, 0xF1,
  0xDC, 0x3F, 0xF7, 0x8F, 0xFD, 0xE0, 0xFF, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0x70, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x39, 0xE0, 0x07, 0x8F, 0x00,
  0x78, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0x7F, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0x03, 0xE7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0x78, 0x0F, 0x3C, 0x1F, 0x9F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xF3,
  0xC1, 0xFD, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC1, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F,
  0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFB, 0xE3, 0xE0,
  0x13, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x0C, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x08, 0x00,
  0x7F, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x03, 0xE7, 0x80,
  0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x01, 0xF7, 0x81, 0xF3, 0xC3,
  0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xE7, 0xF1, 0xE3, 0xE0, 0x13,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0x7B, 0xE0, 0x3C,
  0xFC, 0x1E, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x18, 0x00, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x40, 0x3E, 0x70, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0,
  0x07, 0x80, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x01, 0xF3, 0xC0, 0x78, 0xF0,
  0x3E, 0x3C, 0x1F, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0xF8,
  0x0F, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0x7E, 0x03,
  0xCF, 0xC0, 0xF1, 0xF8, 0x3C, 0x3E, 0x0F, 0x07, 0xC3, 0xC0, 0xF8, 0xF0,
  0x3E, 0x3C, 0x07, 0xCF, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x07, 0xFC, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E,
  0x1E, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1D, 0x87, 0x63, 0xB8, 0xEE,
  0x77, 0x19, 0xCE, 0x67, 0x39, 0xCE, 0xE7, 0x39, 0xDC, 0xE7, 0x3F, 0x1C,
  0xE3, 0xE3, 0x9C, 0x7C, 0x73, 0x8F, 0x0E, 0x70, 0xE1, 0xCE, 0x00, 0x3B,
  0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x77,
  0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3C, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xF7, 0x07, 0xFB, 0xC3, 0xFC, 0xE1, 0xFE, 0x78, 0xFF, 0x1C, 0x7F, 0x8F,
  0x3F, 0xC3, 0x9F, 0xE1, 0xEF, 0xF0, 0x77, 0xF8, 0x3B, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x9F,
  0x83, 0xC0, 0xF8, 0xF8, 0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x1E, 0xF8, 0x03,
  0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0x79, 0xE0, 0x0F,
  0x3C, 0x01, 0xE7, 0xC0, 0x7C, 0x78, 0x1F, 0x0F, 0x87, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xDF, 0x83, 0xE0, 0xF8,
  0xF8, 0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7B,
  0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x87, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x00, 0xF3, 0xC0,
  0x3E, 0xF0, 0x07, 0xBC, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF,
  0x8F, 0xE3, 0xC7, 0x80, 0x23, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xFA, 0x00, 0x79, 0xC0, 0x7D, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F,
  0xFC, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xF7,
  0xC0, 0x79, 0xF0, 0x7C, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x20,
  0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0xC0, 0x70, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x1C, 0xF0, 0x03, 0xDE,
  0x00, 0x7B, 0xC0, 0x0F, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00,
  0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x0E, 0x70, 0x01,
  0xCE, 0x00, 0x39, 0xC7, 0x87, 0x38, 0xF8, 0xE7, 0x1F, 0x1C, 0xE3, 0xE3,
  0x9C, 0xEC, 0x73, 0x9D, 0xCE, 0x73, 0x39, 0xCE, 0xE3, 0x39, 0xDC, 0x77,
  0x3B, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE1, 0xE0, 0x7C,
  0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1E,
  0x1E, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x3E, 0x03, 0xC7, 0x80, 0x79, 0xF0,
  0x07, 0xBC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x01, 0xE3, 0xC0,
  0x7C, 0x78, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x1F, 0x1F, 0x01, 0xE3,
  0xC0, 0x3E, 0xF8, 0x03, 0xDE, 0x00, 0x7C, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x03, 0xE0,
  0xF0, 0x78, 0x1E, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0x78, 0x03, 0xEF, 0x80, 0xF8, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xF0,
  0xF0, 0x1E, 0x3E, 0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x07, 0x84, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0xC3,
  0xC7, 0xC7, 0xC3, 0xC3, 0x82, 0x0F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFE, 0x3F,
  0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0xFF, 0x1F,
  0xFF, 0x7F, 0xFF, 0x7E, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0x7C, 0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x30, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF3, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0,
  0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0xC7,
  0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x13, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x81, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xE3, 0xC3,
  0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9, 0xF0, 0x7D, 0xF0, 0x1E, 0xF0, 0x0F,
  0x78, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0x9F, 0x83, 0xC7, 0xFF, 0xE1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xC7, 0xC1, 0xF7, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0x06, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x3C, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xC0, 0xC1, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x7F,
  0x7F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xEF, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x40, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0x30,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xEF, 0x83, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xDE,
  0x0F, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE1, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3D, 0x03, 0xFF, 0xFE, 0xFF, 0xF7,
  0xFF, 0x0F, 0xE0, 0x30, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x07, 0xC7, 0x87, 0xC3, 0xC7, 0xC1, 0xE7,
  0xC0, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0x7C, 0x07,
  0x9F, 0x03, 0xC7, 0xC1, 0xE1, 0xF0, 0xF0, 0x7C, 0x78, 0x1F, 0x3C, 0x07,
  0x9E, 0x03, 0xEF, 0x00, 0xF8, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x0E, 0x0E, 0x3F, 0xEF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF1, 0xE3, 0xFC, 0x38, 0x7F, 0x0E, 0x1F, 0xC3,
  0x87, 0xF0, 0xE1, 0xFC, 0x38, 0x7F, 0x0E, 0x1F, 0xC3, 0x87, 0xF0, 0xE1,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0x0F, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF,
  0x07, 0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3E, 0x0F, 0x9F, 0x01, 0xE7, 0x80, 0x7D, 0xE0, 0x0F,
  0x78, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE,
  0x00, 0xF7, 0xC0, 0x7C, 0xF0, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0,
  0x7E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xFC,
  0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x03, 0xF2, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x80,
  0x5E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF,
  0xEF, 0x80, 0x5E, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0,
  0x3F, 0xFF, 0xFB, 0xFF, 0xF3, 0xFF, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x0C, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xF8, 0xF8, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3,
  0xC0, 0x3C, 0x78, 0x07, 0x9F, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x0E, 0x1F, 0xE3,
  0xC3, 0xBC, 0x7C, 0x73, 0x8F, 0x8E, 0x71, 0xF1, 0xCE, 0x7E, 0x39, 0xCE,
  0xEF, 0x39, 0xDD, 0xE7, 0xF3, 0xB8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0,
  0xFC, 0x3E, 0x0F, 0x87, 0x81, 0xE0, 0x70, 0x1C, 0x00, 0xF8, 0x07, 0xC7,
  0x80, 0xF0, 0xF8, 0x3C, 0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x0F, 0x78, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFB, 0xE0, 0x1E, 0x3C, 0x07, 0x83, 0xC1, 0xE0, 0x7C, 0x3C,
  0x07, 0x8F, 0x00, 0xFB, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xDF, 0x00, 0xF3,
  0xC0, 0x7C, 0xF0, 0x1E, 0x3E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF9, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF8,
  0x3E, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0xC1, 0xFF, 0x03,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0x01, 0xE7, 0xF8, 0x39, 0xFF, 0xCF, 0x3D,
  0xFF, 0xEF, 0x0F, 0xF9, 0xC0, 0x7E, 0x00,
};

const GFXglyph UbuntuSansMono_Medium37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 6, 26, 21, 7, -26 },
  { 21, 11, 11, 21, 5, -28 },
  { 37, 19, 26, 21, 1, -26 },
  { 99, 17, 33, 21, 2, -29 },
  { 170, 19, 27, 21, 1, -26 },
  { 235, 19, 26, 21, 1, -26 },
  { 297, 5, 11, 21, 8, -28 },
  { 304, 12, 36, 21, 4, -29 },
  { 358, 12, 36, 21, 4, -29 },
  { 412, 17, 16, 21, 2, -26 },
  { 446, 17, 18, 21, 2, -20 },
  { 485, 8, 12, 21, 6, -6 },
  { 497, 10, 4, 21, 5, -13 },
  { 502, 7, 6, 21, 7, -6 },
  { 508, 16, 36, 21, 2, -29 },
  { 580, 17, 27, 21, 2, -26 },
  { 638, 16, 26, 21, 3, -26 },
  { 690, 17, 26, 21, 2, -26 },
  { 746, 16, 27, 21, 2, -26 },
  { 800, 18, 26, 21, 1, -26 },
  { 859, 16, 27, 21, 2, -26 },
  { 913, 17, 27, 21, 2, -26 },
  { 971, 17, 26, 21, 2, -26 },
  { 1027, 17, 27, 21, 2, -26 },
  { 1085, 17, 26, 21, 2, -26 },
  { 1141, 7, 19, 21, 7, -19 },
  { 1158, 9, 25, 21, 5, -19 },
  { 1187, 17, 17, 21, 2, -19 },
  { 1224, 17, 12, 21, 2, -17 },
  { 1250, 17, 17, 21, 2, -19 },
  { 1287, 14, 26, 21, 3, -26 },
  { 1333, 18, 32, 21, 1, -26 },
  { 1405, 20, 26, 21, 0, -26 },
  { 1470, 17, 26, 21, 2, -26 },
  { 1526, 17, 27, 21, 2, -26 },
  { 1584, 17, 26, 21, 2, -26 },
  { 1640, 16, 26, 21, 3, -26 },
  { 1692, 15, 26, 21, 3, -26 },
  { 1741, 17, 27, 21, 2, -26 },
  { 1799, 17, 26, 21, 2, -26 },
  { 1855, 15, 26, 21, 3, -26 },
  { 1904, 16, 27, 21, 2, -26 },
  { 1958, 18, 26, 21, 2, -26 },
  { 2017, 16, 26, 21, 3, -26 },
  { 2069, 19, 26, 21, 1, -26 },
  { 2131, 17, 26, 21, 2, -26 },
  { 2187, 19, 27, 21, 1, -26 },
  { 2252, 16, 26, 21, 3, -26 },
  { 2304, 19, 33, 21, 1, -26 },
  { 2383, 18, 26, 21, 2, -26 },
  { 2442, 17, 27, 21, 2, -26 },
  { 2500, 18, 26, 21, 1, -26 },
  { 2559, 17, 27, 21, 2, -26 },
  { 2617, 19, 26, 21, 1, -26 },
  { 2679, 19, 26, 21, 1, -26 },
  { 2741, 19, 26, 21, 1, -26 },
  { 2803, 19, 26, 21, 1, -26 },
  { 2865, 17, 26, 21, 2, -26 },
  { 2921, 11, 36, 21, 5, -29 },
  { 2971, 15, 36, 21, 3, -29 },
  { 3039, 10, 36, 21, 5, -29 },
  { 3084, 19, 15, 21, 1, -26 },
  { 3120, 20, 4, 21, 0, 3 },
  { 3130, 7, 8, 21, 7, -29 },
  { 3137, 16, 20, 21, 2, -20 },
  { 3177, 16, 29, 21, 3, -29 },
  { 3235, 17, 20, 21, 2, -20 },
  { 3278, 17, 29, 21, 1, -29 },
  { 3340, 17, 20, 21, 2, -20 },
  { 3383, 18, 29, 21, 2, -29 },
  { 3449, 16, 27, 21, 2, -20 },
  { 3503, 15, 29, 21, 3, -29 },
  { 3558, 17, 28, 21, 2, -28 },
  { 3618, 13, 35, 21, 3, -28 },
  { 3675, 17, 29, 21, 3, -29 },
  { 3737, 17, 29, 21, 2, -29 },
  { 3799, 18, 20, 21, 1, -20 },
  { 3844, 15, 20, 21, 3, -20 },
  { 3882, 18, 20, 21, 1, -20 },
  { 3927, 16, 27, 21, 3, -20 },
  { 3981, 16, 27, 21, 2, -20 },
  { 4035, 15, 20, 21, 4, -20 },
  { 4073, 15, 20, 21, 3, -20 },
  { 4111, 17, 25, 21, 2, -25 },
  { 4165, 15, 19, 21, 3, -19 },
  { 4201, 19, 19, 21, 1, -19 },
  { 4247, 19, 19, 21, 1, -19 },
  { 4293, 19, 19, 21, 1, -19 },
  { 4339, 18, 26, 21, 1, -19 },
  { 4398, 15, 19, 21, 3, -19 },
  { 4434, 15, 36, 21, 3, -29 },
  { 4502, 4, 36, 21, 8, -29 },
  { 4520, 15, 36, 21, 3, -29 },
  { 4588, 19, 6, 21, 1, -14 },
};

const GFXfont UbuntuSansMono_Medium37pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium37pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium37pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUSANSMONO_MEDIUM37PT7B_H_
