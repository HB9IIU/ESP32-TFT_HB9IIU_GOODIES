#ifndef _UBUNTUSANSMONO_MEDIUM23PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x05, 0xFF, 0xCF, 0x9F, 0x1E, 0x3C, 0x78,
  0xC0, 0x1C, 0xC3, 0x18, 0x63, 0x0C, 0x6F, 0xFF, 0xFF, 0xCC, 0x61, 0x8C,
  0x31, 0x86, 0x73, 0xFF, 0xFF, 0xF6, 0x30, 0xC6, 0x19, 0xC7, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x1F, 0xE7, 0xFC, 0xE0, 0x98, 0x03, 0x80, 0x78, 0x07,
  0xE0, 0x7E, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x3B, 0x9E, 0xFF, 0x83, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x78, 0x33, 0x61, 0xB3, 0x19, 0x99, 0x8C, 0xCC,
  0x26, 0xC1, 0xEC, 0x06, 0x60, 0x06, 0x60, 0x7F, 0x83, 0x6C, 0x33, 0x21,
  0x99, 0x98, 0xC9, 0x86, 0xDC, 0x1E, 0x3E, 0x0F, 0xE1, 0x8C, 0x31, 0x86,
  0x30, 0xEE, 0x0F, 0x81, 0xE6, 0x7C, 0xDD, 0xDB, 0x1F, 0x61, 0xEC, 0x19,
  0xC7, 0xBF, 0xF9, 0xF7, 0xFF, 0xFE, 0x90, 0x04, 0x1C, 0x71, 0xC7, 0x0E,
  0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x70, 0x60, 0xE0, 0xE0,
  0xE0, 0xE0, 0xC0, 0xC1, 0xC1, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x0E, 0x0C,
  0x18, 0x30, 0x60, 0xC3, 0x86, 0x1C, 0x38, 0xE3, 0x8E, 0x18, 0x00, 0x0E,
  0x01, 0xC1, 0x39, 0x3A, 0xEF, 0xFE, 0x1C, 0x06, 0xC1, 0xDC, 0x31, 0x82,
  0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xC3, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x00, 0x33, 0xDE, 0xF1, 0xBB, 0x90, 0xFF, 0xFF,
  0xF8, 0x77, 0xBE, 0xE0, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38,
  0x18, 0x1C, 0x0E, 0x06, 0x00, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x6E, 0x0D,
  0xC1, 0xFB, 0x3F, 0x77, 0xEE, 0xFC, 0x1F, 0x83, 0xF0, 0x66, 0x0C, 0xE3,
  0x8F, 0xE0, 0xF8, 0x0C, 0x07, 0x07, 0xC3, 0xF0, 0xCC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x3F,
  0x1F, 0xF1, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0x3F, 0x1F, 0xE4,
  0x1C, 0x07, 0x01, 0xC0, 0x61, 0xF8, 0x7C, 0x1F, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xD0, 0x77, 0xFB, 0xFC, 0x03, 0x80, 0x70, 0x1E, 0x06, 0xC1, 0xD8,
  0x33, 0x0C, 0x63, 0x8C, 0x61, 0x98, 0x33, 0xFF, 0xFF, 0xF0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xE1,
  0xFE, 0x07, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xD0, 0x77, 0xFB, 0xFC, 0x03,
  0xC1, 0xF8, 0x78, 0x1C, 0x07, 0x00, 0xE0, 0x1F, 0xC7, 0xFC, 0xE1, 0xDC,
  0x1B, 0x83, 0xF0, 0x76, 0x0C, 0xE3, 0x8F, 0xF0, 0xFC, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x3F, 0x8F, 0xF9, 0xC7, 0x30,
  0x66, 0x0C, 0xC1, 0x9E, 0x61, 0xF8, 0x3F, 0x8E, 0x3B, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0x9F, 0xF1, 0xFC, 0x3F, 0x0F, 0xF1, 0xC7, 0x70, 0x6E, 0x0D,
  0xC1, 0xF8, 0x3B, 0x87, 0x7F, 0xE3, 0xD8, 0x07, 0x00, 0xE0, 0x38, 0x1E,
  0x1F, 0x83, 0xC0, 0x77, 0xBE, 0xE0, 0x00, 0x00, 0x77, 0xBE, 0xE0, 0x39,
  0xE7, 0xCE, 0x00, 0x00, 0x00, 0x38, 0xE7, 0xCE, 0x18, 0xEF, 0x30, 0x00,
  0x40, 0x3C, 0x3F, 0x1F, 0x8F, 0x81, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3C, 0x01, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x40, 0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xC1, 0xF8, 0xFC,
  0xFC, 0x1E, 0x01, 0x00, 0x00, 0x7E, 0x7F, 0xA0, 0xE0, 0x70, 0x38, 0x38,
  0x38, 0x38, 0x1C, 0x0C, 0x00, 0x00, 0x01, 0x01, 0xE0, 0xF0, 0x70, 0x1F,
  0x87, 0xF9, 0xC3, 0xB0, 0x3E, 0x07, 0x8F, 0xF3, 0xFE, 0x73, 0xCC, 0x79,
  0x8F, 0x31, 0xE6, 0x3C, 0xE7, 0x8F, 0xD8, 0xFB, 0x00, 0x30, 0x07, 0xD8,
  0x3F, 0x00, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x1B, 0x01, 0xD8, 0x0C, 0xE0,
  0x63, 0x03, 0x18, 0x38, 0xE1, 0x87, 0x0F, 0xF8, 0xFF, 0xC7, 0x07, 0x30,
  0x39, 0x80, 0xDC, 0x07, 0xFF, 0x1F, 0xF3, 0x87, 0x70, 0xEE, 0x0D, 0xC3,
  0xB8, 0xE7, 0xF8, 0xFF, 0xDC, 0x1B, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xBF,
  0xF7, 0xF8, 0x0F, 0xC7, 0xFD, 0xE1, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x4F, 0xF8, 0xFF,
  0xFE, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1D, 0xC7, 0xBF, 0xE7, 0xF0, 0xFF, 0xBF,
  0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFC, 0xFF, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0x0F, 0xC7, 0xFD, 0xE1, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x0E, 0xF1, 0xCF, 0xF8, 0xFF, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xC7, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3,
  0xFF, 0xFF, 0x3F, 0xCF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xD0, 0xFF, 0xF9, 0xFC, 0xE0, 0xEE,
  0x1C, 0xE1, 0x8E, 0x38, 0xE7, 0x0E, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0E,
  0xF0, 0xE7, 0x0E, 0x38, 0xE1, 0xCE, 0x1C, 0xE0, 0xEE, 0x07, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0x60, 0xCE, 0x39, 0xC7, 0x78, 0xED,
  0x37, 0xB6, 0xF6, 0xDE, 0x73, 0xCE, 0x79, 0xCF, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xFC, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF9,
  0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xDF, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x07, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0x7E, 0x0F, 0x81, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xF0, 0x7E, 0x0E, 0xE3, 0x9F, 0xE1, 0xF8,
  0xFE, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0E, 0xFF, 0xBF,
  0xCC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1F, 0x07, 0xF1, 0xC7,
  0x70, 0x7E, 0x0F, 0xC1, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xF0,
  0x7E, 0x0E, 0xE3, 0x9F, 0xE1, 0xF8, 0x0E, 0x00, 0xE0, 0x1F, 0x80, 0xE0,
  0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x0D, 0xC1, 0xB8, 0x77, 0x1E, 0xFF,
  0x9F, 0xE3, 0x8C, 0x71, 0xCE, 0x19, 0xC3, 0xB8, 0x3F, 0x07, 0x1F, 0xCF,
  0xF9, 0xC2, 0x30, 0x06, 0x00, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x78,
  0x03, 0x00, 0x70, 0x0E, 0x83, 0xBF, 0xF3, 0xFC, 0xFF, 0xFF, 0xFC, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E,
  0xE3, 0x9F, 0xF1, 0xFC, 0xE0, 0x3B, 0x01, 0x9C, 0x1C, 0xE0, 0xE7, 0x06,
  0x18, 0x30, 0xC3, 0x87, 0x1C, 0x18, 0xC0, 0xC6, 0x07, 0x70, 0x3B, 0x00,
  0xD8, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF3, 0x9E, 0x73, 0xCE, 0x7B, 0x6F, 0x6D, 0xE9, 0xBF, 0x14,
  0xE3, 0x9C, 0x73, 0x06, 0x70, 0x73, 0x06, 0x38, 0xE1, 0x8C, 0x1D, 0xC0,
  0xD8, 0x0F, 0x80, 0x70, 0x0F, 0x80, 0xF8, 0x1D, 0xC1, 0x8C, 0x38, 0xE3,
  0x06, 0x70, 0x7E, 0x07, 0xE0, 0x3B, 0x83, 0x9C, 0x1C, 0x60, 0xC3, 0x8E,
  0x0C, 0x60, 0x77, 0x01, 0xB0, 0x0F, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0x00, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xC0,
  0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07,
  0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38,
  0x1C, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xC0, 0x0E, 0x01, 0xC0,
  0x7C, 0x1D, 0xC3, 0xB8, 0xE3, 0x98, 0x37, 0x07, 0x40, 0x40, 0xFF, 0xFF,
  0xFF, 0xC0, 0x47, 0x1C, 0x71, 0x00, 0x3F, 0x8F, 0xF0, 0x1C, 0x03, 0x00,
  0xCF, 0xF7, 0xFF, 0x83, 0xE0, 0xF8, 0x37, 0xFC, 0xFF, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0F, 0xF3, 0xFE, 0xE3, 0xB0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x0E, 0xFF, 0x3F, 0x80, 0x1F, 0xE7, 0xF9, 0xE0,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0xFD, 0xFF, 0x71,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0D, 0xC3, 0x7F, 0xC7, 0xF0,
  0x1F, 0x8F, 0xF9, 0xC7, 0x70, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x0E, 0x09, 0xFF, 0x0F, 0xE0, 0x03, 0xD0, 0xFE, 0x1E, 0x61, 0xC0, 0x18,
  0x01, 0x80, 0xFF, 0xCF, 0xFC, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xDF, 0xF7, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xDF, 0xF3, 0xFC, 0x03, 0x01,
  0xE0, 0x77, 0xFB, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xF9,
  0xFE, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xC0, 0x08, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x71, 0x0F,
  0xE0, 0xFC, 0x06, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x7F, 0x7F, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x87, 0xFE, 0xFE,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1F, 0x0E, 0xC7, 0x33,
  0x8D, 0xC3, 0xE0, 0xDC, 0x33, 0x8C, 0x73, 0x0E, 0xC3, 0xB0, 0x70, 0xFC,
  0x1F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x71, 0x0F, 0xE0, 0xFC,
  0xFB, 0xDF, 0xFF, 0x31, 0xE7, 0x3C, 0xE7, 0x9C, 0xF3, 0x9E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x30, 0xFE, 0x7F, 0xB0, 0xF8, 0x7C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x1F, 0x0F, 0xF1, 0xC7, 0x70,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEE, 0x39, 0xFE, 0x0F, 0x80,
  0xFE, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8,
  0xEF, 0xFB, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1F, 0xDF, 0xF7, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xDC, 0x77, 0xFC, 0xFF, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x7F, 0xFF, 0xB8, 0x38, 0x0F, 0x03,
  0xF0, 0x7C, 0x0F, 0x01, 0xC0, 0xFF, 0xFF, 0xE0, 0x04, 0x03, 0x80, 0x70,
  0x0E, 0x0F, 0xFF, 0xFF, 0xC7, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x47, 0xF8, 0x7F, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xDF, 0xEF, 0xF0, 0xC0, 0x7C, 0x1F, 0x83,
  0x30, 0x67, 0x1C, 0xE3, 0x0C, 0xE1, 0xDC, 0x1B, 0x03, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x36, 0x03, 0x60, 0x36, 0x73, 0x67, 0x36, 0x73, 0x6D, 0xB6,
  0xDA, 0x3D, 0xE3, 0x8E, 0x38, 0xE3, 0x0E, 0xE0, 0xEE, 0x38, 0xC6, 0x1D,
  0xC1, 0xF0, 0x1C, 0x07, 0xC0, 0xD8, 0x3B, 0x8E, 0x39, 0x83, 0x70, 0x70,
  0xE0, 0xEC, 0x1D, 0xC3, 0x38, 0x63, 0x1C, 0x63, 0x0E, 0x60, 0xDC, 0x1F,
  0x01, 0xE0, 0x3C, 0x03, 0x00, 0xE0, 0x18, 0x3F, 0x07, 0xC0, 0xFF, 0xFF,
  0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x3F, 0xFF, 0xF0,
  0x0F, 0x8F, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x3C,
  0x1E, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xF8,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7E,
  0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0xE0, 0xF0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xC7, 0xC0, 0x38,
  0x4F, 0x8F, 0xBF, 0xE3, 0xE0,
};

const GFXglyph UbuntuSansMono_Medium23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 7, 6, 13, 3, -17 },
  { 13, 11, 16, 13, 1, -16 },
  { 35, 11, 21, 13, 1, -18 },
  { 64, 13, 16, 13, 0, -16 },
  { 90, 11, 16, 13, 1, -16 },
  { 112, 3, 7, 13, 5, -17 },
  { 115, 7, 22, 13, 3, -18 },
  { 135, 7, 22, 13, 3, -18 },
  { 155, 11, 10, 13, 1, -16 },
  { 169, 11, 11, 13, 1, -12 },
  { 185, 5, 8, 13, 4, -4 },
  { 190, 7, 3, 13, 3, -8 },
  { 193, 5, 4, 13, 4, -4 },
  { 196, 9, 22, 13, 2, -18 },
  { 221, 11, 16, 13, 1, -16 },
  { 243, 10, 16, 13, 2, -16 },
  { 263, 11, 16, 13, 1, -16 },
  { 285, 10, 16, 13, 1, -16 },
  { 305, 11, 16, 13, 1, -16 },
  { 327, 10, 16, 13, 1, -16 },
  { 347, 11, 16, 13, 1, -16 },
  { 369, 11, 16, 13, 1, -16 },
  { 391, 11, 16, 13, 1, -16 },
  { 413, 11, 16, 13, 1, -16 },
  { 435, 5, 12, 13, 4, -12 },
  { 443, 6, 16, 13, 3, -12 },
  { 455, 11, 11, 13, 1, -12 },
  { 471, 11, 7, 13, 1, -10 },
  { 481, 11, 11, 13, 1, -12 },
  { 497, 9, 16, 13, 2, -16 },
  { 515, 11, 19, 13, 1, -16 },
  { 542, 13, 16, 13, 0, -16 },
  { 568, 11, 16, 13, 1, -16 },
  { 590, 11, 16, 13, 1, -16 },
  { 612, 11, 16, 13, 1, -16 },
  { 634, 10, 16, 13, 2, -16 },
  { 654, 9, 16, 13, 2, -16 },
  { 672, 11, 16, 13, 1, -16 },
  { 694, 11, 16, 13, 1, -16 },
  { 716, 9, 16, 13, 2, -16 },
  { 734, 10, 16, 13, 1, -16 },
  { 754, 12, 16, 13, 1, -16 },
  { 778, 10, 16, 13, 2, -16 },
  { 798, 11, 16, 13, 1, -16 },
  { 820, 11, 16, 13, 1, -16 },
  { 842, 11, 16, 13, 1, -16 },
  { 864, 10, 16, 13, 2, -16 },
  { 884, 11, 20, 13, 1, -16 },
  { 912, 11, 16, 13, 1, -16 },
  { 934, 11, 16, 13, 1, -16 },
  { 956, 11, 16, 13, 1, -16 },
  { 978, 11, 16, 13, 1, -16 },
  { 1000, 13, 16, 13, 0, -16 },
  { 1026, 11, 16, 13, 1, -16 },
  { 1048, 12, 16, 13, 0, -16 },
  { 1072, 13, 16, 13, 0, -16 },
  { 1098, 11, 16, 13, 1, -16 },
  { 1120, 7, 22, 13, 3, -18 },
  { 1140, 9, 22, 13, 2, -18 },
  { 1165, 7, 22, 13, 3, -18 },
  { 1185, 11, 9, 13, 1, -16 },
  { 1198, 13, 2, 13, 0, 2 },
  { 1202, 5, 5, 13, 4, -18 },
  { 1206, 10, 12, 13, 1, -12 },
  { 1221, 10, 18, 13, 2, -18 },
  { 1244, 11, 12, 13, 1, -12 },
  { 1261, 10, 18, 13, 1, -18 },
  { 1284, 11, 12, 13, 1, -12 },
  { 1301, 12, 18, 13, 1, -18 },
  { 1328, 10, 16, 13, 1, -12 },
  { 1348, 9, 18, 13, 2, -18 },
  { 1369, 11, 18, 13, 1, -18 },
  { 1394, 8, 22, 13, 2, -18 },
  { 1416, 10, 18, 13, 2, -18 },
  { 1439, 11, 18, 13, 1, -18 },
  { 1464, 11, 12, 13, 1, -12 },
  { 1481, 9, 12, 13, 2, -12 },
  { 1495, 11, 12, 13, 1, -12 },
  { 1512, 10, 16, 13, 2, -12 },
  { 1532, 10, 16, 13, 1, -12 },
  { 1552, 9, 12, 13, 3, -12 },
  { 1566, 9, 12, 13, 2, -12 },
  { 1580, 11, 16, 13, 1, -16 },
  { 1602, 9, 12, 13, 2, -12 },
  { 1616, 11, 12, 13, 1, -12 },
  { 1633, 12, 12, 13, 0, -12 },
  { 1651, 11, 12, 13, 1, -12 },
  { 1668, 11, 16, 13, 1, -12 },
  { 1690, 9, 12, 13, 2, -12 },
  { 1704, 9, 22, 13, 2, -18 },
  { 1729, 3, 22, 13, 5, -18 },
  { 1738, 9, 22, 13, 2, -18 },
  { 1763, 11, 4, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_Medium23pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium23pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium23pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUSANSMONO_MEDIUM23PT7B_H_
