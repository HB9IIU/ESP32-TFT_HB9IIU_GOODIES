#ifndef _UBUNTUSANSMONO_MEDIUM26PT7B_H_
#define _UBUNTUSANSMONO_MEDIUM26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Medium.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Medium26pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0x00, 0x7F, 0xF7, 0xE7, 0xE7,
  0xE7, 0xE3, 0xE3, 0x63, 0x63, 0x63, 0x0E, 0x70, 0x63, 0x83, 0x18, 0x38,
  0xC1, 0xC6, 0x7F, 0xFF, 0xFF, 0xE3, 0x18, 0x38, 0xC1, 0xC6, 0x0E, 0x71,
  0xFF, 0xFF, 0xFF, 0xB8, 0xC1, 0xC6, 0x0E, 0x70, 0x63, 0x83, 0x1C, 0x00,
  0x07, 0x00, 0x70, 0x07, 0x01, 0xFE, 0x3F, 0xE7, 0x82, 0x70, 0x07, 0x00,
  0x78, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x40, 0x77, 0xFF, 0xFF, 0xE1, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7C,
  0x1D, 0xB0, 0x66, 0x63, 0xB1, 0x8C, 0xC6, 0x61, 0x9B, 0x86, 0xCC, 0x1F,
  0x60, 0x1B, 0x80, 0x0C, 0xC0, 0x67, 0x81, 0xB3, 0x0C, 0xCC, 0x73, 0x31,
  0x8C, 0xCC, 0x33, 0x70, 0xFF, 0x81, 0xE0, 0x1F, 0x01, 0xFC, 0x1C, 0x70,
  0xE3, 0x87, 0x1C, 0x38, 0xC0, 0xCE, 0x07, 0xE0, 0x3C, 0x33, 0xF3, 0x9F,
  0xDD, 0xCF, 0xEE, 0x3E, 0x60, 0xF3, 0x83, 0x9C, 0x7E, 0x7F, 0xF1, 0xF1,
  0xC0, 0xFF, 0xFF, 0xF6, 0x01, 0x01, 0x81, 0xE1, 0xC1, 0xC1, 0xC0, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1F, 0x07, 0x01, 0x00, 0x40, 0x60,
  0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x40,
  0x0E, 0x01, 0xC2, 0x38, 0x76, 0x7F, 0x7F, 0xFF, 0x87, 0x81, 0xD8, 0x7B,
  0x8E, 0x78, 0x44, 0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x3D, 0xF3, 0xCF, 0x1C, 0xEF, 0x38, 0xFF, 0xFF, 0xF8, 0xF7, 0xFF, 0xE0,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F,
  0x83, 0xFC, 0x78, 0xE7, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x73, 0xE7,
  0x3E, 0x73, 0xE2, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0xE7, 0x8E, 0x3F,
  0xC1, 0xF8, 0x07, 0x01, 0xE0, 0xFC, 0x7F, 0x8F, 0x70, 0x8E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x7F, 0xEF, 0xFC, 0x7F, 0x1F, 0xF3, 0x8F, 0x40, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x07,
  0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F, 0xF1, 0x0F, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0xFC, 0x1F, 0x03, 0xF8, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x3E, 0x1E, 0xFF, 0xDF, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0xEE, 0x0E, 0x70, 0x63, 0x87, 0x1C, 0x30, 0xE3, 0x87, 0x38, 0x39, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7F,
  0xCF, 0xF9, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x7F, 0x80,
  0xF8, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x1E, 0xFF, 0xDF, 0xE0,
  0x01, 0xE0, 0x7E, 0x0F, 0x81, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0xFC,
  0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x07, 0x70, 0x77, 0x8E,
  0x3F, 0xE1, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0x1F, 0xC3, 0xFE, 0x78, 0xE7, 0x07, 0x70, 0x77,
  0x07, 0x70, 0xE3, 0xDE, 0x1F, 0xC3, 0xFC, 0x71, 0xE7, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x77, 0x0F, 0x7F, 0xE1, 0xFC, 0x1F, 0x83, 0xFE, 0x70, 0xE7,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x78, 0xF3, 0xFF, 0x1F, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC3, 0xF8, 0x7F, 0x07, 0x80, 0xF7, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0x00, 0x79, 0xF7, 0xDE, 0x00, 0x00,
  0x00, 0x01, 0xE7, 0xDF, 0x7C, 0x63, 0xBC, 0xE0, 0x00, 0x70, 0x1F, 0x07,
  0xE3, 0xF8, 0xFC, 0x0F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00,
  0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x60, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0x01,
  0xF0, 0xFE, 0x3F, 0x0F, 0xC0, 0x70, 0x04, 0x00, 0xFF, 0x9F, 0xE4, 0x3C,
  0x07, 0x01, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x00, 0x0F, 0xC0, 0xFF, 0x0E, 0x1C,
  0xE0, 0x66, 0x03, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xCE, 0x3E, 0x71, 0xF3,
  0x8F, 0x9C, 0x7C, 0xE3, 0xF7, 0x1F, 0x9E, 0xFC, 0x7F, 0x61, 0xF3, 0x80,
  0x0E, 0x00, 0x3C, 0x40, 0xFE, 0x01, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x7C,
  0x03, 0xB0, 0x0E, 0xE0, 0x33, 0x81, 0xCE, 0x07, 0x18, 0x18, 0x70, 0x61,
  0xC3, 0x83, 0x0F, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7, 0x03, 0x9C, 0x07, 0x70,
  0x1F, 0x80, 0x70, 0xFF, 0x1F, 0xF3, 0x0F, 0x60, 0xEC, 0x0F, 0x81, 0xB0,
  0x77, 0xFC, 0xFF, 0x1F, 0xFB, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x1F, 0xFF, 0xDF, 0xE0, 0x0F, 0xF0, 0xFF, 0x8F, 0x0C, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x86, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x0F,
  0xF8, 0xC7, 0xCC, 0x1C, 0xC0, 0xEC, 0x0E, 0xC0, 0xEC, 0x06, 0xC0, 0x7C,
  0x07, 0xC0, 0x6C, 0x0E, 0xC0, 0xEC, 0x0E, 0xC1, 0xCC, 0x7C, 0xFF, 0x8F,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE,
  0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0xFE, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x00, 0x0F, 0xF1, 0xFF, 0x3C, 0x37, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x07,
  0x78, 0x73, 0xC7, 0x1F, 0xF0, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xF0, 0x3F, 0xE7, 0xFC, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x3B, 0x0F, 0xFF, 0xCF, 0xF0, 0xE0, 0xFE, 0x1E,
  0xE1, 0xCE, 0x38, 0xE7, 0x8E, 0xF0, 0xEE, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0,
  0xEF, 0x0E, 0x70, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x0E, 0xE0, 0xFE, 0x07,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF,
  0xFC, 0x70, 0x73, 0x83, 0x9C, 0x3C, 0xF1, 0xE7, 0x8F, 0x7C, 0xDB, 0xB6,
  0xDD, 0xB6, 0xEF, 0x37, 0x39, 0xB9, 0xCD, 0xC0, 0x6E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xC0, 0xC0, 0xFC, 0x1F, 0xC3, 0xF8,
  0x7F, 0x8F, 0xB1, 0xF7, 0x3E, 0x67, 0xCE, 0xF8, 0xDF, 0x1B, 0xE1, 0xFC,
  0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1C, 0x1F, 0xC1, 0xFF, 0x1E,
  0x38, 0xE0, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0x70, 0x39, 0xC1, 0xCF, 0x1C, 0x3F, 0xE0,
  0xFC, 0x00, 0xFF, 0x9F, 0xFB, 0x8F, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE1, 0xFF, 0xFB, 0xFE, 0x7E, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x00, 0x1F, 0x81, 0xFF, 0x1E, 0x38, 0xE0, 0xEE, 0x07, 0x70,
  0x1B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0x70, 0x39, 0xC1, 0xCF, 0x1C, 0x3F, 0xE0, 0xFE, 0x01, 0xC0, 0x0E, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0xC0, 0xFF, 0x0F, 0xF8, 0xE7, 0xCE, 0x1C, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE7, 0xCF, 0xF8, 0xFF, 0x0E, 0x70, 0xE3,
  0x8E, 0x1C, 0xE1, 0xCE, 0x0E, 0xE0, 0xEE, 0x07, 0x1F, 0xE3, 0xFE, 0x78,
  0x67, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x76, 0x0F, 0x7F, 0xEF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x70, 0x77, 0x8F, 0x3F, 0xE1, 0xFC, 0xF0, 0x1D, 0xC0, 0x77,
  0x01, 0xDC, 0x0E, 0x70, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0C, 0x18, 0x70,
  0x71, 0xC1, 0xC6, 0x07, 0x38, 0x0C, 0xE0, 0x3B, 0x00, 0xEC, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1B, 0x80, 0xDC, 0xE6, 0xE7, 0x37, 0x79, 0xBB, 0x6D, 0xDB, 0x6F,
  0x9B, 0x3C, 0x79, 0xE3, 0xCE, 0x1E, 0x70, 0x73, 0x83, 0x80, 0xE0, 0x7B,
  0x83, 0x9C, 0x38, 0x71, 0xC3, 0x9C, 0x0E, 0xE0, 0x7E, 0x01, 0xF0, 0x07,
  0x00, 0x7C, 0x07, 0xE0, 0x3B, 0x83, 0x9C, 0x1C, 0x71, 0xC3, 0x8E, 0x0E,
  0xE0, 0x77, 0x01, 0xC0, 0xF0, 0x1D, 0xC0, 0x77, 0x03, 0x8E, 0x0E, 0x38,
  0x70, 0x71, 0xC1, 0xCE, 0x03, 0xB8, 0x0E, 0xC0, 0x1F, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F,
  0xFE, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0,
  0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF,
  0xFF, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0x83, 0xDC, 0x1C, 0x71, 0xC3,
  0x8E, 0x0E, 0xE0, 0x7B, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x47, 0x3C, 0x71, 0x00, 0x7F, 0x0F, 0xF1, 0xFF, 0x00, 0xE0, 0x0E, 0x01,
  0xCF, 0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0xFE, 0xFF, 0xC0,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0x0F, 0xFC,
  0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x3C, 0xFF, 0xCF, 0xF0, 0x07, 0xE1, 0xFF, 0x3F, 0xF7, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0xC1,
  0x3F, 0xF0, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x0F, 0x73, 0xFF, 0x7F, 0xF7, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x70, 0x77, 0x87, 0x3F, 0xF1, 0xFF, 0x0F, 0x83, 0xFE,
  0x7F, 0xE7, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0xC2, 0x3F, 0xE1, 0xFF, 0x07, 0xF0, 0xFF, 0x1E, 0x31, 0xC0,
  0x38, 0x03, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x0F, 0xC3, 0xFF, 0x7F, 0xF7, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x07, 0x78, 0xF7, 0xFF, 0x1F, 0xF0, 0x07, 0x00, 0x60, 0x0E,
  0x7F, 0xE7, 0xFC, 0x3F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3F, 0xC7, 0xFC, 0xFF, 0xDC, 0x3B, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x70, 0x0C, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x71,
  0x07, 0xF0, 0x3F, 0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x00, 0x01, 0xFE, 0xFF,
  0x7F, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x3C, 0x1F, 0xFF, 0xFE, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x1E, 0xE3, 0xCE, 0x78, 0xEF,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xEF, 0x0E, 0x78, 0xE3, 0x8E, 0x1C, 0xE0,
  0xEE, 0x0F, 0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x71, 0x07, 0xF0, 0x3F, 0x79, 0xE7, 0xFF, 0xBF,
  0xFD, 0xCC, 0x6E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1C, 0x7F, 0x1F, 0xF3, 0xFF, 0x70,
  0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xC0, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xE1, 0xEE, 0x07, 0x70,
  0x3B, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x03, 0x9C, 0x1C, 0xF1, 0xC3, 0xFE,
  0x0F, 0xC0, 0x7E, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0,
  0x6E, 0x07, 0xE0, 0xEE, 0x0E, 0xE0, 0xEF, 0x1E, 0xFF, 0xCF, 0xF8, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xC3, 0xFF, 0x7F, 0xF7,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0x77,
  0x8F, 0x3F, 0xF1, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x1F, 0xBF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x1F, 0x8F, 0xFB, 0xFF, 0x70, 0x0E,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0xFF, 0xFD,
  0xFF, 0x00, 0x08, 0x07, 0x00, 0xE0, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE1,
  0x1F, 0xE1, 0xFC, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xFC, 0x77, 0xFE, 0x7F, 0xC0, 0xE0,
  0x3F, 0x01, 0xF8, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x70, 0xE3, 0x87, 0x38,
  0x39, 0xC0, 0xEE, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x03, 0x80, 0xE0, 0x0D,
  0x80, 0x76, 0x01, 0xD8, 0xC7, 0x63, 0x9D, 0x8E, 0x77, 0x79, 0x9D, 0xF6,
  0x76, 0xD8, 0xF3, 0x63, 0xCF, 0x8F, 0x1C, 0x38, 0x70, 0xE0, 0xC0, 0xE0,
  0x7B, 0x83, 0x9E, 0x38, 0x73, 0x81, 0xDC, 0x07, 0xC0, 0x3C, 0x01, 0xF0,
  0x1F, 0x80, 0xEE, 0x0E, 0x38, 0xE1, 0xC7, 0x07, 0x70, 0x3C, 0xE0, 0x3B,
  0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x06, 0x1C, 0x70, 0xE3, 0x83, 0x9C, 0x1D,
  0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0xFE, 0x07, 0xE0, 0x3C, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xE1, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x7C, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x7F, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x3F,
  0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70,
  0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x81, 0xE3, 0xF0, 0xF8, 0x00, 0x3C, 0x13, 0xF1, 0xFF, 0xFD, 0x87,
  0xE4, 0x0C, 0x00,
};

const GFXglyph UbuntuSansMono_Medium26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 18, 15, 5, -18 },
  { 10, 8, 8, 15, 3, -20 },
  { 18, 13, 18, 15, 1, -18 },
  { 48, 12, 23, 15, 1, -20 },
  { 83, 14, 18, 15, 0, -18 },
  { 115, 13, 18, 15, 1, -18 },
  { 145, 3, 8, 15, 6, -20 },
  { 148, 9, 26, 15, 3, -21 },
  { 178, 8, 26, 15, 3, -21 },
  { 204, 11, 11, 15, 2, -18 },
  { 220, 12, 13, 15, 1, -14 },
  { 240, 6, 8, 15, 4, -4 },
  { 246, 7, 3, 15, 4, -9 },
  { 249, 5, 4, 15, 5, -4 },
  { 252, 11, 25, 15, 2, -20 },
  { 287, 12, 18, 15, 1, -18 },
  { 314, 11, 18, 15, 2, -18 },
  { 339, 11, 18, 15, 2, -18 },
  { 364, 11, 18, 15, 2, -18 },
  { 389, 13, 18, 15, 1, -18 },
  { 419, 11, 18, 15, 2, -18 },
  { 444, 12, 18, 15, 1, -18 },
  { 471, 11, 18, 15, 2, -18 },
  { 496, 12, 18, 15, 1, -18 },
  { 523, 12, 18, 15, 1, -18 },
  { 550, 5, 13, 15, 5, -13 },
  { 559, 6, 17, 15, 4, -13 },
  { 572, 12, 12, 15, 1, -13 },
  { 590, 12, 8, 15, 1, -12 },
  { 602, 12, 12, 15, 1, -13 },
  { 620, 10, 18, 15, 2, -18 },
  { 643, 13, 22, 15, 1, -18 },
  { 679, 14, 18, 15, 0, -18 },
  { 711, 11, 18, 15, 2, -18 },
  { 736, 13, 18, 15, 1, -18 },
  { 766, 12, 18, 15, 2, -18 },
  { 793, 11, 18, 15, 2, -18 },
  { 818, 11, 18, 15, 2, -18 },
  { 843, 12, 18, 15, 1, -18 },
  { 870, 12, 18, 15, 1, -18 },
  { 897, 10, 18, 15, 2, -18 },
  { 920, 11, 18, 15, 1, -18 },
  { 945, 12, 18, 15, 2, -18 },
  { 972, 11, 18, 15, 2, -18 },
  { 997, 13, 18, 15, 1, -18 },
  { 1027, 11, 18, 15, 2, -18 },
  { 1052, 13, 18, 15, 1, -18 },
  { 1082, 11, 18, 15, 2, -18 },
  { 1107, 13, 23, 15, 1, -18 },
  { 1145, 12, 18, 15, 2, -18 },
  { 1172, 12, 18, 15, 1, -18 },
  { 1199, 13, 18, 15, 1, -18 },
  { 1229, 12, 18, 15, 1, -18 },
  { 1256, 14, 18, 15, 0, -18 },
  { 1288, 13, 18, 15, 1, -18 },
  { 1318, 13, 18, 15, 1, -18 },
  { 1348, 14, 18, 15, 0, -18 },
  { 1380, 12, 18, 15, 1, -18 },
  { 1407, 7, 25, 15, 4, -20 },
  { 1429, 11, 25, 15, 2, -20 },
  { 1464, 8, 25, 15, 3, -20 },
  { 1489, 13, 10, 15, 1, -18 },
  { 1506, 14, 3, 15, 0, 2 },
  { 1512, 5, 5, 15, 5, -20 },
  { 1516, 11, 14, 15, 2, -14 },
  { 1536, 12, 20, 15, 2, -20 },
  { 1566, 12, 14, 15, 1, -14 },
  { 1587, 12, 20, 15, 1, -20 },
  { 1617, 12, 14, 15, 1, -14 },
  { 1638, 12, 20, 15, 2, -20 },
  { 1668, 12, 19, 15, 1, -14 },
  { 1697, 11, 20, 15, 2, -20 },
  { 1725, 12, 20, 15, 1, -20 },
  { 1755, 9, 25, 15, 2, -20 },
  { 1784, 12, 20, 15, 2, -20 },
  { 1814, 12, 20, 15, 1, -20 },
  { 1844, 13, 14, 15, 1, -14 },
  { 1867, 11, 14, 15, 2, -14 },
  { 1887, 13, 14, 15, 1, -14 },
  { 1910, 12, 19, 15, 2, -14 },
  { 1939, 12, 19, 15, 1, -14 },
  { 1968, 10, 14, 15, 3, -14 },
  { 1986, 11, 14, 15, 2, -14 },
  { 2006, 11, 18, 15, 2, -18 },
  { 2031, 11, 14, 15, 2, -14 },
  { 2051, 13, 14, 15, 1, -14 },
  { 2074, 14, 14, 15, 0, -14 },
  { 2099, 13, 14, 15, 1, -14 },
  { 2122, 13, 19, 15, 1, -14 },
  { 2153, 11, 14, 15, 2, -14 },
  { 2173, 11, 25, 15, 2, -20 },
  { 2208, 3, 25, 15, 6, -20 },
  { 2218, 10, 25, 15, 2, -20 },
  { 2250, 13, 5, 15, 1, -10 },
};

const GFXfont UbuntuSansMono_Medium26pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Medium26pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Medium26pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUSANSMONO_MEDIUM26PT7B_H_
