#ifndef _NOTOSANS_SEMICONDENSED_BLACK20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x4F, 0xFE, 0xF7, 0xE7, 0xE7, 0xE7,
  0xE7, 0x0E, 0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x1D, 0xC1,
  0x98, 0xFF, 0xFF, 0xFF, 0x3B, 0x83, 0xB8, 0x33, 0x03, 0x30, 0x08, 0x1F,
  0x3F, 0xFF, 0xFE, 0x8F, 0x43, 0xE0, 0xFE, 0x3F, 0x87, 0xC2, 0xF9, 0x7F,
  0xFF, 0xF8, 0x20, 0x10, 0x7C, 0x1C, 0x1F, 0x8E, 0x06, 0xE3, 0x83, 0x99,
  0xC0, 0xE6, 0x70, 0x1B, 0xB9, 0xC7, 0xEE, 0xF8, 0xF7, 0x7E, 0x01, 0xDD,
  0xC0, 0xE7, 0x70, 0x39, 0xDC, 0x1C, 0x77, 0x07, 0x1F, 0x83, 0x83, 0xC0,
  0x3F, 0x01, 0xFE, 0x07, 0x38, 0x1C, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xE7,
  0xBF, 0xDE, 0xFF, 0xF3, 0x9F, 0xCE, 0x3E, 0x3F, 0xFC, 0xFF, 0xF9, 0xFD,
  0xF0, 0xFE, 0xEE, 0xE0, 0x3C, 0xE7, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0xC7, 0x1C, 0x78, 0xF0, 0xF1, 0xC3, 0x8E, 0x3C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0xF3, 0x8E, 0x7B, 0xC0, 0x0E, 0x03, 0x04, 0xCD,
  0xFF, 0xFF, 0xC7, 0x83, 0xF1, 0xEE, 0x13, 0x00, 0x1C, 0x0E, 0x07, 0x03,
  0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0xFF, 0xEE, 0xEC, 0xFF,
  0xFF, 0xC0, 0x4F, 0xFE, 0x07, 0x83, 0x83, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x80, 0x3E, 0x3F, 0xBF, 0xFE,
  0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFD, 0xFF, 0xF7, 0xF1, 0xF0,
  0x0F, 0x3F, 0x7F, 0xFF, 0xFF, 0x6F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x3F, 0xBF, 0xE7, 0xFC, 0x8F, 0x03, 0xC0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x81, 0xFF, 0x7F, 0xDF, 0xF0, 0xFF, 0x7F, 0xDF, 0xE0,
  0xF0, 0x79, 0xF8, 0xF0, 0x7E, 0x07, 0x83, 0xE1, 0xFF, 0xFF, 0xF7, 0xF0,
  0x07, 0x80, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x77, 0x0E, 0xE3, 0x9C, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0x3F, 0xBF, 0xDE,
  0x0F, 0x07, 0xFB, 0xFC, 0xFF, 0x07, 0x83, 0xE1, 0xFF, 0xFF, 0xF7, 0xF0,
  0x1F, 0xBF, 0xDF, 0x3E, 0x0E, 0x47, 0x7B, 0xFF, 0xEF, 0xE3, 0xF1, 0xFC,
  0xFF, 0xF7, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0x78, 0x3C,
  0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0x83, 0xC0, 0x7F, 0x7F, 0xFD, 0xFC,
  0x7F, 0x7B, 0xF8, 0xF8, 0xFE, 0xF7, 0xF1, 0xF8, 0xFF, 0xFF, 0xFB, 0xF8,
  0x7E, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFF, 0x7B, 0x81, 0xC1,
  0xFF, 0xEF, 0xE7, 0xE0, 0xFF, 0xF4, 0x00, 0x04, 0xFF, 0xF0, 0xFF, 0xF4,
  0x00, 0x00, 0xFF, 0xEE, 0xEC, 0x00, 0x80, 0xC1, 0xE3, 0xF7, 0xE7, 0x83,
  0xE0, 0xFE, 0x0F, 0x81, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x3C, 0x1F, 0x83, 0xF0, 0x3C, 0x3E, 0x7E,
  0xF8, 0x70, 0x20, 0x00, 0x7F, 0x7F, 0xDF, 0xE8, 0x70, 0x78, 0x78, 0x78,
  0x38, 0x1C, 0x00, 0x02, 0x07, 0x83, 0xC1, 0xE0, 0x0F, 0xF0, 0x7F, 0xF0,
  0xE0, 0x73, 0x9F, 0x7E, 0x7E, 0xFD, 0xCC, 0xF3, 0x19, 0xE6, 0x33, 0xCC,
  0xE7, 0x9D, 0xDF, 0xBF, 0xF7, 0x18, 0xC7, 0x00, 0x87, 0xFE, 0x07, 0xFC,
  0x00, 0x80, 0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x3B, 0x81, 0xDE, 0x0E, 0xF0,
  0xF3, 0x87, 0x9C, 0x3F, 0xF3, 0xFF, 0x9F, 0xFC, 0xF0, 0xFF, 0x07, 0xF8,
  0x3C, 0xFF, 0x9F, 0xFB, 0xFF, 0x78, 0xEF, 0x1D, 0xFF, 0xBF, 0xC7, 0xFE,
  0xF1, 0xFE, 0x3F, 0xC7, 0xFF, 0xEF, 0xFD, 0xFE, 0x00, 0x1F, 0xCF, 0xF7,
  0xFD, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x85, 0xFF,
  0x3F, 0xC7, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0, 0xEF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xF3, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x1F, 0xE3, 0xFE, 0x7F, 0xCF, 0x80, 0xF0, 0x0F,
  0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x0F, 0x78, 0xF7, 0xFF, 0x3F, 0xF1,
  0xFE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFD,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xEF, 0xFF, 0xC0, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFB,
  0xE0, 0xF1, 0xFF, 0x1E, 0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x8F, 0x3C, 0xF3, 0xCF, 0x1E, 0xF1, 0xEF, 0x1F, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF,
  0xFF, 0xFC, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xF7, 0x6F, 0xF7, 0xEF, 0xF7, 0xEF, 0xF7, 0xEF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x9F, 0xDC, 0xFE, 0xF7, 0xF3, 0xBF, 0x9F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x0F, 0xF8, 0x7C, 0x02, 0x00, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF,
  0x8F, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3C, 0xF1,
  0xE7, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0x3F, 0xEF, 0xFF, 0xCF, 0xF3,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00,
  0x02, 0x00, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0x8F, 0x78, 0x3B, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3C, 0xF1, 0xE7, 0xFF, 0x1F, 0xF0, 0x7F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0x78, 0xF3, 0xCF, 0x3C,
  0xF1, 0xEF, 0x1F, 0x7F, 0xFF, 0xFF, 0xDE, 0x2F, 0x07, 0xE1, 0xFC, 0x7E,
  0x0F, 0x83, 0xE1, 0xFF, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0x79, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0xF0, 0x7B,
  0x87, 0x9E, 0x3C, 0xF1, 0xE7, 0x8E, 0x1C, 0xF0, 0xF7, 0x87, 0xBC, 0x1D,
  0xC0, 0xEE, 0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0xE1, 0xEE,
  0x1E, 0x3D, 0xC7, 0xC7, 0x3C, 0xF8, 0xE7, 0x9F, 0x3C, 0x73, 0x67, 0x8E,
  0xEE, 0xE1, 0xDD, 0xDC, 0x3B, 0xBB, 0x87, 0xF7, 0xF0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x00, 0xF8, 0xFB, 0xC7, 0x8F, 0x78,
  0x7B, 0x81, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F,
  0x78, 0xF3, 0xC7, 0x8F, 0x78, 0x3C, 0xF0, 0xF7, 0x8E, 0x79, 0xE3, 0xDC,
  0x3F, 0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x38, 0x1E, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xC0, 0xF0, 0x38, 0x1C,
  0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0x70,
  0x3C, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF,
  0xC0, 0x0C, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xB0, 0x67, 0x1C, 0x63, 0x8E,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xE1, 0xC0, 0x7F, 0x3F, 0xDD,
  0xE0, 0x73, 0xFF, 0xFF, 0xCF, 0xC7, 0xF7, 0xFF, 0xDE, 0x60, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xFF, 0xBF, 0xEF, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x3F,
  0xCF, 0xFF, 0xFF, 0xEE, 0xF0, 0x3F, 0xBF, 0xBF, 0xDE, 0x0E, 0x07, 0x03,
  0x81, 0xE2, 0xFF, 0x3F, 0x8F, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x7F,
  0xDF, 0xFF, 0xFF, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0xCF, 0xFF, 0xDF, 0xF7,
  0x9C, 0x3F, 0x1F, 0xEF, 0x3B, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFB,
  0x9F, 0xE3, 0xF8, 0x1F, 0x3F, 0x3D, 0x38, 0x7E, 0xFE, 0xFE, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x7D, 0xDF, 0xFF, 0xFF, 0xCF, 0xE3,
  0xF8, 0xFE, 0x3F, 0xCF, 0xFF, 0xDF, 0xF7, 0xBC, 0x0F, 0x83, 0xFF, 0xEF,
  0xF1, 0xF8, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1C, 0x2F, 0xF6, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0xF3, 0xC6, 0x00, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFE, 0xF0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x1F, 0xE7, 0xBD, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFE,
  0x7B, 0xCF, 0x3D, 0xE7, 0xBC, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xEF, 0xBE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC7, 0xF3, 0xC7,
  0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7,
  0xEF, 0xBF, 0xFF, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1C, 0x3F, 0x1F, 0xEF, 0xFB, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0xCF,
  0xFF, 0x9F, 0xE3, 0xF0, 0xEF, 0xBF, 0xEF, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F,
  0x3F, 0xCF, 0xFF, 0xFF, 0xEF, 0xF3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x7D, 0xDF, 0xFF, 0xFF, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0xCF, 0xFF, 0xDF,
  0xF7, 0xBC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xE7, 0xEE, 0xFE, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x7F, 0xFE, 0xE6, 0xF0, 0xFC,
  0x7E, 0x3F, 0x0F, 0xFF, 0xFE, 0xFC, 0x18, 0x38, 0x7F, 0xFF, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x3F, 0xCF, 0xFF, 0xDF, 0xF3, 0xDC, 0xF1, 0xEE, 0x3D,
  0xC7, 0x3C, 0xE3, 0xBC, 0x77, 0x0E, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x3C,
  0x00, 0xF3, 0xE7, 0xB9, 0xF3, 0x9C, 0xF9, 0xCE, 0x6D, 0xE7, 0xB6, 0xF1,
  0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3E, 0x7E, 0x0F, 0x1E, 0x07, 0x8F,
  0x00, 0xF9, 0xEF, 0x78, 0xFF, 0x1F, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xFC,
  0x3B, 0xCF, 0x3F, 0xC7, 0x80, 0xF1, 0xEE, 0x3D, 0xE7, 0x3C, 0xE3, 0xBC,
  0x77, 0x0F, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0xFC,
  0x1F, 0x03, 0x80, 0x7F, 0xBF, 0xDF, 0xE1, 0xE1, 0xE0, 0xE0, 0xF0, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8,
  0xF0, 0xFC, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x1F,
  0x1E, 0x7D, 0xE3, 0x87, 0x0E, 0x1C, 0x78, 0xF0, 0x70, 0xFF, 0xFF, 0xF0,
  0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Black20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 14, 6, 1, -14 },
  { 8, 8, 5, 10, 1, -14 },
  { 13, 12, 14, 12, 0, -14 },
  { 34, 9, 16, 11, 1, -15 },
  { 52, 18, 14, 18, 0, -14 },
  { 84, 14, 14, 15, 1, -14 },
  { 109, 4, 5, 6, 1, -14 },
  { 112, 6, 18, 7, 1, -15 },
  { 126, 6, 18, 7, 0, -15 },
  { 140, 10, 9, 10, 0, -15 },
  { 152, 9, 10, 11, 1, -12 },
  { 164, 4, 6, 6, 1, -3 },
  { 167, 6, 3, 6, 0, -7 },
  { 170, 4, 4, 6, 1, -4 },
  { 172, 9, 14, 9, 0, -14 },
  { 188, 9, 14, 11, 1, -14 },
  { 204, 8, 14, 11, 1, -14 },
  { 218, 10, 14, 11, 0, -14 },
  { 236, 9, 14, 11, 1, -14 },
  { 252, 11, 14, 11, 0, -14 },
  { 272, 9, 14, 11, 1, -14 },
  { 288, 9, 14, 11, 1, -14 },
  { 304, 9, 14, 11, 1, -14 },
  { 320, 9, 14, 11, 1, -14 },
  { 336, 9, 14, 11, 1, -14 },
  { 352, 4, 11, 6, 1, -11 },
  { 358, 4, 14, 6, 1, -11 },
  { 365, 9, 11, 11, 1, -13 },
  { 378, 9, 8, 11, 1, -11 },
  { 387, 9, 11, 11, 1, -13 },
  { 400, 9, 14, 9, 0, -14 },
  { 416, 15, 16, 17, 1, -14 },
  { 446, 13, 14, 13, 0, -14 },
  { 469, 11, 14, 13, 1, -14 },
  { 489, 10, 14, 12, 1, -14 },
  { 507, 12, 14, 14, 1, -14 },
  { 528, 8, 14, 10, 1, -14 },
  { 542, 8, 14, 10, 1, -14 },
  { 556, 12, 14, 14, 1, -14 },
  { 577, 12, 14, 14, 1, -14 },
  { 598, 7, 14, 8, 1, -14 },
  { 611, 6, 18, 7, -1, -14 },
  { 625, 12, 14, 13, 1, -14 },
  { 646, 9, 14, 11, 1, -14 },
  { 662, 16, 14, 18, 1, -14 },
  { 690, 13, 14, 15, 1, -14 },
  { 713, 13, 15, 15, 1, -15 },
  { 738, 10, 14, 12, 1, -14 },
  { 756, 13, 18, 15, 1, -15 },
  { 786, 12, 14, 13, 1, -14 },
  { 807, 9, 14, 11, 1, -14 },
  { 823, 10, 14, 11, 0, -14 },
  { 841, 12, 14, 14, 1, -14 },
  { 862, 13, 14, 13, 0, -14 },
  { 885, 19, 14, 19, 0, -14 },
  { 919, 13, 14, 13, 0, -14 },
  { 942, 12, 14, 12, 0, -14 },
  { 963, 10, 14, 11, 1, -14 },
  { 981, 5, 18, 6, 1, -15 },
  { 993, 9, 14, 9, 0, -14 },
  { 1009, 5, 18, 6, 0, -15 },
  { 1021, 11, 9, 11, 0, -14 },
  { 1034, 10, 3, 10, 0, 1 },
  { 1038, 6, 3, 8, 1, -15 },
  { 1041, 9, 11, 12, 1, -11 },
  { 1054, 10, 15, 12, 1, -15 },
  { 1073, 9, 11, 10, 1, -11 },
  { 1086, 10, 15, 12, 1, -15 },
  { 1105, 10, 11, 11, 1, -11 },
  { 1119, 8, 15, 8, 0, -15 },
  { 1134, 10, 16, 12, 1, -11 },
  { 1154, 10, 15, 12, 1, -15 },
  { 1173, 4, 16, 6, 1, -16 },
  { 1181, 6, 21, 6, -1, -16 },
  { 1197, 11, 15, 12, 1, -15 },
  { 1218, 4, 15, 6, 1, -15 },
  { 1226, 16, 11, 18, 1, -11 },
  { 1248, 10, 11, 12, 1, -11 },
  { 1262, 10, 11, 12, 1, -11 },
  { 1276, 10, 16, 12, 1, -11 },
  { 1296, 10, 16, 12, 1, -11 },
  { 1316, 8, 11, 9, 1, -11 },
  { 1327, 8, 11, 9, 1, -11 },
  { 1338, 8, 13, 8, 0, -13 },
  { 1351, 10, 11, 12, 1, -11 },
  { 1365, 11, 11, 11, 0, -11 },
  { 1381, 17, 11, 17, 0, -11 },
  { 1405, 11, 11, 11, 0, -11 },
  { 1421, 11, 16, 11, 0, -11 },
  { 1443, 9, 11, 9, 0, -11 },
  { 1456, 8, 17, 8, 0, -14 },
  { 1473, 3, 19, 10, 3, -15 },
  { 1481, 7, 17, 8, 1, -14 },
  { 1496, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Black20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK20PT7B_H_
