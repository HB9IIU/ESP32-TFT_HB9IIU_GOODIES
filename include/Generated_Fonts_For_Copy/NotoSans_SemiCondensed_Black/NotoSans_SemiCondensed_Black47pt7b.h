#ifndef _NOTOSANS_SEMICONDENSED_BLACK47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xE7,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0x83, 0x00, 0xFF, 0x9F, 0xF7, 0xF9, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x0F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xCF, 0xE7, 0x8F, 0x3F, 0x9E, 0x04, 0xFE, 0x78, 0x03, 0xF9, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x79, 0xFC, 0x01, 0xE7, 0xFC, 0x07, 0x9F, 0xFC,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xC0, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFF,
  0xF8, 0x0F, 0xC0, 0x03, 0xF9, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x7E, 0x07,
  0xE0, 0x00, 0xFE, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xE1, 0xF8, 0x00, 0x0F, 0xE3,
  0xF1, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0xFC, 0x0E, 0x03, 0xF9, 0xFC, 0xFE,
  0x3F, 0xE0, 0xFE, 0xFE, 0x7E, 0x3F, 0xF8, 0x7F, 0xFE, 0x7F, 0x3F, 0xFE,
  0x1F, 0xFF, 0x3F, 0x3F, 0xFF, 0x0F, 0xFF, 0x3F, 0x9F, 0xFF, 0xC3, 0xFF,
  0x1F, 0x8F, 0xC7, 0xE0, 0x7E, 0x1F, 0xC7, 0xE3, 0xF0, 0x00, 0x0F, 0xC7,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x07,
  0xF7, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFC,
  0x07, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFE, 0x1F,
  0xF0, 0xFF, 0xFF, 0xCF, 0xF8, 0x7F, 0xFF, 0xFB, 0xFE, 0x1F, 0xF3, 0xFF,
  0xFF, 0x87, 0xF8, 0x7F, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x81,
  0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF3, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xBF, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF0, 0x03, 0xF8, 0x3F, 0xC1,
  0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0x0F, 0xC3, 0x9F, 0xBF, 0x7F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0x3F, 0x83, 0xFC, 0xFF, 0x07, 0xE1, 0xF8, 0x07, 0x87, 0x80,
  0x04, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x08, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0x87, 0xFB, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFD, 0xFE, 0x1F,
  0xF7, 0xF8, 0x7F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xDF, 0xF3, 0xF3, 0xFE, 0x3C, 0x7F, 0xC3, 0x0F, 0xF8, 0x41,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xC7, 0xFE, 0x1E, 0x07, 0xFC, 0x38, 0x07,
  0xF8, 0x20, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0x87, 0xFE, 0x10, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F,
  0xEF, 0xF8, 0x0F, 0xEF, 0xF8, 0x1F, 0xCF, 0xF8, 0x1F, 0xCF, 0xF8, 0x3F,
  0x8F, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0x0F, 0xF8, 0xFE, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x84, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF3,
  0xFC, 0x1F, 0xEF, 0xFC, 0x3F, 0xBF, 0xFC, 0x7F, 0x7F, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFC, 0x3F, 0xEF, 0xF8, 0x3F,
  0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFD,
  0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0x3F, 0xE1, 0xFF, 0x7F,
  0xC3, 0xFE, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0x3F, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xCF, 0xF8, 0xFF, 0xDF, 0xE0, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE3,
  0xFE, 0x7F, 0x83, 0xFE, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0xFF, 0xBF, 0xE3, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1,
  0xFF, 0xDF, 0xE1, 0xFF, 0x3F, 0xC0, 0x78, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xC7, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF, 0x82, 0x00, 0x1F,
  0x8F, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF3, 0xFC, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xC1,
  0xFF, 0x30, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x10, 0x0F, 0xC3, 0xF8, 0x3F, 0xFC, 0x7E, 0x3F, 0x07, 0xFF,
  0xE7, 0xE7, 0xF1, 0xFF, 0xFE, 0x3E, 0x7E, 0x1F, 0xFF, 0xE3, 0xF7, 0xE3,
  0xFC, 0x7E, 0x3F, 0xFC, 0x3F, 0x07, 0xE3, 0xFF, 0xC7, 0xF0, 0x7E, 0x3F,
  0xFC, 0x7E, 0x07, 0xE3, 0xFF, 0xC7, 0xE0, 0x7E, 0x3F, 0xFC, 0x7E, 0x07,
  0xE3, 0xFF, 0xC7, 0xE0, 0xFE, 0x3F, 0xFC, 0x7E, 0x0F, 0xE3, 0xFF, 0xC7,
  0xE0, 0xFE, 0x3F, 0xFC, 0x7E, 0x0F, 0xE7, 0xEF, 0xC7, 0xF1, 0xFE, 0x7E,
  0xFC, 0x3F, 0xFF, 0xFF, 0xCF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7E, 0x1F, 0xFD,
  0xFF, 0x87, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xC0, 0x18, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x08, 0x01, 0xFF, 0x00, 0x07, 0x80,
  0x0F, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x9F,
  0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFD, 0xFF, 0x0F, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0,
  0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xF7, 0xFC, 0x0F, 0xFB,
  0xFE, 0x03, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xBF, 0xE0, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xF8, 0x7C, 0x3F, 0xF0, 0x06, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0x0F,
  0xFE, 0x03, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0x9F, 0xF0, 0x1F, 0xFB, 0xFE,
  0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0xDF, 0xF0, 0x3F, 0xF3, 0xFE, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0x3F, 0xF0, 0x01, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F,
  0xE0, 0x1F, 0xEF, 0xFE, 0x03, 0xFC, 0xFF, 0xE0, 0x7F, 0x9F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xFB, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE3,
  0xFF, 0x87, 0xFC, 0x03, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF9, 0xFF,
  0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFC,
  0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xFB,
  0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0x07,
  0xFC, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFF, 0x3F,
  0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F,
  0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xF7, 0xFF, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0x07, 0xEF, 0xFF, 0xF7, 0xF0,
  0x7E, 0xFF, 0xFF, 0x3F, 0x8F, 0xEF, 0xFF, 0xF3, 0xF8, 0xFE, 0xFF, 0xFF,
  0x3F, 0x8F, 0xCF, 0xFF, 0xF3, 0xF9, 0xFC, 0xFF, 0xFF, 0x1F, 0xDF, 0xCF,
  0xFF, 0xF1, 0xFD, 0xF8, 0xFF, 0xFF, 0x1F, 0xDF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xE0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFD, 0xFF, 0x0F, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0xCF, 0xF8, 0xFF, 0xFF,
  0x3F, 0xE3, 0xFF, 0xFC, 0x7F, 0xCF, 0xFF, 0xF1, 0xFF, 0x3F, 0xFF, 0xC3,
  0xFE, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x03,
  0xFF, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xBF,
  0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87,
  0xFC, 0x7F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F,
  0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x3F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xE7, 0xFC, 0x07, 0xFC,
  0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xF0, 0xFC, 0xFF, 0x80, 0x63, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xEF, 0x80, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF,
  0x83, 0xFF, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0xFF, 0xDF, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F,
  0xE3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE,
  0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xF0, 0x1F,
  0xE3, 0xFC, 0x07, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x07, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x3F, 0xC1, 0xFE,
  0x0F, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFD, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xDF, 0x87, 0xFC, 0x0F, 0xF0, 0xFD, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xDF,
  0x87, 0xF8, 0x0F, 0xF1, 0xFD, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xDF, 0xC7,
  0xF8, 0x07, 0xF1, 0xF8, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0x8F, 0xCF, 0xF0,
  0x07, 0xFB, 0xF8, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0x8F, 0xEF, 0xF0, 0x07,
  0xFB, 0xF8, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0x07, 0xFF, 0xE0, 0x03, 0xFB,
  0xF0, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F,
  0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0x01,
  0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xF0, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC,
  0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7,
  0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x01, 0xFD, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F,
  0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0,
  0x7F, 0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF7, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xC0, 0xFF, 0x82, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFE, 0x7F, 0xBF, 0xE0, 0xFF, 0x7F,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFB, 0xFE, 0x3F, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0x7F, 0x1F, 0xFC,
  0x7E, 0x1F, 0xF0, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x07,
  0xF9, 0xFF, 0x8F, 0xF7, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFD, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xF9, 0xFF, 0xC7, 0xF0, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xF7, 0xE7, 0xFC, 0x04, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x77,
  0xFF, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC7,
  0xF8, 0xFF, 0xEF, 0xF1, 0xFF, 0xDF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x3F, 0xEF, 0xFD, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFB, 0xFC, 0x7F, 0xF3, 0xF8, 0x3F, 0x83,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x7F, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x13, 0xFE, 0x01, 0xC7, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0xFE, 0x1F, 0xF9, 0xFC, 0x7F, 0xFB, 0xF9, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xF9, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFB, 0xFF, 0x3F, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0x1F, 0xFD,
  0xFE, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xEE, 0x00, 0x7F, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x87, 0xFB, 0xFF, 0xCF, 0xF7,
  0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x7F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xEF, 0xF7, 0xFB,
  0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF,
  0xE0, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xFB,
  0xFC, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0x3F, 0xC1, 0xFF, 0x8F, 0xF0, 0x7F,
  0xC3, 0xFC, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF3,
  0xFE, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1,
  0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFF, 0x3F,
  0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xFB, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0,
  0x7F, 0xC3, 0xF9, 0xFF, 0xE3, 0xFF, 0x8F, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF,
  0x83, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFC, 0x1F, 0xE1, 0xFC, 0xFF, 0xF3, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xC7,
  0xFE, 0x7F, 0x83, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0x83,
  0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFE, 0x1F,
  0xC1, 0xFC, 0x7F, 0xE3, 0xFD, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFB, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xBF, 0xFC, 0xFF, 0x7F, 0xF1, 0xFE, 0x3F,
  0x83, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0xFE,
  0x1F, 0xF9, 0xFC, 0x7F, 0xFB, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xFB, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0x1F, 0xFD, 0xFE, 0x0F, 0xE3, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFC, 0x1F, 0xFF, 0x1F,
  0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xC0, 0xE7, 0xF8, 0x04, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xFF, 0xE3, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xFB, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF,
  0x7F, 0x3F, 0xFC, 0xFE, 0x1F, 0xF0, 0xFC, 0xFF, 0x80, 0x3F, 0xEF, 0xF0,
  0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8,
  0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE1,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0x81, 0xFE, 0xFF, 0x03, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFE,
  0x07, 0xFB, 0xFE, 0x1F, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7F, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0xF0, 0xFF, 0x1F, 0xE1, 0xFF,
  0xE1, 0xFC, 0x1F, 0xE7, 0xFF, 0xC7, 0xF8, 0x3F, 0xCF, 0xDF, 0xCF, 0xF0,
  0x7F, 0x9F, 0xBF, 0x9F, 0xE0, 0xFF, 0x3F, 0x3F, 0x3F, 0x80, 0xFE, 0x7E,
  0x7E, 0x7F, 0x01, 0xFD, 0xFC, 0xFD, 0xFE, 0x03, 0xFB, 0xF9, 0xFB, 0xFC,
  0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF,
  0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xCF, 0xFC, 0x1F,
  0xF8, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x1F,
  0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFD,
  0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xDF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80,
  0x3F, 0xEF, 0xF0, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xC3,
  0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0x80, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Black47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 35, 13, 2, -34 },
  { 41, 20, 13, 24, 2, -34 },
  { 74, 27, 34, 29, 1, -34 },
  { 189, 22, 39, 26, 2, -36 },
  { 297, 41, 34, 43, 1, -34 },
  { 472, 34, 34, 35, 1, -34 },
  { 617, 9, 13, 13, 2, -34 },
  { 632, 13, 42, 16, 2, -35 },
  { 701, 13, 42, 16, 1, -35 },
  { 770, 22, 22, 24, 1, -36 },
  { 831, 22, 23, 26, 2, -28 },
  { 895, 10, 14, 14, 1, -7 },
  { 913, 13, 7, 15, 1, -16 },
  { 925, 9, 9, 13, 2, -8 },
  { 936, 20, 34, 20, 0, -34 },
  { 1021, 22, 34, 26, 2, -34 },
  { 1115, 19, 34, 26, 2, -34 },
  { 1196, 23, 34, 26, 1, -34 },
  { 1294, 22, 34, 26, 2, -34 },
  { 1388, 24, 34, 26, 1, -34 },
  { 1490, 22, 34, 26, 2, -34 },
  { 1584, 23, 34, 26, 2, -34 },
  { 1682, 22, 34, 26, 2, -34 },
  { 1776, 23, 34, 26, 1, -34 },
  { 1874, 23, 34, 26, 1, -34 },
  { 1972, 9, 27, 13, 2, -26 },
  { 2003, 10, 33, 14, 1, -26 },
  { 2045, 22, 24, 26, 2, -29 },
  { 2111, 22, 17, 26, 2, -25 },
  { 2158, 22, 24, 26, 2, -29 },
  { 2224, 21, 35, 22, 0, -34 },
  { 2316, 36, 38, 40, 2, -34 },
  { 2487, 31, 34, 31, 0, -34 },
  { 2619, 25, 34, 30, 3, -34 },
  { 2726, 25, 34, 28, 2, -34 },
  { 2833, 27, 34, 32, 3, -34 },
  { 2948, 19, 34, 24, 3, -34 },
  { 3029, 19, 34, 24, 3, -34 },
  { 3110, 27, 34, 32, 2, -34 },
  { 3225, 27, 34, 33, 3, -34 },
  { 3340, 17, 34, 19, 1, -34 },
  { 3413, 15, 45, 15, -3, -34 },
  { 3498, 27, 34, 30, 3, -34 },
  { 3613, 20, 34, 25, 3, -34 },
  { 3698, 36, 34, 43, 3, -34 },
  { 3851, 30, 34, 36, 3, -34 },
  { 3979, 30, 34, 34, 2, -34 },
  { 4107, 23, 34, 28, 3, -34 },
  { 4205, 31, 42, 34, 2, -34 },
  { 4368, 27, 34, 30, 3, -34 },
  { 4483, 22, 34, 25, 2, -34 },
  { 4577, 23, 34, 26, 1, -34 },
  { 4675, 27, 34, 33, 3, -34 },
  { 4790, 30, 34, 30, 0, -34 },
  { 4918, 44, 34, 45, 0, -34 },
  { 5105, 30, 34, 31, 0, -34 },
  { 5233, 29, 34, 29, 0, -34 },
  { 5357, 24, 34, 26, 1, -34 },
  { 5459, 12, 43, 15, 2, -35 },
  { 5524, 20, 34, 20, 0, -34 },
  { 5609, 11, 43, 15, 1, -35 },
  { 5669, 25, 23, 25, 0, -34 },
  { 5741, 24, 6, 24, 0, 3 },
  { 5759, 14, 8, 18, 2, -36 },
  { 5773, 23, 26, 27, 1, -26 },
  { 5848, 23, 36, 28, 3, -36 },
  { 5952, 20, 26, 24, 2, -26 },
  { 6017, 23, 36, 28, 2, -36 },
  { 6121, 23, 26, 27, 2, -26 },
  { 6196, 18, 36, 18, 1, -36 },
  { 6277, 23, 37, 28, 2, -26 },
  { 6384, 23, 36, 29, 3, -36 },
  { 6488, 9, 36, 14, 3, -36 },
  { 6529, 14, 47, 14, -2, -36 },
  { 6612, 26, 36, 29, 3, -36 },
  { 6729, 8, 36, 14, 3, -36 },
  { 6765, 38, 26, 43, 3, -26 },
  { 6889, 23, 26, 29, 3, -26 },
  { 6964, 24, 26, 28, 2, -26 },
  { 7042, 23, 37, 28, 3, -26 },
  { 7149, 23, 37, 28, 2, -26 },
  { 7256, 17, 26, 20, 3, -26 },
  { 7312, 19, 26, 22, 2, -26 },
  { 7374, 18, 31, 20, 1, -31 },
  { 7444, 23, 26, 29, 3, -26 },
  { 7519, 27, 26, 27, 0, -26 },
  { 7607, 39, 26, 40, 0, -26 },
  { 7734, 27, 26, 27, 0, -26 },
  { 7822, 27, 37, 27, 0, -26 },
  { 7947, 20, 26, 22, 1, -26 },
  { 8012, 17, 42, 19, 1, -34 },
  { 8102, 6, 46, 22, 8, -36 },
  { 8137, 17, 42, 19, 1, -34 },
  { 8227, 22, 9, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_Black47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK47PT7B_H_
