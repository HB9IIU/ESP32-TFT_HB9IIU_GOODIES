#ifndef _NOTOSANS_SEMICONDENSED_BLACK17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0xEF, 0xDF, 0xBF, 0x70, 0x1D, 0x86,
  0x61, 0xB9, 0xFF, 0x7F, 0xC6, 0xC3, 0xB3, 0xFF, 0xFF, 0xCD, 0x83, 0x61,
  0xD8, 0x10, 0x3C, 0xFE, 0xFE, 0xD0, 0xF0, 0xFC, 0x3E, 0x17, 0x97, 0xFE,
  0xFE, 0x30, 0x10, 0x78, 0x70, 0xF8, 0xC3, 0xB3, 0x87, 0x66, 0x0E, 0xDC,
  0x0F, 0xB7, 0x9E, 0xFF, 0x81, 0xBB, 0x07, 0x76, 0x0C, 0xEC, 0x38, 0xF8,
  0xE1, 0xE0, 0x3E, 0x07, 0xF0, 0x67, 0x07, 0x70, 0x7E, 0x07, 0xCE, 0xFC,
  0xEE, 0xFC, 0xE7, 0xCE, 0x78, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x7B, 0x39,
  0xCE, 0x73, 0x18, 0xC7, 0x39, 0xC6, 0x38, 0xE0, 0xF3, 0x8E, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x77, 0x3B, 0x80, 0x1C, 0x18, 0x5B, 0xFF, 0x3E, 0x3E,
  0x77, 0x34, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x77, 0x6E,
  0xFF, 0xFE, 0xFF, 0x80, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x0E, 0x18, 0x70,
  0xE1, 0x87, 0x00, 0x7C, 0xFE, 0xEE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xEE, 0x7E, 0x7C, 0x1C, 0xF7, 0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x3E, 0x7F, 0x99, 0xC4, 0xE0, 0x70, 0x78, 0x38, 0x38, 0x38, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFC, 0xFE, 0x4E, 0x0E, 0x1E, 0x78, 0x7E, 0x0F, 0x0F, 0x8F,
  0xFE, 0xFC, 0x07, 0x07, 0x87, 0xC3, 0xE3, 0xF3, 0xB9, 0x9D, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0xE0, 0xFE, 0xFE, 0xFE, 0xE0, 0xFC, 0xFE, 0x7E, 0x0F,
  0x0F, 0xCE, 0xFE, 0xFC, 0x3E, 0x7E, 0xF0, 0xE0, 0xDE, 0xFE, 0xEF, 0xE7,
  0xE7, 0xEF, 0xFE, 0x3C, 0xFF, 0xFF, 0xFF, 0x0E, 0x0E, 0x1C, 0x1C, 0x3C,
  0x38, 0x38, 0x70, 0x70, 0x7E, 0xFE, 0xE7, 0xEE, 0xFE, 0x7C, 0xFE, 0xEF,
  0xC7, 0xE7, 0xFE, 0x7C, 0x7C, 0xFE, 0xEE, 0xE7, 0xE7, 0xFF, 0xFF, 0x77,
  0x06, 0x1E, 0xFC, 0xF8, 0x5F, 0xA0, 0x07, 0xFC, 0x27, 0x72, 0x00, 0x00,
  0x77, 0x6E, 0x01, 0x07, 0x1F, 0x7C, 0xF0, 0xF0, 0x7E, 0x0F, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x7C, 0x1F, 0x1F, 0x7C,
  0xF0, 0xC0, 0x7E, 0xFE, 0x47, 0x07, 0x0E, 0x1C, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x38, 0x1F, 0xC1, 0xEF, 0x1C, 0x0D, 0xDF, 0xED, 0xF9, 0xEC, 0xCF,
  0x66, 0x7B, 0x37, 0xDF, 0xF6, 0x77, 0x18, 0x00, 0xFF, 0x81, 0xFC, 0x00,
  0x1F, 0x03, 0xE0, 0x7E, 0x0D, 0xC3, 0xB8, 0x77, 0x0E, 0x73, 0xFE, 0x7F,
  0xCF, 0xFF, 0xC3, 0xF8, 0x70, 0xFE, 0x7F, 0xB9, 0xFC, 0x7E, 0x77, 0xF3,
  0xFD, 0xC7, 0xE3, 0xF3, 0xFF, 0xDF, 0xC0, 0x3F, 0xBF, 0x9C, 0xDC, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xF0, 0x7D, 0x9F, 0xC7, 0xE0, 0xFE, 0x3F, 0xCE,
  0x7B, 0x8F, 0xE3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xBF, 0xEF, 0xF3, 0xF8,
  0xFF, 0xFF, 0x87, 0x0F, 0xFF, 0xFF, 0xF0, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0xE1, 0xC3, 0x87, 0x00, 0x3F, 0x9F,
  0xE7, 0x9B, 0xC0, 0xE0, 0x39, 0xFE, 0x7F, 0x87, 0xF1, 0xDE, 0xF7, 0xFC,
  0xFE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0xBF, 0xF0,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xDC, 0xE3, 0xF8,
  0xEE, 0x73, 0xBC, 0xEE, 0x3F, 0x8F, 0xE3, 0xFC, 0xE7, 0x39, 0xEE, 0x3B,
  0x8F, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0xFF, 0xB7, 0xFD,
  0xF7, 0xEF, 0xBF, 0x3D, 0xF9, 0xCF, 0xCE, 0x70, 0xF0, 0xFF, 0x1F, 0xE3,
  0xFE, 0x7F, 0xCF, 0xDD, 0xFB, 0xBF, 0x3F, 0xE7, 0xFC, 0x7F, 0x8F, 0xF0,
  0xF0, 0x3F, 0x0F, 0xF3, 0xCF, 0x70, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xF1, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0xFE, 0xFF, 0xEF, 0xE7, 0xE7, 0xFF,
  0xFF, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x0F, 0xF3, 0xCF, 0x70, 0xEE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0x78,
  0x07, 0x80, 0x78, 0xFE, 0x3F, 0xCE, 0x73, 0x9E, 0xE7, 0x3F, 0xCF, 0xE3,
  0xF8, 0xE7, 0x39, 0xCE, 0x3B, 0x8F, 0x7F, 0xFE, 0xE6, 0xE0, 0xF0, 0xFC,
  0x3E, 0x1E, 0x8F, 0xFE, 0xFE, 0xFC, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xFF, 0xE7, 0xF8, 0xFC, 0xF1,
  0xFE, 0x39, 0xC7, 0x38, 0xE7, 0xBC, 0x77, 0x0E, 0xE1, 0xDC, 0x1B, 0x03,
  0xE0, 0x7C, 0x0F, 0x00, 0xE1, 0xC7, 0x73, 0xC7, 0x73, 0xCE, 0x73, 0xCE,
  0x73, 0xEE, 0x77, 0xEE, 0x3F, 0x6E, 0x3F, 0x6C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x1E, 0x7C, 0x1E, 0x38, 0xF1, 0xEE, 0x78, 0xEE, 0x1F, 0xC1, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x3B, 0x8F, 0x71, 0xC7, 0x78, 0xF0, 0xF1, 0xDC, 0xF7,
  0x38, 0xEE, 0x3F, 0x07, 0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x7F, 0xBF, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x78, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE0, 0xC1,
  0xC3, 0x83, 0x87, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xFF, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xE0, 0x18, 0x0E, 0x0F, 0x06, 0xC3,
  0x63, 0x19, 0x8D, 0xC7, 0xFF, 0xFF, 0xC0, 0xE3, 0x86, 0x18, 0xFE, 0x7F,
  0x07, 0x7F, 0xFF, 0xE7, 0xEF, 0xFF, 0xF7, 0xE0, 0x70, 0x38, 0x1C, 0x8F,
  0xF7, 0xFB, 0x9D, 0xCE, 0xE7, 0xF3, 0xBD, 0xDF, 0xEF, 0xE0, 0x18, 0xFF,
  0xFF, 0x0E, 0x1C, 0x38, 0x7B, 0xFE, 0xFC, 0x07, 0x07, 0x07, 0x37, 0x7F,
  0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7B, 0x18, 0x7E, 0xFF, 0xE7,
  0xFF, 0xFF, 0xE0, 0xE1, 0xFE, 0x3E, 0x1E, 0x7C, 0xEB, 0xCF, 0xDF, 0x9E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x80, 0x30, 0x7F, 0xFF, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFF, 0x7F, 0x07, 0xCF, 0xFE, 0xFC, 0xE0, 0x70, 0x38, 0x1C,
  0x8F, 0xF7, 0xFB, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x78, 0xFD,
  0x8F, 0xFF, 0xFF, 0xFE, 0x39, 0xC6, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9F, 0xFF, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x7F, 0x7B, 0xB9, 0xF8,
  0xFE, 0x7F, 0x39, 0xDC, 0xEE, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x04,
  0x33, 0xFF, 0xEF, 0xFF, 0xF9, 0xEF, 0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xF9,
  0xC7, 0xE7, 0x1F, 0x9C, 0x70, 0x04, 0x7F, 0xBF, 0xDC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xC0, 0x18, 0x7E, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0x7F, 0x3E, 0x04, 0x7F, 0xBF, 0xDC, 0xEE, 0x77, 0x3F, 0x9D, 0xEE,
  0xFF, 0x77, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x30, 0x7F, 0xFF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFD,
  0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x33, 0xFF, 0xF8, 0xF9, 0xF1, 0xE7, 0xFF,
  0xE0, 0x30, 0x63, 0xFF, 0xF7, 0x0E, 0x1C, 0x38, 0x7A, 0x7C, 0xF8, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xF7, 0xFF, 0x7B, 0xE3, 0xDC, 0xE7, 0x39,
  0xDC, 0x37, 0x0F, 0xC3, 0xE0, 0x78, 0x1E, 0x00, 0xE7, 0x9D, 0xDE, 0x77,
  0x79, 0xDD, 0xFE, 0x76, 0xF8, 0xFB, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xDF, 0xC3, 0xF0, 0xF8, 0x1E, 0x0F, 0xC3, 0xF1, 0xDE, 0xF3, 0xC0,
  0xE3, 0xDC, 0xE7, 0x39, 0xDC, 0x3F, 0x0F, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x0B, 0xC1, 0xE0, 0x70, 0x00, 0x7E, 0x7E, 0x0E, 0x1C, 0x38, 0x38, 0x70,
  0xFF, 0xFF, 0x1C, 0xF3, 0x8E, 0x38, 0xEF, 0xBC, 0x78, 0xE3, 0x8E, 0x3C,
  0x70, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xF0, 0xE1, 0xC3, 0x87,
  0x0F, 0x8F, 0x3C, 0x70, 0xE1, 0xC7, 0x9E, 0x38, 0x00, 0x61, 0xFF, 0xFF,
  0x84,
};

const GFXglyph NotoSans_SemiCondensed_Black17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 7, 4, 9, 1, -12 },
  { 10, 10, 12, 11, 0, -12 },
  { 25, 8, 14, 9, 1, -13 },
  { 39, 15, 12, 15, 0, -12 },
  { 62, 12, 12, 13, 1, -12 },
  { 80, 3, 4, 5, 1, -12 },
  { 82, 5, 15, 6, 1, -12 },
  { 92, 5, 15, 6, 0, -12 },
  { 102, 8, 8, 9, 0, -13 },
  { 110, 8, 8, 9, 1, -10 },
  { 118, 4, 4, 5, 0, -2 },
  { 120, 5, 3, 5, 0, -6 },
  { 122, 3, 3, 5, 1, -3 },
  { 124, 7, 12, 7, 0, -12 },
  { 135, 8, 12, 9, 1, -12 },
  { 147, 6, 12, 9, 1, -12 },
  { 156, 9, 12, 9, 0, -12 },
  { 170, 8, 12, 9, 1, -12 },
  { 182, 9, 12, 9, 0, -12 },
  { 196, 8, 12, 9, 1, -12 },
  { 208, 8, 12, 9, 1, -12 },
  { 220, 8, 12, 9, 1, -12 },
  { 232, 8, 12, 9, 1, -12 },
  { 244, 8, 12, 9, 1, -12 },
  { 256, 3, 10, 5, 1, -10 },
  { 260, 4, 12, 5, 0, -10 },
  { 266, 8, 9, 9, 1, -11 },
  { 275, 8, 6, 9, 1, -9 },
  { 281, 8, 9, 9, 1, -11 },
  { 290, 8, 12, 8, 0, -12 },
  { 302, 13, 13, 14, 1, -12 },
  { 324, 11, 12, 11, 0, -12 },
  { 341, 9, 12, 11, 1, -12 },
  { 355, 9, 12, 10, 1, -12 },
  { 369, 10, 12, 12, 1, -12 },
  { 384, 7, 12, 9, 1, -12 },
  { 395, 7, 12, 9, 1, -12 },
  { 406, 10, 12, 12, 1, -12 },
  { 421, 10, 12, 12, 1, -12 },
  { 436, 5, 12, 7, 1, -12 },
  { 444, 5, 16, 6, -1, -12 },
  { 454, 10, 12, 11, 1, -12 },
  { 469, 7, 12, 9, 1, -12 },
  { 480, 13, 12, 15, 1, -12 },
  { 500, 11, 12, 13, 1, -12 },
  { 517, 11, 12, 12, 1, -12 },
  { 534, 8, 12, 10, 1, -12 },
  { 546, 11, 15, 12, 1, -12 },
  { 567, 10, 12, 11, 1, -12 },
  { 582, 8, 12, 9, 1, -12 },
  { 594, 9, 12, 9, 0, -12 },
  { 608, 10, 12, 12, 1, -12 },
  { 623, 11, 12, 11, 0, -12 },
  { 640, 16, 12, 16, 0, -12 },
  { 664, 11, 12, 11, 0, -12 },
  { 681, 10, 12, 10, 0, -12 },
  { 696, 9, 12, 10, 0, -12 },
  { 710, 4, 15, 5, 1, -12 },
  { 718, 7, 12, 7, 0, -12 },
  { 729, 5, 15, 5, 0, -12 },
  { 739, 9, 8, 9, 0, -12 },
  { 748, 9, 2, 9, 0, 1 },
  { 751, 5, 3, 7, 1, -13 },
  { 753, 8, 10, 10, 1, -10 },
  { 763, 9, 13, 10, 1, -13 },
  { 778, 7, 10, 9, 1, -10 },
  { 787, 8, 13, 10, 1, -13 },
  { 800, 8, 10, 10, 1, -10 },
  { 810, 7, 13, 6, 0, -13 },
  { 822, 8, 14, 10, 1, -10 },
  { 836, 9, 13, 11, 1, -13 },
  { 851, 3, 13, 5, 1, -13 },
  { 856, 5, 17, 5, -1, -13 },
  { 867, 9, 13, 10, 1, -13 },
  { 882, 3, 13, 5, 1, -13 },
  { 887, 14, 10, 16, 1, -10 },
  { 905, 9, 10, 11, 1, -10 },
  { 917, 8, 10, 10, 1, -10 },
  { 927, 9, 14, 10, 1, -10 },
  { 943, 8, 14, 10, 1, -10 },
  { 957, 6, 10, 7, 1, -10 },
  { 965, 6, 10, 8, 1, -10 },
  { 973, 7, 11, 7, 0, -11 },
  { 983, 8, 9, 11, 1, -9 },
  { 992, 10, 9, 10, 0, -9 },
  { 1004, 14, 9, 14, 0, -9 },
  { 1020, 10, 9, 10, 0, -9 },
  { 1032, 10, 13, 10, 0, -9 },
  { 1049, 8, 9, 8, 0, -9 },
  { 1058, 6, 15, 7, 0, -12 },
  { 1070, 2, 17, 8, 3, -13 },
  { 1075, 7, 15, 7, 0, -12 },
  { 1089, 8, 4, 9, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Black17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK17PT7B_H_
