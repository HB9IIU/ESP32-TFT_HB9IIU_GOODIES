#ifndef _NOTOSANS_SEMICONDENSED_BLACK19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xEE, 0xEE, 0xE0, 0x0E, 0xFE, 0xEF, 0xEF, 0xE7, 0xE6,
  0xE6, 0x0C, 0xC1, 0x98, 0x37, 0x0E, 0xE7, 0xFE, 0xFF, 0xC6, 0x60, 0xCC,
  0xFF, 0xFF, 0xFC, 0xEC, 0x19, 0x83, 0x30, 0x6E, 0x00, 0x18, 0x3F, 0xBF,
  0xDF, 0xED, 0x87, 0xC3, 0xF8, 0xFE, 0x1F, 0x8D, 0xE6, 0xFF, 0xEF, 0xF0,
  0xC0, 0x60, 0x38, 0x18, 0x3E, 0x1C, 0x1F, 0x8C, 0x1D, 0xCE, 0x0E, 0xE6,
  0x07, 0x77, 0x01, 0xBB, 0x7C, 0xFB, 0xBE, 0x39, 0xBB, 0x81, 0xDD, 0xC0,
  0xCE, 0xE0, 0xE7, 0x70, 0x61, 0xF0, 0x70, 0x78, 0x1E, 0x01, 0xF8, 0x1F,
  0xE0, 0xE7, 0x07, 0x78, 0x3F, 0x80, 0xF9, 0xEF, 0xCE, 0xFF, 0xF7, 0x3F,
  0x38, 0xF9, 0xFF, 0xCF, 0xFF, 0x3F, 0x7C, 0xFF, 0xFE, 0x3B, 0x9C, 0xEE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x79, 0xCE, 0x38, 0xF1, 0xC3, 0x8E, 0x38,
  0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x9C, 0xF0, 0x1C, 0x06, 0x1B,
  0xFF, 0xF3, 0xF1, 0xF1, 0xFC, 0x67, 0x1C, 0x0E, 0x07, 0x1F, 0xFF, 0xFF,
  0xFC, 0x70, 0x38, 0x1C, 0x00, 0xFE, 0xEE, 0xEC, 0xFF, 0xFF, 0xC0, 0xEF,
  0xE0, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70,
  0x70, 0x70, 0xE0, 0x1C, 0x3F, 0x3F, 0xDE, 0xEE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFF, 0xE7, 0xF1, 0xF0, 0x0E, 0x3C, 0xFB, 0xFF, 0xED,
  0xD3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x1E, 0x1F, 0xCF, 0xF9,
  0xCE, 0x23, 0x80, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xFF, 0x7F,
  0xDF, 0xF0, 0x3C, 0x7F, 0xBF, 0xC8, 0xE0, 0x70, 0x78, 0xF0, 0x7C, 0x0F,
  0x03, 0xE1, 0xFF, 0xEF, 0xF7, 0xF0, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x1F,
  0x8F, 0xE3, 0xF9, 0xDE, 0xE7, 0xBF, 0xFF, 0xFC, 0x1E, 0x07, 0x81, 0xE0,
  0x7F, 0x3F, 0xBF, 0xDE, 0x0E, 0x07, 0xF3, 0xFD, 0xFE, 0x07, 0x83, 0xE1,
  0xFF, 0xEF, 0xF7, 0xF0, 0x0F, 0x1F, 0x9F, 0xDE, 0x0E, 0x07, 0x73, 0xFD,
  0xFF, 0xE7, 0xF1, 0xF9, 0xFF, 0xF7, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0xC0,
  0x3C, 0x3F, 0xBF, 0xDC, 0xFE, 0x73, 0xF9, 0xF8, 0xFC, 0xFF, 0x73, 0xF8,
  0xFE, 0xFF, 0xF3, 0xF0, 0x3C, 0x3F, 0x3F, 0xDC, 0xEE, 0x7F, 0x3F, 0x9F,
  0xFF, 0x7B, 0x83, 0xC1, 0xDF, 0xEF, 0xE7, 0xE0, 0x6F, 0xFE, 0x00, 0x00,
  0xEF, 0xE0, 0x6F, 0xFE, 0x00, 0x00, 0xFE, 0xEE, 0xEC, 0x00, 0x81, 0xC3,
  0xE7, 0xCF, 0x87, 0x81, 0xF0, 0x3F, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x80, 0x70, 0x3E, 0x0F, 0xC0, 0xF8, 0x7C,
  0xFD, 0xF8, 0xE0, 0x40, 0x00, 0x3C, 0x7F, 0xBF, 0xC8, 0xF0, 0x70, 0x78,
  0x78, 0x38, 0x38, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0x07, 0xC0, 0x7F,
  0xC3, 0xC7, 0x9C, 0x07, 0x67, 0xEF, 0xBF, 0xBC, 0xCE, 0xF7, 0x3B, 0xDC,
  0xEF, 0x73, 0xBC, 0xFF, 0xB9, 0xCC, 0x70, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xF7, 0x07,
  0x3C, 0x38, 0xE3, 0xFF, 0x1F, 0xFC, 0xE1, 0xEF, 0x07, 0x78, 0x3C, 0xFC,
  0x3F, 0xEF, 0xFF, 0xCF, 0xF3, 0xFC, 0xEF, 0xFB, 0xFE, 0xF3, 0xFC, 0x7F,
  0x3F, 0xFF, 0xFF, 0xBF, 0xC0, 0x0F, 0x0F, 0xF7, 0xF9, 0xE2, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x05, 0xFE, 0x7F, 0x87, 0xE0, 0xFC,
  0x1F, 0xF3, 0xFF, 0x79, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xCF, 0x7F, 0xEF, 0xF9, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F,
  0x87, 0xFD, 0xFF, 0x3C, 0x2F, 0x01, 0xE0, 0x3D, 0xFF, 0xBF, 0xF7, 0xFE,
  0x1F, 0xC3, 0xBF, 0xF3, 0xFE, 0x3F, 0xC0, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xC0, 0xFF, 0xFF, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0xFF, 0xF0, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xFF, 0xFB, 0xC0, 0xF1, 0xFE, 0x3F, 0xCF, 0x79, 0xCF, 0x79, 0xFE,
  0x3F, 0x87, 0xF8, 0xFF, 0x1E, 0xF3, 0xCE, 0x79, 0xEF, 0x1D, 0xE3, 0xC0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFD,
  0x8D, 0xFB, 0x9B, 0xF7, 0x77, 0xF6, 0xEF, 0xEF, 0x9F, 0xDF, 0x3F, 0xBE,
  0x7F, 0x3C, 0xFE, 0x71, 0xC0, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFE,
  0x7E, 0xE7, 0xEF, 0x7E, 0x77, 0xF7, 0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xF1,
  0xFF, 0x0F, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0xFC,
  0x3F, 0xCF, 0xFB, 0xDE, 0xF3, 0xFC, 0xFF, 0x7B, 0xFE, 0xFF, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0xFE, 0x3F,
  0xC1, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xFC, 0x1F, 0xE3, 0xFE, 0x79,
  0xEF, 0x3D, 0xE7, 0xBF, 0xE7, 0xF8, 0xFF, 0x1E, 0xE3, 0xDE, 0x79, 0xEF,
  0x3D, 0xE3, 0xC0, 0x1E, 0x3F, 0xFF, 0xDE, 0x6E, 0x07, 0xC3, 0xF8, 0xFE,
  0x1F, 0x03, 0xE1, 0xDF, 0xEF, 0xF7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xBF, 0xE7, 0xFC, 0x7F, 0x00, 0xF0, 0xFF, 0x0F,
  0x70, 0xF7, 0x8E, 0x79, 0xE3, 0x9E, 0x39, 0xC3, 0xDC, 0x3F, 0xC1, 0xFC,
  0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0xF0, 0xE1, 0xFC, 0x78, 0xF7, 0x1E,
  0x3D, 0xC7, 0x8E, 0x71, 0xE3, 0x9E, 0xFC, 0xE3, 0xBF, 0x78, 0xEF, 0xDC,
  0x3B, 0xB7, 0x0E, 0xCD, 0xC3, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x1E, 0x07,
  0x87, 0x80, 0xF0, 0xF7, 0x8E, 0x79, 0xE3, 0xDC, 0x1F, 0xC1, 0xF8, 0x0F,
  0x80, 0xF0, 0x1F, 0x81, 0xFC, 0x3F, 0xC7, 0x9E, 0x78, 0xEF, 0x0F, 0xF0,
  0xF7, 0x1E, 0x79, 0xE7, 0x9C, 0x3B, 0xC3, 0xF8, 0x1F, 0x81, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF0, 0xF0, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xF8, 0xE0,
  0x70, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xF8,
  0x0C, 0x03, 0x01, 0xE0, 0x78, 0x3F, 0x0C, 0xC7, 0x39, 0x86, 0xE1, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xC3, 0xC0, 0x1C, 0x3F, 0x9F, 0xE8, 0xF1,
  0xFF, 0xFF, 0xDF, 0xCF, 0xE7, 0xFF, 0xDE, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xD8, 0xEF, 0xBF, 0xEF, 0x3B, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xFE, 0xFF,
  0xBB, 0xC0, 0x1C, 0x7F, 0x7F, 0xF2, 0xE0, 0xE0, 0xE0, 0xF1, 0xFF, 0x7F,
  0x3E, 0x03, 0x81, 0xC0, 0xE6, 0x77, 0xFF, 0xFF, 0xDF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFF, 0xF7, 0xFB, 0xDC, 0x1C, 0x3F, 0xBF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF1, 0x3F, 0x8F, 0xC0, 0x0C, 0x3F, 0x3E, 0x38, 0x3E, 0xFE,
  0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3B, 0xBF, 0xFF,
  0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xBF, 0xDE, 0xE0, 0x7C, 0x7F,
  0xFF, 0xFC, 0x30, 0xF0, 0x3C, 0x0F, 0x03, 0xD8, 0xEF, 0xBF, 0xEF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xF0, 0x6F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0xF3, 0xC0, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xEF, 0x98, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0xEF, 0x3D, 0xEF, 0x3F, 0xC7, 0x70, 0xFE, 0x1F, 0xE3, 0xDE, 0x7B,
  0xCF, 0x3D, 0xE7, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0x19, 0xDF, 0xFF, 0xFF, 0xFF, 0x9E, 0x7F, 0x3C, 0xFE, 0x71, 0xFC, 0xE3,
  0xF9, 0xC7, 0xF3, 0x8F, 0xE7, 0x1F, 0xCE, 0x38, 0xE7, 0x3B, 0xEF, 0xFB,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3C, 0x1C, 0x1F,
  0xCF, 0xFB, 0xCE, 0xE3, 0xB8, 0xFE, 0x3B, 0x8E, 0xF7, 0x9F, 0xC3, 0xE0,
  0xE6, 0x3B, 0xEF, 0xFB, 0xCE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xFF, 0xBF,
  0xEF, 0xF3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x3B, 0xBF, 0xFF, 0xFE,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xBF, 0xDE, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0xE7, 0xDF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC0,
  0x39, 0xFF, 0xFF, 0x1F, 0x9F, 0x8F, 0x87, 0xCF, 0xFF, 0xF0, 0x18, 0x38,
  0x3E, 0x7E, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xFF, 0xDF, 0xF7,
  0xDC, 0xF1, 0xFE, 0x39, 0xC7, 0x39, 0xE7, 0xB8, 0x77, 0x0E, 0xE1, 0xF8,
  0x1F, 0x03, 0xE0, 0x78, 0x00, 0xF3, 0xC7, 0xF3, 0xCF, 0x73, 0xCE, 0x73,
  0xEE, 0x77, 0xEE, 0x7F, 0xEE, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1E, 0x78, 0xF1, 0xEF, 0x79, 0xEF, 0x1F, 0xC3, 0xF0, 0x3E, 0x07,
  0xC1, 0xFC, 0x3B, 0x8F, 0x7B, 0xC7, 0x80, 0xF1, 0xFE, 0x39, 0xC7, 0x39,
  0xE7, 0xB8, 0x77, 0x0E, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0xF8, 0x1E, 0x03, 0x00, 0x7F, 0x7F, 0x7F, 0x0F, 0x1E, 0x1C, 0x3C,
  0x78, 0x7F, 0xFF, 0xFF, 0x06, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x7C, 0xF1,
  0xF0, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xC3, 0xCF, 0x1C, 0x71, 0xC7, 0x1F, 0x1C, 0xF7, 0x9C,
  0x71, 0xC7, 0x3C, 0xE0, 0x20, 0xFE, 0xFF, 0xF1, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Black19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 5, 1, -14 },
  { 8, 8, 5, 10, 1, -14 },
  { 13, 11, 14, 12, 0, -14 },
  { 33, 9, 15, 10, 1, -14 },
  { 50, 17, 14, 17, 0, -14 },
  { 80, 13, 14, 14, 1, -14 },
  { 103, 3, 5, 5, 1, -14 },
  { 105, 5, 17, 7, 1, -14 },
  { 116, 6, 17, 7, 0, -14 },
  { 129, 9, 8, 10, 0, -14 },
  { 138, 9, 9, 11, 1, -11 },
  { 149, 4, 6, 6, 1, -3 },
  { 152, 6, 3, 6, 0, -7 },
  { 155, 4, 3, 5, 1, -3 },
  { 157, 8, 14, 8, 0, -14 },
  { 171, 9, 14, 11, 1, -14 },
  { 187, 7, 14, 11, 1, -14 },
  { 200, 10, 14, 11, 0, -14 },
  { 218, 9, 14, 11, 1, -14 },
  { 234, 10, 14, 11, 0, -14 },
  { 252, 9, 14, 11, 1, -14 },
  { 268, 9, 14, 11, 1, -14 },
  { 284, 9, 14, 11, 1, -14 },
  { 300, 9, 14, 11, 1, -14 },
  { 316, 9, 14, 11, 1, -14 },
  { 332, 4, 11, 5, 1, -11 },
  { 338, 4, 14, 6, 1, -11 },
  { 345, 9, 10, 11, 1, -12 },
  { 357, 9, 7, 11, 1, -10 },
  { 365, 9, 10, 11, 1, -12 },
  { 377, 9, 14, 9, 0, -14 },
  { 393, 14, 15, 16, 1, -14 },
  { 420, 13, 14, 13, 0, -14 },
  { 443, 10, 14, 12, 1, -14 },
  { 461, 10, 14, 11, 1, -14 },
  { 479, 11, 14, 13, 1, -14 },
  { 499, 8, 14, 10, 1, -14 },
  { 513, 8, 14, 10, 1, -14 },
  { 527, 11, 14, 13, 1, -14 },
  { 547, 11, 14, 13, 1, -14 },
  { 567, 6, 14, 8, 1, -14 },
  { 578, 6, 18, 6, -1, -14 },
  { 592, 11, 14, 12, 1, -14 },
  { 612, 8, 14, 10, 1, -14 },
  { 626, 15, 14, 17, 1, -14 },
  { 653, 12, 14, 15, 1, -14 },
  { 674, 12, 14, 14, 1, -14 },
  { 695, 10, 14, 11, 1, -14 },
  { 713, 12, 17, 14, 1, -14 },
  { 739, 11, 14, 12, 1, -14 },
  { 759, 9, 14, 10, 1, -14 },
  { 775, 10, 14, 10, 0, -14 },
  { 793, 11, 14, 13, 1, -14 },
  { 813, 12, 14, 12, 0, -14 },
  { 834, 18, 14, 18, 0, -14 },
  { 866, 12, 14, 12, 0, -14 },
  { 887, 12, 14, 12, 0, -14 },
  { 908, 9, 14, 11, 1, -14 },
  { 924, 5, 17, 6, 1, -14 },
  { 935, 8, 14, 8, 0, -14 },
  { 949, 5, 17, 6, 0, -14 },
  { 960, 10, 9, 10, 0, -14 },
  { 972, 10, 3, 10, 0, 1 },
  { 976, 6, 3, 7, 1, -15 },
  { 979, 9, 11, 11, 1, -11 },
  { 992, 10, 14, 11, 1, -14 },
  { 1010, 8, 11, 10, 1, -11 },
  { 1021, 9, 14, 11, 1, -14 },
  { 1037, 9, 11, 11, 1, -11 },
  { 1050, 8, 15, 7, 0, -15 },
  { 1065, 9, 16, 11, 1, -11 },
  { 1083, 10, 14, 12, 1, -14 },
  { 1101, 4, 15, 6, 1, -15 },
  { 1109, 6, 20, 6, -1, -15 },
  { 1124, 11, 14, 12, 1, -14 },
  { 1144, 4, 14, 6, 1, -14 },
  { 1151, 15, 11, 18, 1, -11 },
  { 1172, 10, 11, 12, 1, -11 },
  { 1186, 10, 11, 11, 1, -11 },
  { 1200, 10, 16, 11, 1, -11 },
  { 1220, 9, 16, 11, 1, -11 },
  { 1238, 7, 11, 8, 1, -11 },
  { 1248, 7, 11, 9, 1, -11 },
  { 1258, 8, 13, 8, 0, -13 },
  { 1271, 10, 11, 12, 1, -11 },
  { 1285, 11, 11, 11, 0, -11 },
  { 1301, 16, 11, 16, 0, -11 },
  { 1323, 11, 11, 11, 0, -11 },
  { 1339, 11, 16, 11, 0, -11 },
  { 1361, 8, 11, 9, 0, -11 },
  { 1372, 7, 17, 8, 0, -14 },
  { 1387, 3, 19, 9, 3, -15 },
  { 1395, 6, 17, 8, 1, -14 },
  { 1408, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Black19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK19PT7B_H_
