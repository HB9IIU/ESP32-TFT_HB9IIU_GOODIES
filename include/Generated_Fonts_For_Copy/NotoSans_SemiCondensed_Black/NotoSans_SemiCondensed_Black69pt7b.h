#ifndef _NOTOSANS_SEMICONDENSED_BLACK69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xFF, 0x1F, 0xFC, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x9F,
  0xFC, 0x3F, 0xE0, 0x1E, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE,
  0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE,
  0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF,
  0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0x7F,
  0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07,
  0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x3F, 0x0F, 0xC3,
  0xFF, 0x8F, 0xC0, 0x30, 0xFF, 0xE3, 0xF0, 0x00, 0x3F, 0xF8, 0xFC, 0x00,
  0x0F, 0xFE, 0x3F, 0x00, 0x03, 0xFF, 0xCF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x3F,
  0xFC, 0x00, 0x0F, 0xC7, 0xFF, 0x00, 0x03, 0xF1, 0xFF, 0xD0, 0x00, 0xFC,
  0x7F, 0xF7, 0x00, 0x3F, 0x1F, 0xF9, 0xF8, 0x0F, 0xCF, 0xFE, 0x7F, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF1, 0xFF,
  0x87, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xCF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE,
  0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC7, 0xFC,
  0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x20, 0x07,
  0xF8, 0x01, 0x1E, 0x03, 0xFC, 0x07, 0x8F, 0xE1, 0xFE, 0x1F, 0xCF, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xF8,
  0x03, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xC1, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF,
  0xF9, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0x9F, 0xFE, 0x01,
  0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xDF, 0xFE, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xE0, 0x1F,
  0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x7F, 0xF9, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF,
  0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF9, 0xFF, 0xE3, 0xFE, 0x3F, 0xFC, 0x3F,
  0x8F, 0xFF, 0x87, 0xC1, 0xFF, 0xF0, 0x70, 0x3F, 0xFE, 0x04, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFE, 0x0F,
  0xE0, 0x0F, 0xFF, 0x81, 0xF0, 0x03, 0xFF, 0xE0, 0x38, 0x00, 0x7F, 0xF8,
  0x04, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0x7F, 0xFF, 0xC1, 0xF0, 0x07, 0xFF, 0xE0, 0x60, 0x01, 0xFF, 0xF0, 0x20,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xDF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xDF,
  0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x7F,
  0xF3, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xE0,
  0x0F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x20,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC7,
  0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0xFC, 0x1F, 0xFD, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0x7F, 0xFE,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xDF, 0xFE, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0xFC,
  0x07, 0xFF, 0xDF, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF,
  0xF8, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0x8F, 0xFE, 0x01, 0xFF,
  0xE3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0xCF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF3, 0xFF,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x7F, 0xFC, 0x0F, 0xFF, 0x9F, 0xFE, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF7, 0xFF,
  0xF1, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0xBF, 0xFE, 0x03,
  0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF8,
  0x07, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF7,
  0xFF, 0xC1, 0xFF, 0xFD, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF,
  0x3F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03,
  0x81, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x1E, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x7F, 0x87, 0xFF, 0x1F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF9, 0xFF, 0xC3, 0xFE, 0x01,
  0xE0, 0x03, 0x80, 0x1F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0xF0,
  0xE0, 0x01, 0xFF, 0xE1, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0xFF, 0x83, 0xFE,
  0x07, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x1F, 0xF1,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFC, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xF7, 0xFC, 0x3F, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xFF, 0x87,
  0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF, 0x83, 0xFE, 0x01, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x80,
  0xFF, 0xC1, 0xFE, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x1F, 0xF7, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFF, 0x3F, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xF9, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0xFD, 0xFF,
  0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFC,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xEF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xCF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF9, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE7, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xF7,
  0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0x01, 0xFF,
  0xF3, 0xFF, 0xE0, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x83, 0xFF,
  0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0xF8, 0x1F,
  0xFF, 0x80, 0x03, 0x83, 0xFF, 0xF0, 0x00, 0x08, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x04, 0x3F, 0xFF, 0xC0, 0x01,
  0xC1, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0x80, 0x3F, 0xFF, 0x9F, 0xFF,
  0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0xFF, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0xFF, 0xFB, 0xFF,
  0xE0, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00,
  0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0xFF, 0xFD,
  0xFF, 0xF0, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xFF, 0xE7, 0xFF, 0xC0,
  0x1F, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xFF, 0x1F, 0xFF, 0x01, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x30, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x03,
  0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFF, 0x1F,
  0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xF8, 0x01, 0xFF, 0xF7,
  0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0x80,
  0x1F, 0xFF, 0x9F, 0xFF, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0xFF,
  0xDF, 0xFF, 0xFF, 0xDF, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0,
  0x3F, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xF8, 0x1F, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xCF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFB, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xBF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFE, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFD, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF7,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF7, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xE3, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xDF, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x9F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x03,
  0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x83,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFF,
  0x8F, 0xFF, 0x80, 0x3F, 0xFF, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x03,
  0xF8, 0xFF, 0xF8, 0x00, 0x70, 0xFF, 0xF8, 0x00, 0x10, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xFC, 0x00, 0x3F,
  0xFE, 0xFF, 0xC0, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x5F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE7, 0xFF, 0xF8, 0x3F, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFB, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xEF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFE,
  0x7F, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFE, 0x7F, 0xC1, 0xFF, 0xE0,
  0x07, 0xFF, 0x87, 0xFE, 0x7F, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFE,
  0x7F, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF, 0xE0,
  0x03, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFC,
  0x3F, 0xE3, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFC, 0x3F, 0xE3, 0xFF, 0xC0,
  0x03, 0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFC,
  0x3F, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0x80,
  0x01, 0xFF, 0xCF, 0xF8, 0x1F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xF8,
  0x1F, 0xF7, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xF8, 0x1F, 0xF7, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x9F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x8F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0x00, 0x03, 0xFF, 0xE7, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80,
  0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0xE0, 0x1E, 0x00, 0xFF,
  0xF8, 0x06, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xF0, 0x7F, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFC,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0x8F,
  0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF, 0xC3, 0xFF,
  0xDF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0xDF, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xE0,
  0x1F, 0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0xFD, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xF0,
  0x07, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF,
  0xFC, 0x07, 0xFF, 0xDF, 0xFF, 0xC1, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF7,
  0xFF, 0xFC, 0x1F, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x7E, 0x1F, 0xFF, 0x80, 0x38, 0x7F, 0xFC, 0x00, 0x23, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xBF, 0xFF, 0x00, 0x0E, 0x7F, 0xFE, 0x00, 0xF9, 0xFF, 0xFF, 0x7F,
  0xE7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0x07, 0xFF,
  0xF3, 0xFF, 0xC3, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xDF, 0xFF, 0x03, 0xFF,
  0xF7, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xF0, 0x3F,
  0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF,
  0xE0, 0x1F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xEF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x06, 0x1F, 0xFF, 0x80, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF,
  0x1F, 0xFC, 0x1F, 0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0xC7, 0xFF,
  0xFF, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF1, 0xFF, 0xFD,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x7F, 0xFC, 0x07, 0xFF, 0xDF, 0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xEF, 0xFF, 0x07, 0xFF,
  0xF3, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x00,
  0x70, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFD, 0x80, 0x00, 0x3F, 0xFF, 0x7C, 0x00, 0x1F, 0xFF,
  0x9F, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0x00,
  0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF,
  0xFE, 0x1F, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xFF,
  0xDF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0x01, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0x9F, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x06, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0xBF, 0xFE, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xE0,
  0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x03,
  0xFF, 0xC7, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0xFF,
  0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xFF, 0x9F, 0xFF, 0x80, 0xFF,
  0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xFF, 0xEF, 0xFF,
  0x80, 0x1F, 0xFF, 0xBF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFF, 0x3F, 0xFE, 0x03,
  0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xE7,
  0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x1F, 0xFC,
  0x03, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0x7F,
  0xFF, 0xE1, 0xFF, 0xEF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x7F, 0xFE, 0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0x7F,
  0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0xC0,
  0x1F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xE0,
  0x1F, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0xE0, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFB, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xFF, 0x81, 0xFF, 0xE3,
  0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF, 0x1F, 0xFC, 0x1F, 0xFF,
  0xE7, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xFC, 0x07, 0xFF,
  0xDF, 0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF,
  0xF8, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x70, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x37,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0x83, 0xFC, 0xFF, 0xF0, 0x07, 0x8F,
  0xFF, 0x80, 0x08, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF4, 0x00, 0x0F, 0xFF, 0x70,
  0x00, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x00, 0x0B, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x01, 0x07, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0x87,
  0xFF, 0xFC, 0x7F, 0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0xF0,
  0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x03, 0xFF,
  0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xFF, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00,
  0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0x7F, 0xC3, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0x3F,
  0xE1, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0x9F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x7F, 0xCF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xF8,
  0x07, 0xFF, 0x1F, 0xF3, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xF9, 0xFF,
  0x9F, 0xFC, 0x00, 0xFF, 0xEF, 0xFC, 0x7F, 0xCF, 0xFE, 0x00, 0x7F, 0xF7,
  0xFC, 0x3F, 0xE7, 0xFF, 0x00, 0x3F, 0xFB, 0xFE, 0x1F, 0xF3, 0xFF, 0x00,
  0x1F, 0xFD, 0xFF, 0x0F, 0xFB, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x87, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xBF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xFF, 0xE7,
  0xFF, 0xC0, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x07,
  0xFF, 0xE7, 0xFF, 0xE0, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xF0,
  0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF,
  0x87, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x07,
  0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00,
  0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xEF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xA8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x8F, 0xFF, 0x00,
  0x00, 0xDF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xD8, 0x00, 0x1F, 0xFF, 0x88, 0x00, 0x01, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Black69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 14, 50, 20, 3, -49 },
  { 89, 28, 18, 35, 4, -49 },
  { 152, 41, 49, 43, 1, -49 },
  { 404, 34, 56, 38, 2, -52 },
  { 642, 60, 51, 63, 1, -50 },
  { 1025, 50, 51, 51, 2, -50 },
  { 1344, 12, 18, 19, 4, -49 },
  { 1371, 20, 62, 24, 3, -51 },
  { 1526, 20, 62, 24, 1, -51 },
  { 1681, 33, 33, 35, 1, -53 },
  { 1818, 32, 33, 38, 3, -41 },
  { 1950, 15, 20, 20, 2, -10 },
  { 1988, 19, 11, 22, 2, -24 },
  { 2015, 13, 13, 20, 3, -12 },
  { 2037, 30, 51, 30, 0, -50 },
  { 2229, 34, 51, 38, 2, -50 },
  { 2446, 27, 49, 38, 3, -49 },
  { 2612, 34, 50, 38, 1, -50 },
  { 2825, 33, 51, 38, 2, -50 },
  { 3036, 36, 49, 38, 1, -49 },
  { 3257, 32, 50, 38, 3, -49 },
  { 3457, 34, 51, 38, 2, -50 },
  { 3674, 33, 49, 38, 3, -49 },
  { 3877, 34, 51, 38, 2, -50 },
  { 4094, 34, 51, 38, 2, -50 },
  { 4311, 14, 40, 20, 3, -39 },
  { 4381, 15, 49, 20, 2, -39 },
  { 4473, 32, 36, 38, 3, -43 },
  { 4617, 32, 25, 38, 3, -37 },
  { 4717, 32, 36, 38, 3, -43 },
  { 4861, 31, 51, 32, 0, -50 },
  { 5059, 53, 55, 59, 3, -50 },
  { 5424, 46, 49, 46, 0, -49 },
  { 5706, 35, 49, 44, 5, -49 },
  { 5921, 36, 51, 41, 3, -50 },
  { 6151, 39, 49, 47, 5, -49 },
  { 6390, 27, 49, 35, 5, -49 },
  { 6556, 27, 49, 35, 5, -49 },
  { 6722, 40, 51, 47, 3, -50 },
  { 6977, 39, 49, 49, 5, -49 },
  { 7216, 24, 49, 28, 2, -49 },
  { 7363, 23, 64, 23, -5, -49 },
  { 7547, 39, 49, 44, 5, -49 },
  { 7786, 29, 49, 36, 5, -49 },
  { 7964, 53, 49, 63, 5, -49 },
  { 8289, 43, 49, 53, 5, -49 },
  { 8553, 44, 51, 51, 3, -50 },
  { 8834, 33, 49, 41, 5, -49 },
  { 9037, 45, 62, 51, 3, -50 },
  { 9386, 39, 49, 43, 5, -49 },
  { 9625, 32, 51, 37, 3, -50 },
  { 9829, 34, 49, 37, 2, -49 },
  { 10038, 38, 50, 48, 5, -49 },
  { 10276, 45, 49, 45, 0, -49 },
  { 10552, 64, 49, 66, 1, -49 },
  { 10944, 45, 49, 45, 0, -49 },
  { 11220, 42, 49, 42, 0, -49 },
  { 11478, 35, 49, 39, 2, -49 },
  { 11693, 16, 63, 22, 4, -51 },
  { 11819, 30, 51, 30, 0, -50 },
  { 12011, 17, 63, 22, 1, -51 },
  { 12145, 37, 32, 37, 0, -49 },
  { 12293, 35, 9, 35, 0, 4 },
  { 12333, 21, 11, 27, 3, -53 },
  { 12362, 34, 40, 40, 2, -39 },
  { 12532, 35, 53, 41, 4, -52 },
  { 12764, 30, 40, 35, 3, -39 },
  { 12914, 34, 53, 41, 3, -52 },
  { 13140, 34, 40, 39, 3, -39 },
  { 13310, 27, 53, 26, 1, -53 },
  { 13489, 34, 56, 41, 3, -39 },
  { 13727, 35, 52, 43, 4, -52 },
  { 13955, 13, 54, 21, 4, -54 },
  { 14043, 20, 71, 21, -3, -54 },
  { 14221, 38, 52, 42, 4, -52 },
  { 14468, 13, 52, 21, 4, -52 },
  { 14553, 56, 39, 64, 4, -39 },
  { 14826, 35, 39, 43, 4, -39 },
  { 14997, 35, 40, 41, 3, -39 },
  { 15172, 35, 56, 41, 4, -39 },
  { 15417, 34, 56, 41, 3, -39 },
  { 15655, 25, 39, 30, 4, -39 },
  { 15777, 28, 40, 33, 2, -39 },
  { 15917, 26, 47, 29, 1, -46 },
  { 16070, 35, 39, 43, 4, -38 },
  { 16241, 39, 38, 39, 0, -38 },
  { 16427, 57, 38, 58, 1, -38 },
  { 16698, 39, 38, 40, 0, -38 },
  { 16884, 39, 55, 39, 0, -38 },
  { 17153, 30, 38, 32, 1, -38 },
  { 17296, 24, 62, 28, 2, -50 },
  { 17482, 9, 68, 33, 12, -53 },
  { 17559, 25, 62, 28, 2, -50 },
  { 17753, 33, 13, 38, 3, -31 },
};

const GFXfont NotoSans_SemiCondensed_Black69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK69PT7B_H_
