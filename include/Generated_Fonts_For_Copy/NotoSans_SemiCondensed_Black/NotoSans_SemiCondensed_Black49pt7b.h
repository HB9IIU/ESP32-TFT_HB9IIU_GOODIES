#ifndef _NOTOSANS_SEMICONDENSED_BLACK49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC1, 0xFC,
  0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xF0, 0x30, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xF7, 0xE0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFD, 0xF1, 0xE7, 0xF3, 0xE0, 0x4F, 0xE7,
  0xC0, 0x1F, 0xCF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7D, 0xFE,
  0x00, 0xF9, 0xFE, 0x01, 0xF3, 0xFF, 0x03, 0xE7, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0xC0,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x3F,
  0x8F, 0xE0, 0x00, 0x3F, 0x8F, 0xE3, 0xF0, 0x18, 0x0F, 0xE3, 0xF9, 0xFC,
  0x3F, 0xC1, 0xFD, 0xFC, 0x7E, 0x3F, 0xF8, 0x7F, 0xFF, 0x3F, 0x9F, 0xFF,
  0x0F, 0xFF, 0xCF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE7, 0xF3, 0xFF, 0xF8, 0x7F,
  0xF1, 0xF8, 0xFE, 0x7F, 0x07, 0xF8, 0xFE, 0x3F, 0x9F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xFC,
  0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0xC3, 0xF0,
  0x00, 0x7F, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x7F, 0x00, 0x0F,
  0xE0, 0x3F, 0x9F, 0xC0, 0x03, 0xF0, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x07, 0xFC, 0x07,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF,
  0x83, 0xFF, 0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0xFD, 0xFF, 0x07, 0xFE, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC7, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE,
  0xFE, 0x7E, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x08, 0x0F, 0xC0, 0x9E, 0x1F, 0x0F, 0x3F, 0xBE, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF,
  0xE0, 0x3F, 0xDF, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0x80, 0x78, 0x3E,
  0x00, 0x70, 0x70, 0x00, 0x20, 0x40, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0C, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x3F, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0xC7,
  0xFD, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFD, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF3, 0xFB, 0xFE, 0x3C,
  0x7F, 0xC3, 0x0F, 0xF8, 0x41, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0x87, 0xFE, 0x1F, 0x03, 0xFE, 0x0C, 0x03, 0xFE, 0x08, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x07, 0xFE,
  0x10, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xBF, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xCF, 0xF8, 0x1F, 0xC7, 0xFC, 0x1F,
  0xE3, 0xFE, 0x0F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF0, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xF0, 0xFF, 0x7F, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3,
  0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xC7,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFC,
  0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0xC7, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0x83, 0xFE,
  0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFE, 0xFF, 0xC7, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xE3, 0xFE, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF,
  0xE3, 0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xF9, 0xFE, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0xFC, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xE3, 0xF0, 0x30, 0x1F, 0x87, 0xF9, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF,
  0xCF, 0xF0, 0xFE, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xCF, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0x81, 0xFF, 0x10, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x1C, 0x07, 0xF0, 0xFE, 0x07, 0xFF, 0x8F,
  0xC3, 0xF8, 0x7F, 0xFF, 0x3F, 0x9F, 0xC3, 0xFF, 0xFC, 0x7E, 0x7F, 0x1F,
  0xFF, 0xF1, 0xF9, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0xE3, 0xF8, 0x3F, 0x0F,
  0xFF, 0x8F, 0xC0, 0xFC, 0x3F, 0xFC, 0x7F, 0x03, 0xF0, 0xFF, 0xF1, 0xFC,
  0x0F, 0xC3, 0xFF, 0xC7, 0xF0, 0x3F, 0x0F, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F,
  0xFC, 0x7F, 0x07, 0xF1, 0xFB, 0xF1, 0xFC, 0x1F, 0xC7, 0xEF, 0xC7, 0xF0,
  0x7F, 0x1F, 0xBF, 0x0F, 0xC3, 0xFC, 0xFE, 0xFC, 0x3F, 0xFF, 0xFF, 0xF3,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xE1, 0xFF, 0xEF, 0xFE, 0x1F, 0xC3, 0xFF,
  0x3F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x0F, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0x0F, 0xFE, 0xFF, 0xC1,
  0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFF, 0x03, 0xFE, 0xFF,
  0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC3, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7C, 0x3F, 0xF0, 0x03, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x10, 0xFF, 0xF0, 0x3C, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC1, 0xFF, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF,
  0xFC, 0x0F, 0xFE, 0xFF, 0xC1, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0xF8,
  0x3F, 0xF8, 0x00, 0x81, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF,
  0xE0, 0xFF, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFB, 0xFF, 0x80, 0x7F, 0xCF, 0xFE, 0x03, 0xFE, 0x7F, 0xF8, 0x1F,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFB, 0x1F, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF,
  0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xF3,
  0xFF, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x1F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF,
  0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x01,
  0xFF, 0xBF, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xFF, 0x7F,
  0x03, 0xFB, 0xFF, 0xFD, 0xFC, 0x0F, 0xEF, 0xFF, 0xF7, 0xF8, 0x3F, 0xBF,
  0xFF, 0xCF, 0xE0, 0xFC, 0xFF, 0xFF, 0xBF, 0x87, 0xF3, 0xFF, 0xFE, 0xFF,
  0x1F, 0xCF, 0xFF, 0xF9, 0xFC, 0x7F, 0x3F, 0xFF, 0xE7, 0xF3, 0xF8, 0xFF,
  0xFF, 0x9F, 0xCF, 0xE3, 0xFF, 0xFE, 0x7F, 0xBF, 0x8F, 0xFF, 0xF8, 0xFE,
  0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF7,
  0xFC, 0x1F, 0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0xCF, 0xF8, 0x7F, 0xFF, 0x9F,
  0xF0, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xFE, 0x3F,
  0xE7, 0xFF, 0xFC, 0x7F, 0xCF, 0xFF, 0xF8, 0x7F, 0xDF, 0xFF, 0xF0, 0xFF,
  0xBF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFC,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x07,
  0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03,
  0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xC7, 0xFC,
  0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F,
  0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xE0, 0xFC, 0xFF,
  0x80, 0x31, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xF7, 0xF0, 0x7F, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC,
  0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFD,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xDF,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x8F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF0, 0x7F, 0x81,
  0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7E, 0xFC, 0x1F, 0xF0, 0x3F, 0xC3, 0xFB,
  0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xEF, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xBF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFE, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFB, 0xF8,
  0xFF, 0x00, 0x7F, 0x9F, 0xCF, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x1F, 0x8F,
  0xF0, 0x07, 0xF9, 0xFC, 0x7F, 0x7F, 0xC0, 0x1F, 0xE7, 0xF1, 0xFD, 0xFF,
  0x00, 0x3F, 0xDF, 0xC7, 0xF7, 0xF8, 0x00, 0xFF, 0xFE, 0x1F, 0xDF, 0xE0,
  0x03, 0xFF, 0xF8, 0x3F, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0xFD, 0xFE, 0x00,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0x8F,
  0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF3,
  0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF3, 0xF8, 0x03, 0xF8,
  0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0x83, 0xFF, 0x08, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFE, 0xFE, 0xFF, 0xFD, 0xFC, 0xFF, 0xF3, 0xF8, 0xFF,
  0x83, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0x00, 0xFF, 0x9F, 0xE0, 0xFF,
  0xBF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xF8, 0xFF,
  0x3F, 0xF0, 0xFE, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x7F, 0xE0, 0x67, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x27, 0xFE, 0x07,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xC0,
  0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xFC, 0xFF, 0x1F, 0xFE, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFE, 0xFF, 0x0F, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x00, 0x18,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x04, 0x7F, 0xF0, 0x3C, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x07, 0xFE, 0x20, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFE,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x0F, 0xFE, 0xFF, 0x1F,
  0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFE, 0xFF, 0x0F, 0xFC, 0xFF, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x60,
  0x03, 0xFF, 0x7F, 0x0F, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0x00, 0xFF, 0x9F, 0xF0, 0xFF,
  0xBF, 0xFC, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x3E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xC1, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF1,
  0xFF, 0x07, 0xFE, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF3, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF7, 0xFC, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF,
  0x87, 0xFC, 0x1F, 0xF8, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x3F, 0xF3, 0xFE,
  0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x03, 0x01, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC3, 0xF8, 0xFF, 0xF1, 0xFF, 0xE7, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xFF,
  0x83, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0xFE,
  0x1F, 0xF0, 0xFE, 0x3F, 0xFC, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xC1, 0xFF,
  0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x3F, 0xE7, 0xFC,
  0x1F, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0x00, 0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xF8, 0xFF, 0x7F, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xBF, 0xF8, 0xFF, 0x9F, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x0F, 0xFE, 0xFF, 0x1F, 0xFE, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFE, 0xFF, 0x0F, 0xFC, 0xFF, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xBF, 0x83, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFC, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF0, 0x38, 0xFF,
  0x00, 0x8F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0xE8, 0x01, 0xFF, 0xC0, 0x1F, 0xEF, 0xC7, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x11,
  0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFE, 0x7F, 0x1F, 0xFE, 0x7F, 0x0F, 0xF8,
  0x7F, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7,
  0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F,
  0x9F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFB, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0,
  0x7F, 0xF0, 0x3F, 0xCF, 0xF8, 0x3F, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xFE,
  0x1F, 0xF1, 0xFE, 0x0F, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xFF, 0x87, 0xF8,
  0x7F, 0xC7, 0xFF, 0xC3, 0xFC, 0x1F, 0xE3, 0xF7, 0xE1, 0xFE, 0x0F, 0xF1,
  0xFB, 0xF9, 0xFF, 0x07, 0xF8, 0xFD, 0xFC, 0xFF, 0x03, 0xFC, 0xFE, 0xFE,
  0x7F, 0x80, 0xFF, 0x7F, 0x3F, 0x3F, 0xC0, 0x7F, 0xBF, 0x9F, 0x9F, 0xE0,
  0x3F, 0xDF, 0x8F, 0xCF, 0xE0, 0x1F, 0xEF, 0xC7, 0xFF, 0xF0, 0x07, 0xF7,
  0xE3, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xF7, 0xFE,
  0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF9, 0xFF,
  0x80, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x9F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE,
  0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x9F, 0xF0,
  0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x07, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x02, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Black49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 36, 14, 2, -35 },
  { 46, 19, 13, 25, 3, -35 },
  { 77, 29, 35, 30, 1, -35 },
  { 204, 23, 40, 27, 2, -37 },
  { 319, 42, 35, 44, 1, -35 },
  { 503, 36, 35, 36, 1, -35 },
  { 661, 8, 13, 14, 3, -35 },
  { 674, 14, 44, 17, 2, -36 },
  { 751, 14, 44, 17, 1, -36 },
  { 828, 23, 23, 25, 1, -37 },
  { 895, 23, 24, 27, 2, -29 },
  { 964, 11, 14, 15, 1, -7 },
  { 984, 14, 8, 16, 1, -17 },
  { 998, 10, 10, 14, 2, -9 },
  { 1011, 21, 35, 21, 0, -35 },
  { 1103, 23, 35, 27, 2, -35 },
  { 1204, 19, 35, 27, 2, -35 },
  { 1288, 24, 35, 27, 1, -35 },
  { 1393, 23, 35, 27, 2, -35 },
  { 1494, 25, 35, 27, 1, -35 },
  { 1604, 23, 35, 27, 2, -35 },
  { 1705, 24, 35, 27, 2, -35 },
  { 1810, 23, 35, 27, 2, -35 },
  { 1911, 24, 35, 27, 2, -35 },
  { 2016, 23, 35, 27, 2, -35 },
  { 2117, 10, 28, 14, 2, -27 },
  { 2152, 11, 34, 14, 1, -27 },
  { 2199, 23, 26, 27, 2, -31 },
  { 2274, 23, 17, 27, 2, -26 },
  { 2323, 23, 26, 27, 2, -31 },
  { 2398, 22, 36, 23, 0, -35 },
  { 2497, 38, 39, 42, 2, -35 },
  { 2683, 33, 35, 33, 0, -35 },
  { 2828, 26, 35, 31, 3, -35 },
  { 2942, 26, 35, 29, 2, -35 },
  { 3056, 28, 35, 33, 3, -35 },
  { 3179, 20, 35, 25, 3, -35 },
  { 3267, 20, 35, 25, 3, -35 },
  { 3355, 29, 35, 34, 2, -35 },
  { 3482, 28, 35, 35, 3, -35 },
  { 3605, 17, 35, 20, 2, -35 },
  { 3680, 17, 46, 16, -4, -35 },
  { 3778, 29, 35, 31, 3, -35 },
  { 3905, 21, 35, 26, 3, -35 },
  { 3997, 38, 35, 44, 3, -35 },
  { 4164, 31, 35, 38, 3, -35 },
  { 4300, 32, 36, 36, 2, -36 },
  { 4444, 24, 35, 29, 3, -35 },
  { 4549, 32, 44, 36, 2, -36 },
  { 4725, 28, 35, 31, 3, -35 },
  { 4848, 23, 35, 26, 2, -35 },
  { 4949, 25, 35, 27, 1, -35 },
  { 5059, 28, 35, 34, 3, -35 },
  { 5182, 32, 35, 32, 0, -35 },
  { 5322, 46, 35, 47, 0, -35 },
  { 5524, 32, 35, 32, 0, -35 },
  { 5664, 30, 35, 30, 0, -35 },
  { 5796, 25, 35, 27, 1, -35 },
  { 5906, 13, 44, 15, 2, -36 },
  { 5978, 21, 35, 21, 0, -35 },
  { 6070, 12, 44, 15, 1, -36 },
  { 6136, 26, 23, 26, 0, -35 },
  { 6211, 25, 6, 25, 0, 3 },
  { 6230, 15, 8, 19, 2, -38 },
  { 6245, 23, 28, 28, 2, -28 },
  { 6326, 24, 37, 29, 3, -37 },
  { 6437, 21, 28, 25, 2, -28 },
  { 6511, 24, 37, 29, 2, -37 },
  { 6622, 24, 28, 28, 2, -28 },
  { 6706, 19, 37, 19, 1, -37 },
  { 6794, 24, 40, 29, 2, -28 },
  { 6914, 24, 37, 30, 3, -37 },
  { 7025, 9, 38, 15, 3, -38 },
  { 7068, 14, 50, 15, -2, -38 },
  { 7156, 27, 37, 30, 3, -37 },
  { 7281, 9, 37, 15, 3, -37 },
  { 7323, 39, 28, 45, 3, -28 },
  { 7460, 24, 28, 30, 3, -28 },
  { 7544, 25, 28, 29, 2, -28 },
  { 7632, 24, 40, 29, 3, -28 },
  { 7752, 24, 40, 29, 2, -28 },
  { 7872, 18, 28, 21, 3, -28 },
  { 7935, 20, 28, 23, 2, -28 },
  { 8005, 18, 33, 21, 1, -33 },
  { 8080, 24, 27, 30, 3, -27 },
  { 8161, 28, 27, 28, 0, -27 },
  { 8256, 41, 27, 41, 0, -27 },
  { 8395, 28, 27, 28, 0, -27 },
  { 8490, 28, 39, 28, 0, -27 },
  { 8627, 21, 27, 23, 1, -27 },
  { 8698, 18, 43, 20, 1, -35 },
  { 8795, 7, 48, 23, 8, -37 },
  { 8837, 18, 43, 20, 1, -35 },
  { 8934, 23, 9, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_Black49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK49PT7B_H_
