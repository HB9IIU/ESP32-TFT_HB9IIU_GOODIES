#ifndef _NOTOSANS_SEMICONDENSED_BLACK14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF0, 0xF0, 0xDE, 0xF7, 0xB0, 0x1A, 0x16, 0x16, 0x7F, 0x36,
  0x36, 0xFF, 0x2C, 0x6C, 0x6C, 0x10, 0x79, 0xFF, 0x97, 0x0F, 0x8F, 0x8B,
  0x56, 0xFC, 0xE0, 0x80, 0x70, 0xCF, 0x98, 0xD9, 0x8D, 0xB0, 0x7B, 0xF7,
  0x6F, 0x06, 0xB0, 0xCF, 0x0C, 0xF1, 0x8F, 0x3C, 0x1F, 0x87, 0x60, 0xF8,
  0x3D, 0xDF, 0x76, 0xFB, 0x9E, 0x7F, 0x8F, 0x70, 0xFF, 0x7E, 0xCC, 0xCC,
  0xCC, 0xCC, 0xE7, 0xE6, 0x33, 0x33, 0x33, 0x33, 0x6E, 0x18, 0x31, 0x5F,
  0xF3, 0x8D, 0x8A, 0x00, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x6D, 0xE0, 0xFF,
  0xF0, 0x0C, 0x61, 0x86, 0x30, 0xC7, 0x18, 0x63, 0x80, 0x3C, 0xFD, 0xBB,
  0x3E, 0x7C, 0xD9, 0xB7, 0x7E, 0x78, 0x3B, 0xFF, 0xB9, 0x8C, 0x63, 0x18,
  0xC0, 0x7D, 0xFD, 0x38, 0x70, 0xC3, 0x8E, 0x38, 0xFF, 0xFC, 0xFC, 0xFD,
  0x38, 0x73, 0x87, 0xC3, 0xC7, 0xFF, 0xF8, 0x0C, 0x1C, 0x1C, 0x3C, 0x6C,
  0x6C, 0xFF, 0xFF, 0x0C, 0x0C, 0xFF, 0xFC, 0x34, 0xFB, 0xF1, 0xE7, 0xFF,
  0xE0, 0x1E, 0x7D, 0xC3, 0x67, 0xFF, 0xD9, 0xB3, 0x7E, 0x78, 0xFF, 0xF1,
  0xC7, 0x18, 0xE3, 0x1C, 0x73, 0x80, 0x3C, 0xFD, 0x9B, 0xF3, 0xCF, 0x99,
  0xF3, 0x7E, 0xF8, 0x3C, 0xFD, 0x9F, 0x36, 0xEF, 0xCD, 0x87, 0x7C, 0xF0,
  0xFC, 0x0F, 0x6D, 0x80, 0x1B, 0x78, 0x04, 0x33, 0xF8, 0xE1, 0xF0, 0xC1,
  0xFC, 0x00, 0x3F, 0xFC, 0x83, 0x0F, 0x0F, 0x3F, 0xCC, 0x20, 0x7B, 0xF8,
  0xC7, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x1F, 0x1C, 0x6C, 0xEF, 0x7F, 0xB3,
  0x6C, 0xDB, 0x7F, 0x7F, 0xC0, 0x1C, 0xC3, 0xF0, 0x1E, 0x0F, 0x0F, 0x86,
  0xC3, 0x73, 0x99, 0xFC, 0xFF, 0xE3, 0xF1, 0xC0, 0xFD, 0xFF, 0xBF, 0x7F,
  0xDF, 0xFB, 0xF7, 0xFF, 0xF8, 0x3E, 0xFF, 0x8F, 0x0C, 0x18, 0x30, 0x71,
  0x7E, 0x7C, 0xFC, 0xFE, 0xEE, 0xE7, 0xE7, 0xE7, 0xE7, 0xEE, 0xFE, 0xF8,
  0xFF, 0xFE, 0x38, 0xFB, 0xEE, 0x38, 0xFF, 0xF0, 0xFF, 0xF9, 0xCF, 0xFF,
  0x9C, 0xE7, 0x00, 0x3F, 0x7E, 0xE2, 0xE0, 0xCF, 0xCF, 0xE7, 0xE7, 0x7F,
  0x3F, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFB,
  0xCC, 0x63, 0x18, 0xC6, 0x7F, 0xC0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCF, 0xEE, 0x00, 0xE7, 0xEE, 0xEC, 0xFC, 0xF8, 0xFC, 0xFC, 0xEE, 0xEE,
  0xE7, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xF0, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF9, 0xFD, 0xBF, 0xB7, 0xF7, 0xBE, 0xF7, 0xCE, 0xF9, 0xDC, 0xE3,
  0xF9, 0xFC, 0xFF, 0x7D, 0xBE, 0xFF, 0x37, 0x9F, 0xC7, 0xE3, 0xC0, 0x3E,
  0x3F, 0xB9, 0xDC, 0x6C, 0x3E, 0x1F, 0x8D, 0xCE, 0x7F, 0x1F, 0x00, 0xF9,
  0xFB, 0xBF, 0x7F, 0xFF, 0xBE, 0x70, 0xE1, 0xC0, 0x3E, 0x3F, 0xB9, 0xDC,
  0x6C, 0x3E, 0x1F, 0x8D, 0xCE, 0x7F, 0x1F, 0x03, 0x80, 0xF0, 0xFC, 0xFE,
  0xEE, 0xEE, 0xFE, 0xFC, 0xFC, 0xEC, 0xEE, 0xE7, 0x7F, 0xFC, 0x78, 0xF9,
  0xF1, 0xE7, 0xFF, 0xE0, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0x7C, 0xE3,
  0xF1, 0xD8, 0xCE, 0xE7, 0x71, 0xB0, 0xD8, 0x7C, 0x1C, 0x0E, 0x00, 0xE7,
  0x1F, 0x39, 0xD9, 0xCE, 0xCF, 0x67, 0x7B, 0x3E, 0xD8, 0xF7, 0xC7, 0xBE,
  0x3C, 0xE1, 0xE7, 0x00, 0xE3, 0xBB, 0x8D, 0x87, 0xC1, 0xC0, 0xE0, 0xF8,
  0xEE, 0x77, 0x71, 0xC0, 0xE3, 0xB3, 0x9D, 0x87, 0xC3, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x00, 0xFE, 0xFE, 0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x70,
  0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0xDB, 0x70, 0xE1, 0x86, 0x1C, 0x30, 0xC3,
  0x86, 0x18, 0x30, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x10, 0x38, 0x38,
  0x6C, 0x6C, 0xC6, 0xC7, 0xFF, 0xFC, 0xE6, 0x30, 0x3C, 0xFD, 0x19, 0xF7,
  0xFC, 0xDF, 0xBF, 0xC1, 0x83, 0x06, 0xEF, 0xDD, 0xF3, 0xE7, 0xEF, 0xFB,
  0x70, 0x7F, 0xEE, 0xB0, 0xC3, 0x1F, 0x9E, 0x0E, 0x1C, 0x3B, 0x7F, 0xF9,
  0xF3, 0xE7, 0xCF, 0xFD, 0xF8, 0x7B, 0xFC, 0xFF, 0xFF, 0x0F, 0xDF, 0x3D,
  0xE7, 0x1E, 0xF9, 0xC7, 0x1C, 0x71, 0xC7, 0x00, 0x6F, 0xFF, 0x3E, 0x7C,
  0xF9, 0xFF, 0xBF, 0x0D, 0xFB, 0xF0, 0xC1, 0x83, 0x06, 0xEF, 0xFD, 0xF3,
  0xE7, 0xCF, 0x9F, 0x38, 0xF7, 0xFF, 0xFC, 0x33, 0x13, 0x33, 0x33, 0x33,
  0x33, 0xFF, 0xC0, 0xC0, 0xC0, 0xCE, 0xCC, 0xDC, 0xF8, 0xF8, 0xFC, 0xCE,
  0xCF, 0xFF, 0xFF, 0xFC, 0xDD, 0xDF, 0xFF, 0xBB, 0xE7, 0x3C, 0xE7, 0x9C,
  0xF3, 0x9E, 0x73, 0xDD, 0xFF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0x79, 0xFB,
  0x3E, 0x7C, 0xF9, 0xFF, 0x3C, 0xDD, 0xFB, 0xBE, 0x7C, 0xFD, 0xFF, 0x6E,
  0xC1, 0x83, 0x00, 0x6F, 0xFF, 0x3E, 0x7C, 0xF9, 0xFF, 0xBF, 0x0E, 0x1C,
  0x38, 0xDF, 0xFF, 0x8C, 0x63, 0x18, 0x39, 0xFE, 0x5E, 0x3C, 0x37, 0xDE,
  0x31, 0xEF, 0x9C, 0x71, 0xC7, 0x1F, 0x3C, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xFF, 0xBB, 0xE7, 0xE6, 0x66, 0x6E, 0x7C, 0x3C, 0x3C, 0x18, 0xEE, 0x7E,
  0xF6, 0x6F, 0x66, 0xF6, 0x6F, 0xE6, 0xBC, 0x39, 0xC3, 0x9C, 0xE7, 0x7E,
  0x7E, 0x3C, 0x3C, 0x7E, 0x7E, 0xE7, 0xE7, 0xE7, 0x66, 0x7E, 0x3C, 0x3C,
  0x3C, 0x18, 0x18, 0x78, 0x70, 0xFF, 0xF1, 0xCE, 0x31, 0xCF, 0xFF, 0x39,
  0xCC, 0x63, 0x7B, 0xC6, 0x31, 0x8E, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7,
  0x8C, 0x63, 0x1C, 0xE6, 0x31, 0xBD, 0xC0, 0xF7, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Black14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 5, 4, 7, 1, -10 },
  { 7, 8, 10, 9, 0, -10 },
  { 17, 7, 12, 8, 0, -11 },
  { 28, 12, 10, 13, 0, -10 },
  { 43, 10, 10, 10, 0, -10 },
  { 56, 2, 4, 4, 1, -10 },
  { 57, 4, 12, 5, 1, -10 },
  { 63, 4, 12, 5, 0, -10 },
  { 69, 7, 7, 7, 0, -11 },
  { 76, 6, 6, 8, 1, -8 },
  { 81, 3, 4, 4, 0, -2 },
  { 83, 4, 2, 5, 0, -5 },
  { 84, 2, 2, 4, 1, -2 },
  { 85, 6, 10, 6, 0, -10 },
  { 93, 7, 10, 8, 0, -10 },
  { 102, 5, 10, 8, 1, -10 },
  { 109, 7, 10, 8, 0, -10 },
  { 118, 7, 10, 8, 0, -10 },
  { 127, 8, 10, 8, 0, -10 },
  { 137, 6, 10, 8, 1, -10 },
  { 145, 7, 10, 8, 0, -10 },
  { 154, 6, 10, 8, 1, -10 },
  { 162, 7, 10, 8, 0, -10 },
  { 171, 7, 10, 8, 0, -10 },
  { 180, 2, 8, 4, 1, -8 },
  { 182, 3, 10, 4, 0, -8 },
  { 186, 6, 8, 8, 1, -9 },
  { 192, 6, 5, 8, 1, -7 },
  { 196, 6, 8, 8, 1, -9 },
  { 202, 6, 10, 7, 0, -10 },
  { 210, 10, 11, 12, 1, -10 },
  { 224, 9, 10, 9, 0, -10 },
  { 236, 7, 10, 9, 1, -10 },
  { 245, 7, 10, 8, 1, -10 },
  { 254, 8, 10, 10, 1, -10 },
  { 264, 6, 10, 7, 1, -10 },
  { 272, 5, 10, 7, 1, -10 },
  { 279, 8, 10, 10, 1, -10 },
  { 289, 8, 10, 10, 1, -10 },
  { 299, 5, 10, 6, 0, -10 },
  { 306, 5, 13, 5, -1, -10 },
  { 315, 8, 10, 9, 1, -10 },
  { 325, 6, 10, 7, 1, -10 },
  { 333, 11, 10, 13, 1, -10 },
  { 347, 9, 10, 11, 1, -10 },
  { 359, 9, 10, 10, 1, -10 },
  { 371, 7, 10, 8, 1, -10 },
  { 380, 9, 12, 10, 1, -10 },
  { 394, 8, 10, 9, 1, -10 },
  { 404, 6, 10, 7, 1, -10 },
  { 412, 7, 10, 8, 0, -10 },
  { 421, 8, 10, 10, 1, -10 },
  { 431, 9, 10, 9, 0, -10 },
  { 443, 13, 10, 13, 0, -10 },
  { 460, 9, 10, 9, 0, -10 },
  { 472, 9, 10, 9, 0, -10 },
  { 484, 8, 10, 8, 0, -10 },
  { 494, 3, 12, 4, 1, -10 },
  { 499, 6, 10, 6, 0, -10 },
  { 507, 4, 12, 4, 0, -10 },
  { 513, 8, 7, 7, 0, -10 },
  { 520, 7, 2, 7, 0, 1 },
  { 522, 4, 3, 5, 1, -11 },
  { 524, 7, 8, 8, 0, -8 },
  { 531, 7, 11, 8, 1, -11 },
  { 541, 6, 8, 7, 1, -8 },
  { 547, 7, 11, 8, 1, -11 },
  { 557, 6, 8, 8, 1, -8 },
  { 563, 6, 11, 5, 0, -11 },
  { 572, 7, 11, 8, 1, -8 },
  { 582, 7, 11, 9, 1, -11 },
  { 592, 2, 11, 4, 1, -11 },
  { 595, 4, 14, 4, -1, -11 },
  { 602, 8, 11, 9, 1, -11 },
  { 613, 2, 11, 4, 1, -11 },
  { 616, 11, 8, 13, 1, -8 },
  { 627, 7, 8, 9, 1, -8 },
  { 634, 7, 8, 8, 1, -8 },
  { 641, 7, 11, 8, 1, -8 },
  { 651, 7, 11, 8, 1, -8 },
  { 661, 5, 8, 6, 1, -8 },
  { 666, 6, 8, 7, 0, -8 },
  { 672, 6, 9, 6, 0, -9 },
  { 679, 7, 8, 9, 1, -8 },
  { 686, 8, 8, 8, 0, -8 },
  { 694, 12, 8, 12, 0, -8 },
  { 706, 8, 8, 8, 0, -8 },
  { 714, 8, 11, 8, 0, -8 },
  { 725, 6, 8, 7, 0, -8 },
  { 731, 5, 12, 6, 0, -10 },
  { 739, 2, 14, 7, 2, -11 },
  { 743, 5, 12, 6, 0, -10 },
  { 751, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Black14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK14PT7B_H_
