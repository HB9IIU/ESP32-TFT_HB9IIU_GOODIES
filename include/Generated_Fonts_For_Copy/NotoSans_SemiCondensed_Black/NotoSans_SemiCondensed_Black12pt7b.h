#ifndef _NOTOSANS_SEMICONDENSED_BLACK12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black12pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0xC3, 0xE0, 0xFF, 0xB5, 0x20, 0x14, 0x68, 0xD3, 0xF2,
  0xDF, 0xFF, 0xB4, 0x78, 0x11, 0xFD, 0x7C, 0x78, 0x79, 0xDF, 0x78, 0x40,
  0x61, 0x1E, 0x63, 0x48, 0x6B, 0x07, 0x5C, 0xDA, 0xC2, 0xD8, 0xCB, 0x31,
  0xC0, 0x18, 0x3E, 0x1B, 0x0F, 0x83, 0xBB, 0xFB, 0xBC, 0xFE, 0x7F, 0x80,
  0xFE, 0x36, 0x66, 0x4C, 0x46, 0x66, 0x30, 0xC6, 0x63, 0x33, 0x33, 0x66,
  0xC0, 0x32, 0xDF, 0xCE, 0x78, 0x40, 0x10, 0x4F, 0xFF, 0x10, 0x40, 0x6D,
  0x60, 0xFF, 0xF0, 0x18, 0xCC, 0x63, 0x31, 0x8C, 0xC0, 0x31, 0xF6, 0xFB,
  0xEF, 0xB6, 0xDF, 0x38, 0x19, 0xFE, 0xF1, 0x8C, 0x63, 0x18, 0x33, 0xF4,
  0xC3, 0x18, 0xE7, 0x3F, 0xFC, 0x3B, 0xF4, 0xC7, 0x30, 0x70, 0xFF, 0xF8,
  0x1C, 0x73, 0xCF, 0x7F, 0x7F, 0xC7, 0x1C, 0xFF, 0xF1, 0xCF, 0x8C, 0x7F,
  0xF0, 0x1D, 0xF6, 0x1E, 0xFF, 0xBE, 0xDF, 0x38, 0xFF, 0xF0, 0xC7, 0x18,
  0x63, 0x0C, 0x70, 0x39, 0xF6, 0xDF, 0x39, 0xFC, 0xFF, 0x78, 0x31, 0xFE,
  0xFB, 0x7D, 0xF0, 0xDE, 0x70, 0xF8, 0x3C, 0x6D, 0x00, 0xDA, 0xC0, 0x04,
  0x33, 0xF8, 0x78, 0x70, 0x40, 0xFC, 0x0F, 0xFF, 0x83, 0x87, 0x87, 0x3F,
  0x88, 0x00, 0x77, 0xE6, 0x33, 0x10, 0x0E, 0x70, 0x0E, 0x0F, 0xE6, 0x49,
  0x7B, 0x52, 0xF4, 0xB5, 0xF9, 0xA4, 0x73, 0x07, 0xC0, 0x18, 0x3C, 0x3C,
  0x3C, 0x66, 0x66, 0x7E, 0xE7, 0xE3, 0xF3, 0xFC, 0xF7, 0xFB, 0x7C, 0xFF,
  0xF8, 0x39, 0xFE, 0x70, 0xC3, 0x0C, 0x3E, 0x78, 0xE1, 0xFB, 0x36, 0x7C,
  0xF9, 0xF3, 0x7E, 0xF8, 0xFF, 0xF1, 0x8F, 0x63, 0x1F, 0xF8, 0xFF, 0xF1,
  0x8F, 0x7B, 0x18, 0xC0, 0x38, 0xFB, 0x96, 0x0D, 0xFB, 0xF3, 0xFF, 0x7E,
  0xCF, 0x9F, 0x3E, 0x7F, 0xF9, 0xF3, 0xE7, 0xCE, 0xFF, 0xDC, 0xE7, 0x39,
  0xCE, 0xF8, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFC, 0xCF, 0x9B, 0x67, 0xCF,
  0x1F, 0x36, 0x6E, 0xCE, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xE3, 0xF1,
  0xF8, 0xFE, 0xFF, 0x7F, 0xAF, 0x77, 0xBB, 0xDD, 0x80, 0xE7, 0xCF, 0xDF,
  0xBF, 0xFB, 0xF7, 0xE7, 0xCE, 0x39, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xFF,
  0x7C, 0xE3, 0xED, 0xF7, 0xFB, 0xEC, 0x30, 0xC0, 0x39, 0xFB, 0x3E, 0x3C,
  0x78, 0xF1, 0xFF, 0x7C, 0x18, 0x38, 0xE1, 0xF3, 0x76, 0xEF, 0x9F, 0x36,
  0x6E, 0xCE, 0x39, 0xF6, 0x58, 0x78, 0x70, 0xFF, 0xF8, 0xFF, 0xF3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0x7E, 0x78,
  0xC7, 0xE6, 0x66, 0x66, 0x6E, 0x3C, 0x3C, 0x3C, 0x38, 0xC6, 0x78, 0xCD,
  0xB9, 0xB7, 0x36, 0xFC, 0xD7, 0x9A, 0xF1, 0xCE, 0x39, 0xC0, 0xE7, 0x66,
  0x7C, 0x3C, 0x38, 0x3C, 0x7C, 0x6E, 0xE7, 0xC6, 0xCD, 0xB3, 0xE3, 0x87,
  0x06, 0x0C, 0x18, 0xFF, 0xF0, 0xC6, 0x38, 0xC6, 0x3F, 0xFC, 0xFE, 0x49,
  0x24, 0x93, 0x80, 0xC6, 0x18, 0xC2, 0x18, 0xC3, 0x18, 0xFD, 0xB6, 0xDB,
  0x6F, 0x80, 0x10, 0xC3, 0x9E, 0x4F, 0x30, 0xFC, 0xE3, 0x39, 0xF0, 0xDF,
  0xEF, 0xF7, 0xC0, 0xC3, 0x0D, 0x3E, 0xDF, 0x3D, 0xFE, 0xF8, 0x3D, 0xE6,
  0x38, 0xE1, 0xF7, 0xC0, 0x0C, 0x33, 0xDF, 0x6F, 0xBE, 0xDF, 0x74, 0x39,
  0xF6, 0xFF, 0x61, 0xD3, 0xC0, 0x7B, 0x5D, 0xE6, 0x31, 0x8C, 0x60, 0x35,
  0xF6, 0xFB, 0xED, 0xF7, 0xC3, 0x7D, 0xE0, 0xC3, 0x0D, 0xBF, 0xDF, 0x3C,
  0xF3, 0xCC, 0xFF, 0xFF, 0xC0, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC3,
  0x0C, 0xF6, 0xFB, 0xCF, 0xB6, 0xCC, 0xFF, 0xFF, 0xC0, 0xBB, 0x7F, 0xF7,
  0x7B, 0xBD, 0xDE, 0xEF, 0x76, 0xBB, 0xFD, 0xF3, 0xCF, 0x3C, 0xC0, 0x38,
  0xF9, 0xBF, 0x76, 0xEF, 0x8E, 0x00, 0xD3, 0xED, 0xF3, 0xDF, 0xEF, 0xB0,
  0xC3, 0x00, 0x35, 0xF6, 0xFB, 0xED, 0xF7, 0xC3, 0x0C, 0x30, 0x9F, 0xEC,
  0xCC, 0xC0, 0x33, 0xF8, 0xF3, 0xFF, 0xE0, 0x23, 0xFE, 0xC6, 0x31, 0xEF,
  0xCF, 0x3C, 0xF3, 0xDF, 0xFE, 0xC0, 0xC7, 0xD9, 0xB3, 0x67, 0x87, 0x0E,
  0x00, 0xCC, 0xF3, 0xB7, 0xFD, 0xFE, 0x7F, 0x9C, 0xE3, 0x38, 0xEE, 0xD9,
  0xF1, 0xC7, 0x8D, 0xBB, 0x80, 0xC7, 0xD9, 0xB3, 0x63, 0x87, 0x0E, 0x18,
  0x70, 0xC0, 0xFF, 0xCE, 0x66, 0x7F, 0xE0, 0x19, 0xCC, 0x66, 0x73, 0x86,
  0x31, 0xCE, 0xFF, 0xFF, 0xFF, 0xC7, 0x18, 0xC7, 0x1D, 0xEC, 0x67, 0x38,
  0xFE, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_Black12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 5, 4, 6, 1, -9 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 6, 10, 7, 0, -9 },
  { 24, 11, 9, 11, 0, -9 },
  { 37, 9, 9, 9, 0, -9 },
  { 48, 2, 4, 3, 1, -9 },
  { 49, 4, 11, 4, 0, -9 },
  { 55, 4, 11, 4, 0, -9 },
  { 61, 6, 6, 6, 0, -9 },
  { 66, 6, 6, 7, 0, -7 },
  { 71, 3, 4, 4, 0, -2 },
  { 73, 4, 2, 4, 0, -4 },
  { 74, 2, 2, 3, 1, -2 },
  { 75, 5, 9, 5, 0, -9 },
  { 81, 6, 9, 7, 0, -9 },
  { 88, 5, 9, 7, 0, -9 },
  { 94, 6, 9, 7, 0, -9 },
  { 101, 6, 9, 7, 0, -9 },
  { 108, 6, 9, 7, 0, -9 },
  { 115, 5, 9, 7, 1, -9 },
  { 121, 6, 9, 7, 0, -9 },
  { 128, 6, 9, 7, 0, -9 },
  { 135, 6, 9, 7, 0, -9 },
  { 142, 6, 9, 7, 0, -9 },
  { 149, 2, 7, 3, 1, -7 },
  { 151, 3, 9, 3, 0, -7 },
  { 155, 6, 7, 7, 0, -8 },
  { 161, 6, 4, 7, 0, -6 },
  { 164, 6, 7, 7, 0, -8 },
  { 170, 5, 9, 6, 0, -9 },
  { 176, 10, 10, 10, 0, -9 },
  { 189, 8, 9, 8, 0, -9 },
  { 198, 6, 9, 8, 1, -9 },
  { 205, 6, 9, 7, 1, -9 },
  { 212, 7, 9, 8, 1, -9 },
  { 220, 5, 9, 6, 1, -9 },
  { 226, 5, 9, 6, 1, -9 },
  { 232, 7, 9, 8, 1, -9 },
  { 240, 7, 9, 9, 1, -9 },
  { 248, 5, 9, 5, 0, -9 },
  { 254, 4, 12, 4, -1, -9 },
  { 260, 7, 9, 8, 1, -9 },
  { 268, 5, 9, 6, 1, -9 },
  { 274, 9, 9, 11, 1, -9 },
  { 285, 7, 9, 9, 1, -9 },
  { 293, 7, 9, 9, 1, -9 },
  { 301, 6, 9, 7, 1, -9 },
  { 308, 7, 11, 9, 1, -9 },
  { 318, 7, 9, 8, 1, -9 },
  { 326, 6, 9, 6, 0, -9 },
  { 333, 6, 9, 7, 0, -9 },
  { 340, 7, 9, 8, 1, -9 },
  { 348, 8, 9, 8, 0, -9 },
  { 357, 11, 9, 11, 0, -9 },
  { 370, 8, 9, 8, 0, -9 },
  { 379, 7, 9, 7, 0, -9 },
  { 387, 6, 9, 7, 0, -9 },
  { 394, 3, 11, 4, 1, -9 },
  { 399, 5, 9, 5, 0, -9 },
  { 405, 3, 11, 4, 0, -9 },
  { 410, 6, 6, 6, 0, -9 },
  { 415, 6, 1, 6, 0, 1 },
  { 416, 4, 2, 5, 0, -9 },
  { 417, 6, 7, 7, 0, -7 },
  { 423, 6, 9, 7, 1, -9 },
  { 430, 6, 7, 6, 0, -7 },
  { 436, 6, 9, 7, 0, -9 },
  { 443, 6, 7, 7, 0, -7 },
  { 449, 5, 9, 5, 0, -9 },
  { 455, 6, 10, 7, 0, -7 },
  { 463, 6, 9, 7, 1, -9 },
  { 470, 2, 9, 4, 1, -9 },
  { 473, 4, 12, 4, -1, -9 },
  { 479, 6, 9, 7, 1, -9 },
  { 486, 2, 9, 4, 1, -9 },
  { 489, 9, 7, 11, 1, -7 },
  { 497, 6, 7, 7, 1, -7 },
  { 503, 7, 7, 7, 0, -7 },
  { 510, 6, 10, 7, 1, -7 },
  { 518, 6, 10, 7, 0, -7 },
  { 526, 4, 7, 5, 1, -7 },
  { 530, 5, 7, 6, 0, -7 },
  { 535, 5, 8, 5, 0, -8 },
  { 540, 6, 7, 7, 1, -7 },
  { 546, 7, 7, 7, 0, -7 },
  { 553, 10, 7, 10, 0, -7 },
  { 562, 7, 7, 7, 0, -7 },
  { 569, 7, 10, 7, 0, -7 },
  { 578, 5, 7, 6, 0, -7 },
  { 583, 5, 11, 5, 0, -9 },
  { 590, 2, 12, 6, 2, -9 },
  { 593, 5, 11, 5, 0, -9 },
  { 600, 6, 2, 7, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_Black12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK12PT7B_H_
