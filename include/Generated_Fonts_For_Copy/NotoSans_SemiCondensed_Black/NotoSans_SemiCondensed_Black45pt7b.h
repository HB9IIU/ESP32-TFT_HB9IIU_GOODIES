#ifndef _NOTOSANS_SEMICONDENSED_BLACK45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xDF, 0xEF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFE, 0x18, 0x00, 0xFF, 0x1F, 0xFF, 0xE3, 0xFD, 0xFC, 0x7F, 0x3F, 0x8F,
  0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x01, 0xF8, 0xFC, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF1, 0xFD, 0xE3, 0xCF, 0xE7, 0x81, 0x3F, 0x9E, 0x00, 0x7F,
  0x78, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0x9F, 0xC0, 0x1E, 0x7F, 0x40, 0x79, 0xFD, 0xC1,
  0xE7, 0xF7, 0xF7, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xFF,
  0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x7E,
  0x00, 0x3F, 0x9F, 0x81, 0xFC, 0x00, 0x7E, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0xFE, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x7F,
  0x00, 0x07, 0xE3, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xF3, 0xF8, 0x00, 0x1F,
  0x8F, 0xC7, 0xE0, 0xF0, 0x3F, 0x9F, 0x9F, 0xC7, 0xF8, 0x3F, 0xFF, 0x3F,
  0x3F, 0xF8, 0x7F, 0xFC, 0xFE, 0x7F, 0xF8, 0x7F, 0xF9, 0xF9, 0xFF, 0xF8,
  0x7F, 0xE7, 0xF3, 0xFF, 0xF0, 0x7F, 0x8F, 0xC7, 0xE7, 0xE0, 0x18, 0x3F,
  0x9F, 0xCF, 0xE0, 0x00, 0x7E, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x7E, 0x00, 0x1F,
  0x83, 0xF8, 0xFC, 0x00, 0x7F, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0x07, 0xE7,
  0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0x83, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0xFE, 0xFF, 0x87,
  0xFD, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0xFF, 0xC3, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xF0,
  0x1F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xCF,
  0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x30, 0x7C, 0x19, 0xF3, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x3F,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC1,
  0xFC, 0x7F, 0x03, 0xE3, 0xF0, 0x0E, 0x0E, 0x00, 0x10, 0x40, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFE, 0x3F, 0x8F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C,
  0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x08, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xF3, 0xFE, 0xFF, 0x8F, 0xF7, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFB, 0xFC, 0x7F, 0x9F, 0xF7, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFC, 0xFD, 0xFF, 0x1C, 0x7F, 0xC6, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x30, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xF7, 0xFE, 0x3E, 0x07,
  0xF8, 0x70, 0x1F, 0xE0, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x87, 0xC7, 0xFE, 0x18, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0x7F,
  0x80, 0xFE, 0xFF, 0x01, 0xF9, 0xFE, 0x07, 0xF3, 0xFC, 0x1F, 0xC7, 0xF8,
  0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE3, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC1, 0xFD, 0xFF,
  0xC7, 0xF7, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8,
  0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFD, 0xFF, 0x0F, 0xF3, 0xFE, 0xFF,
  0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x9F, 0xF1, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF3, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFE, 0x1F, 0xF7, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xF7, 0xF8, 0x3F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0x87,
  0xFD, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xDF, 0xF3, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0x7F, 0x1F, 0xF9, 0xFC, 0x1F, 0xCF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC2,
  0x07, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x04,
  0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF3, 0xF8, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC,
  0x7E, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xE0, 0xFF,
  0x38, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x7F, 0xF3,
  0xF0, 0xFC, 0x3F, 0xFF, 0x3F, 0x3F, 0x0F, 0xFF, 0xE7, 0xE7, 0xE3, 0xFF,
  0xFC, 0xFD, 0xF8, 0xFF, 0x1F, 0x8F, 0xBF, 0x1F, 0x83, 0xF1, 0xF7, 0xE3,
  0xF0, 0x7E, 0x3F, 0xFC, 0xFC, 0x0F, 0xC7, 0xFF, 0x1F, 0x81, 0xF0, 0xFF,
  0xE3, 0xF0, 0x3E, 0x1F, 0x7C, 0x7E, 0x0F, 0xC3, 0xEF, 0x8F, 0xC1, 0xF8,
  0x7D, 0xF1, 0xF8, 0x3F, 0x1F, 0xBF, 0x1F, 0x8F, 0xE3, 0xE7, 0xE3, 0xFF,
  0xFF, 0xFC, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0x87, 0xFF, 0x7F, 0xE1, 0xF8,
  0x7F, 0xC7, 0xF8, 0x3F, 0x83, 0xE0, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x20, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xBF,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xF8, 0xFC, 0x3F, 0xE0, 0x18, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x02, 0x7F, 0xF0, 0x0C, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0xFC, 0xFF, 0x01, 0xFF, 0x3F,
  0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F,
  0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF,
  0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xFC,
  0xFF, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF9, 0xFC, 0x3F, 0xF0, 0x02, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0xE0, 0x3F, 0xCF,
  0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F,
  0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x83,
  0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xE0, 0xFF,
  0x8F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x83,
  0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xF8, 0x3F,
  0xE3, 0xFE, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xEF, 0xF8,
  0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xFF, 0x7F, 0x07,
  0xFF, 0xFF, 0xEF, 0xE0, 0xFD, 0xFF, 0xFE, 0xFC, 0x1F, 0xBF, 0xFF, 0xDF,
  0x87, 0xF7, 0xFF, 0xFB, 0xF8, 0xFC, 0xFF, 0xFF, 0x7F, 0x1F, 0x9F, 0xFF,
  0xE7, 0xE3, 0xF3, 0xFF, 0xFC, 0xFE, 0xFE, 0x7F, 0xFF, 0x9F, 0xDF, 0x8F,
  0xFF, 0xF3, 0xFB, 0xF1, 0xFF, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0x87, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xF0, 0x7F, 0xFE,
  0xFF, 0x87, 0xFF, 0xE7, 0xF8, 0x7F, 0xFF, 0x7F, 0xC7, 0xFF, 0xF3, 0xFC,
  0x7F, 0xFF, 0x3F, 0xE7, 0xFF, 0xF1, 0xFE, 0x7F, 0xFF, 0x1F, 0xF7, 0xFF,
  0xF0, 0xFF, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE,
  0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x00,
  0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF,
  0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x7F,
  0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x0F, 0xF1, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xFC,
  0x3F, 0xC3, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF8, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x0F, 0xFB, 0xFC,
  0x03, 0xFF, 0x00, 0x70, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xF8, 0xFC, 0xFF,
  0x00, 0xE7, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0x7F, 0xC0, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFC,
  0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07,
  0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x3F, 0xEF, 0xF0, 0x0F, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xFC, 0x07, 0xFC,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0x1F, 0xE1, 0xFE,
  0x07, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0x1F,
  0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0xFD, 0xF8,
  0x7F, 0x81, 0xFE, 0x1F, 0xBF, 0x0F, 0xF0, 0x1F, 0xC3, 0xF7, 0xE1, 0xFE,
  0x03, 0xF8, 0x7E, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xDF, 0x8F, 0xF0, 0x0F,
  0xF3, 0xFB, 0xF9, 0xFE, 0x01, 0xFE, 0x7E, 0x3F, 0x3F, 0xC0, 0x1F, 0xCF,
  0xC7, 0xE7, 0xF0, 0x03, 0xF9, 0xF8, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x1F,
  0xBF, 0xC0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF9, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFB, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xC7,
  0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x01,
  0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x60, 0x3F,
  0xC1, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFC, 0x3F, 0xDF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF, 0xCF, 0xFE, 0x3F, 0x0F,
  0xF0, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x7E, 0x0F, 0xF7, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xF3, 0xFE, 0xFF, 0x87,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFE, 0x7F, 0xE3, 0xF0, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xF8, 0xF7, 0xFC, 0x04, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFF, 0x8F, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xCF, 0xF1, 0xFF, 0xBF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0x7F, 0x1F, 0xF9, 0xFC, 0x3F, 0xC3, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xBF, 0xE7, 0xF8, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x03, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x7F,
  0xE7, 0xF3, 0xFF, 0xDF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFE, 0xFF, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x70, 0x07, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x0F, 0xF7, 0xFE, 0x3F, 0xBF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF0, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3F, 0x81,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0xCF, 0xF8, 0x3F, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFC, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF,
  0x3F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xDF, 0xE0, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF,
  0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0xFF,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xC7, 0xFF, 0x1F, 0xF8,
  0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF8,
  0x7F, 0xE1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0xFC, 0x3F, 0xC3, 0xF1,
  0xFF, 0xCF, 0xEF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xF1,
  0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFD, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xF3,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFC, 0x3F, 0x83, 0xF9, 0xFF, 0x8F, 0xEF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xDF, 0xF8, 0xFF,
  0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x7F,
  0xE7, 0xF3, 0xFF, 0xDF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFE, 0xFF, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC,
  0x1F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xEF, 0xCF, 0xE0, 0x33, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE3, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0xCF, 0xFE, 0x7F, 0x0F, 0xF0, 0xFC, 0xFF,
  0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0, 0x1F, 0xE3,
  0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F,
  0x80, 0xFF, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFF, 0x03, 0xFD, 0xFE,
  0x0F, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0xC1,
  0xFE, 0x7F, 0x83, 0xFF, 0x07, 0xF8, 0xFF, 0x1F, 0xFE, 0x1F, 0xC3, 0xFC,
  0x7F, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0xE3, 0xFC, 0x3F, 0xC7, 0xFF, 0x8F,
  0xF0, 0x7F, 0x1F, 0xFE, 0x3F, 0x81, 0xFC, 0xFC, 0xFC, 0xFE, 0x07, 0xFB,
  0xF3, 0xF7, 0xF8, 0x1F, 0xEF, 0xCF, 0xDF, 0xE0, 0x3F, 0xBF, 0x3F, 0x7F,
  0x00, 0xFE, 0xFC, 0xFD, 0xFC, 0x03, 0xFB, 0xE1, 0xF7, 0xF0, 0x0F, 0xFF,
  0x87, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xE3,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F,
  0xEF, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x03, 0xF8,
  0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F,
  0xDF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x00, 0x80,
  0x00, 0x3F, 0x80, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Black45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 33, 13, 2, -32 },
  { 39, 19, 11, 23, 2, -32 },
  { 66, 26, 32, 28, 1, -32 },
  { 170, 22, 37, 25, 1, -34 },
  { 272, 39, 33, 41, 1, -33 },
  { 433, 33, 33, 33, 1, -33 },
  { 570, 8, 11, 12, 2, -32 },
  { 581, 13, 40, 16, 2, -33 },
  { 646, 13, 40, 16, 1, -33 },
  { 711, 21, 21, 23, 1, -34 },
  { 767, 21, 22, 25, 2, -27 },
  { 825, 10, 13, 13, 1, -7 },
  { 842, 12, 6, 14, 1, -15 },
  { 851, 9, 9, 13, 2, -8 },
  { 862, 20, 33, 20, 0, -33 },
  { 945, 21, 33, 25, 2, -33 },
  { 1032, 18, 32, 25, 2, -32 },
  { 1104, 22, 33, 25, 1, -33 },
  { 1195, 22, 33, 25, 1, -33 },
  { 1286, 23, 32, 25, 1, -32 },
  { 1378, 21, 32, 25, 2, -32 },
  { 1462, 22, 33, 25, 1, -33 },
  { 1553, 21, 32, 25, 2, -32 },
  { 1637, 22, 33, 25, 1, -33 },
  { 1728, 22, 33, 25, 1, -33 },
  { 1819, 9, 26, 13, 2, -25 },
  { 1849, 10, 31, 13, 1, -25 },
  { 1888, 21, 24, 25, 2, -28 },
  { 1951, 21, 16, 25, 2, -24 },
  { 1993, 21, 24, 25, 2, -28 },
  { 2056, 20, 34, 21, 0, -33 },
  { 2141, 35, 36, 38, 2, -33 },
  { 2299, 30, 32, 30, 0, -32 },
  { 2419, 23, 32, 28, 3, -32 },
  { 2511, 24, 33, 27, 2, -33 },
  { 2610, 26, 32, 31, 3, -32 },
  { 2714, 18, 32, 23, 3, -32 },
  { 2786, 18, 32, 23, 3, -32 },
  { 2858, 26, 33, 31, 2, -33 },
  { 2966, 26, 32, 32, 3, -32 },
  { 3070, 16, 32, 18, 1, -32 },
  { 3134, 15, 42, 15, -3, -32 },
  { 3213, 26, 32, 29, 3, -32 },
  { 3317, 19, 32, 24, 3, -32 },
  { 3393, 35, 32, 41, 3, -32 },
  { 3533, 28, 32, 35, 3, -32 },
  { 3645, 29, 33, 33, 2, -33 },
  { 3765, 22, 32, 27, 3, -32 },
  { 3853, 29, 41, 33, 2, -33 },
  { 4002, 26, 32, 28, 3, -32 },
  { 4106, 21, 33, 24, 2, -33 },
  { 4193, 22, 32, 24, 1, -32 },
  { 4281, 25, 32, 31, 3, -32 },
  { 4381, 29, 32, 29, 0, -32 },
  { 4497, 43, 32, 43, 0, -32 },
  { 4669, 29, 32, 29, 0, -32 },
  { 4785, 28, 32, 28, 0, -32 },
  { 4897, 23, 32, 25, 1, -32 },
  { 4989, 11, 41, 14, 2, -33 },
  { 5046, 19, 33, 20, 0, -33 },
  { 5125, 11, 41, 14, 1, -33 },
  { 5182, 24, 21, 24, 0, -32 },
  { 5245, 23, 5, 23, 0, 3 },
  { 5260, 14, 7, 18, 2, -34 },
  { 5273, 22, 25, 26, 1, -25 },
  { 5342, 22, 34, 27, 3, -34 },
  { 5436, 19, 25, 23, 2, -25 },
  { 5496, 22, 34, 27, 2, -34 },
  { 5590, 22, 25, 26, 2, -25 },
  { 5659, 17, 34, 17, 1, -34 },
  { 5732, 22, 36, 27, 2, -25 },
  { 5831, 22, 34, 28, 3, -34 },
  { 5925, 8, 35, 14, 3, -35 },
  { 5960, 13, 46, 14, -2, -35 },
  { 6035, 24, 34, 27, 3, -34 },
  { 6137, 8, 34, 14, 3, -34 },
  { 6171, 36, 25, 42, 3, -25 },
  { 6284, 22, 25, 28, 3, -25 },
  { 6353, 23, 25, 27, 2, -25 },
  { 6425, 22, 36, 27, 3, -25 },
  { 6524, 22, 36, 27, 2, -25 },
  { 6623, 16, 25, 20, 3, -25 },
  { 6673, 18, 25, 21, 2, -25 },
  { 6730, 17, 30, 19, 1, -30 },
  { 6794, 22, 25, 28, 3, -25 },
  { 6863, 25, 25, 26, 0, -25 },
  { 6942, 38, 25, 38, 0, -25 },
  { 7061, 26, 25, 26, 0, -25 },
  { 7143, 25, 36, 25, 0, -25 },
  { 7256, 19, 25, 21, 1, -25 },
  { 7316, 16, 41, 18, 1, -33 },
  { 7398, 6, 44, 21, 8, -34 },
  { 7431, 16, 41, 18, 1, -33 },
  { 7513, 21, 8, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Black45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK45PT7B_H_
