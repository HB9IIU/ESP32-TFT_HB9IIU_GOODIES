#ifndef _NOTOSANS_SEMICONDENSED_BLACK29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE0,
  0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xFB, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0x07, 0x9C, 0x07, 0x9C, 0x07, 0x3C, 0x07, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0, 0x38, 0xE0, 0x39, 0xE0, 0x03, 0x00,
  0x0C, 0x01, 0xFE, 0x0F, 0xFE, 0x7F, 0xFB, 0xFF, 0xEF, 0xB1, 0xBC, 0xC0,
  0xFB, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x37,
  0xC0, 0xCF, 0xC3, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x3E, 0x01, 0xE0, 0x3F, 0x80, 0xF0, 0x3F, 0xE0,
  0xF0, 0x1E, 0xF0, 0x78, 0x0F, 0x7C, 0x78, 0x07, 0x9E, 0x3C, 0x03, 0xCF,
  0x3C, 0x01, 0xE7, 0x9E, 0x00, 0xF3, 0xDE, 0x38, 0x7B, 0xCF, 0x7F, 0x3F,
  0xEF, 0x3F, 0xCF, 0xE7, 0xBF, 0xE3, 0xE7, 0x9E, 0xF0, 0x03, 0xCF, 0x3C,
  0x03, 0xC7, 0x9E, 0x01, 0xE3, 0xCF, 0x01, 0xE1, 0xE7, 0x80, 0xF0, 0xF7,
  0x80, 0xF0, 0x7F, 0xC0, 0x78, 0x1F, 0xC0, 0x78, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x1F,
  0x8F, 0xF8, 0xF8, 0xFF, 0xE7, 0xC7, 0xFF, 0xFE, 0x7E, 0xFF, 0xE3, 0xE3,
  0xFF, 0x1F, 0x0F, 0xF0, 0xFC, 0x7F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFE, 0x7F, 0x80, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0x1F,
  0x8F, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0xC0, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x3E, 0x3E,
  0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0xF0, 0x0F, 0x80, 0x38, 0x01, 0xC1,
  0x0E, 0x1F, 0x77, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xC1, 0xFF, 0x0F,
  0x78, 0xFB, 0xE1, 0x8C, 0x04, 0x40, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7D, 0xF7, 0x9E, 0xFB, 0xEF,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0x7F, 0xF9, 0xF3, 0xEF, 0xCF, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x3F,
  0x7C, 0xF9, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x3F,
  0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xF7, 0xBF, 0x33, 0xF1, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE,
  0x7F, 0xF9, 0xC3, 0xE2, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFE, 0x7B, 0xF8, 0x83, 0xE0, 0x0F, 0x80, 0x7E, 0x1F, 0xF0, 0x7F, 0x01,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xC1, 0xFF,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xF0, 0x07,
  0xC0, 0x1F, 0x60, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xE1, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC,
  0x7F, 0xC0, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x7F, 0x09, 0xF0,
  0x07, 0xC0, 0x3E, 0x78, 0xFB, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0x7C, 0xFD, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x7C,
  0xFD, 0xF1, 0xF7, 0xCF, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xFC, 0x7F, 0xFB, 0xF3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xF7,
  0xFF, 0x9F, 0xFE, 0x1F, 0xE0, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x1F, 0xFE,
  0xFD, 0xFB, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF,
  0xDF, 0xFF, 0x7F, 0xFC, 0x7D, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF9, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xDE, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7D, 0xF7, 0x9E, 0xFB, 0xEF, 0x3C, 0x00, 0x0C, 0x00,
  0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF0, 0x3F, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xE7,
  0xFE, 0x3F, 0xC0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x1F, 0xC3, 0xFF,
  0xBF, 0xFC, 0xFF, 0xF7, 0x9F, 0xA0, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFC, 0x0F, 0x83, 0xE0, 0x07, 0x87, 0x87,
  0xC7, 0x9E, 0x3F, 0xEF, 0x3C, 0xFF, 0xCE, 0x73, 0xE7, 0x9D, 0xE7, 0x8F,
  0x3F, 0xCF, 0x1E, 0x7F, 0x9C, 0x3C, 0xEF, 0x38, 0x79, 0xDE, 0x78, 0xF7,
  0xBC, 0xF3, 0xEF, 0x79, 0xFF, 0xFC, 0x79, 0xF9, 0xF0, 0xF0, 0xC0, 0xC0,
  0xF0, 0x00, 0x01, 0xF8, 0x06, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x03, 0xEF, 0x80, 0x7C, 0xF0, 0x0F, 0x9F,
  0x03, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3E, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF,
  0xEF, 0x9F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3E, 0xFF, 0xFD, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0xEF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xF8, 0x0F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x7E, 0x04, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x0E, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7E, 0xFB,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0xC7,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFD, 0xF3, 0xF8, 0x09, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFB, 0xE0,
  0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x7F, 0x0F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1,
  0xFF, 0xF0, 0x7F, 0xF0, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xFB, 0xFE, 0xFF, 0x3F,
  0xCF, 0xE0, 0x80, 0xF8, 0x1F, 0xFC, 0x1F, 0xBE, 0x1F, 0x9F, 0x0F, 0xCF,
  0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xE1, 0xF7, 0xE0, 0xFB, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF8, 0xF8, 0xFC, 0x7C, 0x3F, 0x3E, 0x1F, 0x9F, 0x07, 0xEF, 0x83, 0xF8,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0x1F, 0xFF,
  0xBC, 0xF7, 0xFE, 0xF3, 0xDF, 0xFB, 0xEF, 0x7F, 0xE7, 0xF9, 0xFF, 0x9F,
  0xE7, 0xFE, 0x7F, 0x9F, 0xF9, 0xFE, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7,
  0xFE, 0x3F, 0x1F, 0xF8, 0x7C, 0x7C, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xFF, 0xE7, 0xFE, 0xF9, 0xFF, 0xBF, 0x7F, 0xE7, 0xDF, 0xF9, 0xFB, 0xFE,
  0x3E, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFB, 0xFC, 0xFC, 0x1F, 0x9F, 0x81, 0xF3, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7E, 0xF8, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x7E, 0x7F, 0x1F, 0xC7, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0xCF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF,
  0xE7, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFB, 0xFC, 0xFC, 0x1F, 0x9F,
  0x81, 0xF3, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0x7E, 0x7F,
  0x1F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0xFF,
  0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC3, 0xE3,
  0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xFE, 0x07, 0xCF, 0x83, 0xE7, 0xE1, 0xF1, 0xF0, 0xF8, 0xFC, 0x7C,
  0x3E, 0x3E, 0x1F, 0x9F, 0x07, 0xEF, 0x83, 0xF8, 0x0F, 0xE0, 0xFF, 0xF7,
  0xFF, 0x9F, 0xFE, 0xFE, 0xF3, 0xF0, 0x4F, 0xC0, 0x3F, 0x80, 0x7F, 0x81,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0xF1, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0xFE, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xFF, 0x80, 0xF9, 0xF0, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0x7C, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x1F, 0x03, 0xEF, 0x83, 0xE0,
  0x7D, 0xF0, 0x7E, 0x0F, 0xBE, 0x0F, 0xC1, 0xF7, 0xC1, 0xF8, 0x7E, 0xF8,
  0x7F, 0x0F, 0x8F, 0x8F, 0xF1, 0xF1, 0xF1, 0xFE, 0x3E, 0x3E, 0x3F, 0xC7,
  0xC7, 0xCF, 0xF9, 0xF0, 0x79, 0xEF, 0x3E, 0x0F, 0xBC, 0xF7, 0xC1, 0xF7,
  0x9E, 0xF8, 0x3E, 0xF3, 0xDE, 0x03, 0xDE, 0x7F, 0xC0, 0x7F, 0x8F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xF8, 0x7E,
  0x1F, 0x8F, 0x81, 0xF3, 0xF0, 0x3F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0x3F, 0x07, 0xE3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xDF, 0x03, 0xE7,
  0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0xFF, 0xFF, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x80, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x3C, 0x78, 0x3C, 0x78,
  0x1E, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x1F, 0x07,
  0xC1, 0xF0, 0x1F, 0xF1, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x10, 0x7C, 0x01,
  0xF1, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFB, 0xCF, 0xCF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xBF, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xCF, 0x80, 0x0F, 0xF0, 0xFF,
  0xCF, 0xFC, 0xFF, 0xE7, 0xC2, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x27, 0xFF, 0x3F, 0xF8, 0xFF, 0xC1, 0xFC, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC7, 0xDF,
  0x9F, 0xDF, 0x7F, 0xFE, 0xFF, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF3, 0xFB, 0xE3, 0xE7, 0xC0, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0x9F, 0xBF,
  0x7C, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x1F, 0x01, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x07, 0xF1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0x01, 0xF0, 0x3F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x3E, 0x7F, 0x7D, 0xFF, 0xFB,
  0xFF, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xE3, 0xF7, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0xBF,
  0x00, 0x7E, 0x00, 0xF9, 0xC3, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x07,
  0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xBF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xF0, 0x27, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x1F, 0x1F, 0x1F,
  0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xBF, 0xFF, 0xFE,
  0xFE, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF9, 0xF8, 0xFB, 0xF0,
  0xFB, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFD, 0xF0,
  0xF9, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8, 0x7E, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF3, 0xF1, 0xF9, 0xEF, 0xF7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xE7, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8,
  0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87,
  0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF3, 0xF3,
  0xDF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF1, 0xFB, 0xE3,
  0xF7, 0xFF, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF0, 0xF3, 0xF3, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x3E, 0xF8,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x1F, 0x3E, 0x7F, 0x7D, 0xFF, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xF7,
  0xFF, 0xEF, 0xFF, 0xCF, 0xEF, 0x8F, 0xBF, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0xF3, 0xFD, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x3F, 0xC7, 0xFF, 0xFF, 0xEF, 0xDE, 0xF8,
  0x2F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0x1E, 0x0F, 0x83, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE4,
  0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB, 0xCF, 0xCF, 0xFC, 0x1F, 0x7C,
  0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x1E,
  0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x7E, 0x1F, 0x7C, 0x7F, 0x1F, 0x7C,
  0x7F, 0x1F, 0x7C, 0x7F, 0x3E, 0x7C, 0xFF, 0x3E, 0x3E, 0xFF, 0x3E, 0x3E,
  0xF7, 0x3E, 0x3E, 0xF7, 0xBC, 0x3E, 0xF7, 0xBC, 0x1F, 0xE7, 0xFC, 0x1F,
  0xE7, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x7E, 0x3E, 0x3E, 0x7E, 0x3F,
  0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F, 0xFC,
  0x3F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x7E, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x4F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3,
  0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xFC, 0x7F, 0x0F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x0F, 0xE3, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0,
  0x7F, 0x0F, 0xC3, 0xF1, 0xFC, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x8F, 0xE3, 0xF0, 0xFC, 0x38, 0x00, 0x3C, 0x07, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFA, 0x00, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Black29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 21, 8, 1, -21 },
  { 17, 11, 8, 15, 2, -21 },
  { 28, 16, 21, 18, 1, -21 },
  { 70, 14, 24, 16, 1, -22 },
  { 112, 25, 21, 26, 1, -21 },
  { 178, 21, 21, 22, 1, -21 },
  { 234, 5, 8, 8, 2, -21 },
  { 239, 9, 26, 10, 1, -21 },
  { 269, 8, 26, 10, 1, -21 },
  { 295, 13, 14, 15, 1, -22 },
  { 318, 14, 14, 16, 1, -17 },
  { 343, 6, 8, 9, 1, -4 },
  { 349, 8, 4, 9, 1, -10 },
  { 353, 6, 5, 8, 1, -5 },
  { 357, 13, 21, 13, 0, -21 },
  { 392, 14, 21, 16, 1, -21 },
  { 429, 12, 21, 16, 1, -21 },
  { 461, 14, 21, 16, 1, -21 },
  { 498, 14, 21, 16, 1, -21 },
  { 535, 16, 21, 16, 0, -21 },
  { 577, 14, 21, 16, 1, -21 },
  { 614, 14, 21, 16, 1, -21 },
  { 651, 14, 21, 16, 1, -21 },
  { 688, 14, 21, 16, 1, -21 },
  { 725, 14, 21, 16, 1, -21 },
  { 762, 6, 16, 8, 1, -16 },
  { 774, 6, 20, 8, 1, -16 },
  { 789, 14, 15, 16, 1, -18 },
  { 816, 14, 10, 16, 1, -15 },
  { 834, 14, 15, 16, 1, -18 },
  { 861, 13, 21, 14, 0, -21 },
  { 896, 23, 23, 25, 1, -21 },
  { 963, 19, 21, 19, 0, -21 },
  { 1013, 15, 21, 18, 2, -21 },
  { 1053, 16, 21, 17, 1, -21 },
  { 1095, 16, 21, 20, 2, -21 },
  { 1137, 11, 21, 15, 2, -21 },
  { 1166, 11, 21, 15, 2, -21 },
  { 1195, 17, 21, 20, 1, -21 },
  { 1240, 17, 21, 21, 2, -21 },
  { 1285, 10, 21, 12, 1, -21 },
  { 1312, 10, 28, 10, -2, -21 },
  { 1347, 17, 21, 19, 2, -21 },
  { 1392, 12, 21, 15, 2, -21 },
  { 1424, 22, 21, 26, 2, -21 },
  { 1482, 18, 21, 22, 2, -21 },
  { 1530, 19, 21, 21, 1, -21 },
  { 1580, 14, 21, 17, 2, -21 },
  { 1617, 19, 26, 21, 1, -21 },
  { 1679, 17, 21, 18, 2, -21 },
  { 1724, 14, 21, 15, 1, -21 },
  { 1761, 14, 21, 16, 1, -21 },
  { 1798, 16, 21, 20, 2, -21 },
  { 1840, 19, 21, 19, 0, -21 },
  { 1890, 27, 21, 28, 0, -21 },
  { 1961, 19, 21, 19, 0, -21 },
  { 2011, 18, 21, 18, 0, -21 },
  { 2059, 15, 21, 16, 1, -21 },
  { 2099, 8, 26, 9, 1, -21 },
  { 2125, 13, 21, 13, 0, -21 },
  { 2160, 7, 26, 9, 1, -21 },
  { 2183, 16, 14, 15, 0, -21 },
  { 2211, 15, 3, 15, 0, 2 },
  { 2217, 9, 4, 11, 1, -22 },
  { 2222, 14, 16, 17, 1, -16 },
  { 2250, 14, 22, 17, 2, -22 },
  { 2289, 13, 16, 15, 1, -16 },
  { 2315, 15, 22, 17, 1, -22 },
  { 2357, 14, 16, 16, 1, -16 },
  { 2385, 12, 22, 11, 0, -22 },
  { 2418, 15, 23, 17, 1, -16 },
  { 2462, 14, 22, 18, 2, -22 },
  { 2501, 5, 23, 9, 2, -23 },
  { 2516, 8, 30, 9, -1, -23 },
  { 2546, 16, 22, 18, 2, -22 },
  { 2590, 5, 22, 9, 2, -22 },
  { 2604, 23, 16, 27, 2, -16 },
  { 2650, 14, 16, 18, 2, -16 },
  { 2678, 15, 16, 17, 1, -16 },
  { 2708, 14, 23, 17, 2, -16 },
  { 2749, 15, 23, 17, 1, -16 },
  { 2793, 10, 16, 13, 2, -16 },
  { 2813, 12, 16, 14, 1, -16 },
  { 2837, 10, 19, 12, 1, -19 },
  { 2861, 14, 16, 18, 2, -16 },
  { 2889, 16, 16, 16, 0, -16 },
  { 2921, 24, 16, 25, 0, -16 },
  { 2969, 16, 16, 17, 0, -16 },
  { 3001, 16, 23, 16, 0, -16 },
  { 3047, 12, 16, 14, 1, -16 },
  { 3071, 10, 26, 12, 1, -21 },
  { 3104, 4, 28, 14, 5, -22 },
  { 3118, 10, 26, 12, 1, -21 },
  { 3151, 14, 6, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Black29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK29PT7B_H_
