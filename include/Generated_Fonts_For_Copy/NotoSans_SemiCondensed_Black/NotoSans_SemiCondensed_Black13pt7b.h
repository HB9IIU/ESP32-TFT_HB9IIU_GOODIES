#ifndef _NOTOSANS_SEMICONDENSED_BLACK13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xDE, 0xF6, 0x16, 0x36, 0x7F, 0x7F, 0x3C, 0xFE,
  0xFE, 0x6C, 0x68, 0x10, 0xF9, 0xF6, 0x87, 0x07, 0x87, 0xCB, 0x7C, 0x70,
  0x40, 0x71, 0x8D, 0xB0, 0xDB, 0x0D, 0xEC, 0x77, 0xE0, 0xDA, 0x0D, 0xB1,
  0x9A, 0x18, 0xE0, 0x3C, 0x19, 0x87, 0xE0, 0xF0, 0x79, 0x9B, 0xEE, 0xF1,
  0xFC, 0x7F, 0xC0, 0xFC, 0x33, 0x66, 0x66, 0xE6, 0x66, 0x63, 0xC6, 0x63,
  0x33, 0x33, 0x37, 0x6E, 0x30, 0x4F, 0xDF, 0x79, 0xB0, 0x20, 0x82, 0x3F,
  0x20, 0x82, 0x00, 0x6D, 0xE0, 0xFF, 0xF0, 0x1C, 0x61, 0x8C, 0x31, 0x86,
  0x18, 0xC0, 0x7C, 0xF9, 0xBF, 0x7E, 0xED, 0xDB, 0xBE, 0x38, 0x3B, 0xFF,
  0x73, 0x9C, 0xE7, 0x38, 0x7D, 0xF9, 0x30, 0x61, 0xC7, 0x1C, 0x7F, 0xFE,
  0xFC, 0xF8, 0x31, 0xE3, 0xC1, 0xC3, 0xFE, 0xFC, 0x1C, 0x38, 0xF3, 0x66,
  0xDF, 0xFF, 0x86, 0x0C, 0xFB, 0xEC, 0x3E, 0xF8, 0x71, 0xFE, 0xF0, 0x3C,
  0xF9, 0x83, 0xEF, 0xFD, 0xDB, 0xBE, 0x3C, 0xFF, 0xFC, 0x30, 0x61, 0x83,
  0x0E, 0x18, 0x70, 0x7C, 0xDD, 0xB3, 0xE7, 0xCD, 0xF9, 0xBF, 0x7C, 0x7C,
  0xFB, 0xBF, 0x77, 0xEE, 0xC3, 0x3E, 0x78, 0xF0, 0x3C, 0x6C, 0x00, 0xDB,
  0xC0, 0x06, 0x3D, 0xE7, 0x03, 0xC1, 0xC0, 0x80, 0xFF, 0xF0, 0x3F, 0xFC,
  0x83, 0x87, 0x87, 0xF3, 0x08, 0x00, 0xFB, 0xF0, 0xCE, 0x30, 0xC0, 0x1C,
  0x30, 0x1F, 0x86, 0x19, 0xBD, 0x2D, 0xB5, 0xB7, 0xB6, 0x97, 0xF3, 0x24,
  0x39, 0x83, 0xE0, 0x1C, 0x1E, 0x0D, 0x86, 0xC7, 0x63, 0xF9, 0xFD, 0xC6,
  0xE3, 0x80, 0xFD, 0xFB, 0x37, 0xEF, 0xD9, 0xF3, 0xFE, 0xF8, 0x7F, 0xFC,
  0x30, 0xC3, 0x0E, 0x3F, 0x7C, 0xFD, 0xFF, 0x3E, 0x3C, 0x78, 0xF3, 0xFE,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0x1F, 0xF8, 0xFF, 0xF1, 0x8F, 0xE3, 0x18,
  0xC0, 0x7F, 0xFB, 0x86, 0x0D, 0xF8, 0xF9, 0xFF, 0x7E, 0xC7, 0x8F, 0x1F,
  0xFF, 0xF8, 0xF1, 0xE3, 0xC6, 0xFB, 0x9C, 0xE7, 0x39, 0xCF, 0xF8, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xFE, 0xCF, 0x9B, 0x77, 0xCF, 0x9F, 0xB7, 0x67,
  0xCE, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xE3, 0xFC, 0xFF, 0x3F, 0xCB,
  0xD6, 0xF7, 0xBD, 0xEF, 0x73, 0xCC, 0xC0, 0xE3, 0xF3, 0xF3, 0xFB, 0xDB,
  0xDF, 0xCF, 0xCF, 0xC7, 0x7E, 0xFE, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFE,
  0x7C, 0xFB, 0xFC, 0xF3, 0xFF, 0xEC, 0x30, 0xC0, 0x7E, 0xFE, 0xC7, 0xC7,
  0xC7, 0xC7, 0xE7, 0xFE, 0x7C, 0x0E, 0x07, 0xFD, 0xFB, 0x36, 0x6F, 0x9F,
  0x37, 0x66, 0xCE, 0x7E, 0xF9, 0x83, 0xC3, 0xC3, 0xA3, 0xFE, 0xF8, 0xFF,
  0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xFF, 0x7C, 0xE3, 0x67, 0x67, 0x76, 0x76, 0x3E, 0x3C, 0x3C, 0x1C,
  0xE6, 0x36, 0x73, 0x67, 0x76, 0xF6, 0x6F, 0x67, 0xD6, 0x3D, 0xE3, 0x9E,
  0x39, 0xC0, 0xE7, 0x76, 0x3E, 0x3C, 0x1C, 0x3C, 0x7E, 0x66, 0xE7, 0xE7,
  0x66, 0x7E, 0x3C, 0x3C, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFC, 0x30, 0xC3,
  0x86, 0x1C, 0x7F, 0xFE, 0xFF, 0x6D, 0xB6, 0xDB, 0x70, 0xC1, 0x86, 0x1C,
  0x30, 0xC1, 0x86, 0x1C, 0xFD, 0xB6, 0xDB, 0x6D, 0xF0, 0x30, 0x70, 0xE3,
  0x64, 0xD8, 0xC0, 0xFE, 0xC7, 0x7C, 0x5C, 0x7B, 0xFE, 0xFF, 0xDD, 0x80,
  0xC3, 0x0C, 0x3F, 0xFF, 0x3C, 0xF3, 0xFF, 0xE0, 0x3D, 0xF6, 0x38, 0x61,
  0xF3, 0xC0, 0x06, 0x0C, 0x1B, 0xF7, 0xEC, 0xF9, 0xB3, 0x7E, 0xEC, 0x7C,
  0xDD, 0x9F, 0xF6, 0x0F, 0x8F, 0x00, 0x3B, 0xD9, 0xFF, 0xB1, 0x8C, 0x63,
  0x00, 0x7E, 0xFD, 0x9F, 0x36, 0x6F, 0xDD, 0x83, 0x7E, 0xF8, 0xC3, 0x0C,
  0x3F, 0xFF, 0x3C, 0xF3, 0xCF, 0x30, 0xF3, 0xFF, 0xF0, 0x33, 0x03, 0x33,
  0x33, 0x33, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x7D, 0xDF, 0x3E, 0x7C, 0xDD,
  0x9C, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C,
  0xCC, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xC0, 0x3C, 0xFD, 0x9F, 0x36, 0x6F,
  0xCF, 0x00, 0xFF, 0xFC, 0xF3, 0xCF, 0xFF, 0xB0, 0xC3, 0x00, 0x7E, 0xFD,
  0x9F, 0x36, 0x6F, 0xDD, 0x83, 0x06, 0x0C, 0xFF, 0xB1, 0x8C, 0x63, 0x00,
  0x7F, 0xA7, 0x1E, 0x1F, 0xFF, 0x80, 0x23, 0x3F, 0xF6, 0x31, 0x8F, 0x38,
  0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xC0, 0xE6, 0xDD, 0xB3, 0x63, 0xC7, 0x0E,
  0x00, 0xEE, 0xED, 0xD9, 0xAB, 0x3D, 0xE7, 0xBC, 0x77, 0x0E, 0xE0, 0xEE,
  0xF8, 0xF1, 0xC7, 0xCD, 0xF9, 0x80, 0xE6, 0xDD, 0xB3, 0x63, 0xC7, 0x0E,
  0x1C, 0x70, 0xE0, 0xFF, 0xF3, 0x8C, 0x73, 0xFF, 0xC0, 0x39, 0x8C, 0x6F,
  0x71, 0xC6, 0x31, 0xCE, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0x8C, 0x63, 0x8C,
  0xC6, 0x37, 0xB8, 0x73, 0xFE, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_Black13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 5, 3, 7, 1, -9 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 7, 11, 7, 0, -10 },
  { 25, 12, 9, 12, 0, -9 },
  { 39, 10, 9, 10, 0, -9 },
  { 51, 2, 3, 4, 1, -9 },
  { 52, 4, 12, 5, 0, -10 },
  { 58, 4, 12, 5, 0, -10 },
  { 64, 6, 6, 7, 0, -10 },
  { 69, 6, 7, 7, 1, -8 },
  { 75, 3, 4, 4, 0, -2 },
  { 77, 4, 2, 4, 0, -4 },
  { 78, 2, 2, 4, 1, -2 },
  { 79, 6, 9, 6, 0, -9 },
  { 86, 7, 9, 7, 0, -9 },
  { 94, 5, 9, 7, 1, -9 },
  { 100, 7, 9, 7, 0, -9 },
  { 108, 7, 9, 7, 0, -9 },
  { 116, 7, 9, 7, 0, -9 },
  { 124, 6, 9, 7, 1, -9 },
  { 131, 7, 9, 7, 0, -9 },
  { 139, 7, 9, 7, 0, -9 },
  { 147, 7, 9, 7, 0, -9 },
  { 155, 7, 9, 7, 0, -9 },
  { 163, 2, 7, 4, 1, -7 },
  { 165, 3, 9, 4, 0, -7 },
  { 169, 7, 7, 7, 0, -8 },
  { 176, 6, 5, 7, 1, -7 },
  { 180, 6, 7, 7, 1, -8 },
  { 186, 6, 9, 6, 0, -9 },
  { 193, 11, 10, 11, 0, -9 },
  { 207, 9, 9, 9, 0, -9 },
  { 218, 7, 9, 8, 1, -9 },
  { 226, 6, 9, 8, 1, -9 },
  { 233, 7, 9, 9, 1, -9 },
  { 241, 5, 9, 7, 1, -9 },
  { 247, 5, 9, 7, 1, -9 },
  { 253, 7, 9, 9, 1, -9 },
  { 261, 7, 9, 9, 1, -9 },
  { 269, 5, 9, 5, 0, -9 },
  { 275, 4, 12, 4, -1, -9 },
  { 281, 7, 9, 8, 1, -9 },
  { 289, 5, 9, 7, 1, -9 },
  { 295, 10, 9, 12, 1, -9 },
  { 307, 8, 9, 10, 1, -9 },
  { 316, 8, 9, 10, 1, -9 },
  { 325, 6, 9, 8, 1, -9 },
  { 332, 8, 11, 10, 1, -9 },
  { 343, 7, 9, 8, 1, -9 },
  { 351, 7, 9, 7, 0, -9 },
  { 359, 7, 9, 7, 0, -9 },
  { 367, 7, 9, 9, 1, -9 },
  { 375, 8, 9, 8, 0, -9 },
  { 384, 12, 9, 12, 0, -9 },
  { 398, 8, 9, 8, 0, -9 },
  { 407, 8, 9, 8, 0, -9 },
  { 416, 7, 9, 7, 0, -9 },
  { 424, 3, 12, 4, 1, -10 },
  { 429, 6, 9, 6, 0, -9 },
  { 436, 3, 12, 4, 0, -10 },
  { 441, 7, 6, 7, 0, -9 },
  { 447, 7, 1, 7, 0, 1 },
  { 448, 4, 2, 5, 1, -10 },
  { 449, 7, 7, 7, 0, -7 },
  { 456, 6, 10, 8, 1, -10 },
  { 464, 6, 7, 7, 0, -7 },
  { 470, 7, 10, 8, 0, -10 },
  { 479, 7, 7, 7, 0, -7 },
  { 486, 5, 10, 5, 0, -10 },
  { 493, 7, 10, 8, 0, -7 },
  { 502, 6, 10, 8, 1, -10 },
  { 510, 2, 10, 4, 1, -10 },
  { 513, 4, 13, 4, -1, -10 },
  { 520, 7, 10, 8, 1, -10 },
  { 529, 2, 10, 4, 1, -10 },
  { 532, 10, 7, 12, 1, -7 },
  { 541, 6, 7, 8, 1, -7 },
  { 547, 7, 7, 8, 0, -7 },
  { 554, 6, 10, 8, 1, -7 },
  { 562, 7, 10, 8, 0, -7 },
  { 571, 5, 7, 6, 1, -7 },
  { 576, 6, 7, 6, 0, -7 },
  { 582, 5, 9, 5, 0, -9 },
  { 588, 6, 7, 8, 1, -7 },
  { 594, 7, 7, 7, 0, -7 },
  { 601, 11, 7, 11, 0, -7 },
  { 611, 7, 7, 7, 0, -7 },
  { 618, 7, 10, 7, 0, -7 },
  { 627, 6, 7, 6, 0, -7 },
  { 633, 5, 11, 5, 0, -9 },
  { 640, 2, 13, 6, 2, -10 },
  { 644, 5, 11, 5, 0, -9 },
  { 651, 7, 3, 7, 0, -6 },
};

const GFXfont NotoSans_SemiCondensed_Black13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK13PT7B_H_
