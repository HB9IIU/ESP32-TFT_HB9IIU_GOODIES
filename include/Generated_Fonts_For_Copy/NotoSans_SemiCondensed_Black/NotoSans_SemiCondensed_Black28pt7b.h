#ifndef _NOTOSANS_SEMICONDENSED_BLACK28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00,
  0x1C, 0xFB, 0xFF, 0xDE, 0xF9, 0xF7, 0x9F, 0x79, 0xF7, 0x9F, 0x79, 0xF7,
  0x9E, 0x79, 0xE0, 0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x70, 0x1E,
  0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3C, 0xE0, 0x3C,
  0xE0, 0x39, 0xE0, 0x39, 0xE0, 0x79, 0xE0, 0x03, 0x00, 0x18, 0x0F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xCC, 0x5E, 0x60, 0xFF, 0x03, 0xFC, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0x0D, 0xF8, 0x6F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0x80, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x3E, 0x01, 0xE0,
  0x7F, 0x03, 0xC0, 0xFF, 0x83, 0x80, 0xF7, 0x87, 0x80, 0xF7, 0x8F, 0x00,
  0xE7, 0x8F, 0x00, 0xE7, 0x9E, 0x00, 0xF7, 0x9E, 0x00, 0xF7, 0xBC, 0xFC,
  0xFF, 0xBD, 0xFE, 0x7F, 0x79, 0xFE, 0x3E, 0x7B, 0xCF, 0x00, 0xF3, 0xCF,
  0x00, 0xF3, 0xCF, 0x01, 0xE3, 0xCF, 0x01, 0xE3, 0xCF, 0x03, 0xC3, 0xCF,
  0x03, 0xC1, 0xFE, 0x07, 0x81, 0xFE, 0x07, 0x80, 0xFC, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xE7, 0x80,
  0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x7E, 0x7F, 0xE7,
  0xE7, 0xFF, 0x7C, 0xF9, 0xFF, 0xCF, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0xC7,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFE, 0x7F, 0xFB,
  0xDE, 0xF7, 0xBD, 0xE0, 0x0F, 0x1F, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78,
  0x7C, 0x3C, 0x3E, 0x1E, 0x1F, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0,
  0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0xFC, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x18, 0xE6, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0,
  0x0F, 0xE0, 0x7F, 0xC3, 0xCF, 0x87, 0x38, 0x04, 0x40, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x7D, 0xF7, 0x9E, 0xFB,
  0xCF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7B, 0xEF, 0xFF, 0x78, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFC,
  0x7C, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F,
  0xFE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0xCF, 0x9F, 0x3E, 0x7F, 0xF8, 0xFF,
  0xC3, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFF, 0xFF,
  0xDF, 0xF9, 0xDF, 0x33, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0xC3, 0xFF, 0x3F,
  0xFD, 0xFF, 0xF7, 0x9F, 0x90, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC7, 0xFF, 0xBF, 0xFC, 0xFF, 0xF2,
  0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x7E, 0x1F, 0xE0, 0xFC, 0x07, 0xF8, 0x3F,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8,
  0xFF, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1E, 0xF8, 0x79, 0xF0, 0xF3, 0xE3, 0xC7,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xF8, 0x7F, 0xF3, 0xFF, 0x9F, 0xFE, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0xFF,
  0x80, 0x07, 0xF0, 0x3F, 0xC3, 0xFF, 0x0F, 0xFC, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xBF, 0x3E, 0xF8, 0x7F,
  0xE1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x1F,
  0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xF8, 0xF9, 0xE3, 0xE7, 0xDF, 0x9F,
  0xFC, 0x3F, 0xE0, 0x7F, 0x03, 0xFE, 0x1F, 0xFC, 0xFC, 0xFB, 0xE3, 0xEF,
  0x87, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFF, 0x87, 0xFF, 0x3F, 0xFE, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E,
  0xF8, 0xFF, 0xFF, 0xF7, 0xFF, 0x9F, 0xDE, 0x3F, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x7F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x31, 0xEF, 0xFF,
  0x78, 0x40, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xDE, 0x31, 0xEF, 0xFF,
  0x78, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xF7, 0x9E, 0xFB, 0xCF, 0x3C,
  0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F,
  0xC0, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x7F, 0xCF, 0xF9,
  0xFF, 0x0F, 0xC0, 0x78, 0x03, 0x00, 0x00, 0x3F, 0xC7, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE6, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0xFC,
  0x07, 0xC0, 0x1E, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xC0, 0x7C, 0x3C, 0x00, 0xF1, 0xE3, 0xFD, 0xE7, 0x9F, 0xF3, 0x9C,
  0xFF, 0xCF, 0xF3, 0xC7, 0x3F, 0xCE, 0x1C, 0xFF, 0x78, 0xF3, 0xFD, 0xE3,
  0xCF, 0xF7, 0x8F, 0x3B, 0xCF, 0x3D, 0xEF, 0x3F, 0xFF, 0x9C, 0x7E, 0xFC,
  0x78, 0xE1, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x18, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x1F, 0x1E, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7C, 0x0F, 0xCF, 0x80, 0xFB,
  0xF0, 0x1F, 0x7E, 0x03, 0xF0, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF,
  0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x3E, 0xFF, 0xFB, 0xFF, 0x8F, 0xFF,
  0xBF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7,
  0xF0, 0xCF, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x86, 0x3F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E,
  0xF9, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xC7, 0xFF, 0xC7, 0xF0, 0x63, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0xFB, 0xE0, 0x7D,
  0xF8, 0x3E, 0xFE, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x00,
  0xF8, 0x3F, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF8,
  0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFD, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8, 0x7E,
  0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xDE, 0x1F, 0xFE, 0xF1, 0xEF, 0xFF, 0x8F, 0x7F, 0xFE, 0x7B,
  0xFE, 0xF3, 0xDF, 0xF7, 0xBC, 0xFF, 0xBD, 0xE7, 0xFC, 0xFF, 0x3F, 0xE7,
  0xF1, 0xFF, 0x3F, 0x8F, 0xF9, 0xFC, 0x7F, 0xC7, 0xE3, 0xFE, 0x3E, 0x1F,
  0xF1, 0xF0, 0xF0, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xDF, 0x1F, 0xF7, 0xE7, 0xFE,
  0xF9, 0xFF, 0xBF, 0x7F, 0xE7, 0xDF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0x1F, 0x9F,
  0x83, 0xF7, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xFD, 0xFC, 0x7E,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFE, 0xF9, 0xFB, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x03,
  0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E, 0x03,
  0xEF, 0xC0, 0xFC, 0xF8, 0x1F, 0x9F, 0x83, 0xF3, 0xF8, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0xFC,
  0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xF0,
  0xF9, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3F,
  0x1F, 0xE1, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xC3, 0x7C, 0x03, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x7E, 0x03,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3E, 0xFC, 0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0,
  0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xF9, 0xF8, 0x3E, 0x7E, 0x1F, 0x8F,
  0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0x7C, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0xF8, 0x1F, 0x07,
  0xDF, 0x07, 0xC1, 0xF7, 0xC1, 0xF0, 0x7D, 0xF0, 0xFC, 0x1F, 0x7C, 0x3F,
  0x8F, 0x8F, 0x0F, 0xE3, 0xE3, 0xE3, 0xF8, 0xF8, 0xF9, 0xFE, 0x3E, 0x3E,
  0x7B, 0x8F, 0x8F, 0x9E, 0xF7, 0xC1, 0xE7, 0xBD, 0xF0, 0x7D, 0xEF, 0x7C,
  0x1F, 0xF3, 0xDF, 0x07, 0xFC, 0x77, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0xFC, 0x0F, 0xDF, 0x87, 0xE3, 0xE1, 0xF0, 0xFC, 0xFC, 0x1F,
  0x3E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0x7C, 0xF8, 0x3F, 0x3F, 0x1F, 0x87, 0xE7, 0xE1, 0xFB, 0xF0, 0x3F, 0xFC,
  0x1F, 0xBE, 0x0F, 0x9F, 0x87, 0xC7, 0xC7, 0xC3, 0xE3, 0xE0, 0xFB, 0xF0,
  0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3F, 0xFF, 0xFF, 0xFC, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x0E, 0x78, 0x3C, 0x78, 0x78,
  0xF1, 0xE0, 0xF3, 0xC1, 0xEF, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x1F, 0x07, 0xC0, 0xF0, 0x07, 0x83, 0xFF, 0x8F, 0xFE, 0x7F,
  0xF3, 0x0F, 0x80, 0x7C, 0x3F, 0xE7, 0xFF, 0x7F, 0xFF, 0xE7, 0xFE, 0x3F,
  0xF1, 0xFF, 0xDF, 0xFF, 0xFD, 0xFD, 0xE7, 0xC7, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE7, 0x0F, 0xFF, 0x3F, 0xFC, 0xFF, 0xFB,
  0xF7, 0xEF, 0x8F, 0xBE, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF8, 0xFB, 0xFF, 0xEF, 0xFF, 0xBD, 0xFC, 0xF3, 0xE0, 0x07, 0xC1, 0xFF,
  0x3F, 0xF7, 0xFF, 0x7E, 0x6F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC1, 0x7F, 0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x39, 0xF3, 0xF7, 0xDF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xFC, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x3C, 0x07, 0x80,
  0x7F, 0x83, 0xFF, 0x9F, 0xFE, 0x7C, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x02, 0x7F, 0x79, 0xFF, 0xE3, 0xFF,
  0x83, 0xFC, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xA3, 0xE0, 0x7C, 0x1F, 0xF7,
  0xFE, 0xFF, 0xC7, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x0E, 0x00, 0xFE, 0xF7, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFF, 0x1F, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xDF, 0x00,
  0x7E, 0x01, 0xF7, 0x1F, 0xDF, 0xFE, 0x7F, 0xF9, 0xFF, 0x81, 0xF8, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE7, 0x0F, 0xFF,
  0x3F, 0xFE, 0xFF, 0xFB, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7C, 0x77, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0xFF, 0xFE, 0xFE, 0xFC, 0xF0, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x1F, 0x7C, 0x7C, 0xF9,
  0xF9, 0xF7, 0xE3, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF8, 0xF9, 0xF1, 0xF3, 0xF3, 0xE3, 0xF7, 0xC3, 0xEF, 0x87, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xC1, 0xE3, 0xDF, 0xCF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0xFF, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3E, 0x1F,
  0xF8, 0xF8, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8,
  0xF8, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0x01, 0xC3,
  0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFD, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0x07, 0x80, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0xFF, 0xF1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDF, 0x1F, 0x7F,
  0xFC, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0x01, 0xC3, 0xDF, 0xCF, 0xFF, 0x3F,
  0xFE, 0xFD, 0xFB, 0xE3, 0xEF, 0x8F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF,
  0x8F, 0xFE, 0x3E, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3E, 0xF8, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0E,
  0x00, 0xFE, 0xF7, 0xFF, 0xDF, 0xFF, 0x7C, 0xFF, 0xF1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0x7F, 0xFD, 0xFF, 0xF3,
  0xFF, 0xC7, 0xDF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x0F, 0x0F, 0xFD, 0xFF, 0xFF, 0xEF, 0x85, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F,
  0xE3, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF3, 0xF3,
  0xC0, 0xFC, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x7E, 0x3E, 0xF8, 0xFC,
  0x7D, 0xF3, 0xF8, 0xFB, 0xE7, 0xF1, 0xE7, 0xCF, 0xF7, 0xC7, 0x9D, 0xEF,
  0x8F, 0xBB, 0xDF, 0x1F, 0xF7, 0xBC, 0x3F, 0xE7, 0x78, 0x3F, 0xCF, 0xF0,
  0x7F, 0x9F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x7E, 0x7E, 0x3E, 0x7C, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x5F, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x7C,
  0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xC7, 0xF1, 0xFC, 0x7E, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x8F, 0xE3, 0xF0, 0xF8, 0x3F, 0x87, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0x07, 0xF1, 0xFC, 0x3F, 0x02, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x81, 0xFC, 0x7F, 0x07, 0xC7, 0xF3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x3F, 0x0F, 0xC3, 0xE0, 0xC0, 0x00, 0x10, 0x0B, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_Black28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 20, 8, 1, -20 },
  { 16, 12, 7, 14, 1, -20 },
  { 27, 16, 20, 17, 1, -20 },
  { 67, 13, 23, 15, 1, -21 },
  { 105, 24, 20, 25, 1, -20 },
  { 165, 20, 20, 21, 1, -20 },
  { 215, 5, 7, 8, 1, -20 },
  { 220, 8, 25, 10, 1, -21 },
  { 245, 9, 25, 10, 0, -21 },
  { 274, 14, 13, 14, 0, -21 },
  { 297, 13, 14, 16, 1, -17 },
  { 320, 6, 8, 8, 1, -4 },
  { 326, 7, 5, 9, 1, -10 },
  { 331, 6, 5, 8, 1, -5 },
  { 335, 12, 20, 12, 0, -20 },
  { 365, 14, 20, 15, 1, -20 },
  { 400, 11, 20, 15, 1, -20 },
  { 428, 13, 20, 15, 1, -20 },
  { 461, 13, 20, 15, 1, -20 },
  { 494, 15, 20, 15, 0, -20 },
  { 532, 13, 20, 15, 1, -20 },
  { 565, 14, 20, 15, 1, -20 },
  { 600, 14, 20, 15, 1, -20 },
  { 635, 14, 20, 15, 1, -20 },
  { 670, 14, 20, 15, 1, -20 },
  { 705, 6, 16, 8, 1, -16 },
  { 717, 6, 20, 8, 1, -16 },
  { 732, 13, 15, 16, 1, -18 },
  { 757, 13, 10, 16, 1, -15 },
  { 774, 13, 15, 16, 1, -18 },
  { 799, 13, 20, 13, 0, -20 },
  { 832, 22, 22, 24, 1, -20 },
  { 893, 19, 20, 19, 0, -20 },
  { 941, 14, 20, 18, 2, -20 },
  { 976, 15, 20, 17, 1, -20 },
  { 1014, 16, 20, 19, 2, -20 },
  { 1054, 11, 20, 14, 2, -20 },
  { 1082, 11, 20, 14, 2, -20 },
  { 1110, 17, 20, 19, 1, -20 },
  { 1153, 16, 20, 20, 2, -20 },
  { 1193, 10, 20, 11, 1, -20 },
  { 1218, 9, 26, 9, -2, -20 },
  { 1248, 16, 20, 18, 2, -20 },
  { 1288, 12, 20, 15, 2, -20 },
  { 1318, 21, 20, 25, 2, -20 },
  { 1371, 18, 20, 22, 2, -20 },
  { 1416, 18, 20, 21, 1, -20 },
  { 1461, 14, 20, 17, 2, -20 },
  { 1496, 19, 25, 21, 1, -20 },
  { 1556, 16, 20, 18, 2, -20 },
  { 1596, 13, 20, 15, 1, -20 },
  { 1629, 14, 20, 15, 1, -20 },
  { 1664, 16, 20, 19, 2, -20 },
  { 1704, 18, 20, 18, 0, -20 },
  { 1749, 26, 20, 27, 0, -20 },
  { 1814, 18, 20, 18, 0, -20 },
  { 1859, 17, 20, 17, 0, -20 },
  { 1902, 14, 20, 16, 1, -20 },
  { 1937, 7, 26, 9, 1, -21 },
  { 1960, 12, 20, 12, 0, -20 },
  { 1990, 6, 26, 9, 1, -21 },
  { 2010, 15, 13, 15, 0, -20 },
  { 2035, 14, 3, 14, 0, 2 },
  { 2041, 9, 4, 11, 1, -21 },
  { 2046, 13, 16, 16, 1, -16 },
  { 2072, 14, 21, 17, 2, -21 },
  { 2109, 12, 16, 14, 1, -16 },
  { 2133, 14, 21, 17, 1, -21 },
  { 2170, 14, 16, 16, 1, -16 },
  { 2198, 11, 21, 11, 0, -21 },
  { 2227, 14, 23, 17, 1, -16 },
  { 2268, 14, 21, 17, 2, -21 },
  { 2305, 5, 22, 8, 2, -22 },
  { 2319, 8, 29, 8, -1, -22 },
  { 2348, 15, 21, 17, 2, -21 },
  { 2388, 5, 21, 8, 2, -21 },
  { 2402, 22, 16, 26, 2, -16 },
  { 2446, 14, 16, 17, 2, -16 },
  { 2474, 14, 16, 17, 1, -16 },
  { 2502, 14, 23, 17, 2, -16 },
  { 2543, 14, 23, 17, 1, -16 },
  { 2584, 10, 16, 12, 2, -16 },
  { 2604, 11, 16, 13, 1, -16 },
  { 2626, 10, 19, 12, 1, -19 },
  { 2650, 14, 15, 17, 2, -15 },
  { 2677, 16, 15, 16, 0, -15 },
  { 2707, 23, 15, 24, 0, -15 },
  { 2751, 16, 15, 16, 0, -15 },
  { 2781, 16, 22, 16, 0, -15 },
  { 2825, 11, 15, 13, 1, -15 },
  { 2846, 10, 25, 11, 1, -20 },
  { 2878, 4, 27, 13, 5, -21 },
  { 2892, 10, 25, 11, 1, -20 },
  { 2924, 13, 6, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Black28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK28PT7B_H_
