#ifndef _NOTOSANS_SEMICONDENSED_BLACK39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xE0, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xC7, 0xC0, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x81, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFE, 0xFF, 0xEF, 0x9F, 0x9C, 0x13, 0xF3, 0x80, 0x7F, 0x70, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0E, 0x7E, 0x01, 0xCF, 0xD8,
  0x39, 0xFB, 0xF7, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F,
  0xFF, 0x80, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1F,
  0xC0, 0x07, 0xC0, 0x0F, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0xF8, 0x01,
  0xFF, 0xC0, 0x7E, 0x00, 0xFD, 0xF8, 0x1F, 0x00, 0x3F, 0x3E, 0x0F, 0xC0,
  0x0F, 0x8F, 0x83, 0xE0, 0x03, 0xE3, 0xE1, 0xF8, 0x00, 0xF8, 0xF8, 0x7C,
  0x00, 0x3E, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x8F, 0x80, 0x03, 0xE3, 0xE7,
  0xE3, 0xF0, 0xFD, 0xF9, 0xF3, 0xFE, 0x1F, 0xFE, 0xFD, 0xFF, 0xC7, 0xFF,
  0x3E, 0x7F, 0xF8, 0xFF, 0x9F, 0x9F, 0x7E, 0x1F, 0xC7, 0xCF, 0xCF, 0x80,
  0x03, 0xF3, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x3F,
  0x00, 0x1F, 0x0F, 0x8F, 0xC0, 0x0F, 0xC3, 0xE3, 0xE0, 0x03, 0xE0, 0xFC,
  0xF8, 0x01, 0xF8, 0x1F, 0x3E, 0x00, 0x7C, 0x07, 0xFF, 0x80, 0x3F, 0x01,
  0xFF, 0xC0, 0x0F, 0x80, 0x3F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x1F, 0xE0, 0xFF, 0xE1, 0xFE, 0x1F,
  0xFE, 0x1F, 0xC3, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF, 0xBF, 0xC7, 0xF3, 0xFF,
  0xF8, 0xFF, 0x3F, 0xFF, 0x8F, 0xE1, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0x0F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF, 0xE0, 0x7F, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9F, 0x3E, 0x7C, 0xF8, 0x07, 0xE1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F,
  0xE1, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x18, 0x78,
  0x7F, 0xDE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF0,
  0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xF3, 0xF1, 0xFC, 0xFE, 0x1E,
  0x1E, 0x01, 0x87, 0x00, 0x21, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x3F, 0x3F, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xC7, 0xF3, 0xF8, 0x7E, 0x7F,
  0x0F, 0xEF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC,
  0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x3F, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFD, 0xF3, 0xF9, 0xC7, 0xF1, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0x07, 0xF0, 0xC0, 0xFE, 0x10,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x86, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x01,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFB, 0xF8,
  0x1F, 0xBF, 0x83, 0xF3, 0xF8, 0x7E, 0x3F, 0x87, 0xE3, 0xF8, 0xFC, 0x3F,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xF8, 0xF7, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xDF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFB, 0x8F, 0xF0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC1, 0x01, 0xF9, 0xFC, 0x3F, 0x7F, 0xCF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF,
  0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0x3F, 0x9F,
  0xC3, 0xFB, 0xF8, 0x7E, 0x7F, 0x1F, 0xC7, 0xF3, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFE, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC7, 0xF7, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF1, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xF7, 0xE3, 0xFC, 0xFC, 0x0E,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x88, 0x7F, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x39,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x1E, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE3, 0x81, 0xFC, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x83, 0xFE, 0x7C, 0x3E, 0x1F,
  0xFE, 0x7C, 0x7C, 0x7F, 0xFC, 0xF9, 0xF1, 0xFF, 0xF9, 0xF3, 0xE3, 0xF1,
  0xF1, 0xF7, 0xCF, 0xC3, 0xE3, 0xEF, 0x9F, 0x07, 0xC7, 0xDE, 0x3E, 0x0F,
  0x8F, 0xFC, 0x7C, 0x1F, 0x1F, 0xF8, 0xF8, 0x3E, 0x3C, 0xF1, 0xF0, 0xFC,
  0xF9, 0xF3, 0xE1, 0xF9, 0xF3, 0xE7, 0xFF, 0xFF, 0xC7, 0xC7, 0xFF, 0xFF,
  0x8F, 0x8F, 0xFD, 0xFE, 0x0F, 0x87, 0xF3, 0xF8, 0x1F, 0x83, 0x00, 0xC0,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x00, 0x3F, 0xE0, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE0, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x80,
  0x7F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFE, 0x1F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFE, 0x3F, 0xEF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xC0, 0xC7, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x06, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xE1, 0xFF, 0x3F, 0x83, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0,
  0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x81, 0xFE, 0xFE, 0x0F, 0xF3, 0xF8, 0x7F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFE, 0x03, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x7F, 0x80, 0xFD, 0xFF, 0x03, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFC, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xFF,
  0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x07, 0xC0, 0x00, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0xBF, 0x83, 0xFC, 0xFE, 0x0F, 0xE3,
  0xF8, 0x7F, 0x8F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x83, 0xFB,
  0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xE7, 0xF8, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x8F, 0xE1,
  0xFE, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F,
  0xBF, 0x80, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xDF, 0x07, 0xFF, 0xFF, 0x7E, 0x1F, 0x7F, 0xFD, 0xF8, 0x7D, 0xFF,
  0xF7, 0xE3, 0xF7, 0xFF, 0xCF, 0x8F, 0x9F, 0xFF, 0x3F, 0x3E, 0x7F, 0xFC,
  0xFD, 0xF9, 0xFF, 0xF1, 0xF7, 0xE7, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xF1, 0xFF, 0xF0, 0xFF, 0xC7, 0xFF, 0xC3, 0xFE,
  0x1F, 0xFF, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F, 0xE1, 0xFF, 0xF0, 0x7F, 0x07,
  0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFD, 0xFC, 0x3F, 0xFD, 0xFC, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC,
  0xFE, 0x3F, 0xFC, 0x7F, 0x3F, 0xFC, 0x7F, 0x3F, 0xFC, 0x3F, 0xBF, 0xFC,
  0x3F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8,
  0x0F, 0xF3, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0x8F, 0xF7, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xEF, 0xE3, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF1, 0xFF, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F,
  0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F,
  0xF3, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3F, 0x9F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE,
  0x3F, 0x87, 0xF8, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0x7F, 0xBF,
  0x80, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xC0, 0xE3, 0xF8, 0x04, 0x7F, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0xFE,
  0x03, 0xFB, 0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F,
  0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x7F, 0x80, 0xFE,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xEF, 0xF0, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xE0, 0x1F, 0xDF, 0xC0,
  0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xE0, 0x7F,
  0x1F, 0x81, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xF8, 0x1F, 0x87, 0xF0, 0x7F,
  0xC1, 0xFC, 0x3F, 0x83, 0xFF, 0x0F, 0xE0, 0xFC, 0x3F, 0xF8, 0x7F, 0x07,
  0xE1, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xBE, 0x1F, 0x81, 0xFC, 0x7D, 0xF1,
  0xFC, 0x0F, 0xE3, 0xEF, 0xCF, 0xE0, 0x3F, 0x3F, 0x7E, 0x7F, 0x01, 0xF9,
  0xF9, 0xF3, 0xF0, 0x0F, 0xEF, 0xCF, 0x9F, 0x80, 0x7F, 0x7C, 0x7D, 0xFC,
  0x01, 0xFB, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F,
  0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xDF,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE,
  0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0x01, 0xF0,
  0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xF7,
  0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1E, 0x3F,
  0xC2, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0x3E,
  0x3F, 0x87, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x3E, 0x0F, 0xE7, 0xF8, 0xFE, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFE, 0xFF, 0xDF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFE, 0xFF, 0x8F, 0xC7, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF8, 0x31, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x02, 0x7F, 0xC7, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xC7, 0xF0, 0xFF, 0x7F, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x8F, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0xDF, 0xF7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xF3, 0xF0, 0xFE, 0x3F, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xF8, 0xFE, 0x7F, 0x07, 0xE7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xFC, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x8F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0xFF, 0x3F, 0x1F, 0xFB, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x8F, 0xF7, 0xF0, 0x7F, 0x7F,
  0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF7,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0xCF, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xF7, 0xF0, 0xFE, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x60, 0x0F, 0xF7, 0xE1, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x0F, 0xE7, 0xF8, 0xFE, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE9, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0x3F,
  0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F,
  0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFB, 0xF8, 0x3F, 0xCF, 0xF0, 0xFE,
  0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x07,
  0xFB, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0xFF, 0x8F, 0xF8, 0xFD, 0xFF, 0xDF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFE,
  0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0xFE,
  0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0xFE,
  0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0xFE,
  0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0xFC,
  0x3F, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xEF, 0xF1, 0xFE, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0xBF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xF7, 0xF0, 0x7F, 0xBF, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x8F, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0xFC, 0x3E, 0x0F, 0xC7, 0xF8, 0xFE, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0xFF, 0xDF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0xFF, 0x8F, 0xE7, 0xF0, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC3,
  0xF0, 0xFF, 0x3F, 0x1F, 0xFB, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0x8F, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7,
  0xF0, 0x7F, 0x7F, 0xCF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xF7, 0xF0, 0xFE, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x3F, 0xF8, 0xFB, 0xF3, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFE, 0x1C, 0xFE, 0x04,
  0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xCC, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x3F, 0xF3, 0xF0, 0xFE, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03,
  0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xE0,
  0x7F, 0x3F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x3F, 0xBF, 0x87, 0xFC, 0x1F, 0x9F, 0xC3, 0xFE, 0x1F,
  0xCF, 0xE1, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0x87, 0xF1, 0xF8, 0x7F, 0xC3,
  0xF0, 0xFE, 0x7D, 0xF1, 0xF8, 0x7F, 0x3E, 0xF9, 0xFC, 0x3F, 0x9F, 0x7C,
  0xFE, 0x0F, 0xCF, 0xBE, 0x7E, 0x07, 0xE7, 0xDF, 0x3F, 0x03, 0xF7, 0xEF,
  0xDF, 0x81, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8,
  0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFD, 0xFE, 0x0F,
  0xE3, 0xF8, 0x7F, 0x8F, 0xF1, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0xBF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x7F, 0x3F, 0xC3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFE, 0x7F, 0x83, 0xFB, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x83, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x3F, 0x80,
  0xFC, 0xFE, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0xBF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x0F, 0xFC, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x03,
  0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0xC3,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC3,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x08, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE8, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Black39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 28, 11, 2, -28 },
  { 26, 16, 10, 20, 2, -28 },
  { 46, 23, 28, 24, 1, -28 },
  { 127, 19, 32, 21, 1, -30 },
  { 203, 34, 28, 35, 1, -28 },
  { 322, 28, 28, 29, 1, -28 },
  { 420, 7, 10, 11, 2, -28 },
  { 429, 11, 35, 14, 2, -29 },
  { 478, 11, 35, 14, 1, -29 },
  { 527, 18, 19, 20, 1, -30 },
  { 570, 18, 19, 22, 2, -23 },
  { 613, 8, 11, 12, 1, -6 },
  { 624, 11, 6, 13, 1, -13 },
  { 633, 7, 7, 11, 2, -7 },
  { 640, 17, 28, 17, 0, -28 },
  { 700, 19, 28, 22, 1, -28 },
  { 767, 15, 28, 22, 2, -28 },
  { 820, 19, 28, 22, 1, -28 },
  { 887, 19, 28, 22, 1, -28 },
  { 954, 20, 28, 22, 1, -28 },
  { 1024, 18, 28, 22, 2, -28 },
  { 1087, 19, 28, 22, 1, -28 },
  { 1154, 19, 28, 22, 1, -28 },
  { 1221, 19, 28, 22, 1, -28 },
  { 1288, 19, 28, 22, 1, -28 },
  { 1355, 7, 22, 11, 2, -22 },
  { 1375, 8, 27, 11, 1, -22 },
  { 1402, 18, 20, 22, 2, -24 },
  { 1447, 18, 14, 22, 2, -21 },
  { 1479, 18, 20, 22, 2, -24 },
  { 1524, 18, 28, 18, 0, -28 },
  { 1587, 31, 31, 33, 1, -28 },
  { 1708, 26, 28, 26, 0, -28 },
  { 1799, 20, 28, 25, 3, -28 },
  { 1869, 20, 28, 23, 2, -28 },
  { 1939, 22, 28, 27, 3, -28 },
  { 2016, 15, 28, 20, 3, -28 },
  { 2069, 15, 28, 20, 3, -28 },
  { 2122, 22, 28, 27, 2, -28 },
  { 2199, 22, 28, 28, 3, -28 },
  { 2276, 14, 28, 16, 1, -28 },
  { 2325, 13, 37, 13, -3, -28 },
  { 2386, 22, 28, 25, 3, -28 },
  { 2463, 16, 28, 21, 3, -28 },
  { 2519, 30, 28, 35, 3, -28 },
  { 2624, 24, 28, 30, 3, -28 },
  { 2708, 25, 28, 29, 2, -28 },
  { 2796, 19, 28, 23, 3, -28 },
  { 2863, 25, 35, 29, 2, -28 },
  { 2973, 22, 28, 25, 3, -28 },
  { 3050, 19, 28, 21, 1, -28 },
  { 3117, 19, 28, 21, 1, -28 },
  { 3184, 22, 28, 27, 3, -28 },
  { 3261, 25, 28, 25, 0, -28 },
  { 3349, 37, 28, 37, 0, -28 },
  { 3479, 25, 28, 25, 0, -28 },
  { 3567, 24, 28, 24, 0, -28 },
  { 3651, 20, 28, 22, 1, -28 },
  { 3721, 10, 36, 12, 2, -29 },
  { 3766, 17, 28, 17, 0, -28 },
  { 3826, 9, 36, 12, 1, -29 },
  { 3867, 21, 18, 21, 0, -28 },
  { 3915, 20, 4, 20, 0, 3 },
  { 3925, 12, 6, 15, 2, -30 },
  { 3934, 19, 22, 22, 1, -22 },
  { 3987, 20, 30, 23, 2, -30 },
  { 4062, 18, 22, 20, 1, -22 },
  { 4112, 20, 30, 23, 1, -30 },
  { 4187, 20, 22, 22, 1, -22 },
  { 4242, 15, 30, 15, 1, -30 },
  { 4299, 20, 31, 23, 1, -22 },
  { 4377, 20, 30, 24, 2, -30 },
  { 4452, 8, 30, 12, 2, -30 },
  { 4482, 12, 39, 12, -2, -30 },
  { 4541, 22, 30, 24, 2, -30 },
  { 4624, 7, 30, 12, 2, -30 },
  { 4651, 32, 22, 36, 2, -22 },
  { 4739, 20, 22, 24, 2, -22 },
  { 4794, 21, 22, 23, 1, -22 },
  { 4852, 20, 31, 23, 2, -22 },
  { 4930, 20, 31, 23, 1, -22 },
  { 5008, 15, 22, 17, 2, -22 },
  { 5050, 16, 22, 18, 1, -22 },
  { 5094, 14, 26, 16, 1, -26 },
  { 5140, 20, 22, 24, 2, -22 },
  { 5195, 22, 22, 22, 0, -22 },
  { 5256, 33, 22, 33, 0, -22 },
  { 5347, 22, 22, 22, 0, -22 },
  { 5408, 22, 31, 22, 0, -22 },
  { 5494, 16, 22, 18, 1, -22 },
  { 5538, 14, 35, 16, 1, -28 },
  { 5600, 5, 39, 19, 7, -30 },
  { 5625, 14, 35, 16, 1, -28 },
  { 5687, 18, 7, 22, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Black39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK39PT7B_H_
