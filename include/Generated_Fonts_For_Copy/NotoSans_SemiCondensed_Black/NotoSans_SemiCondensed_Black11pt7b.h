#ifndef _NOTOSANS_SEMICONDENSED_BLACK11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black11pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xA4, 0x17, 0xBB, 0xB0, 0x3C, 0x59, 0xFB, 0xF2, 0x9F, 0x9E,
  0x2C, 0x31, 0xED, 0x1C, 0x38, 0x7F, 0x9C, 0x10, 0x63, 0x3C, 0x8D, 0x63,
  0xD6, 0x6F, 0xC2, 0xB1, 0xBC, 0xCE, 0x38, 0x6C, 0x6C, 0x38, 0x7F, 0xDE,
  0xFE, 0x7F, 0xE0, 0x36, 0x44, 0xCC, 0x46, 0x63, 0xCD, 0x92, 0x5B, 0x78,
  0x37, 0xDE, 0xF5, 0x00, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x69, 0x60, 0xFC,
  0x5C, 0x19, 0x8C, 0x66, 0x31, 0x18, 0x79, 0xE4, 0xF3, 0xCF, 0x37, 0x9E,
  0x1B, 0xFE, 0xB1, 0x8C, 0x63, 0x7B, 0xE5, 0x86, 0x31, 0xCF, 0xFF, 0xF9,
  0xE1, 0x9E, 0x78, 0x7F, 0xFE, 0x18, 0xE3, 0x9E, 0xDB, 0xF1, 0x86, 0xF7,
  0xB1, 0xEB, 0x0F, 0xDE, 0x39, 0xE4, 0x3E, 0xFF, 0x37, 0xDE, 0xFF, 0xF1,
  0x86, 0x18, 0xC3, 0x18, 0x79, 0xF6, 0x9E, 0x7B, 0x3E, 0xDE, 0x71, 0xEC,
  0xF3, 0x7C, 0x27, 0x9C, 0xE8, 0x07, 0xC0, 0xE8, 0x06, 0x96, 0x04, 0x77,
  0x3C, 0x3C, 0x10, 0xFF, 0xF0, 0x3F, 0x83, 0x83, 0x87, 0xF2, 0x00, 0x77,
  0xC6, 0x66, 0x01, 0x8C, 0x1E, 0x11, 0x97, 0xEA, 0xDF, 0x6E, 0xBD, 0x6C,
  0xE4, 0x1E, 0x00, 0x38, 0x70, 0xB3, 0x66, 0xCF, 0xFF, 0xE3, 0xF7, 0xF7,
  0xFF, 0xEF, 0xFF, 0x7F, 0xF1, 0x8C, 0x63, 0xEF, 0xF3, 0xEC, 0xF3, 0xCF,
  0x3F, 0xBC, 0xFF, 0xCF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFC, 0xCC, 0x7F, 0xEC,
  0x37, 0xDF, 0x3F, 0xDF, 0xCF, 0x3C, 0xFF, 0xFF, 0x3C, 0xF3, 0xF7, 0x66,
  0x66, 0x6F, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xCF, 0x6F, 0xBC, 0xF3, 0x6D,
  0xB3, 0xCC, 0xCC, 0xCC, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xDB,
  0xDB, 0xE7, 0xCF, 0x9F, 0xBF, 0x7B, 0xF7, 0xE7, 0x79, 0xFB, 0x36, 0x7C,
  0xF9, 0xBF, 0x3C, 0xF7, 0xF7, 0xBF, 0xE3, 0x18, 0x79, 0xFB, 0x36, 0x7C,
  0xF9, 0xBF, 0x3C, 0x1C, 0x1C, 0xF3, 0xED, 0xB6, 0xF3, 0xED, 0xB7, 0x7D,
  0xEE, 0x1C, 0x38, 0x7F, 0xBE, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3F, 0xDE, 0xC7, 0xCD, 0xB3, 0x66, 0xC5, 0x0E, 0x1C,
  0xCC, 0xF3, 0x36, 0xED, 0xBB, 0x7A, 0x9E, 0xE3, 0xB8, 0xCE, 0xEE, 0xD9,
  0xF1, 0xC3, 0x8F, 0x9B, 0x73, 0xCE, 0xD9, 0xB1, 0xC3, 0x86, 0x0C, 0x18,
  0xFF, 0xF1, 0x8E, 0x31, 0x8F, 0xFF, 0xEA, 0xAA, 0xF0, 0xC2, 0x18, 0xC2,
  0x18, 0xC3, 0xED, 0xB6, 0xDB, 0xFC, 0x20, 0xC7, 0x16, 0xCC, 0xFC, 0xF0,
  0x79, 0x37, 0xFB, 0xFD, 0xF0, 0xC6, 0x3F, 0xBD, 0xEF, 0xF6, 0x7B, 0x71,
  0x87, 0xBC, 0x0C, 0x37, 0xDB, 0xCF, 0x37, 0xDF, 0x79, 0xBF, 0xFF, 0x65,
  0xE0, 0x76, 0xF6, 0x66, 0x66, 0x7D, 0xBC, 0xF3, 0x7D, 0xF0, 0xDF, 0x70,
  0xC6, 0x3F, 0xBD, 0xEF, 0x7B, 0xB3, 0xFF, 0xC0, 0x23, 0x03, 0x33, 0x33,
  0x33, 0xEC, 0xC3, 0x1D, 0xBC, 0xF3, 0xCD, 0xB7, 0xFF, 0xFF, 0xBF, 0x6F,
  0xB6, 0x7B, 0x3D, 0x9E, 0xCC, 0xBE, 0xF7, 0xBD, 0xEC, 0x79, 0xBC, 0xF3,
  0x6D, 0xE0, 0xBE, 0xF7, 0xBF, 0xFB, 0x18, 0xC0, 0x7D, 0xBC, 0xF3, 0x7D,
  0xF0, 0xC3, 0x0C, 0xBF, 0xCC, 0xCC, 0x7E, 0x5C, 0x7D, 0xF8, 0x6F, 0x66,
  0x67, 0x70, 0xDE, 0xF7, 0xBF, 0xFC, 0xCD, 0x37, 0x9E, 0x38, 0xC0, 0xDD,
  0xEE, 0xDD, 0x6E, 0xA7, 0x73, 0xB8, 0xED, 0xE3, 0x9E, 0x7B, 0xB0, 0xCD,
  0xB7, 0x9E, 0x38, 0xC3, 0x1C, 0x40, 0xF8, 0xCC, 0xCF, 0xFC, 0x33, 0x66,
  0xEE, 0x66, 0x33, 0xFF, 0xC0, 0xEE, 0x66, 0x37, 0x66, 0xEC, 0x67, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Black11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 6, 1, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 9, 6, 0, -8 },
  { 20, 10, 8, 10, 0, -8 },
  { 30, 8, 8, 8, 0, -8 },
  { 38, 1, 3, 3, 1, -8 },
  { 39, 4, 10, 4, 0, -8 },
  { 44, 3, 10, 4, 0, -8 },
  { 48, 5, 5, 6, 0, -8 },
  { 52, 6, 6, 6, 0, -7 },
  { 57, 3, 4, 3, 0, -2 },
  { 59, 3, 2, 4, 0, -4 },
  { 60, 3, 2, 3, 0, -2 },
  { 61, 5, 8, 5, 0, -8 },
  { 66, 6, 8, 6, 0, -8 },
  { 72, 5, 8, 6, 0, -8 },
  { 77, 6, 8, 6, 0, -8 },
  { 83, 6, 8, 6, 0, -8 },
  { 89, 6, 8, 6, 0, -8 },
  { 95, 5, 8, 6, 1, -8 },
  { 100, 6, 8, 6, 0, -8 },
  { 106, 6, 8, 6, 0, -8 },
  { 112, 6, 8, 6, 0, -8 },
  { 118, 6, 8, 6, 0, -8 },
  { 124, 3, 6, 3, 0, -6 },
  { 127, 3, 8, 3, 0, -6 },
  { 130, 6, 6, 6, 0, -7 },
  { 135, 6, 4, 6, 0, -6 },
  { 138, 6, 6, 6, 0, -7 },
  { 143, 5, 8, 5, 0, -8 },
  { 148, 9, 9, 9, 0, -8 },
  { 159, 7, 8, 7, 0, -8 },
  { 166, 5, 8, 7, 1, -8 },
  { 171, 5, 8, 7, 1, -8 },
  { 176, 6, 8, 7, 1, -8 },
  { 182, 4, 8, 6, 1, -8 },
  { 186, 4, 8, 6, 1, -8 },
  { 190, 6, 8, 8, 1, -8 },
  { 196, 6, 8, 8, 1, -8 },
  { 202, 4, 8, 4, 0, -8 },
  { 206, 4, 10, 4, -1, -8 },
  { 211, 6, 8, 7, 1, -8 },
  { 217, 4, 8, 6, 1, -8 },
  { 221, 8, 8, 10, 1, -8 },
  { 229, 7, 8, 8, 1, -8 },
  { 236, 7, 8, 8, 1, -8 },
  { 243, 5, 8, 7, 1, -8 },
  { 248, 7, 10, 8, 1, -8 },
  { 257, 6, 8, 7, 1, -8 },
  { 263, 6, 8, 6, 0, -8 },
  { 269, 6, 8, 6, 0, -8 },
  { 275, 6, 8, 8, 1, -8 },
  { 281, 7, 8, 7, 0, -8 },
  { 288, 10, 8, 11, 0, -8 },
  { 298, 7, 8, 7, 0, -8 },
  { 305, 7, 8, 7, 0, -8 },
  { 312, 6, 8, 6, 0, -8 },
  { 318, 2, 10, 3, 1, -8 },
  { 321, 5, 8, 5, 0, -8 },
  { 326, 3, 10, 3, 0, -8 },
  { 330, 6, 5, 6, 0, -8 },
  { 334, 6, 1, 6, 0, 1 },
  { 335, 4, 1, 4, 0, -8 },
  { 336, 6, 6, 6, 0, -6 },
  { 341, 5, 8, 7, 1, -8 },
  { 346, 5, 6, 6, 0, -6 },
  { 350, 6, 8, 7, 0, -8 },
  { 356, 6, 6, 6, 0, -6 },
  { 361, 4, 8, 4, 0, -8 },
  { 365, 6, 9, 7, 0, -6 },
  { 372, 5, 8, 7, 1, -8 },
  { 377, 2, 9, 3, 1, -9 },
  { 380, 4, 12, 3, -1, -9 },
  { 386, 6, 8, 7, 1, -8 },
  { 392, 2, 8, 3, 1, -8 },
  { 394, 9, 6, 10, 1, -6 },
  { 401, 5, 6, 7, 1, -6 },
  { 405, 6, 6, 7, 0, -6 },
  { 410, 5, 9, 7, 1, -6 },
  { 416, 6, 9, 7, 0, -6 },
  { 423, 4, 6, 5, 1, -6 },
  { 426, 5, 6, 5, 0, -6 },
  { 430, 4, 7, 5, 0, -7 },
  { 434, 5, 6, 7, 1, -6 },
  { 438, 6, 6, 6, 0, -6 },
  { 443, 9, 6, 9, 0, -6 },
  { 450, 6, 6, 6, 0, -6 },
  { 455, 6, 9, 6, 0, -6 },
  { 462, 5, 6, 5, 0, -6 },
  { 466, 4, 10, 5, 0, -8 },
  { 471, 1, 10, 5, 2, -8 },
  { 473, 4, 10, 5, 0, -8 },
  { 478, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_Black11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK11PT7B_H_
