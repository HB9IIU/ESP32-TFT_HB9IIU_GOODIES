#ifndef _NOTOSANS_SEMICONDENSED_BLACK33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xE7,
  0xCF, 0x9F, 0x3E, 0x00, 0x00, 0xE3, 0xEF, 0xFF, 0xDF, 0xBE, 0xF9, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xF8, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x87, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x79, 0xF0, 0x0F, 0x3C,
  0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x07, 0xF0, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0xF9, 0x84, 0xF9, 0x80, 0xFD, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xBF, 0x01, 0x9F, 0xC1, 0x9F,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x1F, 0x00, 0x3C, 0x03, 0xF8, 0x07, 0xC0, 0x7F,
  0xC0, 0x78, 0x0F, 0xFC, 0x0F, 0x80, 0xFB, 0xE0, 0xF0, 0x0F, 0x3E, 0x1F,
  0x00, 0xF1, 0xE1, 0xE0, 0x0F, 0x1E, 0x3E, 0x00, 0xF1, 0xE3, 0xC0, 0x0F,
  0x3E, 0x7C, 0x20, 0xFB, 0xE7, 0x9F, 0xCF, 0xFE, 0xFB, 0xFE, 0x7F, 0xCF,
  0x3F, 0xE3, 0xF9, 0xF7, 0xDF, 0x1F, 0x1E, 0x7D, 0xF0, 0x03, 0xE7, 0x8F,
  0x00, 0x3C, 0x78, 0xF0, 0x07, 0xC7, 0x8F, 0x00, 0x78, 0x78, 0xF0, 0x0F,
  0x87, 0xDF, 0x00, 0xF0, 0x7F, 0xF0, 0x1F, 0x03, 0xFE, 0x01, 0xE0, 0x3F,
  0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0xFC, 0x3F, 0xF8, 0xFC, 0x7F, 0xFD, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFC, 0xFF, 0xF8, 0xFC, 0x7F, 0xF8, 0xFC, 0x3F, 0xF0, 0xFE, 0x1F,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC3,
  0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8,
  0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8,
  0x7C, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0x8F, 0x80, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x0E, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xF8, 0x1F, 0xC0, 0x7F, 0xC1, 0xF7, 0xC7, 0xEF, 0xC7, 0x8F, 0x03, 0x18,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7E, 0xFD, 0xFB,
  0xE7, 0xCF, 0x9F, 0x7C, 0xF9, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x38, 0xFB, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E,
  0x7E, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F,
  0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7D, 0xF9, 0xCF, 0xC4, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0x7C, 0xFE, 0x30, 0x7E, 0x20, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFE, 0x38, 0xFE, 0x20, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x07, 0xFC, 0x1F,
  0xF8, 0x1F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xBF, 0x07, 0xDF, 0x87, 0xCF, 0xC7, 0xC7, 0xE3, 0xE3, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xCE, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F,
  0xFC, 0x7F, 0xF0, 0x00, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x70, 0xFD, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7E, 0x3F, 0x7C, 0x3F, 0x7E, 0x3E, 0x7F, 0x7E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xFE, 0x7F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF8, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFE, 0xFE, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x3F, 0xDF, 0x1F, 0xBF, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xC0, 0x7C, 0xFF, 0xFB, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x8F, 0xDF, 0xFF, 0x7E, 0xF8, 0x7C, 0xFD, 0xFB, 0xF7, 0xC7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xBF, 0x7C, 0xF9, 0xF7,
  0xEF, 0x9F, 0x3C, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x0F, 0xE0, 0x7F, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF,
  0x0F, 0xC8, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x07, 0xC3, 0xE1, 0xFC, 0xF8, 0xF1, 0xFF,
  0x9E, 0x7C, 0xFF, 0xE7, 0x9E, 0x7F, 0x79, 0xF7, 0x9F, 0x1E, 0x3F, 0xE7,
  0x87, 0x8F, 0xF1, 0xE1, 0xE3, 0xFC, 0xF8, 0x78, 0xFF, 0x3E, 0x1E, 0x7F,
  0xC7, 0x8F, 0x9E, 0xF9, 0xF3, 0xE7, 0x9E, 0x7F, 0xFF, 0xC7, 0x8F, 0xFF,
  0xF1, 0xF1, 0xF9, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x02, 0x01, 0xFC,
  0x07, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF0, 0x1F, 0x87, 0xE0,
  0x7E, 0x1F, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xBF, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xFB,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xE0, 0x01, 0xF8, 0x03,
  0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF3, 0xFC, 0x71, 0xF8, 0x09,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0xCF, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFC,
  0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9,
  0xF9, 0xFF, 0xBF, 0x07, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF0, 0xFF, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0x07, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFD, 0xFC, 0x1F,
  0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFC,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFB, 0xFF, 0x7F, 0xEF, 0xF9, 0xFE, 0x3F,
  0x80, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x7E, 0x0F, 0xCF, 0xC3,
  0xF9, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE7, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF,
  0x03, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xF7, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7F, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x1E, 0xFF, 0xF7, 0xCF, 0xBF, 0xFD, 0xF3, 0xEF, 0xFF, 0x7C,
  0xF3, 0xFF, 0xCF, 0xBC, 0xFF, 0xF3, 0xFF, 0x3F, 0xFC, 0xFF, 0xCF, 0xFF,
  0x3F, 0xE3, 0xFF, 0xC7, 0xF8, 0xFF, 0xF1, 0xFE, 0x3F, 0xFC, 0x7F, 0x8F,
  0xFF, 0x1F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0x7E, 0x3F, 0xFB, 0xF1, 0xFF, 0xCF, 0xCF, 0xFE, 0x7E, 0x7F, 0xF1,
  0xFB, 0xFF, 0x8F, 0xDF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0x87, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x3F,
  0x9F, 0xC3, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x87, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0xFE, 0x03,
  0xF7, 0xF0, 0x3F, 0x9F, 0xC3, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF8,
  0xFE, 0x3F, 0x0F, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0x9F, 0x87, 0xE3, 0xF1,
  0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xE7,
  0xE0, 0xFC, 0xFE, 0x1F, 0x8F, 0xC3, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF9, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xFF,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3C, 0xFE, 0x04, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7E, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFD, 0xF8, 0x3F, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xDF, 0x80,
  0xFE, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x80, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x00, 0xFB, 0xF0, 0x07,
  0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x7E,
  0xF8, 0x0F, 0xC0, 0xFD, 0xF8, 0x1F, 0x81, 0xFB, 0xF0, 0x7F, 0x03, 0xF7,
  0xE0, 0xFE, 0x0F, 0xCF, 0xC1, 0xFE, 0x1F, 0x8F, 0x83, 0xFC, 0x3F, 0x1F,
  0x87, 0xF8, 0x7E, 0x3F, 0x1F, 0xF0, 0xF8, 0x7E, 0x3F, 0xE3, 0xF0, 0x7C,
  0x7B, 0xE7, 0xE0, 0xF8, 0xF7, 0xCF, 0xC1, 0xFB, 0xEF, 0x9F, 0x83, 0xF7,
  0xCF, 0x3E, 0x03, 0xEF, 0x9E, 0xFC, 0x07, 0xDF, 0x3F, 0xF8, 0x0F, 0xBC,
  0x7F, 0xF0, 0x1F, 0x78, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1,
  0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xFB, 0xF8, 0x3F, 0x8F, 0xC1,
  0xFC, 0x7F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xE7, 0xE0, 0x3F, 0x7E, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7E, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0x1F, 0xC3, 0xF8, 0x7E,
  0x3F, 0x83, 0xF9, 0xFC, 0x0F, 0xDF, 0xC0, 0x7F, 0xFE, 0x03, 0xF7, 0xE0,
  0x7F, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F,
  0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1F,
  0x7C, 0x07, 0x8F, 0x03, 0xE3, 0xE0, 0xF8, 0x78, 0x7C, 0x1F, 0x1F, 0x03,
  0xC7, 0x80, 0xFB, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x18, 0x3F, 0x00, 0x3F, 0x01,
  0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x3F, 0x8F, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x60, 0xFD, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9,
  0xF8, 0x00, 0xE0, 0x1F, 0xF8, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0xCF, 0xE3,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x08, 0x7E, 0x3F, 0xBF, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF,
  0xEF, 0xEF, 0xF7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xEF, 0xC3, 0xF7, 0xF7, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xBF, 0x1F, 0x8F, 0x80, 0x01, 0x80, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0x7D, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x18, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xF1, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xA3, 0xF0, 0x3F, 0x07, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0x00, 0x0F, 0xEF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF,
  0xFB, 0xF9, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFB, 0xF0, 0xFD, 0xFD, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x9F, 0xEF, 0xC7, 0xE7, 0xE0, 0x03, 0xF0, 0x01, 0xFB, 0x01,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x20, 0xFD, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x33, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x03,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF,
  0xFB, 0xFE, 0xFF, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0xFC,
  0x3F, 0x3F, 0x1F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF0, 0xFD, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xF3, 0xF8, 0xFC, 0x7F, 0x3F, 0x0F, 0xCF, 0xC3, 0xFB, 0xF0, 0x7E, 0xFC,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x08,
  0x1F, 0x3F, 0x8F, 0xE3, 0xEF, 0xFB, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFE, 0xFF, 0xBF, 0xBF, 0x8F, 0xE3, 0xF7, 0xE1, 0xF8, 0x7F,
  0xFC, 0x3F, 0x07, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFE, 0x1F,
  0x83, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0x7E, 0x0F, 0xFF, 0x0F, 0xC1, 0xFF,
  0xE1, 0xF8, 0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0xFC,
  0x1F, 0x80, 0x00, 0x60, 0xF9, 0xFC, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF,
  0xC7, 0xFF, 0xF3, 0xF1, 0xFD, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xFC, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x60, 0xF9,
  0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFD, 0xF8, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0x00, 0x0F, 0xEF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7,
  0xFF, 0xFB, 0xF9, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFB, 0xF0, 0xFD, 0xFD, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFF, 0x9F, 0xEF, 0xC7, 0xE7, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x3F, 0x9F, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0x81, 0xFF, 0x9F, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7E, 0x0B, 0xF8, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x87, 0xFE,
  0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x1F, 0x8F, 0xFC, 0x0F,
  0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x3F, 0x83, 0xF7, 0xE3, 0xFC, 0x7E,
  0x7E, 0x3F, 0xC7, 0xE7, 0xE3, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7, 0xC3, 0xE7,
  0xFC, 0x7C, 0x3F, 0x7F, 0xEF, 0xC3, 0xF7, 0xBE, 0xFC, 0x3F, 0x79, 0xEF,
  0x81, 0xF7, 0x9E, 0xF8, 0x1F, 0x79, 0xEF, 0x81, 0xFF, 0x9E, 0xF8, 0x1F,
  0xF1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0x1F, 0xEF, 0xE3,
  0xF8, 0xFC, 0x7E, 0x1F, 0xDF, 0x81, 0xFB, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F,
  0xDF, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0xBF,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xC0, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0x0F, 0xF0, 0xFC, 0x0F,
  0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x05, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x03,
  0xF0, 0x7F, 0x1F, 0xF1, 0xFC, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x0C, 0x00, 0x1C,
  0x01, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x80,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_Black33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 24, 9, 1, -24 },
  { 22, 13, 9, 17, 2, -24 },
  { 37, 19, 24, 20, 1, -24 },
  { 94, 16, 27, 18, 1, -25 },
  { 148, 28, 24, 30, 1, -24 },
  { 232, 24, 24, 24, 1, -24 },
  { 304, 5, 9, 9, 2, -24 },
  { 310, 10, 29, 11, 1, -24 },
  { 347, 9, 29, 11, 1, -24 },
  { 380, 15, 15, 17, 1, -25 },
  { 409, 16, 16, 18, 1, -20 },
  { 441, 7, 10, 10, 1, -5 },
  { 450, 9, 5, 11, 1, -11 },
  { 456, 7, 6, 9, 1, -6 },
  { 462, 14, 24, 14, 0, -24 },
  { 504, 16, 24, 18, 1, -24 },
  { 552, 13, 24, 18, 1, -24 },
  { 591, 16, 24, 18, 1, -24 },
  { 639, 16, 24, 18, 1, -24 },
  { 687, 17, 24, 18, 1, -24 },
  { 738, 15, 24, 18, 2, -24 },
  { 783, 16, 24, 18, 1, -24 },
  { 831, 16, 24, 18, 1, -24 },
  { 879, 16, 24, 18, 1, -24 },
  { 927, 16, 24, 18, 1, -24 },
  { 975, 7, 18, 9, 1, -18 },
  { 991, 7, 23, 10, 1, -18 },
  { 1012, 16, 18, 18, 1, -21 },
  { 1048, 16, 11, 18, 1, -17 },
  { 1070, 16, 18, 18, 1, -21 },
  { 1106, 15, 24, 15, 0, -24 },
  { 1151, 26, 26, 28, 1, -24 },
  { 1236, 22, 24, 22, 0, -24 },
  { 1302, 17, 24, 21, 2, -24 },
  { 1353, 17, 24, 20, 2, -24 },
  { 1404, 19, 24, 22, 2, -24 },
  { 1461, 13, 24, 17, 2, -24 },
  { 1500, 13, 24, 17, 2, -24 },
  { 1539, 19, 24, 23, 2, -24 },
  { 1596, 19, 24, 23, 2, -24 },
  { 1653, 11, 24, 13, 1, -24 },
  { 1686, 11, 31, 11, -2, -24 },
  { 1729, 19, 24, 21, 2, -24 },
  { 1786, 14, 24, 17, 2, -24 },
  { 1828, 26, 24, 30, 2, -24 },
  { 1906, 21, 24, 25, 2, -24 },
  { 1969, 21, 24, 24, 2, -24 },
  { 2032, 16, 24, 20, 2, -24 },
  { 2080, 21, 30, 24, 2, -24 },
  { 2159, 19, 24, 21, 2, -24 },
  { 2216, 16, 24, 18, 1, -24 },
  { 2264, 16, 24, 18, 1, -24 },
  { 2312, 19, 24, 23, 2, -24 },
  { 2369, 21, 24, 21, 0, -24 },
  { 2432, 31, 24, 32, 0, -24 },
  { 2525, 21, 24, 21, 0, -24 },
  { 2588, 20, 24, 20, 0, -24 },
  { 2648, 17, 24, 18, 1, -24 },
  { 2699, 8, 30, 10, 2, -24 },
  { 2729, 14, 24, 14, 0, -24 },
  { 2771, 8, 30, 10, 1, -24 },
  { 2801, 18, 16, 18, 0, -24 },
  { 2837, 17, 4, 17, 0, 2 },
  { 2846, 11, 5, 13, 1, -25 },
  { 2853, 16, 19, 19, 1, -19 },
  { 2891, 16, 25, 20, 2, -25 },
  { 2941, 15, 19, 17, 1, -19 },
  { 2977, 17, 25, 20, 1, -25 },
  { 3031, 17, 19, 19, 1, -19 },
  { 3072, 12, 25, 13, 1, -25 },
  { 3110, 17, 27, 20, 1, -19 },
  { 3168, 16, 25, 20, 2, -25 },
  { 3218, 6, 26, 10, 2, -26 },
  { 3238, 10, 34, 10, -2, -26 },
  { 3281, 18, 25, 20, 2, -25 },
  { 3338, 6, 25, 10, 2, -25 },
  { 3357, 27, 19, 30, 2, -19 },
  { 3422, 16, 19, 20, 2, -19 },
  { 3460, 17, 19, 20, 1, -19 },
  { 3501, 16, 27, 20, 2, -19 },
  { 3555, 17, 27, 20, 1, -19 },
  { 3613, 12, 19, 14, 2, -19 },
  { 3642, 13, 19, 16, 1, -19 },
  { 3673, 12, 22, 14, 1, -22 },
  { 3706, 16, 18, 20, 2, -18 },
  { 3742, 19, 18, 19, 0, -18 },
  { 3785, 28, 18, 28, 0, -18 },
  { 3848, 19, 18, 19, 0, -18 },
  { 3891, 19, 26, 19, 0, -18 },
  { 3953, 14, 18, 15, 1, -18 },
  { 3985, 12, 30, 14, 1, -24 },
  { 4030, 4, 32, 16, 6, -25 },
  { 4046, 12, 30, 14, 1, -24 },
  { 4091, 16, 7, 18, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_Black33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK33PT7B_H_
