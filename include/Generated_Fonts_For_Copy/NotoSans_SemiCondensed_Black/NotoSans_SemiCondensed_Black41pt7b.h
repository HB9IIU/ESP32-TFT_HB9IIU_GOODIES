#ifndef _NOTOSANS_SEMICONDENSED_BLACK41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xEF, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E,
  0x3F, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xF1,
  0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xF1,
  0xF0, 0x03, 0xE3, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xC7, 0xE0, 0x07, 0xC7,
  0xC0, 0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x8F, 0x80, 0x0F, 0x8F,
  0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0x73, 0xCF, 0xE7, 0x04, 0xFE, 0x70, 0x0F, 0xE7,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x77, 0xF0,
  0x07, 0x3F, 0x40, 0x73, 0xF7, 0x07, 0x7F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x10, 0x03, 0xFC,
  0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x03, 0xE0, 0x07,
  0xFF, 0x80, 0xFC, 0x01, 0xF9, 0xF8, 0x1F, 0x00, 0x3F, 0x3F, 0x07, 0xE0,
  0x07, 0xE7, 0xE0, 0xF8, 0x00, 0xFC, 0xFC, 0x3F, 0x00, 0x1F, 0x9F, 0x87,
  0xC0, 0x03, 0xF3, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x3E, 0x00, 0x0F, 0xCF,
  0xCF, 0xC7, 0xE1, 0xF9, 0xF9, 0xF1, 0xFF, 0x1F, 0xFE, 0x7E, 0x7F, 0xE3,
  0xFF, 0xCF, 0x9F, 0xFE, 0x3F, 0xF3, 0xF3, 0xFF, 0xE3, 0xFC, 0x7C, 0xFC,
  0xFC, 0x1E, 0x1F, 0x9F, 0x9F, 0x80, 0x03, 0xE3, 0xF1, 0xF0, 0x00, 0xFC,
  0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0xC7, 0xC0, 0x07, 0xE1, 0xF8, 0xF8, 0x00,
  0xF8, 0x3F, 0x1F, 0x00, 0x3F, 0x07, 0xE7, 0xE0, 0x07, 0xC0, 0x7E, 0xFC,
  0x01, 0xF8, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F,
  0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0xFF, 0x07, 0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0x8F, 0xE1, 0xFF, 0xFF,
  0x7F, 0x87, 0xFB, 0xFF, 0xFE, 0x1F, 0xC7, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFC, 0x3F, 0xFE, 0x0F, 0xF0, 0x7F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0x07, 0xE1, 0xF8, 0x7F,
  0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x08, 0x1F, 0x02, 0xE3, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0x7C, 0x07, 0xEF, 0xC1, 0xFC, 0xFC, 0x3F, 0x1F, 0x81, 0xE1, 0xC0, 0x08,
  0x20, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x9F, 0xCF, 0xE7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF8, 0xFE, 0x7F, 0x0F,
  0xF7, 0xF0, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F,
  0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x8F, 0xF7,
  0xF8, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E,
  0xFF, 0x3C, 0xFF, 0x38, 0xFF, 0x10, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x87, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xE1, 0xFE, 0x18,
  0x0F, 0xE1, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x01, 0xFF, 0xF0, 0x7F,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xF7, 0xF0, 0x1F, 0xBF, 0x81, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x7F,
  0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x10, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1F, 0xF8, 0x23, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x08, 0x07, 0xF7, 0xF8, 0x7E, 0xFF, 0xC7, 0xEF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF8, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0xFF, 0x7F, 0x0F, 0xE7, 0xF8, 0xFE,
  0x3F, 0x9F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xDF, 0xE7, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x7F,
  0x8F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xF7, 0xF0, 0xFE, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x1E, 0x3F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFC, 0xFC,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xCF, 0xE7, 0xF3, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8,
  0x03, 0xFC, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF3, 0xF3, 0xFC, 0xE0, 0x7F, 0x20, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x7E, 0x3F, 0x0F, 0xFC, 0x7C, 0xFC, 0x3F, 0xFC, 0xF9, 0xF0, 0xFF,
  0xF8, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0x8F, 0xE3, 0xE3, 0xFF, 0x1F, 0x87,
  0xC7, 0xFE, 0x3E, 0x0F, 0x8F, 0xFC, 0xFC, 0x1F, 0x1F, 0xF9, 0xF8, 0x3E,
  0x3F, 0xF3, 0xF0, 0x7C, 0x7F, 0xE7, 0xE1, 0xF8, 0xFF, 0xCF, 0xC3, 0xF1,
  0xFF, 0x8F, 0xC7, 0xE7, 0xDF, 0x1F, 0xFF, 0xFF, 0xBE, 0x1F, 0xFF, 0xFE,
  0x7E, 0x3F, 0xE7, 0xF8, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0C, 0x01, 0xFF, 0x83, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7E, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFE, 0x01, 0xFE,
  0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x3F, 0xDF,
  0xC0, 0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0xBF, 0x83, 0xFD, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF8, 0x0C, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x4F, 0xFC,
  0x0E, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x83,
  0xFF, 0x7F, 0x03, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFF, 0xBF, 0x87, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xE0,
  0x18, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xE0,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0xFF, 0xFB,
  0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0x1F,
  0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFE, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3,
  0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFD, 0xF8, 0x1F, 0x7F, 0xFB, 0xF0,
  0x7E, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xEF, 0xC3,
  0xEF, 0xFF, 0xDF, 0x8F, 0xDF, 0xFF, 0xBF, 0x1F, 0xBF, 0xFF, 0x7F, 0x3F,
  0x7F, 0xFE, 0x7E, 0x7C, 0xFF, 0xFC, 0xFD, 0xF9, 0xFF, 0xF9, 0xFB, 0xF3,
  0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFE, 0x3F, 0xFF, 0x0F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF0, 0xFF,
  0xFC, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0xF0, 0x7F, 0x07, 0xFF,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0x7F, 0x07,
  0xFF, 0xDF, 0xE1, 0xFF, 0xF3, 0xF8, 0x7F, 0xFE, 0xFF, 0x1F, 0xFF, 0x9F,
  0xC7, 0xFF, 0xE7, 0xF9, 0xFF, 0xF8, 0xFE, 0x7F, 0xFE, 0x3F, 0xDF, 0xFF,
  0x87, 0xF7, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF1, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xEF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xDF,
  0xE0, 0x1F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0x80, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0,
  0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF8, 0xFE, 0x0F,
  0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0x8F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xF9, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xFC, 0x1F,
  0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC,
  0x0F, 0xF3, 0xF8, 0x1F, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0xE0, 0x00,
  0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xF8, 0x1C, 0xFE, 0x00, 0x9F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xF7, 0xC1, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xBF, 0xE1, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE, 0x01,
  0xFE, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0,
  0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x3F,
  0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0x03, 0xF9, 0xFC, 0x03, 0xFC,
  0x07, 0xF3, 0xF8, 0x0F, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0xF0, 0x3F, 0xC7,
  0xF0, 0x3F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFF,
  0xC1, 0xFC, 0x3F, 0x83, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xFF, 0x0F, 0xF0,
  0x7F, 0x0F, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x7C, 0x3F, 0x81, 0xFC, 0x7E,
  0xFC, 0x7F, 0x01, 0xF8, 0xFD, 0xF8, 0xFE, 0x03, 0xF9, 0xFB, 0xF3, 0xF8,
  0x07, 0xF3, 0xF3, 0xE7, 0xF0, 0x0F, 0xE7, 0xC7, 0xCF, 0xE0, 0x1F, 0xDF,
  0x8F, 0xDF, 0xC0, 0x1F, 0xBF, 0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x3F, 0x7E,
  0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F,
  0xC7, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xDF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x03,
  0xFC, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE1, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x00, 0x7F, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xC7, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFC, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xFE, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFD, 0xFF,
  0x0C, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFB, 0xF3, 0xFF, 0x3F, 0x1F, 0xE1, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0x07, 0xFB, 0xFE, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0x3F, 0xE3, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xF8,
  0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xF8, 0x33, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x02, 0xFF, 0x01, 0xBF, 0xFF, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xC7, 0xF1, 0xFE, 0x7F, 0x3F, 0xF7,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0x3F,
  0x0F, 0xE3, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE7, 0xF9, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x27, 0xF8, 0x1C,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xE4, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x07, 0xC3, 0xF1, 0xFF, 0x7F, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xF7, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x78, 0x1F, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0x87, 0xFB, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xE0,
  0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x87, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE,
  0x1F, 0xE3, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xCF, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0xDF, 0xE0,
  0x7F, 0xBF, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x3F, 0xF3, 0xFF, 0x3F, 0xBF, 0xFB, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8,
  0x3F, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFC, 0x1F,
  0xE0, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0x83,
  0xFC, 0x1F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0x83, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFC, 0x1F, 0xE0, 0xFE, 0xFC,
  0x1F, 0x87, 0xF3, 0xFE, 0x3F, 0xBF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF3, 0xFC, 0x3F, 0xDF, 0xE0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xDF, 0xE0, 0xFE, 0xFF, 0x0F, 0xF3, 0xFC, 0xFF, 0x9F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFE, 0x1F, 0x07, 0xF3, 0xFE, 0x3F, 0xBF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xBF, 0xE3, 0xFC,
  0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xC3, 0xF1, 0xFF, 0x7F, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xF7, 0xF1, 0xFF, 0x7F, 0x0F,
  0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0xFC, 0x1F, 0xF8, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF3, 0xF8, 0xF3,
  0xFC, 0x08, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x40, 0x3F, 0xBE,
  0x3F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFC,
  0xFC, 0x3F, 0xC7, 0xE0, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFD, 0xFC, 0x07,
  0xF3, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0,
  0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x07, 0xFC, 0x1F, 0xDF, 0xC1, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0xC1, 0xFD,
  0xFC, 0x1F, 0xF0, 0xFF, 0x7F, 0x8F, 0xFC, 0x3F, 0x8F, 0xE3, 0xFF, 0x8F,
  0xE3, 0xF8, 0xFF, 0xE3, 0xF8, 0xFE, 0x3E, 0xF8, 0xFE, 0x3F, 0x8F, 0xBE,
  0x7F, 0x07, 0xF7, 0xEF, 0x9F, 0xC1, 0xFD, 0xFB, 0xE7, 0xF0, 0x7F, 0x7C,
  0xFD, 0xFC, 0x1F, 0xDF, 0x3F, 0x7E, 0x03, 0xF7, 0xC7, 0xDF, 0x80, 0xFD,
  0xF1, 0xF7, 0xE0, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x01,
  0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0xFF, 0x81, 0xFE, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F,
  0xC1, 0xFE, 0x7F, 0x83, 0xFD, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0x9F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x3F, 0xCF, 0xF0, 0x7F, 0xBF, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x9F,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x03, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x1F,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0x80,
  0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xE0, 0x1F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Black41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 29, 12, 2, -29 },
  { 30, 17, 10, 21, 2, -29 },
  { 52, 24, 29, 25, 1, -29 },
  { 139, 20, 33, 22, 1, -31 },
  { 222, 35, 30, 37, 1, -30 },
  { 354, 30, 30, 30, 1, -30 },
  { 467, 7, 10, 11, 2, -29 },
  { 476, 11, 36, 14, 2, -30 },
  { 526, 12, 36, 14, 1, -30 },
  { 580, 19, 19, 21, 1, -31 },
  { 626, 19, 19, 23, 2, -24 },
  { 672, 9, 12, 12, 1, -6 },
  { 686, 11, 6, 13, 1, -14 },
  { 695, 8, 7, 12, 2, -7 },
  { 702, 18, 30, 18, 0, -30 },
  { 770, 20, 30, 23, 1, -30 },
  { 845, 16, 29, 23, 2, -29 },
  { 903, 20, 30, 23, 1, -30 },
  { 978, 20, 30, 23, 1, -30 },
  { 1053, 21, 29, 23, 1, -29 },
  { 1130, 19, 29, 23, 2, -29 },
  { 1199, 20, 30, 23, 1, -30 },
  { 1274, 19, 29, 23, 2, -29 },
  { 1343, 20, 30, 23, 1, -30 },
  { 1418, 20, 30, 23, 1, -30 },
  { 1493, 8, 23, 12, 2, -23 },
  { 1516, 9, 29, 12, 1, -23 },
  { 1549, 19, 22, 23, 2, -26 },
  { 1602, 19, 15, 23, 2, -22 },
  { 1638, 19, 22, 23, 2, -26 },
  { 1691, 18, 30, 19, 0, -30 },
  { 1759, 31, 33, 35, 2, -30 },
  { 1887, 27, 29, 27, 0, -29 },
  { 1985, 21, 29, 26, 3, -29 },
  { 2062, 21, 30, 24, 2, -30 },
  { 2141, 23, 29, 28, 3, -29 },
  { 2225, 16, 29, 21, 3, -29 },
  { 2283, 16, 29, 21, 3, -29 },
  { 2341, 24, 30, 28, 2, -30 },
  { 2431, 23, 29, 29, 3, -29 },
  { 2515, 15, 29, 17, 1, -29 },
  { 2570, 14, 38, 13, -3, -29 },
  { 2637, 23, 29, 26, 3, -29 },
  { 2721, 17, 29, 22, 3, -29 },
  { 2783, 31, 29, 37, 3, -29 },
  { 2896, 26, 29, 32, 3, -29 },
  { 2991, 26, 30, 30, 2, -30 },
  { 3089, 20, 29, 24, 3, -29 },
  { 3162, 27, 37, 30, 2, -30 },
  { 3287, 23, 29, 26, 3, -29 },
  { 3371, 19, 30, 22, 2, -30 },
  { 3443, 20, 29, 22, 1, -29 },
  { 3516, 23, 29, 29, 3, -29 },
  { 3600, 26, 29, 26, 0, -29 },
  { 3695, 39, 29, 39, 0, -29 },
  { 3837, 27, 29, 27, 0, -29 },
  { 3935, 25, 29, 25, 0, -29 },
  { 4026, 21, 29, 23, 1, -29 },
  { 4103, 10, 37, 13, 2, -30 },
  { 4150, 18, 30, 18, 0, -30 },
  { 4218, 10, 37, 13, 1, -30 },
  { 4265, 22, 19, 22, 0, -29 },
  { 4318, 21, 5, 21, 0, 3 },
  { 4332, 12, 6, 16, 2, -31 },
  { 4341, 20, 23, 24, 1, -23 },
  { 4399, 21, 31, 25, 2, -31 },
  { 4481, 18, 23, 21, 2, -23 },
  { 4533, 20, 31, 25, 2, -31 },
  { 4611, 20, 23, 23, 2, -23 },
  { 4669, 16, 31, 16, 1, -31 },
  { 4731, 20, 33, 25, 2, -23 },
  { 4814, 21, 31, 25, 2, -31 },
  { 4896, 8, 32, 12, 2, -32 },
  { 4928, 12, 42, 12, -2, -32 },
  { 4991, 23, 31, 25, 2, -31 },
  { 5081, 8, 31, 12, 2, -31 },
  { 5112, 33, 23, 38, 2, -23 },
  { 5207, 21, 23, 25, 2, -23 },
  { 5268, 21, 23, 24, 2, -23 },
  { 5329, 21, 33, 25, 2, -23 },
  { 5416, 20, 33, 25, 2, -23 },
  { 5499, 15, 23, 18, 2, -23 },
  { 5543, 17, 23, 19, 1, -23 },
  { 5592, 15, 27, 17, 1, -27 },
  { 5643, 21, 23, 25, 2, -23 },
  { 5704, 23, 23, 23, 0, -23 },
  { 5771, 34, 23, 35, 0, -23 },
  { 5869, 23, 23, 24, 0, -23 },
  { 5936, 23, 33, 23, 0, -23 },
  { 6031, 17, 23, 19, 1, -23 },
  { 6080, 15, 37, 17, 1, -30 },
  { 6150, 6, 40, 20, 7, -31 },
  { 6180, 15, 37, 17, 1, -30 },
  { 6250, 19, 7, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Black41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK41PT7B_H_
