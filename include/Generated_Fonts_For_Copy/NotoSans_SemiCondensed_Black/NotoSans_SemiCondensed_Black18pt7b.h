#ifndef _NOTOSANS_SEMICONDENSED_BLACK18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0xEF, 0xDF, 0xBF, 0x7E, 0xE0, 0x0D,
  0xC1, 0xB0, 0x76, 0x0C, 0xC7, 0xFE, 0xFF, 0xC6, 0xE7, 0xFE, 0xFF, 0xDF,
  0xF8, 0xCC, 0x1B, 0x83, 0x70, 0x18, 0x18, 0x7F, 0xFF, 0xD9, 0xF8, 0xF8,
  0x7E, 0x1F, 0x1F, 0x9B, 0xFF, 0xFE, 0x18, 0x18, 0x38, 0x38, 0x7C, 0x70,
  0x6C, 0x60, 0xEE, 0xE0, 0xEE, 0xC0, 0x6D, 0xDC, 0x7D, 0xBE, 0x3B, 0xB7,
  0x03, 0x37, 0x07, 0x37, 0x06, 0x37, 0x0E, 0x3F, 0x0C, 0x1E, 0x3E, 0x07,
  0xF0, 0x77, 0x07, 0x70, 0x7F, 0x03, 0xE0, 0x7C, 0xFF, 0xEE, 0xEF, 0xEE,
  0x7C, 0xFF, 0xCF, 0xFE, 0x7E, 0xF0, 0xFF, 0xFE, 0x3B, 0x9D, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x39, 0xC7, 0xF1, 0xC3, 0x8E, 0x38, 0xE1, 0x87,
  0x1C, 0x63, 0x8E, 0x38, 0xC7, 0x38, 0x1C, 0x0E, 0x13, 0x2F, 0xFF, 0xF8,
  0xF0, 0xF8, 0xEE, 0x12, 0x00, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0xFF, 0xFD, 0x80, 0xFF, 0xFE, 0xFF, 0x80, 0x07, 0x0E, 0x0E,
  0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0x3C, 0x7E,
  0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7E, 0x3C, 0x0E,
  0x7D, 0xFF, 0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x3E,
  0x3F, 0xBF, 0xE4, 0x70, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1F, 0xEF,
  0xF7, 0xF8, 0x7C, 0xFE, 0xFF, 0x87, 0x0F, 0x7E, 0x7C, 0x7F, 0x07, 0x07,
  0xFF, 0xFE, 0xFC, 0x07, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0xC7, 0x71,
  0x9C, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x07, 0x00, 0xFE, 0xFE, 0xFE, 0xE0,
  0xE0, 0xFE, 0xFF, 0x4F, 0x07, 0x07, 0xFF, 0xFE, 0xFC, 0x1F, 0x7F, 0x7F,
  0xE0, 0xEC, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF, 0x7F, 0x3E, 0xFF, 0xFF,
  0xFF, 0x07, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x3E,
  0xFF, 0xFF, 0xE7, 0xFF, 0x7E, 0x7C, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF, 0x7E,
  0x3C, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0x37, 0x07, 0x9E, 0xFE,
  0xF8, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xEC, 0x01, 0x07,
  0x1F, 0x7C, 0xE0, 0xF8, 0x3F, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x3E, 0x07, 0x1F, 0xFC, 0xF0, 0x80, 0x7E,
  0xFF, 0x7F, 0x47, 0x07, 0x1E, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38,
  0x0F, 0xC0, 0xFF, 0xC7, 0x03, 0x19, 0xE6, 0xEF, 0xDB, 0x73, 0x7D, 0xCD,
  0xF6, 0x37, 0xDD, 0xDB, 0x3F, 0xEE, 0xF7, 0x1C, 0x00, 0x7F, 0xE0, 0x7F,
  0x80, 0x0F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1D, 0xC3, 0x9C, 0x39, 0xC3,
  0x9C, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0x0F, 0xF0, 0xF0, 0xFE, 0x3F, 0xEF,
  0xFB, 0xCE, 0xF3, 0xBF, 0xEF, 0xF3, 0xFE, 0xF3, 0xBC, 0xFF, 0xFB, 0xFE,
  0xFF, 0x00, 0x1F, 0x1F, 0xDF, 0xFE, 0x1F, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x78, 0x1F, 0xEF, 0xF3, 0xF8, 0xFE, 0x3F, 0xEF, 0xFB, 0xCF, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFF, 0xFB, 0xFC, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x8F, 0x1F, 0xFF, 0xFF, 0xF1, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x8F, 0x1F, 0xFF, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x00, 0x1F, 0x8F,
  0xF7, 0xFB, 0xC0, 0xF0, 0x39, 0xFE, 0x7F, 0x9F, 0xF1, 0xFC, 0x77, 0xFD,
  0xFF, 0x1F, 0xC0, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xC0, 0xFF, 0xF7, 0x9C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x3F, 0xFC, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xBE, 0xF0, 0xF1, 0xFE, 0x7B, 0xCE, 0x7B,
  0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF8, 0xF7, 0x1E, 0xF3, 0xCE, 0x79, 0xEF,
  0x1E, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0xFF, 0xB3,
  0xFE, 0xED, 0xFB, 0xB7, 0xEF, 0xDF, 0x9F, 0x7E, 0x79, 0xF9, 0xE7, 0xE3,
  0x9C, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFE, 0x7E, 0xE7, 0xEF, 0x7E,
  0x77, 0xE7, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xF0, 0x1F, 0x0F, 0xF9,
  0xFF, 0x78, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x3D, 0xFF,
  0xBF, 0xE1, 0xF8, 0xFE, 0x7F, 0xBF, 0xFE, 0x7F, 0x3F, 0xBF, 0xFF, 0xFE,
  0xFC, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0xFC, 0x7F, 0xCF, 0x1E,
  0xF0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF0, 0xEF, 0x1E, 0x7F, 0xE7, 0xFC,
  0x1F, 0x80, 0x3C, 0x03, 0xC0, 0x1F, 0xFE, 0x3F, 0xCF, 0xFB, 0xCE, 0xF3,
  0xBD, 0xEF, 0xF3, 0xF8, 0xFF, 0x3D, 0xCF, 0x7B, 0xCF, 0xF1, 0xC0, 0x3E,
  0xFF, 0xFE, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xFF, 0xFE, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x77, 0xFD, 0xFE, 0x3F, 0x00, 0xF0, 0xFF, 0x0E, 0x71,
  0xE7, 0x1E, 0x79, 0xC3, 0x9C, 0x3B, 0xC3, 0xB8, 0x1F, 0x81, 0xF8, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xE1, 0xC3, 0xF8, 0xE3, 0xDC, 0x79, 0xCE, 0x7C,
  0xE7, 0x3E, 0x73, 0x9B, 0x38, 0xED, 0xBC, 0x76, 0xFC, 0x3F, 0x7E, 0x1F,
  0x9F, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE7, 0x9E, 0x3B,
  0xC3, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xFC, 0x79,
  0xC7, 0x1E, 0xF0, 0xF0, 0xF1, 0xEE, 0x39, 0xE7, 0x1D, 0xC3, 0xB8, 0x3E,
  0x07, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x7F, 0xDF,
  0xF7, 0xF8, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xFF, 0xE0,
  0x60, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x07,
  0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF, 0x0C, 0x07,
  0x01, 0xE0, 0xF8, 0x37, 0x1C, 0xC6, 0x3B, 0x86, 0xE1, 0xC0, 0xFF, 0xFF,
  0xC0, 0xF3, 0x8E, 0x7E, 0x7F, 0x67, 0x07, 0x7F, 0xFF, 0xE7, 0xE7, 0xFF,
  0xFB, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xF7, 0xFB, 0xFF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFE, 0xFF, 0xF7, 0x78, 0x3F, 0x7E, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF6, 0x7E, 0x3E, 0x07, 0x83, 0xC1, 0xE0, 0xF7, 0xBF, 0xFF, 0xFF, 0xCF,
  0xE3, 0xF1, 0xF8, 0xFE, 0xFF, 0xFB, 0xDC, 0x3E, 0x3F, 0xB9, 0xDC, 0x7F,
  0xFF, 0xFF, 0x81, 0xE2, 0x7F, 0x1F, 0x80, 0x1E, 0x7C, 0xF9, 0xC7, 0xFF,
  0xFF, 0x9C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x7B, 0xFF, 0xFD, 0xFC,
  0xFE, 0x3F, 0x1F, 0x8F, 0xEF, 0xFF, 0xBF, 0xC1, 0xF8, 0xEF, 0xF7, 0xF0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xF7, 0xFF, 0xFF, 0xE7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1C, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xCE,
  0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xF7, 0xFF, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE3, 0xF9, 0xEE, 0xF3, 0xB8, 0xFE, 0x3F, 0x8F, 0xF3,
  0x9E, 0xE3, 0xB8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xEF, 0x79,
  0xFF, 0xFB, 0xFF, 0xF7, 0x9C, 0xFE, 0x39, 0xFC, 0x73, 0xF8, 0xE7, 0xF1,
  0xCF, 0xE3, 0x9F, 0xC7, 0x3C, 0xEF, 0x7F, 0xFF, 0xFE, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xEF, 0x7F, 0x1F, 0x00, 0xEF, 0x7F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xFF, 0xFF, 0x77, 0xB8, 0x1C, 0x0E, 0x07, 0x00, 0x7B, 0xFF, 0xFD,
  0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xEF, 0xFF, 0xBF, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0xEF, 0xFF, 0xF7, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x7D, 0xFF,
  0x97, 0x8F, 0xCF, 0xC7, 0xC7, 0xFF, 0xF8, 0x38, 0x71, 0xFF, 0xFF, 0xEF,
  0x1E, 0x3C, 0x78, 0x74, 0xF9, 0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xEF, 0xFF, 0xBD, 0xC0, 0xF1, 0xDC, 0xF7, 0x39, 0xCE, 0x3B,
  0x8F, 0xC3, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0xE3, 0xCE, 0xE7, 0x9D, 0xDF,
  0x73, 0xB6, 0xE7, 0x6D, 0xC6, 0xDB, 0x8D, 0xBE, 0x1F, 0x7C, 0x3C, 0x78,
  0x38, 0xF0, 0xF3, 0xDE, 0xE3, 0xF8, 0xFC, 0x1F, 0x07, 0xC3, 0xF0, 0xFE,
  0x73, 0xBC, 0xF0, 0xF1, 0xDC, 0xF7, 0x39, 0xCE, 0x3B, 0x8F, 0xC3, 0xF0,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x7C, 0x1E, 0x00, 0x7F, 0x7F, 0x7F,
  0x0E, 0x1C, 0x3C, 0x78, 0x7F, 0xFF, 0xFF, 0x0E, 0x3C, 0xF1, 0xC3, 0x87,
  0x0E, 0x7C, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x87, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF1, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x0F, 0x1E, 0x78, 0xE1,
  0xC3, 0x8F, 0x3E, 0x78, 0xF1, 0xFF, 0x9F,
};

const GFXglyph NotoSans_SemiCondensed_Black18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 7, 5, 9, 1, -13 },
  { 11, 11, 13, 11, 0, -13 },
  { 29, 8, 15, 10, 1, -14 },
  { 44, 16, 13, 16, 0, -13 },
  { 70, 12, 13, 13, 1, -13 },
  { 90, 3, 5, 5, 1, -13 },
  { 92, 5, 16, 6, 1, -13 },
  { 102, 6, 16, 6, 0, -13 },
  { 114, 9, 9, 9, 0, -14 },
  { 125, 8, 9, 10, 1, -11 },
  { 134, 3, 6, 5, 1, -3 },
  { 137, 5, 3, 6, 0, -6 },
  { 139, 3, 3, 5, 1, -3 },
  { 141, 8, 13, 8, 0, -13 },
  { 154, 8, 13, 10, 1, -13 },
  { 167, 7, 13, 10, 1, -13 },
  { 179, 9, 13, 10, 0, -13 },
  { 194, 8, 13, 10, 1, -13 },
  { 207, 10, 13, 10, 0, -13 },
  { 224, 8, 13, 10, 1, -13 },
  { 237, 8, 13, 10, 1, -13 },
  { 250, 8, 13, 10, 1, -13 },
  { 263, 8, 13, 10, 1, -13 },
  { 276, 8, 13, 10, 1, -13 },
  { 289, 3, 10, 5, 1, -10 },
  { 293, 3, 13, 5, 1, -10 },
  { 298, 8, 9, 10, 1, -11 },
  { 307, 8, 7, 10, 1, -10 },
  { 314, 8, 9, 10, 1, -11 },
  { 323, 8, 13, 8, 0, -13 },
  { 336, 14, 14, 15, 1, -13 },
  { 361, 12, 13, 12, 0, -13 },
  { 381, 10, 13, 11, 1, -13 },
  { 398, 9, 13, 11, 1, -13 },
  { 413, 10, 13, 12, 1, -13 },
  { 430, 7, 13, 9, 1, -13 },
  { 442, 7, 13, 9, 1, -13 },
  { 454, 10, 13, 12, 1, -13 },
  { 471, 10, 13, 13, 1, -13 },
  { 488, 6, 13, 7, 1, -13 },
  { 498, 6, 17, 6, -1, -13 },
  { 511, 11, 13, 11, 1, -13 },
  { 529, 8, 13, 9, 1, -13 },
  { 542, 14, 13, 16, 1, -13 },
  { 565, 12, 13, 14, 1, -13 },
  { 585, 11, 13, 13, 1, -13 },
  { 603, 9, 13, 11, 1, -13 },
  { 618, 12, 16, 13, 1, -13 },
  { 642, 10, 13, 11, 1, -13 },
  { 659, 8, 13, 10, 1, -13 },
  { 672, 9, 13, 10, 0, -13 },
  { 687, 10, 13, 13, 1, -13 },
  { 704, 12, 13, 12, 0, -13 },
  { 724, 17, 13, 17, 0, -13 },
  { 752, 12, 13, 12, 0, -13 },
  { 772, 11, 13, 11, 0, -13 },
  { 790, 10, 13, 10, 0, -13 },
  { 807, 4, 16, 6, 1, -13 },
  { 815, 8, 13, 8, 0, -13 },
  { 828, 5, 16, 6, 0, -13 },
  { 838, 10, 9, 10, 0, -13 },
  { 850, 9, 2, 9, 0, 1 },
  { 853, 5, 3, 7, 1, -14 },
  { 855, 8, 10, 10, 1, -10 },
  { 865, 9, 14, 11, 1, -14 },
  { 881, 8, 10, 9, 1, -10 },
  { 891, 9, 14, 11, 1, -14 },
  { 907, 9, 10, 10, 1, -10 },
  { 919, 7, 14, 7, 0, -14 },
  { 932, 9, 14, 11, 1, -10 },
  { 948, 9, 14, 11, 1, -14 },
  { 964, 3, 14, 5, 1, -14 },
  { 970, 5, 18, 5, -1, -14 },
  { 982, 10, 14, 11, 1, -14 },
  { 1000, 3, 14, 5, 1, -14 },
  { 1006, 15, 10, 17, 1, -10 },
  { 1025, 9, 10, 11, 1, -10 },
  { 1037, 9, 10, 11, 1, -10 },
  { 1049, 9, 14, 11, 1, -10 },
  { 1065, 9, 14, 11, 1, -10 },
  { 1081, 7, 10, 8, 1, -10 },
  { 1090, 7, 10, 9, 1, -10 },
  { 1099, 7, 12, 8, 0, -12 },
  { 1110, 9, 10, 11, 1, -10 },
  { 1122, 10, 10, 10, 0, -10 },
  { 1135, 15, 10, 15, 0, -10 },
  { 1154, 10, 10, 10, 0, -10 },
  { 1167, 10, 14, 10, 0, -10 },
  { 1185, 8, 10, 8, 0, -10 },
  { 1195, 7, 16, 7, 0, -13 },
  { 1209, 2, 18, 9, 3, -14 },
  { 1214, 7, 16, 7, 0, -13 },
  { 1228, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Black18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK18PT7B_H_
