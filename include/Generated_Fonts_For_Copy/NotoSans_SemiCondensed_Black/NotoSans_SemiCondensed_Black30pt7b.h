#ifndef _NOTOSANS_SEMICONDENSED_BLACK30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0x7C, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x1E, 0xF1,
  0xEF, 0x1E, 0xF1, 0xE0, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3,
  0x80, 0xF3, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC,
  0x39, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8E,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x7E, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xBF, 0xBE, 0xE2, 0xFB, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xC0, 0xEF, 0x83, 0xBF, 0x8E, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF8, 0xFF, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x00,
  0x1F, 0xC0, 0x7C, 0x07, 0xF8, 0x1E, 0x03, 0xFE, 0x0F, 0x80, 0xF3, 0xC3,
  0xC0, 0x3C, 0xF1, 0xF0, 0x0F, 0x3C, 0x78, 0x03, 0xCF, 0x3E, 0x00, 0xF3,
  0xCF, 0x00, 0x3C, 0xF7, 0xCF, 0x8F, 0xFD, 0xE7, 0xF1, 0xFE, 0xFB, 0xFE,
  0x3F, 0x3C, 0xF7, 0x83, 0x9F, 0x79, 0xE0, 0x07, 0x9E, 0x7C, 0x03, 0xE7,
  0x9F, 0x00, 0xF1, 0xE7, 0xC0, 0x78, 0x79, 0xE0, 0x1E, 0x0F, 0x78, 0x0F,
  0x03, 0xFE, 0x03, 0xC0, 0x7F, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1E,
  0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xF8, 0x7C, 0x7F, 0xC7, 0xE7, 0xFF, 0x3F, 0x7E, 0xFF, 0xF3, 0xF3, 0xFF,
  0x9F, 0x8F, 0xF8, 0xFC, 0x7F, 0xC7, 0xF3, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0xFF, 0xFF, 0xEF, 0x7B, 0xC0,
  0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC3,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E,
  0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0xE7, 0x3B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC0, 0x7F, 0x83, 0xFE, 0x1F, 0x7C, 0x3C, 0xF8, 0x23, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0x7D, 0xF7, 0xDE, 0x7B, 0xEF, 0xBC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7B, 0xFF, 0xFF, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0x80, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0xC7,
  0xFF, 0x8F, 0x9F, 0xBF, 0x1F, 0x7E, 0x3E, 0xFC, 0x7D, 0xF8, 0xFB, 0xF1,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xBF, 0x1F, 0x7E, 0x3E, 0x7C, 0x7C,
  0xFD, 0xF9, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x7F, 0x0F, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0x7D, 0xF3, 0x9F, 0x11, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0x80, 0xFF, 0x87, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFD, 0xE3, 0xF2, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFE, 0x7F, 0xFC, 0x83, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x7F, 0xC1, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x07,
  0xFE, 0x0F, 0x7C, 0x3F, 0xF8, 0x7B, 0xF1, 0xE7, 0xE7, 0xCF, 0xCF, 0x1F,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCC,
  0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC3, 0xFF, 0x8F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF9, 0xF1, 0xF7, 0xF3,
  0xFF, 0xF7, 0xFF, 0xEF, 0xC7, 0xDF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7E, 0xFD, 0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF,
  0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7E, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80,
  0xFF, 0x87, 0xFF, 0x8F, 0xDF, 0xBF, 0x1F, 0x7C, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0x80, 0x3F,
  0xC0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xDF, 0x9F, 0xBE, 0x1F, 0x7C, 0x3E,
  0xF8, 0x7D, 0xF8, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFB, 0xC7, 0xFF, 0x87,
  0x9F, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE,
  0x0F, 0xF0, 0x00, 0x39, 0xFF, 0xFF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7C, 0x39, 0xFF, 0xFF, 0x7C, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF7, 0xDF, 0x7B, 0xEF, 0xBE, 0xF0, 0x00, 0x04, 0x00, 0x30,
  0x03, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x0F,
  0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFC,
  0x0F, 0xF1, 0xFF, 0x9F, 0xF0, 0xFF, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00,
  0x07, 0x80, 0xFF, 0x8F, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0x83, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x7F, 0xBF, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x07, 0x8F, 0x1F, 0xE7, 0xBC,
  0x7F, 0xEF, 0x79, 0xFF, 0x9E, 0xE7, 0xC7, 0x1F, 0xCF, 0x1E, 0x3F, 0x9E,
  0x3C, 0x7F, 0x3C, 0x78, 0xFE, 0x78, 0xF3, 0xFC, 0xF1, 0xE7, 0xF9, 0xFF,
  0xFE, 0x71, 0xFF, 0xFC, 0xF1, 0xFB, 0xF1, 0xF0, 0x80, 0x81, 0xF0, 0x00,
  0x03, 0xF0, 0x0E, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7D, 0xE0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x01, 0xF9,
  0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFF, 0xFC, 0xFF,
  0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x00,
  0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x06, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0x3F, 0x9E, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xC7, 0xF7, 0xE1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFD, 0xF8, 0x7E, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xE0, 0xC7, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xDF, 0x1F, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7F, 0x0F, 0xCF, 0xE3,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xE3, 0xE0, 0xFC, 0x1F, 0xFE,
  0x1F, 0xBF, 0x1F, 0x9F, 0x8F, 0xCF, 0xCF, 0xC7, 0xE7, 0xE3, 0xF7, 0xE1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x87, 0xEF, 0xC3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F,
  0x0F, 0xDF, 0x87, 0xEF, 0xC1, 0xF8, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFB, 0xC7, 0xBF, 0xF7, 0x8F, 0x7F, 0xEF, 0x9E,
  0xFF, 0xDF, 0x7D, 0xFF, 0x9E, 0xF3, 0xFF, 0x3F, 0xE7, 0xFE, 0x7F, 0xCF,
  0xFC, 0x7F, 0x1F, 0xF8, 0xFE, 0x3F, 0xF1, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF,
  0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xE0, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xFB, 0xE3, 0xFF, 0x7E, 0x7F, 0xE7, 0xCF, 0xFC, 0xFD, 0xFF, 0x8F,
  0xBF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFE, 0x01, 0xF0, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE3, 0xF9, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xCF,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7D, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE3, 0xF9, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0xC3, 0xF3, 0xE1, 0xF9,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x3F, 0x0F, 0xDF, 0x87, 0xEF, 0xC1, 0xF8,
  0x07, 0x80, 0x7F, 0xE3, 0xFF, 0xDF, 0xFE, 0x7F, 0xFB, 0xF0, 0x6F, 0xC0,
  0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x7F, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0x87,
  0xFF, 0x80, 0xFF, 0x80, 0xFC, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0xFC, 0x1F,
  0x1F, 0x83, 0xF3, 0xE0, 0x7E, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F,
  0x7C, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x0F, 0x81, 0xF7, 0xC1, 0xF8,
  0x1F, 0x7C, 0x1F, 0x83, 0xF7, 0xC1, 0xFC, 0x3F, 0x7E, 0x1F, 0xC3, 0xE3,
  0xE1, 0xFC, 0x3E, 0x3E, 0x3F, 0xC3, 0xE3, 0xE3, 0xFC, 0x7E, 0x3E, 0x3D,
  0xE7, 0xC1, 0xF3, 0xDE, 0x7C, 0x1F, 0x7D, 0xE7, 0xC1, 0xF7, 0xDE, 0x7C,
  0x1F, 0x79, 0xEF, 0x81, 0xF7, 0x8F, 0xF8, 0x0F, 0x78, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xEF, 0xC1,
  0xF8, 0xFC, 0x7E, 0x0F, 0x8F, 0xC1, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFD, 0xF8, 0x1F, 0x9F,
  0x87, 0xE3, 0xF1, 0xF8, 0x3F, 0x3F, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x83, 0xE7, 0xE1, 0xF8, 0xFC, 0x7C, 0x3F, 0x3F, 0x07, 0xCF, 0xC1,
  0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF,
  0xFF, 0xF8, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x3C, 0x7C, 0x3E,
  0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0xE0, 0x7F, 0xF0,
  0xFF, 0xF1, 0xFF, 0xE1, 0x8F, 0xC0, 0x0F, 0x80, 0x7F, 0x9F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xDF, 0x3F, 0x3E, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x78, 0x7D, 0xFC, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF,
  0xF7, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF8, 0xFF, 0xF3, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3C, 0xFC, 0x00,
  0x07, 0xE0, 0xFF, 0xCF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x17, 0xE1, 0xBF, 0xFC, 0xFF,
  0xE7, 0xFF, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC3, 0xCF, 0x9F, 0xDF, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7D, 0xF9, 0xFB, 0xFF, 0xF7, 0xFF, 0xE7, 0xF7, 0xC7, 0xC7, 0x80,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xE7, 0xDF, 0x87, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x4F, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x0F, 0xC3, 0xFC, 0xFF,
  0x9F, 0xE3, 0xE0, 0x7C, 0x0F, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0x0F, 0x3E, 0x7F, 0x7C, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xF7, 0xE7, 0xEF, 0xFF, 0xDF, 0xFF, 0x9F, 0xDF, 0x1F, 0x3E,
  0x00, 0x7C, 0x01, 0xFB, 0x07, 0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x1F,
  0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x7C, 0x7D, 0xFC, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xF7,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0xBF, 0xFF, 0xFF, 0xFE, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF8, 0x7E, 0xF8, 0x7C,
  0xF8, 0xFC, 0xF9, 0xF8, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFD, 0xF8, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8, 0x7E,
  0xF8, 0x7E, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xF0, 0x78, 0xF3, 0xF9,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E,
  0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF1, 0xF1,
  0xE7, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7E, 0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFC, 0x7E, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0xF1, 0xE1, 0xF7, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF,
  0xFF, 0xDF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xE3, 0xFF, 0xCF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0xFB, 0xF1,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x0F, 0x3E, 0x7F, 0x7C, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xF7,
  0xE7, 0xEF, 0xFF, 0xDF, 0xFF, 0x9F, 0xDF, 0x1F, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF1, 0xFE,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFD, 0xFE, 0xBF, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83,
  0xFF, 0x7F, 0xFF, 0xFE, 0xF8, 0x6F, 0xC0, 0xFF, 0x07, 0xFC, 0x7F, 0xE1,
  0xFF, 0x07, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF1, 0x3F, 0xE7,
  0xFC, 0xFF, 0x8F, 0xF0, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xDF, 0x3F, 0x3E,
  0xFC, 0x1F, 0xFE, 0x0F, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xE3, 0xF1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x03, 0xDF, 0x01,
  0xEF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0,
  0x00, 0xFC, 0x3F, 0x0F, 0xBE, 0x3F, 0x87, 0xDF, 0x1F, 0xC7, 0xEF, 0x8F,
  0xE3, 0xE7, 0xC7, 0xF9, 0xF1, 0xF3, 0xFC, 0xF8, 0xFB, 0xDE, 0x7C, 0x7D,
  0xEF, 0x7C, 0x3E, 0xF7, 0xBE, 0x0F, 0x7B, 0xDF, 0x07, 0xBC, 0xFF, 0x83,
  0xDC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0xBF, 0x1F, 0x8F,
  0x8F, 0xC7, 0xEF, 0xC1, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xF7, 0xC1, 0xFB,
  0xF0, 0xF8, 0xFC, 0xFC, 0x7E, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xFE, 0x0F,
  0xDF, 0x07, 0xCF, 0xC3, 0xE7, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3E,
  0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x03, 0xDF, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF3, 0xFC, 0xFE, 0x3E, 0x0F, 0xE3, 0xF8, 0x3F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7F, 0x1F, 0xC3, 0xF0, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0xE1, 0xFE, 0x0F, 0xC3, 0xF8, 0xFF,
  0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x87, 0xF0, 0xFE,
  0x1F, 0x83, 0xE0, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Black30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 21, 8, 1, -21 },
  { 17, 12, 7, 15, 2, -21 },
  { 28, 17, 21, 19, 1, -21 },
  { 73, 14, 25, 16, 1, -23 },
  { 117, 26, 22, 27, 1, -22 },
  { 189, 21, 22, 22, 1, -22 },
  { 247, 5, 7, 8, 2, -21 },
  { 252, 9, 27, 10, 1, -22 },
  { 283, 8, 27, 10, 1, -22 },
  { 310, 14, 14, 15, 1, -23 },
  { 335, 14, 15, 17, 1, -18 },
  { 362, 6, 8, 9, 1, -4 },
  { 368, 8, 4, 10, 1, -10 },
  { 372, 6, 5, 8, 1, -5 },
  { 376, 13, 22, 13, 0, -22 },
  { 412, 15, 22, 17, 1, -22 },
  { 454, 12, 21, 17, 1, -21 },
  { 486, 14, 22, 17, 1, -22 },
  { 525, 14, 22, 17, 1, -22 },
  { 564, 15, 21, 17, 1, -21 },
  { 604, 14, 21, 17, 1, -21 },
  { 641, 15, 22, 17, 1, -22 },
  { 683, 15, 21, 17, 1, -21 },
  { 723, 15, 22, 17, 1, -22 },
  { 765, 15, 22, 17, 1, -22 },
  { 807, 6, 17, 9, 1, -17 },
  { 820, 6, 21, 9, 1, -17 },
  { 836, 14, 16, 17, 1, -19 },
  { 864, 14, 11, 17, 1, -16 },
  { 884, 14, 16, 17, 1, -19 },
  { 912, 14, 22, 14, 0, -22 },
  { 951, 23, 24, 25, 1, -22 },
  { 1020, 20, 21, 20, 0, -21 },
  { 1073, 16, 21, 19, 2, -21 },
  { 1115, 16, 22, 18, 1, -22 },
  { 1159, 17, 21, 20, 2, -21 },
  { 1204, 12, 21, 15, 2, -21 },
  { 1236, 12, 21, 15, 2, -21 },
  { 1268, 18, 22, 21, 1, -22 },
  { 1318, 17, 21, 21, 2, -21 },
  { 1363, 10, 21, 12, 1, -21 },
  { 1390, 10, 28, 10, -2, -21 },
  { 1425, 17, 21, 19, 2, -21 },
  { 1470, 13, 21, 16, 2, -21 },
  { 1505, 23, 21, 27, 2, -21 },
  { 1566, 19, 21, 23, 2, -21 },
  { 1616, 20, 22, 22, 1, -22 },
  { 1671, 15, 21, 18, 2, -21 },
  { 1711, 20, 27, 22, 1, -22 },
  { 1779, 17, 21, 19, 2, -21 },
  { 1824, 14, 22, 16, 1, -22 },
  { 1863, 15, 21, 16, 1, -21 },
  { 1903, 17, 21, 21, 2, -21 },
  { 1948, 19, 21, 19, 0, -21 },
  { 1998, 28, 21, 29, 0, -21 },
  { 2072, 19, 21, 19, 0, -21 },
  { 2122, 18, 21, 18, 0, -21 },
  { 2170, 15, 21, 17, 1, -21 },
  { 2210, 7, 27, 9, 2, -22 },
  { 2234, 13, 22, 13, 0, -22 },
  { 2270, 7, 27, 9, 1, -22 },
  { 2294, 16, 14, 16, 0, -21 },
  { 2322, 15, 4, 15, 0, 2 },
  { 2330, 9, 5, 12, 1, -23 },
  { 2336, 15, 17, 17, 1, -17 },
  { 2368, 15, 23, 18, 2, -23 },
  { 2412, 13, 17, 15, 1, -17 },
  { 2440, 15, 23, 18, 1, -23 },
  { 2484, 15, 17, 17, 1, -17 },
  { 2516, 11, 23, 11, 1, -23 },
  { 2548, 15, 24, 18, 1, -17 },
  { 2593, 15, 23, 19, 2, -23 },
  { 2637, 5, 23, 9, 2, -23 },
  { 2652, 8, 30, 9, -1, -23 },
  { 2682, 16, 23, 18, 2, -23 },
  { 2728, 5, 23, 9, 2, -23 },
  { 2743, 24, 17, 28, 2, -17 },
  { 2794, 15, 17, 19, 2, -17 },
  { 2826, 16, 17, 18, 1, -17 },
  { 2860, 15, 24, 18, 2, -17 },
  { 2905, 15, 24, 18, 1, -17 },
  { 2950, 11, 17, 13, 2, -17 },
  { 2974, 12, 17, 14, 1, -17 },
  { 3000, 11, 20, 13, 1, -20 },
  { 3028, 15, 17, 19, 2, -17 },
  { 3060, 17, 17, 17, 0, -17 },
  { 3097, 25, 17, 25, 0, -17 },
  { 3151, 17, 17, 17, 0, -17 },
  { 3188, 17, 24, 17, 0, -17 },
  { 3239, 12, 17, 14, 1, -17 },
  { 3265, 10, 27, 12, 1, -22 },
  { 3299, 4, 30, 14, 5, -23 },
  { 3314, 11, 27, 12, 1, -22 },
  { 3352, 14, 5, 17, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Black30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK30PT7B_H_
