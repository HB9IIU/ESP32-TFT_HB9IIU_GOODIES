#ifndef _NOTOSANS_SEMICONDENSED_BLACK7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black7pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0xF4, 0x5F, 0x6F, 0x60, 0x7C, 0x6D, 0xE0, 0xCA, 0xCD,
  0xCB, 0x6C, 0x63, 0x9B, 0xFF, 0x80, 0xE0, 0x7A, 0xD0, 0x55, 0x70, 0xEF,
  0x80, 0x4F, 0x40, 0xE0, 0xC0, 0xC0, 0x29, 0x28, 0x6F, 0xFF, 0x60, 0x7C,
  0x92, 0xEA, 0x24, 0xF0, 0xE2, 0x63, 0xE0, 0x26, 0xEF, 0x20, 0x6C, 0xE3,
  0xE0, 0x6C, 0xFF, 0x60, 0xF2, 0x26, 0x40, 0x6F, 0x6B, 0xE0, 0x6B, 0xF2,
  0x60, 0xC3, 0xC3, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3, 0xC0, 0xE5, 0x04,
  0x79, 0xDB, 0x6E, 0x48, 0x40, 0x63, 0x95, 0xED, 0x80, 0xFD, 0xFD, 0xF0,
  0x7C, 0xCC, 0x70, 0xFD, 0xDD, 0xF0, 0xFB, 0xEE, 0xFB, 0xEC, 0x7C, 0xFD,
  0x70, 0xDD, 0xFD, 0xD0, 0xE9, 0x2E, 0x24, 0x93, 0xF0, 0xDF, 0xB9, 0xED,
  0x00, 0xDB, 0x6E, 0xCF, 0xBF, 0x7D, 0xF4, 0xCF, 0x7B, 0xBD, 0x80, 0x76,
  0xF7, 0xB7, 0x00, 0xFD, 0xFC, 0xC0, 0x76, 0xF7, 0xB7, 0x0C, 0xFD, 0xFF,
  0xD0, 0x7C, 0x63, 0xE0, 0xF6, 0x66, 0x60, 0xDD, 0xDD, 0x70, 0xDE, 0x9C,
  0xC6, 0x00, 0x97, 0xE9, 0xD3, 0x66, 0xC0, 0xD3, 0x98, 0xED, 0x80, 0xD7,
  0x66, 0x60, 0xF2, 0x64, 0xF0, 0xEA, 0xB0, 0x89, 0x22, 0xD5, 0x70, 0x46,
  0xB0, 0xF0, 0xC0, 0x63, 0xFD, 0xCF, 0xDD, 0xF0, 0x7B, 0x30, 0x35, 0xFD,
  0x70, 0x6D, 0xE7, 0x7D, 0x24, 0x7D, 0xD7, 0xB6, 0xCF, 0xDD, 0xD0, 0xFF,
  0xC0, 0xFF, 0xF8, 0xCD, 0xEE, 0xD0, 0xFF, 0xC0, 0xFF, 0x5D, 0x75, 0xFD,
  0xDD, 0x6D, 0xD6, 0xFD, 0xDF, 0xCC, 0x7D, 0xD7, 0x11, 0xBB, 0x60, 0xF9,
  0xF0, 0x5D, 0x26, 0xDD, 0xD7, 0x9E, 0x66, 0xB7, 0xF7, 0x96, 0xF6, 0x6F,
  0x97, 0x66, 0x4C, 0xED, 0x70, 0x69, 0x64, 0xC0, 0xFE, 0xC9, 0x35, 0x80,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Black7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 4, 0, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 6, 5, 6, 0, -5 },
  { 14, 5, 5, 5, 0, -5 },
  { 18, 2, 2, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 2, 6, 2, 0, -5 },
  { 23, 3, 3, 4, 0, -5 },
  { 25, 4, 3, 4, 0, -4 },
  { 27, 2, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -2 },
  { 29, 2, 1, 2, 0, -1 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 2, 4, 2, 0, -4 },
  { 62, 2, 5, 2, 0, -4 },
  { 64, 4, 3, 4, 0, -4 },
  { 66, 4, 3, 4, 0, -4 },
  { 68, 4, 3, 4, 0, -4 },
  { 70, 3, 5, 3, 0, -5 },
  { 72, 6, 6, 6, 0, -5 },
  { 77, 5, 5, 5, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 4, 5, 5, 0, -5 },
  { 90, 3, 5, 4, 0, -5 },
  { 92, 3, 5, 4, 0, -5 },
  { 94, 4, 5, 5, 0, -5 },
  { 97, 4, 5, 5, 0, -5 },
  { 100, 3, 5, 3, 0, -5 },
  { 102, 3, 7, 2, -1, -5 },
  { 105, 5, 5, 4, 0, -5 },
  { 109, 3, 5, 4, 0, -5 },
  { 111, 6, 5, 6, 0, -5 },
  { 115, 5, 5, 5, 0, -5 },
  { 119, 5, 5, 5, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 5, 6, 5, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 4, 5, 5, 0, -5 },
  { 142, 5, 5, 5, 0, -5 },
  { 146, 7, 5, 7, 0, -5 },
  { 151, 5, 5, 5, 0, -5 },
  { 155, 4, 5, 4, 0, -5 },
  { 158, 4, 5, 4, 0, -5 },
  { 161, 2, 6, 2, 0, -5 },
  { 163, 3, 5, 3, 0, -5 },
  { 165, 2, 6, 2, 0, -5 },
  { 167, 4, 3, 4, 0, -5 },
  { 169, 4, 1, 4, 0, 0 },
  { 170, 2, 1, 3, 0, -5 },
  { 171, 4, 4, 4, 0, -4 },
  { 173, 4, 5, 4, 0, -5 },
  { 176, 3, 4, 4, 0, -4 },
  { 178, 4, 5, 4, 0, -5 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 3, 5, 3, 0, -5 },
  { 185, 4, 6, 4, 0, -4 },
  { 188, 4, 5, 4, 0, -5 },
  { 191, 2, 5, 2, 0, -5 },
  { 193, 2, 7, 2, 0, -5 },
  { 195, 4, 5, 4, 0, -5 },
  { 198, 2, 5, 2, 0, -5 },
  { 200, 6, 4, 6, 0, -4 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 6, 4, 0, -4 },
  { 210, 4, 6, 4, 0, -4 },
  { 213, 3, 4, 3, 0, -4 },
  { 215, 3, 4, 3, 0, -4 },
  { 217, 3, 5, 3, 0, -5 },
  { 219, 4, 4, 4, 0, -4 },
  { 221, 4, 4, 4, 0, -4 },
  { 223, 6, 4, 6, 0, -4 },
  { 226, 4, 4, 4, 0, -4 },
  { 228, 4, 6, 4, 0, -4 },
  { 231, 3, 4, 3, 0, -4 },
  { 233, 3, 6, 3, 0, -5 },
  { 236, 1, 7, 3, 1, -5 },
  { 237, 3, 6, 3, 0, -5 },
  { 240, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Black7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK7PT7B_H_
