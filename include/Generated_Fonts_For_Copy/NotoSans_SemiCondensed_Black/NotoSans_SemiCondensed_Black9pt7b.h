#ifndef _NOTOSANS_SEMICONDENSED_BLACK9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x70, 0xD5, 0x2F, 0xDD, 0xF5, 0x28, 0x23, 0xB8, 0xE3, 0xFD,
  0xC4, 0x40, 0xE4, 0xA8, 0xEE, 0x55, 0x15, 0x27, 0x20, 0xF1, 0xE3, 0xAF,
  0xDB, 0x9F, 0x80, 0xD0, 0x69, 0x6D, 0x93, 0xC9, 0xB6, 0xDE, 0x2B, 0x77,
  0x27, 0xC8, 0x40, 0x70, 0xE0, 0x70, 0x33, 0x26, 0x44, 0xC0, 0x23, 0xB7,
  0xBD, 0xA9, 0xC0, 0x7F, 0x33, 0x33, 0x27, 0x94, 0x66, 0x23, 0xE0, 0x27,
  0x84, 0xC1, 0x4F, 0xC0, 0x33, 0x95, 0xFF, 0x88, 0x72, 0x1C, 0x39, 0xF8,
  0x13, 0x91, 0xED, 0xED, 0xC0, 0xF8, 0x8C, 0x66, 0x30, 0x23, 0xB6, 0xED,
  0x6D, 0xC0, 0x23, 0xB7, 0xB7, 0x89, 0xC0, 0xD1, 0xC0, 0xD0, 0x70, 0x09,
  0xF8, 0xE1, 0x80, 0xF8, 0x3E, 0x87, 0x0E, 0xEC, 0x00, 0x2F, 0x36, 0x44,
  0x60, 0x18, 0xCD, 0x7F, 0x7A, 0xAF, 0xD9, 0x0C, 0x31, 0xE7, 0x9E, 0xFF,
  0x30, 0xFB, 0xEB, 0xBF, 0x13, 0xD1, 0x8C, 0x35, 0xE0, 0xF4, 0xE7, 0x3B,
  0x70, 0xF3, 0xC9, 0xC0, 0xF3, 0xF9, 0x00, 0x15, 0xE4, 0x37, 0xDD, 0xB7,
  0xC0, 0x9C, 0xFF, 0x39, 0xCC, 0xED, 0xB7, 0xC0, 0x24, 0x92, 0x5F, 0xBD,
  0xB9, 0xCB, 0x4C, 0x92, 0x49, 0xC0, 0xCF, 0x9F, 0xFD, 0xBB, 0x76, 0xC0,
  0xCF, 0x7B, 0x7B, 0xCC, 0x11, 0xF4, 0xF3, 0xCD, 0xB7, 0x80, 0xFB, 0xFE,
  0x88, 0x11, 0xF4, 0xF3, 0xCD, 0xB7, 0x82, 0x0C, 0xF5, 0xBD, 0xCB, 0x4C,
  0x2B, 0xB0, 0xE3, 0x4F, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x9C, 0xE7, 0x3D,
  0xF8, 0xCD, 0x27, 0x9E, 0x70, 0xC0, 0xD9, 0xAC, 0x97, 0xCA, 0xE7, 0x63,
  0xB0, 0xDD, 0xE3, 0x1C, 0x7B, 0x30, 0xDD, 0xE7, 0x0C, 0x30, 0xC0, 0xF9,
  0x8C, 0xC4, 0x7C, 0xFF, 0x6D, 0xB7, 0xE0, 0x8C, 0x46, 0x22, 0x30, 0xF5,
  0x57, 0xC0, 0x23, 0x95, 0x30, 0xF8, 0xC4, 0x72, 0xDF, 0xB7, 0x80, 0x88,
  0xFB, 0xBB, 0xF0, 0x7D, 0xCD, 0x70, 0x18, 0xDF, 0xBD, 0xED, 0xE0, 0x76,
  0xFF, 0x97, 0x00, 0x74, 0xE4, 0x44, 0x40, 0x7E, 0xF7, 0xB7, 0xCD, 0xC0,
  0x88, 0xFB, 0xBB, 0xB0, 0xD5, 0x54, 0xD5, 0x55, 0xC0, 0x88, 0xBA, 0xEB,
  0xB0, 0xFE, 0xFD, 0x6E, 0xDD, 0xBB, 0x60, 0xFB, 0xBB, 0xB0, 0x76, 0xF7,
  0xB7, 0x00, 0xFB, 0xBB, 0xF8, 0x80, 0x7E, 0xF7, 0xB7, 0x8C, 0x60, 0xFE,
  0x48, 0x7C, 0x7B, 0xF0, 0x4E, 0x44, 0x47, 0xBB, 0xBB, 0xD0, 0xDA, 0xD4,
  0xE3, 0x00, 0xDB, 0xDA, 0x7E, 0x6E, 0x6C, 0xDB, 0x9C, 0xED, 0x80, 0xDA,
  0xD4, 0xE3, 0x13, 0x80, 0xF3, 0x64, 0xF0, 0x2D, 0xBC, 0xDB, 0x20, 0xFF,
  0x80, 0x99, 0x32, 0xD6, 0x80, 0xFC, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Black9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 3, 0, -6 },
  { 3, 4, 2, 5, 0, -6 },
  { 4, 5, 6, 6, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 8, 7, 8, 0, -7 },
  { 20, 7, 7, 7, 0, -7 },
  { 27, 2, 2, 3, 0, -6 },
  { 28, 3, 8, 3, 0, -7 },
  { 31, 3, 8, 3, 0, -7 },
  { 34, 4, 4, 5, 0, -7 },
  { 36, 5, 4, 5, 0, -5 },
  { 39, 2, 2, 3, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 2, 2, 3, 0, -2 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 5, 7, 5, 0, -7 },
  { 51, 4, 6, 5, 0, -6 },
  { 54, 5, 7, 5, 0, -7 },
  { 59, 5, 7, 5, 0, -7 },
  { 64, 5, 6, 5, 0, -6 },
  { 68, 5, 6, 5, 0, -6 },
  { 72, 5, 7, 5, 0, -7 },
  { 77, 5, 6, 5, 0, -6 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 2, 5, 3, 0, -5 },
  { 93, 2, 6, 3, 0, -5 },
  { 95, 5, 5, 5, 0, -6 },
  { 99, 5, 3, 5, 0, -5 },
  { 101, 5, 5, 5, 0, -6 },
  { 105, 4, 7, 4, 0, -7 },
  { 109, 7, 8, 8, 0, -7 },
  { 116, 6, 6, 6, 0, -6 },
  { 121, 4, 6, 6, 1, -6 },
  { 124, 5, 7, 5, 0, -7 },
  { 129, 5, 6, 6, 1, -6 },
  { 133, 3, 6, 5, 1, -6 },
  { 136, 3, 6, 5, 1, -6 },
  { 139, 6, 7, 6, 0, -7 },
  { 145, 5, 6, 6, 1, -6 },
  { 149, 3, 6, 4, 0, -6 },
  { 152, 3, 8, 3, -1, -6 },
  { 155, 5, 6, 6, 1, -6 },
  { 159, 3, 6, 5, 1, -6 },
  { 162, 7, 6, 8, 1, -6 },
  { 168, 5, 6, 7, 1, -6 },
  { 172, 6, 7, 7, 0, -7 },
  { 178, 4, 6, 5, 1, -6 },
  { 181, 6, 9, 7, 0, -7 },
  { 188, 5, 6, 6, 1, -6 },
  { 192, 5, 7, 5, 0, -7 },
  { 197, 5, 6, 5, 0, -6 },
  { 201, 5, 6, 6, 1, -6 },
  { 205, 6, 6, 6, 0, -6 },
  { 210, 9, 6, 9, 0, -6 },
  { 217, 6, 6, 6, 0, -6 },
  { 222, 6, 6, 6, 0, -6 },
  { 227, 5, 6, 5, 0, -6 },
  { 231, 3, 9, 3, 0, -7 },
  { 235, 4, 7, 4, 0, -7 },
  { 239, 2, 9, 3, 0, -7 },
  { 242, 5, 4, 5, 0, -6 },
  { 245, 5, 1, 5, 0, 1 },
  { 246, 3, 2, 4, 0, -7 },
  { 247, 5, 5, 5, 0, -5 },
  { 251, 4, 7, 5, 1, -7 },
  { 255, 4, 5, 5, 0, -5 },
  { 258, 5, 7, 5, 0, -7 },
  { 263, 5, 5, 5, 0, -5 },
  { 267, 4, 7, 3, 0, -7 },
  { 271, 5, 7, 5, 0, -5 },
  { 276, 4, 7, 6, 1, -7 },
  { 280, 2, 7, 3, 0, -7 },
  { 282, 2, 9, 3, 0, -7 },
  { 285, 4, 7, 5, 1, -7 },
  { 289, 1, 7, 3, 1, -7 },
  { 290, 7, 5, 8, 1, -5 },
  { 295, 4, 5, 6, 1, -5 },
  { 298, 5, 5, 5, 0, -5 },
  { 302, 4, 7, 5, 1, -5 },
  { 306, 5, 7, 5, 0, -5 },
  { 311, 3, 5, 4, 1, -5 },
  { 313, 4, 5, 4, 0, -5 },
  { 316, 4, 6, 4, 0, -6 },
  { 319, 4, 5, 6, 1, -5 },
  { 322, 5, 5, 5, 0, -5 },
  { 326, 8, 5, 8, 0, -5 },
  { 331, 5, 5, 5, 0, -5 },
  { 335, 5, 7, 5, 0, -5 },
  { 340, 4, 5, 4, 0, -5 },
  { 343, 3, 9, 4, 0, -7 },
  { 347, 1, 9, 4, 2, -7 },
  { 349, 3, 9, 4, 0, -7 },
  { 353, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Black9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK9PT7B_H_
