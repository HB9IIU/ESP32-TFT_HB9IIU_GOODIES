#ifndef _NOTOSANS_SEMICONDENSED_BLACK21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0xFF, 0xF0, 0xF7, 0xFB, 0xFD,
  0xDC, 0xEE, 0x70, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x19, 0xC7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xE3, 0xB8, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x73, 0x03, 0xB8,
  0x1D, 0xC0, 0xEE, 0x00, 0x0C, 0x03, 0x07, 0xFB, 0xFE, 0xED, 0xBB, 0x0F,
  0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x37, 0xEF, 0xFF, 0xEF, 0xF0, 0x30,
  0x0C, 0x00, 0x3C, 0x0E, 0x0F, 0xC3, 0x81, 0xDC, 0x60, 0x73, 0x9C, 0x0E,
  0x73, 0x01, 0xCE, 0xE0, 0x1D, 0xD9, 0xE3, 0xF7, 0x7E, 0x3C, 0xCF, 0xC0,
  0x3B, 0x9C, 0x06, 0x73, 0x81, 0xCE, 0x70, 0x30, 0xFC, 0x0E, 0x1F, 0x83,
  0x81, 0xE0, 0x1F, 0x00, 0x7F, 0x01, 0xEF, 0x03, 0x9E, 0x07, 0xBC, 0x0F,
  0xF0, 0x0F, 0xC0, 0x3F, 0x9E, 0xFF, 0x79, 0xEF, 0xF3, 0xCF, 0xE7, 0x8F,
  0x8F, 0xFF, 0x1F, 0xFF, 0x0F, 0xDF, 0x80, 0xFF, 0xFE, 0xE0, 0x3D, 0xE7,
  0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0xC7, 0x1C, 0x78, 0xF0,
  0xF1, 0xE3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xCE,
  0x7B, 0xC0, 0x0E, 0x03, 0x84, 0xE5, 0xFF, 0x7F, 0xEF, 0xE1, 0xF0, 0xEE,
  0x7B, 0x84, 0x40, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFC,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xFF, 0xFE, 0xEE, 0xFF, 0xFF, 0xC0, 0x6F,
  0xFF, 0x03, 0x83, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1E,
  0x0E, 0x0F, 0x07, 0x03, 0x83, 0xC0, 0x3E, 0x1F, 0xC7, 0xFB, 0xCE, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCE, 0x7F, 0x9F, 0xE3,
  0xE0, 0x0F, 0x1F, 0x3F, 0x7F, 0xFF, 0x6F, 0x4F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x0F, 0xFB, 0xFF, 0x19, 0xE2, 0x1C, 0x07,
  0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xFE, 0xFF, 0xDF,
  0xF8, 0x7F, 0x3F, 0xEF, 0xF9, 0x1E, 0x03, 0x81, 0xE3, 0xF0, 0xFC, 0x3F,
  0x81, 0xF0, 0x3E, 0x1F, 0xFF, 0xBF, 0xEF, 0xE0, 0x03, 0xC0, 0xF8, 0x1F,
  0x07, 0xE1, 0xFC, 0x3F, 0x8E, 0xF3, 0xDE, 0x73, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0xF0, 0x3F,
  0x8F, 0xFB, 0xFE, 0x47, 0xC0, 0xF0, 0x3E, 0x1F, 0xFF, 0xBF, 0xEF, 0xE0,
  0x1F, 0x8F, 0xE7, 0xF9, 0xE0, 0xF0, 0x3B, 0xCF, 0xFB, 0xFF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xFF, 0x9F, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F,
  0x07, 0x80, 0x3F, 0x1F, 0xEF, 0xFB, 0xCF, 0xF3, 0x9F, 0xE7, 0xF0, 0xFC,
  0x7F, 0xBC, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0xE3, 0xF0, 0x3E, 0x1F, 0xCF,
  0xFB, 0xCE, 0xE3, 0xF8, 0xFF, 0x3F, 0xFF, 0x7F, 0xCE, 0xF0, 0x38, 0x1E,
  0x7F, 0x1F, 0xC7, 0xC0, 0x6F, 0xFF, 0x00, 0x00, 0x6F, 0xFF, 0x6F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xEE, 0xE0, 0x00, 0xC0, 0xF0, 0xFC, 0xFC, 0xFC,
  0x3C, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xF0, 0x04, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x38, 0x0F, 0x81, 0xF8, 0x0F, 0x80,
  0xF1, 0xFD, 0xFC, 0xF8, 0x38, 0x08, 0x00, 0x7F, 0x7F, 0xDF, 0xE8, 0x70,
  0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x0E, 0x00, 0x03, 0x03, 0xC1, 0xE0, 0x70,
  0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x1E, 0x70, 0x0E, 0x73, 0xF7, 0xE7, 0xF7,
  0xEE, 0x77, 0xEE, 0x77, 0xCE, 0x77, 0xCE, 0x77, 0xEF, 0xFE, 0xE7, 0xFE,
  0x73, 0x08, 0x78, 0x08, 0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0x80, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x73, 0x81, 0xCF, 0x0F, 0x3C,
  0x3C, 0xF0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x78, 0x7B, 0xE0, 0xFF, 0x03,
  0xC0, 0xFF, 0x9F, 0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0xF7, 0xFE,
  0xFF, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F, 0xC7,
  0xFD, 0xFF, 0x3C, 0x2F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xE0, 0x3C, 0x27, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF,
  0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x3E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xFD, 0xFE, 0xFF, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xFD, 0xFE, 0xFF, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0x0F, 0xE3, 0xFF, 0x7F, 0xE7, 0xC2, 0xF8, 0x0F,
  0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8, 0xF7, 0x8F, 0x7F, 0xF3,
  0xFF, 0x1F, 0xF0, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x70, 0xFF, 0xFF, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xCF, 0xDF, 0xFF, 0x80, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x9F, 0xFF, 0xF7, 0x80, 0xF0, 0xFF,
  0x8F, 0xBC, 0x79, 0xE7, 0x8F, 0x3C, 0x7B, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF,
  0x87, 0xDE, 0x3C, 0xF1, 0xE7, 0xCF, 0x1E, 0x78, 0xFB, 0xC3, 0xC0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xFC, 0xDF, 0xEE, 0xEF, 0xF7, 0x77, 0xFB,
  0xBB, 0xFC, 0xF9, 0xFE, 0x7C, 0xFF, 0x3E, 0x7F, 0x9F, 0x3F, 0xC7, 0x1E,
  0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xFF, 0x7B,
  0xFD, 0xEF, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x07, 0xC0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF1, 0xFF, 0x87, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1E, 0xF1, 0xF7, 0xFF,
  0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0x1F, 0xFB, 0xFF, 0x79, 0xFF, 0x1F, 0xE3,
  0xFC, 0xF7, 0xFE, 0xFF, 0x9F, 0xE3, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x00, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x3E, 0xF8, 0x7B, 0xC1, 0xEF,
  0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x87, 0x9E, 0x3E, 0x7F, 0xF0,
  0xFF, 0x81, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0xFF, 0xCF, 0x3E, 0xF1, 0xEF, 0x1E, 0xF7, 0xCF, 0xFC, 0xFF,
  0x8F, 0x78, 0xF3, 0xCF, 0x3C, 0xF1, 0xEF, 0x1E, 0xF0, 0xF0, 0x3F, 0xDF,
  0xEF, 0xFB, 0xC6, 0xF0, 0x3E, 0x0F, 0xE1, 0xFC, 0x1F, 0x81, 0xE0, 0x3F,
  0x1E, 0xFF, 0xBF, 0xCF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F, 0xF3, 0xFE, 0x1F,
  0xC0, 0xF0, 0x7F, 0xE1, 0xE7, 0x87, 0x9E, 0x3C, 0x78, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x78, 0x1D, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x00, 0xF0, 0xF0, 0xF7, 0x0F, 0x0F, 0x70, 0xF0, 0xE7,
  0x8F, 0x1E, 0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x39, 0xF9, 0xC3, 0x9F, 0x9C,
  0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x79, 0xE3, 0xC3, 0xCF, 0x0F,
  0x78, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x01,
  0xFE, 0x0F, 0x78, 0x7C, 0xF1, 0xE3, 0xEF, 0x87, 0xC0, 0xF0, 0x7B, 0xC7,
  0x9E, 0x3C, 0x7B, 0xC3, 0xDE, 0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xFF, 0xFE, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xE0,
  0x70, 0x38, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1E, 0xFF, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x01, 0xC0, 0x7C, 0x0F, 0x83, 0xB8, 0x77, 0x1C, 0x73, 0x8E,
  0x70, 0xFC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xE1, 0xC0, 0x1E,
  0x1F, 0xE7, 0xFC, 0x8F, 0x03, 0xDF, 0xFF, 0xFF, 0xCF, 0xF3, 0xFF, 0xFF,
  0xDD, 0xE7, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x71, 0xFF, 0xBF, 0xF7,
  0xDE, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xBF, 0xF7, 0x3C,
  0x1F, 0x1F, 0xDF, 0xDF, 0x2F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xFF, 0xDF,
  0xE7, 0xE0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x39, 0xDF, 0x7F, 0xFF, 0xCF,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xFF, 0xF7, 0xFC, 0xF7, 0x1E, 0x1F,
  0xE7, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3F, 0xE7, 0xF8,
  0xFE, 0x1F, 0x3F, 0x3F, 0x3C, 0x3F, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x39, 0xDF, 0x7F, 0xFF, 0xCF, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF3, 0xFF, 0xF7, 0xFC, 0xF7, 0x01, 0xE0, 0xFF, 0xFF,
  0xFE, 0x7F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x79, 0xFF, 0xBF,
  0xF7, 0xDF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xF3, 0xC0,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFE,
  0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xFF, 0x1E, 0xF3, 0xCF,
  0x78, 0xF7, 0x8F, 0xF0, 0xFF, 0x8F, 0xF8, 0xF3, 0xCF, 0x3C, 0xF1, 0xEF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x8E, 0x7F,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7C, 0xFF, 0x1E, 0x7F, 0x8F, 0x3F, 0xC7, 0x9F,
  0xE3, 0xCF, 0xF1, 0xE7, 0xF8, 0xF3, 0xFC, 0x79, 0xFE, 0x3C, 0xF0, 0xE7,
  0x9F, 0xFB, 0xFF, 0x7D, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xF0, 0x1E, 0x0F, 0xF1, 0xFF, 0x79, 0xEF, 0x1D, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF3, 0xCF, 0xF9, 0xFE, 0x1F, 0x80, 0xE7, 0x1F, 0xFB,
  0xFF, 0x7D, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xFB, 0xFF,
  0x7B, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x39, 0xDF, 0x7F,
  0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xFF, 0xF7, 0xFC, 0xF7,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE3, 0xEF, 0xFF, 0xFF, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x3C, 0xFF, 0xFF, 0xE2, 0xF8,
  0xFE, 0x7F, 0x1F, 0x87, 0xFF, 0xFF, 0xFE, 0x1C, 0x3C, 0x3F, 0x7F, 0xFF,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x3F, 0x1F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFF, 0xFD, 0xFF,
  0x9E, 0x70, 0xF0, 0xFF, 0x0F, 0x79, 0xE7, 0x9E, 0x79, 0xC3, 0x9C, 0x3F,
  0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0xF1, 0xE3, 0xFC, 0x78,
  0xE7, 0x3E, 0x79, 0xEF, 0xDE, 0x7B, 0xF7, 0x9E, 0xFD, 0xC3, 0xB7, 0x70,
  0xFC, 0xDC, 0x3F, 0x3F, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0xF8,
  0xF7, 0x9E, 0x7D, 0xE3, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0xC3, 0xFC, 0x79, 0xEF, 0x9F, 0xF0, 0xFF, 0x0F, 0x79, 0xE7, 0x9E, 0x79,
  0xC3, 0x9C, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0x7E, 0x07, 0xC0, 0x78, 0x00, 0x7F, 0xBF, 0xDF, 0xE0, 0xF0,
  0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x1F, 0x1F,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF8, 0xFC, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1E, 0x1F, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xE3,
  0xE3, 0xC7, 0x8F, 0x1E, 0x1E, 0x3E, 0x3C, 0xFB, 0xC7, 0x8F, 0x1E, 0x3C,
  0xF9, 0xE2, 0x00, 0xFC, 0x7F, 0xF9, 0xFE, 0x0C,
};

const GFXglyph NotoSans_SemiCondensed_Black21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 9, 5, 11, 1, -15 },
  { 15, 13, 15, 13, 0, -15 },
  { 40, 10, 17, 11, 1, -16 },
  { 62, 19, 15, 19, 0, -15 },
  { 98, 15, 15, 16, 1, -15 },
  { 127, 4, 5, 6, 1, -15 },
  { 130, 6, 18, 7, 1, -15 },
  { 144, 6, 18, 7, 0, -15 },
  { 158, 10, 10, 11, 0, -16 },
  { 171, 10, 11, 12, 1, -13 },
  { 185, 4, 6, 6, 1, -3 },
  { 188, 6, 3, 7, 0, -7 },
  { 191, 4, 4, 6, 1, -4 },
  { 193, 9, 15, 9, 0, -15 },
  { 210, 10, 15, 12, 1, -15 },
  { 229, 8, 15, 12, 1, -15 },
  { 244, 11, 15, 12, 0, -15 },
  { 265, 10, 15, 12, 1, -15 },
  { 284, 11, 15, 12, 0, -15 },
  { 305, 10, 15, 12, 1, -15 },
  { 324, 10, 15, 12, 1, -15 },
  { 343, 10, 15, 12, 1, -15 },
  { 362, 10, 15, 12, 1, -15 },
  { 381, 10, 15, 12, 1, -15 },
  { 400, 4, 12, 6, 1, -12 },
  { 406, 4, 15, 6, 1, -12 },
  { 414, 10, 11, 12, 1, -13 },
  { 428, 10, 7, 12, 1, -11 },
  { 437, 10, 11, 12, 1, -13 },
  { 451, 9, 15, 10, 0, -15 },
  { 468, 16, 17, 18, 1, -15 },
  { 502, 14, 15, 14, 0, -15 },
  { 529, 11, 15, 13, 1, -15 },
  { 550, 11, 15, 13, 1, -15 },
  { 571, 12, 15, 14, 1, -15 },
  { 594, 9, 15, 11, 1, -15 },
  { 611, 9, 15, 11, 1, -15 },
  { 628, 12, 15, 14, 1, -15 },
  { 651, 12, 15, 15, 1, -15 },
  { 674, 7, 15, 9, 1, -15 },
  { 688, 7, 20, 7, -2, -15 },
  { 706, 13, 15, 13, 1, -15 },
  { 731, 9, 15, 11, 1, -15 },
  { 748, 17, 15, 19, 1, -15 },
  { 780, 14, 15, 16, 1, -15 },
  { 807, 13, 15, 15, 1, -15 },
  { 832, 11, 15, 12, 1, -15 },
  { 853, 14, 19, 15, 1, -15 },
  { 887, 12, 15, 13, 1, -15 },
  { 910, 10, 15, 11, 1, -15 },
  { 929, 11, 15, 11, 0, -15 },
  { 950, 12, 15, 15, 1, -15 },
  { 973, 14, 15, 14, 0, -15 },
  { 1000, 20, 15, 20, 0, -15 },
  { 1038, 14, 15, 14, 0, -15 },
  { 1065, 13, 15, 13, 0, -15 },
  { 1090, 10, 15, 12, 1, -15 },
  { 1109, 5, 19, 7, 1, -15 },
  { 1121, 9, 15, 9, 0, -15 },
  { 1138, 6, 19, 7, 0, -15 },
  { 1153, 11, 10, 11, 0, -15 },
  { 1167, 11, 3, 11, 0, 1 },
  { 1172, 6, 3, 8, 1, -16 },
  { 1175, 10, 12, 12, 1, -12 },
  { 1190, 11, 16, 13, 1, -16 },
  { 1212, 9, 12, 11, 1, -12 },
  { 1226, 10, 16, 13, 1, -16 },
  { 1246, 10, 12, 12, 1, -12 },
  { 1261, 8, 16, 8, 0, -16 },
  { 1277, 10, 17, 13, 1, -12 },
  { 1299, 11, 16, 13, 1, -16 },
  { 1321, 4, 16, 6, 1, -16 },
  { 1329, 6, 21, 6, -1, -16 },
  { 1345, 12, 16, 13, 1, -16 },
  { 1369, 4, 16, 6, 1, -16 },
  { 1377, 17, 12, 19, 1, -12 },
  { 1403, 11, 12, 13, 1, -12 },
  { 1420, 11, 12, 12, 1, -12 },
  { 1437, 11, 17, 13, 1, -12 },
  { 1461, 10, 17, 13, 1, -12 },
  { 1483, 8, 12, 9, 1, -12 },
  { 1495, 8, 12, 10, 1, -12 },
  { 1507, 8, 14, 9, 0, -14 },
  { 1521, 11, 12, 13, 1, -12 },
  { 1538, 12, 12, 12, 0, -12 },
  { 1556, 18, 12, 18, 0, -12 },
  { 1583, 12, 12, 12, 0, -12 },
  { 1601, 12, 17, 12, 0, -12 },
  { 1627, 9, 12, 10, 0, -12 },
  { 1641, 8, 19, 9, 0, -15 },
  { 1660, 2, 21, 10, 4, -16 },
  { 1666, 7, 19, 9, 1, -15 },
  { 1683, 10, 4, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Black21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK21PT7B_H_
