#ifndef _NOTOSANS_SEMICONDENSED_BLACK8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x30, 0xF7, 0x32, 0xBF, 0xF5, 0x30, 0x2F, 0xE3, 0xBE, 0x4D,
  0x52, 0xD2, 0xF2, 0xA4, 0xC0, 0x71, 0x47, 0x1F, 0xD9, 0xF0, 0xD0, 0x6B,
  0x6C, 0x98, 0xD5, 0x5C, 0x6F, 0x67, 0x22, 0xF2, 0xF0, 0xC0, 0xC0, 0x25,
  0xA5, 0x80, 0x6F, 0xDD, 0xD7, 0x3F, 0x73, 0x33, 0x6F, 0x32, 0x4F, 0xE7,
  0x77, 0x3F, 0x33, 0x7F, 0xF3, 0x77, 0x6F, 0x1F, 0x34, 0xFD, 0xD7, 0xFF,
  0x32, 0x64, 0x6D, 0x77, 0xD7, 0x6F, 0xD7, 0x36, 0xC3, 0xC1, 0xC0, 0x16,
  0xE3, 0xF0, 0xF0, 0x86, 0x3C, 0xEB, 0x24, 0x04, 0x38, 0x8A, 0xF5, 0x7B,
  0xC8, 0x8E, 0x00, 0x33, 0x94, 0xBF, 0xE4, 0xEB, 0xEE, 0xBE, 0x3B, 0xB1,
  0x84, 0xB8, 0xEF, 0xB9, 0xBE, 0xFF, 0xF9, 0xC0, 0xFE, 0x79, 0x00, 0x3B,
  0x71, 0xB4, 0xBC, 0x99, 0xFF, 0x99, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x5E,
  0xBA, 0xEE, 0xAB, 0x92, 0x49, 0xC0, 0xCF, 0x7D, 0xF7, 0xBE, 0xB0, 0xDE,
  0xFF, 0x7B, 0xDC, 0x33, 0xF3, 0x94, 0xBC, 0xFE, 0xF9, 0x00, 0x31, 0xEC,
  0xB2, 0x49, 0xE1, 0xC0, 0xEA, 0xBE, 0xAB, 0x7D, 0xE7, 0x9F, 0xFF, 0x66,
  0x66, 0x99, 0x99, 0xBE, 0xDE, 0xD4, 0xA7, 0x18, 0xDB, 0xDA, 0x5A, 0x7E,
  0x6E, 0x6C, 0xDA, 0x9C, 0xE5, 0x6C, 0xDA, 0x9C, 0x42, 0x10, 0xFF, 0x26,
  0x4F, 0xFF, 0xFC, 0x89, 0x32, 0x40, 0xD5, 0x5C, 0x26, 0x79, 0xF0, 0xE0,
  0x27, 0x7D, 0xF0, 0xCD, 0xFD, 0xDF, 0x27, 0xCC, 0x70, 0x15, 0xFD, 0xD7,
  0x27, 0xFC, 0x70, 0x6B, 0xA4, 0x80, 0x47, 0xDD, 0x79, 0xF0, 0xCD, 0xFD,
  0xDD, 0xCF, 0xF0, 0xCF, 0xFF, 0xC6, 0x75, 0xCF, 0x6C, 0xFF, 0xF0, 0x15,
  0xFF, 0x5E, 0xBD, 0x60, 0x1F, 0xDD, 0xD0, 0x27, 0xDD, 0x70, 0x1F, 0xDD,
  0xFC, 0xC0, 0x47, 0xDD, 0x71, 0x10, 0x3F, 0x6C, 0x4E, 0xE3, 0xE0, 0x5D,
  0x26, 0xDD, 0xD7, 0xDA, 0x9C, 0xC0, 0xF6, 0xF9, 0xB3, 0x60, 0xFB, 0x1D,
  0xB0, 0xDA, 0x9C, 0xC6, 0x60, 0xE6, 0x4F, 0x29, 0x64, 0x98, 0xFF, 0xC9,
  0x34, 0xB0, 0x5F,
};

const GFXglyph NotoSans_SemiCondensed_Black8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 7, 6, 7, 0, -6 },
  { 17, 6, 6, 6, 0, -6 },
  { 22, 2, 2, 2, 0, -6 },
  { 23, 3, 7, 3, 0, -6 },
  { 26, 2, 7, 3, 0, -6 },
  { 28, 4, 4, 4, 0, -6 },
  { 30, 4, 4, 4, 0, -5 },
  { 32, 2, 2, 2, 0, -1 },
  { 33, 2, 1, 3, 0, -3 },
  { 34, 2, 1, 2, 0, -1 },
  { 35, 3, 6, 3, 0, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 4, 6, 4, 0, -6 },
  { 68, 2, 4, 2, 0, -4 },
  { 69, 2, 5, 2, 0, -4 },
  { 71, 4, 4, 4, 0, -5 },
  { 73, 4, 3, 4, 0, -4 },
  { 75, 4, 4, 4, 0, -5 },
  { 77, 4, 6, 4, 0, -6 },
  { 80, 7, 7, 7, 0, -6 },
  { 87, 5, 6, 5, 0, -6 },
  { 91, 4, 6, 5, 1, -6 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 4, 6, 5, 1, -6 },
  { 101, 3, 6, 4, 1, -6 },
  { 104, 3, 6, 4, 1, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 4, 6, 6, 1, -6 },
  { 114, 3, 6, 3, 0, -6 },
  { 117, 3, 8, 3, -1, -6 },
  { 120, 4, 6, 5, 1, -6 },
  { 123, 3, 6, 4, 1, -6 },
  { 126, 6, 6, 7, 1, -6 },
  { 131, 5, 6, 6, 1, -6 },
  { 135, 5, 6, 6, 0, -6 },
  { 139, 3, 6, 5, 1, -6 },
  { 142, 6, 7, 6, 0, -6 },
  { 148, 4, 6, 5, 1, -6 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 4, 6, 4, 0, -6 },
  { 157, 4, 6, 6, 1, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 8, 6, 8, 0, -6 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 5, 6, 5, 0, -6 },
  { 178, 4, 6, 4, 0, -6 },
  { 181, 2, 7, 3, 0, -6 },
  { 183, 3, 6, 3, 0, -6 },
  { 186, 2, 7, 3, 0, -6 },
  { 188, 4, 4, 4, 0, -6 },
  { 190, 4, 1, 4, 0, 0 },
  { 191, 3, 1, 3, 0, -6 },
  { 192, 4, 5, 5, 0, -5 },
  { 195, 4, 6, 5, 0, -6 },
  { 198, 4, 5, 4, 0, -5 },
  { 201, 4, 6, 5, 0, -6 },
  { 204, 4, 5, 5, 0, -5 },
  { 207, 3, 6, 3, 0, -6 },
  { 210, 4, 7, 5, 0, -5 },
  { 214, 4, 6, 5, 0, -6 },
  { 217, 2, 6, 2, 0, -6 },
  { 219, 2, 8, 2, 0, -6 },
  { 221, 5, 6, 5, 0, -6 },
  { 225, 2, 6, 2, 0, -6 },
  { 227, 7, 5, 7, 0, -5 },
  { 232, 4, 5, 5, 0, -5 },
  { 235, 4, 5, 5, 0, -5 },
  { 238, 4, 7, 5, 0, -5 },
  { 242, 4, 7, 5, 0, -5 },
  { 246, 3, 5, 3, 0, -5 },
  { 248, 4, 5, 4, 0, -5 },
  { 251, 3, 5, 3, 0, -5 },
  { 253, 4, 4, 5, 0, -4 },
  { 255, 5, 4, 5, 0, -4 },
  { 258, 7, 4, 7, 0, -4 },
  { 262, 5, 4, 5, 0, -4 },
  { 265, 5, 6, 5, 0, -4 },
  { 269, 4, 4, 4, 0, -4 },
  { 271, 3, 7, 3, 0, -6 },
  { 274, 1, 8, 4, 1, -6 },
  { 275, 3, 7, 3, 0, -6 },
  { 278, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Black8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK8PT7B_H_
