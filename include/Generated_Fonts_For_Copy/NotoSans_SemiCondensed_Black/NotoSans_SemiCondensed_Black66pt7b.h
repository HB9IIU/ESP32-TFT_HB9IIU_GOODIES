#ifndef _NOTOSANS_SEMICONDENSED_BLACK66PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0xFC, 0x3F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xF8, 0xFF, 0x81, 0xE0, 0xFF, 0xF0, 0xFF, 0xEF, 0xFE,
  0x1F, 0xFD, 0xFF, 0xC3, 0xFF, 0xBF, 0xF8, 0x7F, 0xF7, 0xFF, 0x0F, 0xFE,
  0xFF, 0xE1, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB, 0xFF, 0x07, 0xFF, 0x7F, 0xE0,
  0xFF, 0xEF, 0xFC, 0x1F, 0xFD, 0xFF, 0x81, 0xFF, 0x3F, 0xF0, 0x3F, 0xE7,
  0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03,
  0xFE, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xEF, 0xF8, 0xFF, 0xE7, 0xE0, 0x78, 0xFF, 0xC7, 0xE0, 0x18, 0xFF,
  0xC7, 0xE0, 0x00, 0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0xE7, 0xE0, 0x00, 0xFF,
  0xF7, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xEF, 0xFF, 0x00, 0x07, 0xE7, 0xFF, 0x00,
  0x07, 0xE3, 0xFF, 0x00, 0x07, 0xE3, 0xFF, 0x60, 0x07, 0xE3, 0xFF, 0x78,
  0x07, 0xE3, 0xFF, 0x7F, 0x87, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC3,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0xFF, 0x83, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE0, 0xFF, 0xF0, 0x1F, 0xF9, 0xFF, 0x8F, 0xF8, 0x7F, 0xFE, 0x03, 0xFF,
  0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x3F,
  0xE3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0x87, 0xFC, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0xFF, 0x80, 0x1F, 0x80, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x87, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE,
  0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x20, 0x0F, 0xF0,
  0x04, 0x3C, 0x0F, 0xF0, 0x3C, 0x3F, 0x8F, 0xF1, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x01,
  0xFE, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFC, 0x7F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE,
  0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF8,
  0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8,
  0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8,
  0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8,
  0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF,
  0xCF, 0xFF, 0x3F, 0xE3, 0xFF, 0xC7, 0xF0, 0xFF, 0xF0, 0xF8, 0x3F, 0xFC,
  0x1C, 0x0F, 0xFF, 0x02, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x01, 0xFF,
  0xF0, 0x3C, 0x00, 0x7F, 0xF8, 0x0C, 0x00, 0x3F, 0xFC, 0x04, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFC, 0x0F, 0x00, 0x3F,
  0xFC, 0x04, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0x01, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xF7, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF,
  0xC0, 0x0F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x30, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF6, 0x00,
  0x03, 0xFF, 0xEF, 0x00, 0x0F, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0xFF,
  0x80, 0x7F, 0xF3, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xF0, 0x7F, 0xEF, 0xFF,
  0xF8, 0x7F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F,
  0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE,
  0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE,
  0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFE,
  0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xD0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE,
  0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF,
  0x03, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x10, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x9F, 0xF8, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0F, 0xF8,
  0xFF, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xE3, 0xFE, 0x03, 0x80, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F,
  0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0xFF, 0xE3,
  0xFF, 0x83, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0xFF,
  0x83, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x07, 0xFF, 0xC7, 0xC0,
  0x0F, 0xFF, 0x0C, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF,
  0xE1, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x3F, 0xE1, 0xFF, 0x03, 0xFF,
  0xFF, 0xE3, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x7F, 0xCF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x87, 0xF9, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xC1,
  0xFF, 0x83, 0xFE, 0x1F, 0xEF, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFD, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x1F, 0xEF, 0xF0, 0xFF, 0x80, 0xFF,
  0x83, 0xFD, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xBF, 0xC3, 0xFE, 0x03,
  0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0xFF, 0x07, 0xFC,
  0x1F, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xF3, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8,
  0x3F, 0xFF, 0xEF, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xF9, 0xFF, 0xF8, 0x1F,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x8F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF,
  0xEF, 0xFF, 0x01, 0xFF, 0xFB, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xF0, 0x0F,
  0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xC0, 0xFF, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xFC, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC7, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0x83, 0xFF, 0xF0, 0x00, 0x60, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x38, 0x7F, 0xFF, 0x80, 0x1F,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0xDF, 0xFE,
  0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF,
  0xBF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x07, 0xFF,
  0xDF, 0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0x80,
  0x1F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xFF, 0x8F,
  0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC7,
  0xFE, 0x07, 0xFF, 0xF0, 0x00, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x40, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF7, 0xFF, 0x80, 0x01, 0xFF,
  0xDF, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xF0,
  0x00, 0x7F, 0xF7, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFF, 0xC0, 0x07, 0xFF,
  0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xA0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x1F,
  0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xE3, 0xFF,
  0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF8,
  0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0xFF, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x03, 0xFF, 0xDF, 0xFF, 0x00,
  0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x8F,
  0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x07,
  0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x3F,
  0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xF3, 0xFF, 0xC0, 0x07,
  0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0x07,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0x80,
  0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFC,
  0x0F, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xC0, 0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0xE7,
  0xFE, 0x1F, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0x87, 0xFC, 0x7F, 0xFF, 0xFE,
  0x3F, 0xF1, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFC, 0xFF, 0x87, 0xFF, 0xFF,
  0xE3, 0xFF, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xCF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xDF, 0xFE, 0x03,
  0xFF, 0xFF, 0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF9, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFC, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xBF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xE7, 0xFF, 0xE0, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF7, 0xFF, 0x80, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F,
  0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F,
  0xFE, 0xFF, 0xF0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE3, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x00,
  0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xEF, 0xFF, 0x80, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xBF,
  0xFE, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x7F,
  0xFD, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x01, 0xFF, 0xF3,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x8F, 0xFF,
  0x80, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x5F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x9F, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xFE, 0x3F, 0xFC, 0x01,
  0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFF, 0x7F,
  0xF8, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0x3F, 0xFE, 0x00, 0xF8, 0xFF, 0xF0, 0x00, 0x63, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xFE, 0x7F,
  0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F,
  0xFF, 0x9F, 0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC7, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xF1, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFD, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0x7F, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xDF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x87, 0xFE,
  0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF3, 0xFE, 0x1F, 0xFC, 0x00,
  0xFF, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xF8, 0xFF,
  0x87, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0xF8, 0x00, 0xFF,
  0xE7, 0xFE, 0x3F, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0, 0xFF, 0x9F,
  0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xCF,
  0xF8, 0x3F, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xC1, 0xFF, 0x7F, 0xF8,
  0x00, 0x3F, 0xFB, 0xFE, 0x0F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x87,
  0xFF, 0xC0, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC7,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xBF, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xFF, 0xE3,
  0xFF, 0xC0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF,
  0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03,
  0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x1F, 0xFF,
  0x01, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0x1F, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x83,
  0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0xE0, 0xFF, 0xF7,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFD, 0xFF, 0xFD, 0xFF, 0xF8, 0x3F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F,
  0xFC, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0xF0, 0x3F,
  0xFE, 0xFF, 0xFE, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xBF, 0xFF, 0xE1, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC,
  0x03, 0x8F, 0xFF, 0x80, 0x08, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x02, 0xFF, 0xFC, 0x00, 0xE7, 0xFF, 0xE0,
  0x7E, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0x1F, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x8F, 0xFF,
  0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xFC, 0x1F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F,
  0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x04, 0x7F, 0xFC, 0x00, 0x1C, 0x7F,
  0xFF, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF,
  0xFE, 0x7F, 0xF1, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFB, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0x01, 0xC0, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x40, 0x00, 0x0F, 0xFF, 0x38,
  0x00, 0x0F, 0xFF, 0x9F, 0x80, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFC, 0x03, 0xFF,
  0xC7, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xC7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x7F,
  0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0,
  0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF,
  0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0xF7,
  0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F,
  0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xEF, 0xFF, 0x80, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F,
  0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0xC0, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0xFE, 0x1F, 0xF9, 0xFF, 0xFF, 0x8F,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF,
  0x80, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xBF,
  0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFE,
  0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF0,
  0x07, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xF1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC,
  0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0x07, 0xFF, 0xDF, 0xFF, 0x01, 0xFF, 0xEF,
  0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0xFE, 0x07,
  0xFF, 0xDF, 0xFF, 0xC7, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0xFC, 0x1F, 0xFE,
  0x7F, 0xFC, 0x0F, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xF8,
  0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xF1, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFB, 0xFF, 0xC3, 0xFF, 0xF9,
  0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0x01, 0xC0,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC,
  0xFF, 0x1F, 0xFE, 0x01, 0xE3, 0xFF, 0xC0, 0x0C, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x60, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0xE1, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xDF,
  0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x0F,
  0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF,
  0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x7F,
  0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xE7, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xDF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0,
  0xFF, 0x7F, 0xC3, 0xFF, 0x81, 0xFF, 0xC7, 0xFC, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xCF, 0xF9, 0xFF,
  0xC0, 0x3F, 0xF9, 0xFF, 0x3F, 0xE7, 0xFF, 0x00, 0xFF, 0xE7, 0xF8, 0xFF,
  0x9F, 0xFC, 0x03, 0xFF, 0xBF, 0xE3, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0xFF,
  0x87, 0xF9, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x1F, 0xF7, 0xFE, 0x00, 0x7F,
  0xEF, 0xF8, 0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xC1, 0xFF, 0xFF, 0xC0,
  0x03, 0xFE, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFB, 0xFF, 0xF0, 0x0F,
  0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF,
  0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFE,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xBF,
  0xFE, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE1, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xEF,
  0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x3F, 0xF8,
  0x00, 0x05, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF4, 0x00, 0x07, 0xFF, 0xC8, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Black66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 48, 19, 3, -47 },
  { 79, 27, 17, 34, 3, -47 },
  { 137, 39, 47, 41, 1, -47 },
  { 367, 32, 54, 36, 2, -50 },
  { 583, 58, 49, 60, 1, -48 },
  { 939, 47, 49, 49, 2, -48 },
  { 1227, 12, 17, 18, 3, -47 },
  { 1253, 19, 58, 23, 3, -48 },
  { 1391, 19, 58, 23, 1, -48 },
  { 1529, 32, 31, 34, 1, -50 },
  { 1653, 31, 32, 37, 3, -39 },
  { 1777, 14, 19, 20, 2, -10 },
  { 1811, 18, 10, 21, 2, -23 },
  { 1834, 13, 13, 19, 3, -12 },
  { 1856, 29, 49, 29, 0, -48 },
  { 2034, 32, 49, 37, 2, -48 },
  { 2230, 26, 47, 37, 3, -47 },
  { 2383, 33, 48, 37, 1, -48 },
  { 2581, 32, 49, 37, 2, -48 },
  { 2777, 35, 47, 37, 1, -47 },
  { 2983, 31, 48, 37, 3, -47 },
  { 3169, 32, 49, 37, 2, -48 },
  { 3365, 31, 47, 37, 3, -47 },
  { 3548, 32, 49, 37, 2, -48 },
  { 3744, 32, 49, 37, 2, -48 },
  { 3940, 13, 38, 19, 3, -37 },
  { 4002, 14, 46, 19, 2, -37 },
  { 4083, 31, 35, 37, 3, -41 },
  { 4219, 31, 23, 37, 3, -35 },
  { 4309, 31, 35, 37, 3, -41 },
  { 4445, 30, 49, 31, 0, -48 },
  { 4629, 51, 53, 56, 3, -48 },
  { 4967, 44, 47, 44, 0, -47 },
  { 5226, 34, 47, 42, 5, -47 },
  { 5426, 35, 49, 39, 3, -48 },
  { 5641, 37, 47, 45, 5, -47 },
  { 5859, 26, 47, 34, 5, -47 },
  { 6012, 26, 47, 33, 5, -47 },
  { 6165, 38, 49, 45, 3, -48 },
  { 6398, 37, 47, 47, 5, -47 },
  { 6616, 23, 47, 27, 2, -47 },
  { 6752, 22, 62, 22, -5, -47 },
  { 6923, 38, 47, 42, 5, -47 },
  { 7147, 28, 47, 35, 5, -47 },
  { 7312, 50, 47, 60, 5, -47 },
  { 7606, 41, 47, 51, 5, -47 },
  { 7847, 42, 49, 48, 3, -48 },
  { 8105, 32, 47, 39, 5, -47 },
  { 8293, 43, 59, 48, 3, -48 },
  { 8611, 37, 47, 42, 5, -47 },
  { 8829, 30, 49, 35, 3, -48 },
  { 9013, 33, 47, 36, 1, -47 },
  { 9207, 38, 48, 46, 4, -47 },
  { 9435, 43, 47, 43, 0, -47 },
  { 9688, 61, 47, 63, 1, -47 },
  { 10047, 43, 47, 43, 0, -47 },
  { 10300, 40, 47, 40, 0, -47 },
  { 10535, 33, 47, 37, 2, -47 },
  { 10729, 17, 59, 21, 3, -48 },
  { 10855, 29, 49, 29, 0, -48 },
  { 11033, 16, 59, 21, 1, -48 },
  { 11151, 35, 31, 35, 0, -47 },
  { 11287, 33, 8, 33, 0, 4 },
  { 11320, 20, 11, 26, 3, -51 },
  { 11348, 32, 38, 38, 2, -37 },
  { 11500, 33, 51, 40, 4, -50 },
  { 11711, 28, 38, 33, 3, -37 },
  { 11844, 33, 51, 40, 3, -50 },
  { 12055, 32, 38, 37, 3, -37 },
  { 12207, 26, 50, 25, 1, -50 },
  { 12370, 33, 53, 40, 3, -37 },
  { 12589, 33, 50, 41, 4, -50 },
  { 12796, 12, 51, 20, 4, -51 },
  { 12873, 19, 67, 20, -3, -51 },
  { 13033, 36, 50, 40, 4, -50 },
  { 13258, 12, 50, 20, 4, -50 },
  { 13333, 53, 37, 61, 4, -37 },
  { 13579, 33, 37, 41, 4, -37 },
  { 13732, 34, 38, 39, 3, -37 },
  { 13894, 33, 53, 40, 4, -37 },
  { 14113, 33, 53, 40, 3, -37 },
  { 14332, 24, 37, 29, 4, -37 },
  { 14443, 27, 38, 31, 2, -37 },
  { 14572, 25, 45, 28, 1, -44 },
  { 14713, 33, 38, 41, 4, -37 },
  { 14870, 37, 37, 37, 0, -37 },
  { 15042, 54, 37, 56, 1, -37 },
  { 15292, 37, 37, 38, 0, -37 },
  { 15464, 37, 53, 37, 0, -37 },
  { 15710, 28, 37, 31, 1, -37 },
  { 15840, 23, 59, 27, 2, -48 },
  { 16010, 9, 65, 31, 11, -50 },
  { 16084, 23, 59, 27, 2, -48 },
  { 16254, 31, 13, 37, 3, -30 },
};

const GFXfont NotoSans_SemiCondensed_Black66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK66PT7B_H_
