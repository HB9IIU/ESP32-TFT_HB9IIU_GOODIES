#ifndef _NOTOSANS_SEMICONDENSED_BLACK15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xED, 0xB0, 0xDF, 0x00, 0xDF, 0x7D, 0xF3, 0x1B, 0x0D, 0x86,
  0xCF, 0xF7, 0xF9, 0xB3, 0xFF, 0xFF, 0x36, 0x12, 0x1B, 0x00, 0x18, 0x7E,
  0x7E, 0xF8, 0x78, 0x7E, 0x1F, 0x1F, 0x7F, 0x7E, 0x38, 0x18, 0x30, 0xC3,
  0xC6, 0x36, 0x61, 0xBB, 0x0D, 0xB2, 0x3D, 0xBC, 0xDB, 0x60, 0xDB, 0x0C,
  0xD8, 0x67, 0xC6, 0x1C, 0x1C, 0x07, 0xC1, 0xDC, 0x1B, 0x83, 0xE0, 0x79,
  0xDF, 0xF7, 0x3E, 0xE7, 0x8F, 0xF8, 0xFF, 0x80, 0xFF, 0x76, 0xEC, 0xCC,
  0xCC, 0xCC, 0xEE, 0x70, 0xE3, 0x8C, 0x63, 0x1C, 0xE7, 0x39, 0x8C, 0xEE,
  0x00, 0x19, 0x37, 0xFB, 0xE3, 0xCD, 0xCA, 0x00, 0x30, 0x60, 0xC7, 0xFF,
  0xE6, 0x0C, 0x00, 0x76, 0x6E, 0xFF, 0xDF, 0x00, 0x0E, 0x18, 0x70, 0xC1,
  0x87, 0x0C, 0x38, 0x60, 0xC3, 0x80, 0x79, 0xFB, 0xF6, 0x7C, 0xF9, 0xF3,
  0xE7, 0xED, 0xF9, 0xE0, 0x1C, 0xF7, 0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71,
  0xC0, 0x3C, 0xFE, 0x7E, 0x46, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF,
  0x3C, 0x7E, 0x6E, 0x06, 0x3E, 0x3C, 0x3E, 0x07, 0x87, 0xFE, 0xFC, 0x0E,
  0x0E, 0x1E, 0x3E, 0x3E, 0x6E, 0xEE, 0xFF, 0xFF, 0x0E, 0x0E, 0xFD, 0xFB,
  0xF7, 0x0F, 0x9F, 0x87, 0x87, 0x9F, 0xFB, 0xE0, 0x1E, 0x3E, 0x78, 0x60,
  0x7E, 0x7F, 0xE7, 0x67, 0x77, 0x7E, 0x3C, 0xFF, 0xFF, 0xF8, 0x61, 0xC3,
  0x0E, 0x1C, 0x70, 0xE3, 0xC0, 0x3C, 0x7E, 0x77, 0x76, 0x7E, 0x3C, 0x7E,
  0x67, 0xE7, 0x7F, 0x3E, 0x3C, 0x7E, 0x7E, 0xE7, 0xE7, 0x7F, 0x7F, 0x06,
  0x0E, 0x7E, 0x78, 0xFC, 0x01, 0xBE, 0x77, 0x00, 0x00, 0x76, 0x6E, 0x06,
  0x3D, 0xE7, 0x0F, 0x87, 0xC3, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81,
  0xC1, 0xF0, 0x73, 0xDE, 0x30, 0x40, 0x79, 0xF9, 0x38, 0x71, 0xC7, 0x0C,
  0x00, 0x30, 0x70, 0xC0, 0x0F, 0x07, 0xF9, 0x83, 0x67, 0xBD, 0xB7, 0xE6,
  0xEC, 0xDE, 0xDB, 0xDF, 0xD8, 0x01, 0xEE, 0x1F, 0xC0, 0x1E, 0x07, 0x81,
  0xF0, 0xFC, 0x3B, 0x0C, 0xC7, 0x39, 0xFE, 0x7F, 0xB8, 0x7E, 0x1C, 0xFC,
  0xFE, 0xEF, 0xE7, 0xFE, 0xFC, 0xFF, 0xE7, 0xE7, 0xFE, 0xFC, 0x1F, 0x7E,
  0xF6, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE2, 0x7E, 0x3E, 0xF8, 0x7F, 0x3F,
  0xDC, 0xEE, 0x37, 0x1F, 0x8D, 0xCE, 0xEF, 0x7F, 0x3F, 0x00, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0xE3, 0xFF,
  0xF8, 0xE3, 0x8E, 0x00, 0x1E, 0x7F, 0xF3, 0xE0, 0xE0, 0xEF, 0xEF, 0xE3,
  0xF3, 0x7F, 0x3F, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xE3, 0xF1, 0xF8, 0xE0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xFF,
  0xC0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0x78, 0xE3, 0xF3,
  0xBB, 0x9D, 0xCF, 0xC7, 0xE3, 0xF1, 0xDC, 0xEE, 0x73, 0xB9, 0xE0, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFF, 0x9F, 0xD9, 0xFF, 0xB7, 0xFF, 0x7E, 0xF7, 0xEF, 0x7E, 0xE7, 0xEE,
  0x70, 0xF1, 0xF8, 0xFE, 0x7F, 0x3D, 0xDF, 0xEF, 0xBF, 0xDF, 0xE7, 0xF3,
  0xF8, 0xE0, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7,
  0xBF, 0x8F, 0x80, 0xF9, 0xFF, 0xFF, 0x3E, 0xFF, 0xFF, 0x70, 0xE1, 0xC3,
  0x80, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xBF,
  0x8F, 0x80, 0xE0, 0x78, 0x1C, 0xF8, 0x7F, 0x3B, 0x9C, 0xCE, 0xE7, 0xF3,
  0xF1, 0xD8, 0xEE, 0x73, 0xB9, 0xE0, 0x7F, 0xFB, 0xB6, 0x0F, 0x1F, 0x8F,
  0x07, 0x8D, 0xFB, 0xE0, 0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7,
  0x7F, 0x3E, 0xE1, 0xF8, 0xE7, 0x39, 0xCE, 0x73, 0x0D, 0xC3, 0xF0, 0xFC,
  0x3E, 0x07, 0x81, 0xE0, 0xE3, 0x1F, 0x8E, 0x76, 0x79, 0xD9, 0xE6, 0x77,
  0x99, 0xDE, 0xE3, 0x6F, 0x8F, 0xBE, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x00,
  0xE3, 0x9C, 0xE7, 0x70, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0xFC, 0x77, 0x1C,
  0xEE, 0x3C, 0xE3, 0xB1, 0xDD, 0xC6, 0xE3, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x70,
  0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xDB, 0x6F, 0xC0, 0xE1, 0x86, 0x1C, 0x30,
  0xC3, 0x86, 0x1C, 0x70, 0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF,
  0x18, 0x18, 0x3C, 0x3C, 0x6E, 0x66, 0xC7, 0xFF, 0xFF, 0xE3, 0x7E, 0x3F,
  0x07, 0x7F, 0x77, 0xE7, 0x7F, 0x7B, 0xE1, 0xC3, 0x87, 0xFF, 0xFC, 0xF9,
  0xF3, 0xEF, 0xFF, 0x70, 0x7F, 0xFE, 0x30, 0xC3, 0x9F, 0xDF, 0x0E, 0x1C,
  0x3F, 0xFF, 0xFD, 0xF1, 0xE3, 0xEF, 0xFD, 0xD8, 0x7D, 0xDF, 0x3F, 0xFF,
  0xFC, 0x3F, 0x3E, 0x3D, 0xF7, 0x3F, 0xFD, 0xC7, 0x1C, 0x71, 0xC7, 0x00,
  0xF7, 0xFF, 0x3E, 0x3C, 0x7D, 0xFF, 0xBF, 0x0F, 0xFF, 0xF3, 0x80, 0xE1,
  0xC3, 0x87, 0xFF, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x98, 0xDF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x31, 0xCC, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xCC,
  0xE0, 0xE0, 0xE0, 0xEF, 0xEE, 0xFC, 0xFC, 0xFC, 0xEE, 0xEE, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xDF, 0xEF, 0xFF, 0xEE, 0x7E, 0x67, 0xE6, 0x7E,
  0x67, 0xE6, 0x7E, 0x67, 0xDF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0x7D,
  0xFF, 0x3E, 0x3C, 0x7D, 0xFF, 0xBE, 0xDF, 0xFF, 0x9F, 0x3E, 0x7D, 0xFF,
  0xFE, 0xE1, 0xC3, 0x87, 0x00, 0xF7, 0xFF, 0x3E, 0x3C, 0x7D, 0xFF, 0xBF,
  0x0E, 0x1C, 0x38, 0x70, 0xDF, 0xF9, 0xCE, 0x73, 0x9C, 0xFF, 0xEE, 0x3E,
  0x7A, 0x7F, 0xBE, 0x30, 0xCF, 0xFF, 0x71, 0xC7, 0x1C, 0x7C, 0xF0, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7D, 0xFF, 0xBB, 0xE7, 0x67, 0x77, 0x76, 0x3E, 0x3C,
  0x3C, 0x1C, 0xE7, 0x3B, 0x79, 0x9B, 0xDC, 0xFB, 0xE7, 0xDE, 0x1E, 0xF0,
  0xE7, 0x87, 0x3C, 0xF7, 0x3B, 0x0F, 0x87, 0x83, 0xE3, 0xF1, 0xDD, 0xCF,
  0xE7, 0x67, 0x77, 0x76, 0x3E, 0x3E, 0x3C, 0x1C, 0x18, 0x78, 0x70, 0x60,
  0xFF, 0xF8, 0x71, 0xC3, 0x0E, 0x3F, 0xFF, 0x1C, 0xF3, 0x0C, 0x30, 0xCF,
  0x3C, 0x30, 0xC3, 0x0E, 0x3C, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xC3,
  0x0C, 0x30, 0xE3, 0xCF, 0x30, 0xC3, 0x1C, 0xF2, 0x00, 0xE3, 0xFE, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Black15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 4, 1, -11 },
  { 6, 6, 4, 8, 1, -11 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 8, 12, 8, 0, -11 },
  { 34, 13, 11, 14, 0, -11 },
  { 52, 11, 11, 11, 0, -11 },
  { 68, 2, 4, 4, 1, -11 },
  { 69, 4, 13, 5, 1, -11 },
  { 76, 5, 13, 5, 0, -11 },
  { 85, 7, 7, 8, 0, -11 },
  { 92, 7, 7, 8, 1, -9 },
  { 99, 4, 4, 4, 0, -2 },
  { 101, 4, 2, 5, 0, -5 },
  { 102, 3, 3, 4, 1, -3 },
  { 104, 7, 11, 7, 0, -11 },
  { 114, 7, 11, 8, 1, -11 },
  { 124, 6, 11, 8, 1, -11 },
  { 133, 8, 11, 8, 0, -11 },
  { 144, 8, 11, 8, 0, -11 },
  { 155, 8, 11, 8, 0, -11 },
  { 166, 7, 11, 8, 1, -11 },
  { 176, 8, 11, 8, 0, -11 },
  { 187, 7, 11, 8, 1, -11 },
  { 197, 8, 11, 8, 0, -11 },
  { 208, 8, 11, 8, 0, -11 },
  { 219, 3, 8, 4, 1, -8 },
  { 222, 4, 10, 4, 0, -8 },
  { 227, 7, 8, 8, 1, -9 },
  { 234, 7, 5, 8, 1, -8 },
  { 239, 7, 8, 8, 1, -9 },
  { 246, 7, 11, 7, 0, -11 },
  { 256, 11, 12, 13, 1, -11 },
  { 273, 10, 11, 10, 0, -11 },
  { 287, 8, 11, 9, 1, -11 },
  { 298, 8, 11, 9, 1, -11 },
  { 309, 9, 11, 10, 1, -11 },
  { 322, 6, 11, 8, 1, -11 },
  { 331, 6, 11, 8, 1, -11 },
  { 340, 8, 11, 10, 1, -11 },
  { 351, 9, 11, 11, 1, -11 },
  { 364, 6, 11, 6, 0, -11 },
  { 373, 5, 14, 5, -1, -11 },
  { 382, 9, 11, 10, 1, -11 },
  { 395, 6, 11, 8, 1, -11 },
  { 404, 12, 11, 14, 1, -11 },
  { 421, 9, 11, 12, 1, -11 },
  { 434, 9, 11, 11, 1, -11 },
  { 447, 7, 11, 9, 1, -11 },
  { 457, 9, 14, 11, 1, -11 },
  { 473, 9, 11, 9, 1, -11 },
  { 486, 7, 11, 8, 1, -11 },
  { 496, 8, 11, 8, 0, -11 },
  { 507, 8, 11, 10, 1, -11 },
  { 518, 10, 11, 10, 0, -11 },
  { 532, 14, 11, 14, 0, -11 },
  { 552, 10, 11, 10, 0, -11 },
  { 566, 9, 11, 9, 0, -11 },
  { 579, 8, 11, 8, 0, -11 },
  { 590, 3, 14, 5, 1, -11 },
  { 596, 6, 11, 7, 0, -11 },
  { 605, 4, 14, 5, 0, -11 },
  { 612, 8, 7, 8, 0, -11 },
  { 619, 8, 2, 8, 0, 1 },
  { 621, 4, 2, 6, 1, -11 },
  { 622, 8, 8, 9, 0, -8 },
  { 630, 7, 11, 9, 1, -11 },
  { 640, 6, 8, 8, 1, -8 },
  { 646, 7, 11, 9, 1, -11 },
  { 656, 7, 8, 9, 1, -8 },
  { 663, 6, 11, 6, 0, -11 },
  { 672, 7, 12, 9, 1, -8 },
  { 683, 7, 11, 9, 1, -11 },
  { 693, 3, 12, 5, 1, -12 },
  { 698, 5, 16, 5, -1, -12 },
  { 708, 8, 11, 9, 1, -11 },
  { 719, 3, 11, 5, 1, -11 },
  { 724, 12, 8, 14, 1, -8 },
  { 736, 7, 8, 9, 1, -8 },
  { 743, 7, 8, 9, 1, -8 },
  { 750, 7, 12, 9, 1, -8 },
  { 761, 7, 12, 9, 1, -8 },
  { 772, 5, 8, 7, 1, -8 },
  { 777, 6, 8, 7, 1, -8 },
  { 783, 6, 10, 6, 0, -10 },
  { 791, 7, 8, 9, 1, -8 },
  { 798, 8, 8, 9, 0, -8 },
  { 806, 13, 8, 13, 0, -8 },
  { 819, 9, 8, 9, 0, -8 },
  { 828, 8, 12, 8, 0, -8 },
  { 840, 7, 8, 7, 0, -8 },
  { 847, 6, 14, 6, 0, -11 },
  { 858, 2, 14, 7, 3, -11 },
  { 862, 6, 14, 6, 0, -11 },
  { 873, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Black15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK15PT7B_H_
