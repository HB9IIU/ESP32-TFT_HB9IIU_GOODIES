#ifndef _NOTOSANS_SEMICONDENSED_BLACK27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x03,
  0x3E, 0xFB, 0xE7, 0x80, 0xF9, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x9E, 0xF3,
  0xDE, 0x78, 0x0F, 0x38, 0x1E, 0x70, 0x3C, 0xE0, 0x73, 0xC0, 0xE7, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x70, 0x39, 0xE0, 0x73, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x78, 0x1C, 0xF0, 0x39, 0xE0, 0x73, 0x81,
  0xE7, 0x00, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x7F, 0xE7, 0xFF, 0x7F, 0xFB,
  0xDC, 0xDE, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x03,
  0xFC, 0x1D, 0xF0, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0xFF, 0x80, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x07, 0x83, 0xFC, 0x1E,
  0x07, 0xF8, 0x38, 0x0F, 0x78, 0xF0, 0x1C, 0xF1, 0xC0, 0x39, 0xE7, 0x80,
  0x73, 0xCE, 0x00, 0xE7, 0xBC, 0xF1, 0xFF, 0x73, 0xF3, 0xFD, 0xEF, 0xF3,
  0xF3, 0x9E, 0xF1, 0x8F, 0x39, 0xE0, 0x1C, 0x73, 0xC0, 0x78, 0xE7, 0x80,
  0xE1, 0xCF, 0x03, 0xC3, 0xDE, 0x07, 0x07, 0xF8, 0x1E, 0x07, 0xF0, 0x38,
  0x07, 0xC0, 0x01, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xCF, 0x80, 0x79, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xF8, 0xF8, 0xFF, 0x1F, 0x3F, 0xF7, 0xEF, 0xBF, 0xF9, 0xF3, 0xFF, 0x3E,
  0x3F, 0xC7, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xE7, 0xF0, 0xFB, 0xDE, 0xF7, 0xBD, 0xE0, 0x1F, 0x1E, 0x3E, 0x3C, 0x7C,
  0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8,
  0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3E, 0x1F, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E,
  0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x8F, 0x17, 0x73, 0xBF, 0xFD, 0xFF, 0xF7, 0xFE, 0x0F, 0xC0, 0xFF, 0x0F,
  0x7C, 0x79, 0xE0, 0x84, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0x7D, 0xE7, 0x9E, 0xFB, 0xCF, 0x3C, 0xFF, 0xFF, 0xFF,
  0xF0, 0x37, 0xFF, 0xF7, 0x80, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x02,
  0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0xFF, 0x7C, 0x7B, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xEF,
  0x3E, 0x7F, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x7F,
  0x9F, 0xF7, 0xFF, 0xFF, 0xDE, 0xF9, 0x9F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x06,
  0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xEF, 0xFF, 0x38, 0xF8, 0x87, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x03, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE7, 0xFF, 0x10, 0xF8, 0x07, 0xC0, 0x3E, 0x1F, 0xE0, 0xFC,
  0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0xFF, 0xF7,
  0xFF, 0xBF, 0xF8, 0xFF, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0x7C, 0x3C, 0xF8, 0x79, 0xF1,
  0xE3, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7,
  0x80, 0x3C, 0x01, 0xEC, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0x88, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x07, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x1F, 0xE0,
  0x00, 0x40, 0x7F, 0x87, 0xFC, 0x7F, 0xE7, 0xF9, 0x3E, 0x01, 0xE0, 0x1F,
  0x78, 0xF7, 0xF7, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0x7F, 0xFB, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x03, 0x01, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0xDF,
  0x7C, 0x7D, 0xE3, 0xCF, 0xBE, 0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0xEF,
  0xDF, 0x7C, 0x7F, 0xC3, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0x9F, 0xFC, 0x7F,
  0x80, 0x06, 0x01, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0xFF, 0x7C, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x84, 0x7C,
  0x03, 0xC0, 0x3E, 0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFE, 0x00, 0x7B, 0xEF,
  0xFE, 0x78, 0x00, 0x00, 0x00, 0x03, 0x3E, 0xFF, 0xE7, 0x80, 0x7B, 0xEF,
  0xFE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x79, 0xEF, 0xBE, 0xF3, 0xCF,
  0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8,
  0x1F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0x80, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x3F, 0x07, 0xF8, 0xFF, 0x3F, 0xE1, 0xFC, 0x0F, 0x00,
  0x60, 0x00, 0x02, 0x07, 0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xF4, 0x0F, 0x01,
  0xF0, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0x0F, 0xC3, 0xE0, 0x1E, 0x1E, 0x1C, 0x79,
  0xE7, 0xFD, 0xCE, 0x7F, 0xEF, 0xF3, 0xCF, 0x7F, 0xBC, 0x79, 0xFD, 0xE3,
  0xCF, 0xCF, 0x1C, 0xFE, 0x78, 0xE7, 0xFB, 0xCF, 0x3B, 0xCF, 0xFF, 0xDE,
  0x7F, 0xFC, 0x78, 0xF3, 0xC3, 0xC0, 0x00, 0x0F, 0x80, 0x60, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC7, 0xFF, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0xBF, 0x03, 0xFF, 0xC0,
  0x7C, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFB, 0xE3, 0xEF,
  0x8F, 0xBF, 0xFE, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBE, 0x3F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x00,
  0x80, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xF9, 0xF8, 0x27, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x83, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC1, 0xFE, 0xFF, 0xC1,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x8F, 0xDF, 0x0F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x0F,
  0xBE, 0x3F, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xFE, 0xFF, 0xDF, 0xFB,
  0xFF, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFC, 0x7E, 0x04, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F,
  0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xE7,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7E, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xFF, 0xFB, 0xFD, 0xFC, 0xFC, 0x00, 0xF8,
  0x7F, 0xF0, 0xFB, 0xE3, 0xF7, 0xC7, 0xCF, 0x9F, 0x1F, 0x7E, 0x3E, 0xF8,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0x9F, 0x1F,
  0x3F, 0x3E, 0x3E, 0x7C, 0x7E, 0xF8, 0x7D, 0xF0, 0xFF, 0xE1, 0xF8, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xDE, 0x3F, 0xFE, 0xF1, 0xFF, 0xF7,
  0x9E, 0xFF, 0xBC, 0xF7, 0xFC, 0xF7, 0xBF, 0xE7, 0xB9, 0xFF, 0x3F, 0xCF,
  0xF9, 0xFE, 0x7F, 0xC7, 0xF3, 0xFE, 0x3F, 0x1F, 0xF1, 0xF8, 0xFF, 0x87,
  0xC7, 0xFC, 0x3E, 0x3E, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xEF, 0x9F, 0xF7, 0xCF, 0xF9,
  0xF7, 0xFC, 0xFB, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xE0, 0x01, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xE7, 0xC0,
  0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0x80, 0xFF, 0xF0, 0x3E,
  0xFC, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFD,
  0xFF, 0x8F, 0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0x87, 0xE7, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF,
  0x80, 0xFF, 0xF0, 0x3E, 0xFC, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF8,
  0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0xFF, 0xC1,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C,
  0x7C, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0x0F, 0xBE, 0x1F, 0x3E,
  0x3E, 0x7E, 0x7C, 0x7C, 0xF8, 0xFD, 0xF0, 0xFB, 0xE1, 0xF8, 0x02, 0x00,
  0xFF, 0xDF, 0xFC, 0xFF, 0xEF, 0xFF, 0x7C, 0x13, 0xE0, 0x1F, 0x80, 0x7F,
  0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x3E,
  0xFF, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFC, 0x7F, 0xF0,
  0x7F, 0x80, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xE1,
  0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x1F, 0x3E, 0x0F, 0x9E, 0x07,
  0xDF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x1E, 0x0F, 0xDE, 0x0F,
  0x83, 0xE7, 0xC3, 0xF0, 0xF9, 0xF0, 0xFC, 0x3E, 0x7C, 0x3F, 0x0F, 0x0F,
  0x1F, 0xC7, 0xC3, 0xC7, 0xF9, 0xF0, 0xF9, 0xFE, 0x7C, 0x3E, 0x7F, 0x9F,
  0x0F, 0x9D, 0xE7, 0x81, 0xEF, 0x3B, 0xE0, 0x7B, 0xCF, 0xF8, 0x1F, 0xF3,
  0xFE, 0x07, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0xBF,
  0x0F, 0x8F, 0x8F, 0x87, 0xE7, 0xC1, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7D, 0xF8, 0x7C, 0x7C, 0x7E, 0x3F, 0x3E, 0x0F, 0xFF,
  0x03, 0xE0, 0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7,
  0xC0, 0xFB, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0x3C, 0x1E, 0x78, 0x3C, 0x78, 0xF0, 0xF1, 0xE0, 0xF7, 0x81, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x7C, 0x3E, 0x0F, 0x07, 0x1F,
  0xE3, 0xFF, 0x8F, 0xFC, 0x7B, 0xF2, 0x0F, 0x80, 0x7C, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xC7, 0xFE, 0x3F, 0xFB, 0xFF, 0xFF, 0xBF, 0xBC, 0xF9, 0xE0,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xCF, 0x1E,
  0xFE, 0xFF, 0xF7, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0x7E, 0x00, 0x0F,
  0xE3, 0xFF, 0x7F, 0xE7, 0xFE, 0xFC, 0x2F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFC, 0x27, 0xFE, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF1, 0xE7, 0xCF, 0xDF,
  0x7F, 0xFD, 0xFF, 0xFF, 0xCF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xFC, 0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x3C, 0x0F,
  0xC1, 0xFF, 0x9F, 0xFC, 0xF9, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0xFC, 0xE7, 0xFF, 0x1F, 0xF8, 0x7F, 0xC0,
  0x03, 0x81, 0xFC, 0x7F, 0x0F, 0xE3, 0xE0, 0x7C, 0x0F, 0xF7, 0xFE, 0xFF,
  0xDF, 0xF8, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x7C, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF,
  0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F,
  0xDF, 0xFF, 0x7F, 0xFC, 0xFD, 0xF1, 0xF7, 0xC0, 0x1F, 0x80, 0xF9, 0xEF,
  0xE7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xCF, 0x9E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0x80, 0xF7, 0xFF, 0xE6, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x1F, 0x1F, 0x1E, 0x0C,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0xFE, 0xFE, 0xFE, 0xFC, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xFE, 0x3E,
  0xF9, 0xF3, 0xCF, 0xCF, 0x3E, 0x3D, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE,
  0x3F, 0xF8, 0xF9, 0xF3, 0xE7, 0xCF, 0x8F, 0xBE, 0x3F, 0xF8, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF3, 0xE3, 0xE7, 0xFF, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xCF, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8,
  0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC,
  0x7C, 0x7F, 0xE3, 0xE3, 0xE0, 0xE3, 0xE7, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xE0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFE, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xDF, 0xFE, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0xF3, 0xE7, 0xBF,
  0xBF, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x7B, 0xFB, 0xCF, 0x9E, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x7C, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x8F, 0xDF, 0xFF, 0x7F, 0xFC, 0xFD, 0xF1, 0xE7, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0xE3, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE0, 0x3F, 0x8F, 0xFF, 0xFF, 0x7C, 0xEF, 0x81, 0xFC, 0x3F, 0xE3,
  0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0xE0, 0x1C,
  0x0F, 0x03, 0xC1, 0xFE, 0xFF, 0xBF, 0xEF, 0xF9, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFC, 0xFF, 0x3F, 0xC7, 0xF0, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xBC, 0xF9, 0xE0, 0xF8,
  0x3E, 0xF0, 0x7D, 0xF0, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0xBE,
  0x0F, 0x7C, 0x1E, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x7C, 0x3E, 0xF1, 0xF8, 0x79, 0xF3, 0xF9,
  0xF3, 0xE7, 0xF3, 0xE7, 0xCF, 0xE7, 0x87, 0x9D, 0xCF, 0x0F, 0x7B, 0x9E,
  0x1E, 0xF7, 0xFC, 0x3F, 0xEF, 0xF0, 0x3F, 0x9F, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x00,
  0xFC, 0x7E, 0xF8, 0xF8, 0xF9, 0xF1, 0xF7, 0xC1, 0xFF, 0x83, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE1, 0xF7, 0xC3, 0xE7,
  0xCF, 0x8F, 0xBF, 0x0F, 0x80, 0xF8, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xE3,
  0xE3, 0xC7, 0xC7, 0xCF, 0x0F, 0xBE, 0x0F, 0x7C, 0x1E, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x87, 0xC7, 0xE3, 0xF1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x3F, 0x9F, 0x8F, 0x07, 0xE3, 0xF8, 0x7C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFC, 0x7E, 0x1F, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x7C,
  0x3F, 0x1F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0xE3, 0xF0,
  0x78, 0xFC, 0xFE, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC7, 0xE3, 0xF1,
  0xF0, 0x80, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Black27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 19, 8, 1, -19 },
  { 16, 11, 7, 14, 1, -19 },
  { 26, 15, 19, 17, 1, -19 },
  { 62, 13, 23, 15, 1, -21 },
  { 100, 23, 20, 25, 1, -20 },
  { 158, 19, 20, 20, 1, -20 },
  { 206, 5, 7, 7, 1, -19 },
  { 211, 8, 24, 9, 1, -20 },
  { 235, 8, 24, 9, 0, -20 },
  { 259, 13, 13, 14, 0, -21 },
  { 281, 13, 13, 15, 1, -16 },
  { 303, 6, 8, 8, 1, -4 },
  { 309, 7, 4, 9, 1, -9 },
  { 313, 5, 5, 8, 1, -5 },
  { 317, 12, 20, 12, 0, -20 },
  { 347, 13, 20, 15, 1, -20 },
  { 380, 11, 19, 15, 1, -19 },
  { 407, 13, 20, 15, 1, -20 },
  { 440, 13, 20, 15, 1, -20 },
  { 473, 15, 19, 15, 0, -19 },
  { 509, 13, 19, 15, 1, -19 },
  { 540, 13, 20, 15, 1, -20 },
  { 573, 13, 19, 15, 1, -19 },
  { 604, 13, 20, 15, 1, -20 },
  { 637, 13, 20, 15, 1, -20 },
  { 670, 6, 15, 8, 1, -15 },
  { 682, 6, 19, 8, 1, -15 },
  { 697, 13, 14, 15, 1, -17 },
  { 720, 13, 9, 15, 1, -14 },
  { 735, 13, 14, 15, 1, -17 },
  { 758, 12, 20, 13, 0, -20 },
  { 788, 21, 22, 23, 1, -20 },
  { 846, 18, 19, 18, 0, -19 },
  { 889, 14, 19, 17, 2, -19 },
  { 923, 14, 20, 16, 1, -20 },
  { 958, 15, 19, 18, 2, -19 },
  { 994, 11, 19, 14, 2, -19 },
  { 1021, 11, 19, 14, 2, -19 },
  { 1048, 16, 20, 19, 1, -20 },
  { 1088, 15, 19, 19, 2, -19 },
  { 1124, 9, 19, 11, 1, -19 },
  { 1146, 9, 25, 9, -2, -19 },
  { 1175, 15, 19, 17, 2, -19 },
  { 1211, 11, 19, 14, 2, -19 },
  { 1238, 21, 19, 25, 2, -19 },
  { 1288, 17, 19, 21, 2, -19 },
  { 1329, 18, 20, 20, 1, -20 },
  { 1374, 13, 19, 16, 2, -19 },
  { 1405, 18, 25, 20, 1, -20 },
  { 1462, 15, 19, 17, 2, -19 },
  { 1498, 13, 20, 14, 1, -20 },
  { 1531, 13, 19, 15, 1, -19 },
  { 1562, 15, 19, 19, 2, -19 },
  { 1598, 17, 19, 17, 0, -19 },
  { 1639, 26, 19, 26, 0, -19 },
  { 1701, 17, 19, 18, 0, -19 },
  { 1742, 17, 19, 17, 0, -19 },
  { 1783, 13, 19, 15, 1, -19 },
  { 1814, 7, 25, 9, 1, -20 },
  { 1836, 12, 20, 12, 0, -20 },
  { 1866, 6, 25, 9, 1, -20 },
  { 1885, 15, 12, 14, 0, -19 },
  { 1908, 14, 3, 14, 0, 2 },
  { 1914, 8, 5, 11, 1, -21 },
  { 1919, 13, 15, 16, 1, -15 },
  { 1944, 13, 21, 16, 2, -21 },
  { 1979, 12, 15, 14, 1, -15 },
  { 2002, 14, 21, 16, 1, -21 },
  { 2039, 13, 15, 15, 1, -15 },
  { 2064, 11, 21, 10, 0, -21 },
  { 2093, 14, 21, 16, 1, -15 },
  { 2130, 13, 21, 17, 2, -21 },
  { 2165, 5, 21, 8, 2, -21 },
  { 2179, 8, 27, 8, -1, -21 },
  { 2206, 14, 21, 16, 2, -21 },
  { 2243, 5, 21, 8, 2, -21 },
  { 2257, 21, 15, 25, 2, -15 },
  { 2297, 13, 15, 17, 2, -15 },
  { 2322, 14, 15, 16, 1, -15 },
  { 2349, 13, 21, 16, 2, -15 },
  { 2384, 14, 21, 16, 1, -15 },
  { 2421, 9, 15, 12, 2, -15 },
  { 2438, 11, 15, 13, 1, -15 },
  { 2459, 10, 18, 11, 1, -18 },
  { 2482, 13, 15, 17, 2, -15 },
  { 2507, 15, 15, 15, 0, -15 },
  { 2536, 23, 15, 23, 0, -15 },
  { 2580, 15, 15, 15, 0, -15 },
  { 2609, 15, 21, 15, 0, -15 },
  { 2649, 11, 15, 13, 1, -15 },
  { 2670, 9, 25, 11, 1, -20 },
  { 2699, 3, 27, 13, 5, -21 },
  { 2710, 9, 25, 11, 1, -20 },
  { 2739, 13, 5, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Black27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK27PT7B_H_
