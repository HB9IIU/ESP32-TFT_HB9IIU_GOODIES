#ifndef _NOTOSANS_SEMICONDENSED_BLACK23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x07, 0x7B, 0xFE, 0xF3,
  0xFC, 0xEF, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x07, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0x9C, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC7, 0x38, 0x1C, 0xE3, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0x19, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x0C,
  0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xCD, 0xD8, 0x3F, 0x07, 0xF0, 0x7F, 0x83,
  0xF8, 0x3F, 0x86, 0xF8, 0xDF, 0xFF, 0xFF, 0xF7, 0xFC, 0x0C, 0x01, 0x80,
  0x1C, 0x00, 0x03, 0xE0, 0xF0, 0x7F, 0x0E, 0x07, 0x71, 0xE0, 0xF7, 0x1C,
  0x0F, 0x7B, 0xC0, 0x77, 0x38, 0x07, 0x77, 0xBE, 0x7F, 0x77, 0xE3, 0xEF,
  0x7F, 0x1C, 0xEF, 0x70, 0x1E, 0xF7, 0x01, 0xCF, 0x70, 0x3C, 0xF7, 0x03,
  0x87, 0x70, 0x78, 0x7F, 0x07, 0x03, 0xE0, 0x07, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x79, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x1E, 0x7F, 0x9E, 0xFF, 0xFE, 0xF3, 0xFC, 0xF1, 0xFC, 0xF9, 0xF8, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xBF, 0xFF, 0xF7, 0x77, 0x1E, 0x78, 0xE3, 0xC7,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x78, 0xF0,
  0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0xE1, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xE3, 0xCF, 0x00, 0x0F, 0x01,
  0xC0, 0x38, 0x23, 0x17, 0xFE, 0xFF, 0xEF, 0xF0, 0xFC, 0x3F, 0xCF, 0x38,
  0x66, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x7F, 0xBD, 0xEE, 0x70, 0xFF, 0xFF,
  0xFF, 0x77, 0xBF, 0xE0, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x00, 0x0E, 0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0x3D, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x3F, 0xF7, 0x9F, 0xF3, 0xFC,
  0x1F, 0x00, 0x0F, 0x8F, 0xCF, 0xEF, 0xFF, 0xFB, 0xBC, 0x9E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0xFC, 0xFF,
  0xE7, 0xFE, 0x31, 0xE2, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1E, 0x1F,
  0xF3, 0xFF, 0x3F, 0xE4, 0x3C, 0x07, 0x81, 0xF1, 0xFC, 0x3E, 0x07, 0xF8,
  0x1F, 0x01, 0xF0, 0x3F, 0x8F, 0xFF, 0xF7, 0xFE, 0xFF, 0x00, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xDE, 0x3D, 0xE3, 0xBE, 0x7B, 0xEF,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x7F, 0xCF,
  0xF9, 0xFF, 0x38, 0x07, 0x00, 0xFE, 0x3F, 0xE7, 0xFE, 0x7F, 0xC0, 0x7C,
  0x0F, 0x81, 0xFC, 0x7D, 0xFF, 0xBF, 0xE7, 0xF8, 0x03, 0xC3, 0xF8, 0xFF,
  0x3F, 0xE7, 0x81, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xDF, 0x7F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xF7, 0xDF, 0xF3, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x0E, 0x0F, 0xF1, 0xFF, 0x7D, 0xEF,
  0x1F, 0xE7, 0x9F, 0xF3, 0xFC, 0x3F, 0x0F, 0xF3, 0xEF, 0x78, 0xFF, 0x1F,
  0xE3, 0xFF, 0xFB, 0xFE, 0x3F, 0x80, 0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xEF,
  0x3F, 0xE3, 0xFC, 0x7F, 0x9F, 0xFF, 0xFF, 0xFD, 0xF7, 0x88, 0xF0, 0x3C,
  0x0F, 0x9F, 0xE3, 0xF8, 0x7E, 0x00, 0x77, 0xBF, 0xE0, 0x00, 0x00, 0x03,
  0xBD, 0xFF, 0x00, 0x77, 0xBF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0x7B,
  0x9C, 0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0x3F, 0x03, 0xF8,
  0x0F, 0xE0, 0x7C, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xF0, 0x3F, 0x80, 0xFC,
  0x07, 0xC1, 0xF9, 0xFC, 0xFE, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x0E, 0x1F,
  0xEF, 0xFD, 0xFF, 0x43, 0xC0, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x81, 0xC0,
  0x00, 0x00, 0x07, 0x01, 0xE0, 0xF8, 0x1E, 0x00, 0x00, 0xE0, 0x01, 0xFF,
  0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x43, 0x9C, 0xFE, 0xEE, 0x7F, 0x9B,
  0x9C, 0xE7, 0xEE, 0x39, 0xFB, 0x8E, 0x7E, 0xE3, 0x9B, 0xBC, 0xEE, 0xE7,
  0xFF, 0xB8, 0xF7, 0xC7, 0x00, 0x01, 0xE0, 0x10, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x81, 0xEF,
  0x03, 0xDE, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0x7F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0xCF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x1F, 0xE7, 0xFF, 0xF7, 0xFC, 0xFF, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFC, 0x03, 0x81, 0xFF, 0x3F, 0xF7,
  0xFE, 0x7C, 0x27, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0xE6, 0x7F, 0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0x87, 0xFE,
  0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xBC, 0x3D, 0xE3, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xFD, 0xFE, 0xFF, 0x78, 0x3C, 0x1E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83,
  0xFD, 0xFE, 0xFF, 0x7F, 0xBC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x03,
  0xC0, 0xFF, 0xCF, 0xFE, 0xFF, 0xE7, 0xC1, 0x3C, 0x03, 0xE0, 0x1F, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFE, 0x7F, 0xF0, 0xF7, 0x87, 0xBF, 0x3C, 0xFF, 0xE7,
  0xFF, 0x0F, 0xF8, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFF, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFE, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1F, 0xFE, 0xFE, 0xF8, 0xF0, 0xFF, 0x8F, 0xBC, 0xF9, 0xE7,
  0x8F, 0x7C, 0x7B, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x3D, 0xF1,
  0xE7, 0x8F, 0x3E, 0x78, 0xF3, 0xC7, 0xDE, 0x1F, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0x71, 0xFF, 0xB8, 0xFF, 0xDE, 0xFF, 0xEF, 0x77, 0xF3, 0xBB, 0xF9,
  0xDD, 0xFC, 0xFC, 0xFE, 0x3E, 0x7F, 0x1F, 0x3F, 0x8F, 0x9F, 0xC7, 0x8F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x3F, 0xBC, 0xFE, 0xF3,
  0xF9, 0xEF, 0xE7, 0xBF, 0x8F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7,
  0xC7, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xF7, 0x83, 0xCF, 0xDF, 0x8F, 0xFE, 0x1F, 0xF8, 0x0F, 0xE0,
  0xFF, 0x9F, 0xFB, 0xFF, 0x79, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0xFE, 0xFF,
  0xDF, 0xF3, 0xF0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x03, 0x80,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xDF, 0x07, 0xBE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xCF, 0xDF,
  0x8F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xE7, 0xCF, 0x1E, 0x78, 0xF3,
  0xCF, 0x9F, 0xF8, 0xFF, 0x87, 0xFC, 0x3D, 0xE1, 0xE7, 0x8F, 0x3E, 0x78,
  0xF3, 0xC7, 0xDE, 0x1F, 0x0F, 0x07, 0xFD, 0xFF, 0x7F, 0xEF, 0x09, 0xE0,
  0x3F, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0xCF, 0xBF,
  0xF7, 0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF,
  0xFF, 0x7F, 0xE3, 0xF8, 0xF8, 0x3E, 0xF0, 0x79, 0xE1, 0xF3, 0xE3, 0xE7,
  0xC7, 0x87, 0x8F, 0x0F, 0x3E, 0x1F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B,
  0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0xF8, 0x78,
  0x7D, 0xE1, 0xE1, 0xE7, 0x8F, 0x87, 0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0x78,
  0xF3, 0xF3, 0xC3, 0xCF, 0xCF, 0x0F, 0x7F, 0xBC, 0x3D, 0xCE, 0xF0, 0xF7,
  0x3B, 0xC1, 0xDC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7E, 0x1F,
  0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0xF8, 0xF0, 0xF3, 0xE1,
  0xF7, 0x81, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0x8F, 0x8F, 0x1F, 0x1F, 0x7C, 0x1F,
  0xF8, 0x7D, 0xE1, 0xE7, 0xCF, 0x8F, 0x3C, 0x3E, 0xF0, 0x7F, 0x81, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x7C, 0x0F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFC, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x78, 0x0E, 0x03, 0xC0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0xFC, 0x0E, 0x00, 0xF0, 0x0F,
  0x01, 0xF8, 0x1F, 0x83, 0x9C, 0x39, 0xC7, 0x0E, 0x70, 0xEF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0xF0, 0xF0, 0x1F, 0x8F, 0xF9, 0xFF,
  0x91, 0xF0, 0x1E, 0x7F, 0xDF, 0xFF, 0xCF, 0xF1, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF7, 0xCE, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFB, 0x8F, 0x7E, 0xFF,
  0xEF, 0xDF, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF, 0x9F, 0xFF,
  0xEF, 0xFE, 0xF7, 0xC0, 0x1F, 0x8F, 0xF7, 0xFB, 0xF6, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3E, 0x37, 0xFD, 0xFF, 0x1F, 0x80, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF3, 0xDE, 0xFF, 0xDF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xF3, 0xDF, 0xFB, 0xFF, 0x3C, 0xE0, 0x1F, 0x07, 0xF9,
  0xFF, 0x7C, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x05, 0xFF,
  0x3F, 0xE1, 0xFC, 0x06, 0x0F, 0xCF, 0xE7, 0xF3, 0xC1, 0xFF, 0xFF, 0xFF,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00,
  0x3C, 0xEF, 0xDD, 0xFF, 0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFF, 0x3F, 0xFF, 0xBF, 0xF3, 0xDE, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF,
  0xF0, 0x20, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF3, 0xCF, 0x7E,
  0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xF0, 0x77, 0xFE, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x7C, 0xF8, 0xE0, 0x07, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xFF, 0xDF,
  0xBE, 0x10, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x8F, 0xFC, 0xFB,
  0xE7, 0x9F, 0x78, 0xF7, 0xC7, 0xBC, 0x3F, 0xE1, 0xFF, 0x8F, 0xFC, 0x7D,
  0xF3, 0xE7, 0xDF, 0x1E, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF3, 0xC7, 0x9F, 0xFD, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFD, 0xFF, 0x9F, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C, 0x7F, 0xC7, 0x8F,
  0xF8, 0xF1, 0xFF, 0x1E, 0x3F, 0xE3, 0xC7, 0xFC, 0x78, 0xFF, 0x8F, 0x1E,
  0xF3, 0xCF, 0x7E, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xF0, 0x1F, 0x03, 0xFC, 0x7F,
  0xEF, 0x9E, 0xF1, 0xEF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF, 0x9E, 0x7F,
  0xE3, 0xFC, 0x1F, 0x80, 0xF3, 0x8F, 0x7E, 0xFF, 0xEF, 0xDF, 0xF9, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF, 0x9F, 0xFF, 0xEF, 0xFE, 0xF7, 0xCF,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x3C, 0xEF, 0xDD,
  0xFF, 0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x3F, 0xFF,
  0xBF, 0xF3, 0xDE, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF3, 0xFB, 0xFF, 0xFF, 0xEF, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0xFF, 0xDE, 0x2F, 0x87, 0xF1, 0xFC, 0x7F,
  0x0F, 0xC3, 0xFF, 0xFF, 0xEF, 0xE0, 0x1C, 0x0E, 0x0F, 0xEF, 0xFF, 0xF9,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x93, 0xF9, 0xFC, 0x7E, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF9,
  0xFF, 0x9F, 0x7F, 0xF7, 0xFF, 0x3E, 0x70, 0xF0, 0x7F, 0xC7, 0xDE, 0x3C,
  0xF1, 0xE7, 0x8F, 0x1E, 0xF0, 0xF7, 0x83, 0xBC, 0x1D, 0xC0, 0xFE, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x00, 0xF1, 0xF1, 0xEF, 0x3E, 0x3D, 0xE7, 0xE7,
  0xBC, 0xFC, 0xE7, 0x9F, 0xBC, 0x77, 0x77, 0x8E, 0xEE, 0xF1, 0xFD, 0xDC,
  0x3F, 0x9F, 0x83, 0xF3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0xF8, 0xFB, 0xE7, 0x8F, 0x7C, 0x7B, 0xC1, 0xFE, 0x0F, 0xE0, 0x3E, 0x03,
  0xF8, 0x1F, 0xC1, 0xEF, 0x0F, 0x7C, 0xF1, 0xEF, 0x8F, 0x80, 0xF0, 0x7F,
  0xC7, 0xDE, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0xF0, 0xF7, 0x83, 0xBC, 0x1D,
  0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x0F, 0xE0,
  0x7E, 0x03, 0xE0, 0x08, 0x00, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x07, 0x83,
  0xC1, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x1F,
  0x3F, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0xF8, 0xE0, 0xF8, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0xF0, 0xF8, 0x78, 0x38, 0x38, 0x38, 0x38,
  0x3C, 0x3F, 0x0F, 0x3F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF8, 0xF8,
  0xE0, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Black23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 16, 7, 1, -16 },
  { 11, 10, 6, 12, 1, -16 },
  { 19, 14, 16, 14, 0, -16 },
  { 47, 11, 18, 13, 1, -17 },
  { 72, 20, 17, 21, 0, -17 },
  { 115, 16, 17, 17, 1, -17 },
  { 149, 4, 6, 6, 1, -16 },
  { 152, 7, 21, 8, 1, -17 },
  { 171, 7, 21, 8, 0, -17 },
  { 190, 11, 11, 12, 0, -18 },
  { 206, 11, 11, 13, 1, -14 },
  { 222, 5, 6, 7, 1, -3 },
  { 226, 6, 4, 7, 1, -8 },
  { 229, 5, 4, 7, 1, -4 },
  { 232, 10, 17, 10, 0, -17 },
  { 254, 11, 17, 13, 1, -17 },
  { 278, 9, 16, 13, 1, -16 },
  { 296, 12, 17, 13, 0, -17 },
  { 322, 11, 17, 13, 1, -17 },
  { 346, 12, 16, 13, 0, -16 },
  { 370, 11, 16, 13, 1, -16 },
  { 392, 11, 17, 13, 1, -17 },
  { 416, 11, 16, 13, 1, -16 },
  { 438, 11, 17, 13, 1, -17 },
  { 462, 11, 17, 13, 1, -17 },
  { 486, 5, 13, 7, 1, -13 },
  { 495, 5, 16, 7, 1, -13 },
  { 505, 11, 12, 13, 1, -14 },
  { 522, 11, 8, 13, 1, -12 },
  { 533, 11, 12, 13, 1, -14 },
  { 550, 10, 17, 11, 0, -17 },
  { 572, 18, 19, 20, 1, -17 },
  { 615, 15, 16, 15, 0, -16 },
  { 645, 11, 16, 15, 2, -16 },
  { 667, 12, 17, 14, 1, -17 },
  { 693, 13, 16, 16, 2, -16 },
  { 719, 9, 16, 12, 2, -16 },
  { 737, 9, 16, 12, 2, -16 },
  { 755, 13, 17, 16, 1, -17 },
  { 783, 13, 16, 16, 2, -16 },
  { 809, 8, 16, 9, 1, -16 },
  { 825, 8, 21, 8, -2, -16 },
  { 846, 13, 16, 15, 2, -16 },
  { 872, 9, 16, 12, 2, -16 },
  { 890, 17, 16, 21, 2, -16 },
  { 924, 14, 16, 18, 2, -16 },
  { 952, 15, 17, 17, 1, -17 },
  { 984, 11, 16, 14, 2, -16 },
  { 1006, 15, 21, 17, 1, -17 },
  { 1046, 13, 16, 14, 2, -16 },
  { 1072, 11, 17, 12, 1, -17 },
  { 1096, 12, 16, 12, 0, -16 },
  { 1120, 12, 16, 16, 2, -16 },
  { 1144, 15, 16, 15, 0, -16 },
  { 1174, 22, 16, 22, 0, -16 },
  { 1218, 15, 16, 15, 0, -16 },
  { 1248, 14, 16, 14, 0, -16 },
  { 1276, 11, 16, 13, 1, -16 },
  { 1298, 6, 21, 7, 1, -17 },
  { 1314, 10, 17, 10, 0, -17 },
  { 1336, 6, 21, 7, 0, -17 },
  { 1352, 12, 10, 12, 0, -16 },
  { 1367, 12, 3, 12, 0, 1 },
  { 1372, 7, 4, 9, 1, -18 },
  { 1376, 11, 13, 13, 1, -13 },
  { 1394, 12, 17, 14, 1, -17 },
  { 1420, 10, 13, 12, 1, -13 },
  { 1437, 11, 17, 14, 1, -17 },
  { 1461, 11, 13, 13, 1, -13 },
  { 1479, 9, 18, 9, 0, -18 },
  { 1500, 11, 19, 14, 1, -13 },
  { 1527, 12, 17, 14, 1, -17 },
  { 1553, 5, 18, 7, 1, -18 },
  { 1565, 7, 24, 7, -1, -18 },
  { 1586, 13, 17, 14, 1, -17 },
  { 1614, 5, 17, 7, 1, -17 },
  { 1625, 19, 13, 21, 1, -13 },
  { 1656, 12, 13, 14, 1, -13 },
  { 1676, 12, 13, 14, 1, -13 },
  { 1696, 12, 19, 14, 1, -13 },
  { 1725, 11, 19, 14, 1, -13 },
  { 1752, 9, 13, 10, 1, -13 },
  { 1767, 9, 13, 11, 1, -13 },
  { 1782, 9, 15, 10, 0, -15 },
  { 1799, 12, 13, 14, 1, -13 },
  { 1819, 13, 13, 13, 0, -13 },
  { 1841, 19, 13, 19, 0, -13 },
  { 1872, 13, 13, 13, 0, -13 },
  { 1894, 13, 19, 13, 0, -13 },
  { 1925, 10, 13, 11, 0, -13 },
  { 1942, 8, 21, 9, 1, -17 },
  { 1963, 3, 23, 11, 4, -18 },
  { 1972, 8, 21, 9, 1, -17 },
  { 1993, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Black23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK23PT7B_H_
