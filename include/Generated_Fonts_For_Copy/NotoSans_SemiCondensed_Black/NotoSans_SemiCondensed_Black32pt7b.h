#ifndef _NOTOSANS_SEMICONDENSED_BLACK32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x00, 0x00, 0x21, 0xF7, 0xFF, 0xFF, 0x9F, 0x00, 0xF9, 0xFF,
  0xCF, 0xFE, 0x7D, 0xF3, 0xEF, 0x9F, 0x7C, 0x7B, 0xE3, 0xDF, 0x1E, 0x03,
  0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xE7,
  0x87, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0x87, 0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0x03, 0x80, 0x03, 0x80, 0x0F, 0xF8, 0x3F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFC, 0xFF, 0x9C, 0xFB, 0x80, 0xFB, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0x9F, 0x83, 0x9E, 0xF3, 0xBE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F,
  0xE0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x3F, 0x00, 0x78, 0x0F, 0xF0,
  0x1F, 0x01, 0xFF, 0x03, 0xC0, 0x7F, 0xE0, 0xF8, 0x0F, 0x3E, 0x1E, 0x01,
  0xE7, 0xC7, 0xC0, 0x3C, 0xF8, 0xF0, 0x07, 0x9F, 0x3E, 0x00, 0xF3, 0xE7,
  0x80, 0x1E, 0x7D, 0xF3, 0xE3, 0xFF, 0x3C, 0xFF, 0x3F, 0xEF, 0xBF, 0xE7,
  0xF9, 0xE7, 0xFE, 0x3E, 0x7D, 0xF3, 0xC0, 0x0F, 0x3E, 0x78, 0x03, 0xE7,
  0xCF, 0x00, 0x78, 0xF9, 0xE0, 0x1F, 0x1F, 0x3C, 0x03, 0xC3, 0xE7, 0x80,
  0xF8, 0x3F, 0xF0, 0x1E, 0x07, 0xFC, 0x07, 0xC0, 0x7F, 0x80, 0xF0, 0x07,
  0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7,
  0xFF, 0x9F, 0x8F, 0xFF, 0xBF, 0x3F, 0x3F, 0xFC, 0x7E, 0x3F, 0xF8, 0xFC,
  0x3F, 0xE1, 0xF8, 0x7F, 0xC3, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C,
  0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F,
  0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x1F, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x04, 0x3C, 0x2F, 0x7B, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xC0, 0x3F, 0xC0, 0xFF, 0xC1, 0xF7, 0xC7, 0xCF, 0x83, 0x8C, 0x01, 0x10,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0xBE,
  0x7C, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x10, 0xFB, 0xFF, 0xF7,
  0xEF, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0x7E, 0x7C, 0x7E, 0xFC, 0x3E, 0xFC,
  0x3E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3E, 0xFC, 0x3E, 0x7C, 0x7E, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1,
  0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0x3D, 0xF8, 0xCF, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xEF, 0x0F, 0xCC, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF,
  0xE6, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x3F, 0xF0, 0x7F, 0x80,
  0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x1F, 0xF8, 0x00, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x7C, 0xFC, 0x78,
  0xFC, 0xF8, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x3F, 0xFC, 0x7F,
  0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7F, 0xE0, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xFC, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFD, 0xF8, 0xFB,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0x7C, 0x3E, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C,
  0x7E, 0x7C, 0x7E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0xFE, 0x7E, 0xFC, 0x3E, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7E, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC,
  0x3E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFE, 0x1F, 0xBE, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x47,
  0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x38, 0xFB, 0xFF,
  0xF7, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8F, 0x9F, 0xFF, 0x7E,
  0xF8, 0x38, 0xFB, 0xFF, 0xF7, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xDF, 0xBE, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x00, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x1F, 0xF1, 0xFF,
  0x8F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x70, 0x00, 0x80, 0x00, 0x1F, 0xE1,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x81, 0xF0, 0x07, 0xC0, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xFC, 0x1F, 0x81, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF0, 0xFF,
  0xBC, 0xF9, 0xFF, 0xDE, 0x79, 0xFF, 0xE7, 0xBC, 0xF8, 0xF3, 0xFE, 0x78,
  0xF9, 0xFE, 0x7C, 0x7C, 0xFF, 0x3C, 0x3E, 0x7F, 0x9E, 0x1E, 0x3F, 0xCF,
  0x8F, 0x1F, 0xE3, 0xC7, 0xDE, 0xF9, 0xFF, 0xFF, 0x3C, 0xFF, 0x7F, 0x1E,
  0x1F, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x80, 0xFC, 0x03, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xEF, 0x80, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C,
  0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xE0, 0xFF,
  0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB,
  0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0xF7, 0xE7, 0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC0,
  0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFC,
  0x19, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x8F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0x0F, 0xEF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xBF, 0x0F, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0x01, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0xFF, 0xFF,
  0x1F, 0xF7, 0xE3, 0xFE, 0xFC, 0x7F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7F,
  0x07, 0xEF, 0xF0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF,
  0xFF, 0xFB, 0xFE, 0xFF, 0x3F, 0x00, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xF0,
  0x7E, 0x7E, 0x1F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x3F, 0x87, 0xE7,
  0xE0, 0xFD, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xE7, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0xBF, 0x03,
  0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xF7, 0x83, 0xFF, 0xFB, 0xE1, 0xFF, 0xFD, 0xF1,
  0xFF, 0xFF, 0xF8, 0xF7, 0xFF, 0xBC, 0x7B, 0xFF, 0xDF, 0x7D, 0xFF, 0xEF,
  0xBE, 0xFF, 0xF7, 0xDE, 0x7F, 0xF9, 0xFF, 0x3F, 0xFC, 0xFF, 0x9F, 0xFE,
  0x7F, 0xCF, 0xFF, 0x1F, 0xC7, 0xFF, 0x8F, 0xE3, 0xFF, 0xC7, 0xF1, 0xFF,
  0xE3, 0xF0, 0xFF, 0xF0, 0xF8, 0x7E, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFB, 0xF1, 0xFF, 0xBF, 0x1F, 0xF9, 0xF9, 0xFF, 0xDF, 0x9F,
  0xFC, 0xFD, 0xFF, 0xCF, 0xDF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0,
  0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7F, 0x03,
  0xF3, 0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFD, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7F,
  0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7F, 0x03, 0xF3,
  0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x1F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC,
  0x3F, 0x3F, 0x1F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xF3, 0xF0, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3F, 0xBF, 0x07, 0xFF, 0xC0, 0xFC, 0x0F, 0xF8, 0x3F,
  0xFC, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xDF, 0x81, 0xBF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0xFD,
  0xF0, 0x3F, 0x03, 0xF7, 0xC0, 0xFC, 0x0F, 0xDF, 0x83, 0xF8, 0x3F, 0x7E,
  0x0F, 0xE0, 0xF8, 0xF8, 0x3F, 0x87, 0xE3, 0xE1, 0xFE, 0x1F, 0x8F, 0x87,
  0xF8, 0x7E, 0x3F, 0x1F, 0xF1, 0xF0, 0xFC, 0x7F, 0xC7, 0xC1, 0xF3, 0xEF,
  0x3F, 0x07, 0xCF, 0xBC, 0xFC, 0x1F, 0x3E, 0xF3, 0xF0, 0x7E, 0xF3, 0xEF,
  0x80, 0xFB, 0xCF, 0xBE, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0,
  0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE,
  0x07, 0xF3, 0xF0, 0x3F, 0x0F, 0xC3, 0xF8, 0x7F, 0x1F, 0x81, 0xF9, 0xFC,
  0x0F, 0xEF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xE3,
  0xF0, 0x7E, 0x1F, 0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xFB, 0xF8, 0x0F, 0xE0,
  0xFC, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3E, 0xF0, 0x1E, 0x7C, 0x0F, 0x1E,
  0x0F, 0x8F, 0x87, 0x83, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xC0, 0xF0, 0x07, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x1C,
  0x7E, 0x10, 0x3F, 0x00, 0x3F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F,
  0xDF, 0x3F, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB,
  0xFC, 0xF9, 0xF8, 0x03, 0xF0, 0x3F, 0xF3, 0xFF, 0xCF, 0xFE, 0x7F, 0xF9,
  0xF8, 0x2F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x05, 0xFE, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xC0, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x0F,
  0x1F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE,
  0x3F, 0x7F, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0x8F, 0x07,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x06, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x0F,
  0xF1, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0x03, 0xF0, 0x3F, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0xFF, 0xE3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F,
  0x9F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE,
  0x3F, 0x7F, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0xBF, 0x00,
  0x3F, 0x00, 0x3F, 0x60, 0x7F, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xF8, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0x73, 0xFF, 0xFF, 0xF8, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF0, 0x20, 0x00, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xFF, 0xF7, 0xFB, 0xFD, 0xFC, 0x70, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC1, 0xFB, 0xF0, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0x8F, 0xCF,
  0xC3, 0xF7, 0xE0, 0xFF, 0xF8, 0x3E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x0F, 0xCF, 0xC3, 0xFB, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x7E, 0x3E, 0xFF, 0x3F, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0x9F, 0xC7, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0,
  0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF,
  0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0,
  0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xF0, 0xF0,
  0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x07,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xF7, 0xF3, 0xF1, 0xFB,
  0xF0, 0x7D, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xE7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x03,
  0xF8, 0x00, 0xF8, 0xF0, 0xFB, 0xFC, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFD, 0xF8, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x1F, 0xDF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0x7F, 0x7F, 0x7F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0xFF,
  0x9E, 0xFB, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC1, 0xFF, 0xDF, 0xFD, 0xFF, 0xEF, 0xC7, 0x7E, 0x03, 0xFC,
  0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xFE, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xFE, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0xB3, 0xFF, 0x3F, 0xF1,
  0xFF, 0x0F, 0xE0, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F,
  0xDF, 0x3F, 0x9F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0xF9, 0xF8, 0x7E,
  0x7E, 0x1F, 0x8F, 0x87, 0xC3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07,
  0xCF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x3F, 0x87, 0xEF,
  0x87, 0xF0, 0xF9, 0xF0, 0xFE, 0x1F, 0x3F, 0x1F, 0xC7, 0xE7, 0xE7, 0xFC,
  0xFC, 0x7C, 0xF7, 0x9F, 0x0F, 0x9E, 0xF3, 0xE1, 0xF3, 0xDE, 0x7C, 0x3F,
  0x7B, 0xDF, 0x83, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xF8, 0xFF,
  0x81, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xDF,
  0x87, 0xE3, 0xF3, 0xF8, 0xFC, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFE, 0x7E, 0x1F, 0xBF,
  0x87, 0xF0, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0xF9, 0xF8, 0x7E, 0x3E,
  0x1F, 0x8F, 0xC7, 0xC3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xEF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE1, 0xFC, 0x3F, 0x87,
  0xF1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x8F,
  0xF1, 0xFC, 0x3F, 0x07, 0xF8, 0x7F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0xC3, 0xF8, 0x7F, 0x83,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xFE,
  0x1F, 0xC1, 0xF8, 0xFF, 0x1F, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC1, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7E, 0x00, 0x7F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x0F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Black32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 23, 9, 1, -23 },
  { 22, 13, 8, 16, 2, -23 },
  { 35, 18, 23, 20, 1, -23 },
  { 87, 16, 26, 18, 1, -24 },
  { 139, 27, 23, 29, 1, -23 },
  { 217, 23, 23, 24, 1, -23 },
  { 284, 5, 8, 9, 2, -23 },
  { 289, 10, 28, 11, 1, -23 },
  { 324, 9, 28, 11, 1, -23 },
  { 356, 15, 15, 16, 1, -24 },
  { 385, 15, 15, 18, 1, -19 },
  { 414, 7, 9, 9, 1, -5 },
  { 422, 9, 5, 10, 1, -11 },
  { 428, 7, 6, 9, 1, -6 },
  { 434, 14, 23, 14, 0, -23 },
  { 475, 16, 23, 18, 1, -23 },
  { 521, 13, 23, 18, 1, -23 },
  { 559, 15, 23, 18, 1, -23 },
  { 603, 15, 23, 18, 1, -23 },
  { 647, 16, 23, 18, 1, -23 },
  { 693, 15, 23, 18, 1, -23 },
  { 737, 16, 23, 18, 1, -23 },
  { 783, 16, 23, 18, 1, -23 },
  { 829, 16, 23, 18, 1, -23 },
  { 875, 16, 23, 18, 1, -23 },
  { 921, 7, 18, 9, 1, -18 },
  { 937, 7, 22, 9, 1, -18 },
  { 957, 15, 17, 18, 1, -20 },
  { 989, 15, 11, 18, 1, -17 },
  { 1010, 15, 17, 18, 1, -20 },
  { 1042, 14, 23, 15, 0, -23 },
  { 1083, 25, 25, 27, 1, -23 },
  { 1162, 21, 23, 21, 0, -23 },
  { 1223, 17, 23, 20, 2, -23 },
  { 1272, 17, 23, 19, 1, -23 },
  { 1321, 18, 23, 22, 2, -23 },
  { 1373, 13, 23, 16, 2, -23 },
  { 1411, 13, 23, 16, 2, -23 },
  { 1449, 19, 23, 22, 1, -23 },
  { 1504, 18, 23, 23, 2, -23 },
  { 1556, 11, 23, 13, 1, -23 },
  { 1588, 10, 30, 11, -2, -23 },
  { 1626, 19, 23, 20, 2, -23 },
  { 1681, 14, 23, 17, 2, -23 },
  { 1722, 25, 23, 29, 2, -23 },
  { 1794, 20, 23, 25, 2, -23 },
  { 1852, 21, 23, 23, 1, -23 },
  { 1913, 16, 23, 19, 2, -23 },
  { 1959, 21, 28, 23, 1, -23 },
  { 2033, 18, 23, 20, 2, -23 },
  { 2085, 15, 23, 17, 1, -23 },
  { 2129, 16, 23, 17, 1, -23 },
  { 2175, 18, 23, 22, 2, -23 },
  { 2227, 21, 23, 21, 0, -23 },
  { 2288, 30, 23, 31, 0, -23 },
  { 2375, 21, 23, 21, 0, -23 },
  { 2436, 20, 23, 20, 0, -23 },
  { 2494, 16, 23, 18, 1, -23 },
  { 2540, 7, 28, 10, 2, -23 },
  { 2565, 14, 23, 14, 0, -23 },
  { 2606, 7, 28, 10, 1, -23 },
  { 2631, 17, 15, 17, 0, -23 },
  { 2663, 16, 4, 16, 0, 2 },
  { 2671, 10, 6, 12, 1, -25 },
  { 2679, 16, 18, 18, 1, -18 },
  { 2715, 16, 24, 19, 2, -24 },
  { 2763, 14, 18, 16, 1, -18 },
  { 2795, 16, 24, 19, 1, -24 },
  { 2843, 16, 18, 18, 1, -18 },
  { 2879, 12, 24, 12, 1, -24 },
  { 2915, 16, 26, 19, 1, -18 },
  { 2967, 16, 24, 20, 2, -24 },
  { 3015, 6, 25, 10, 2, -25 },
  { 3034, 9, 33, 10, -1, -25 },
  { 3072, 18, 24, 19, 2, -24 },
  { 3126, 6, 24, 10, 2, -24 },
  { 3144, 26, 18, 30, 2, -18 },
  { 3203, 16, 18, 20, 2, -18 },
  { 3239, 17, 18, 19, 1, -18 },
  { 3278, 16, 26, 19, 2, -18 },
  { 3330, 16, 26, 19, 1, -18 },
  { 3382, 12, 18, 14, 2, -18 },
  { 3409, 13, 18, 15, 1, -18 },
  { 3439, 12, 21, 13, 1, -21 },
  { 3471, 16, 18, 20, 2, -18 },
  { 3507, 18, 18, 18, 0, -18 },
  { 3548, 27, 18, 27, 0, -18 },
  { 3609, 18, 18, 18, 0, -18 },
  { 3650, 18, 26, 18, 0, -18 },
  { 3709, 13, 18, 15, 1, -18 },
  { 3739, 11, 28, 13, 1, -23 },
  { 3778, 5, 31, 15, 5, -24 },
  { 3798, 11, 28, 13, 1, -23 },
  { 3837, 15, 6, 18, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_Black32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK32PT7B_H_
