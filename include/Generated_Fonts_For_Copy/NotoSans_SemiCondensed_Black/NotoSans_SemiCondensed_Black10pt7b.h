#ifndef _NOTOSANS_SEMICONDENSED_BLACK10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black10pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x1C, 0xBA, 0x28, 0xAF, 0xDE, 0xFD, 0x45, 0x00, 0x23, 0xFB,
  0xC7, 0x97, 0xEE, 0x20, 0x66, 0x7A, 0x3F, 0x0D, 0x71, 0xF8, 0xBC, 0xCC,
  0x78, 0xD1, 0xE3, 0xBD, 0xFB, 0x9F, 0x80, 0xC0, 0x69, 0x6D, 0x93, 0x20,
  0xCD, 0xB6, 0xDA, 0xC0, 0x21, 0x3E, 0xE5, 0x80, 0x21, 0x3E, 0x42, 0x00,
  0x70, 0xE0, 0x70, 0x33, 0x26, 0x64, 0xC0, 0x72, 0xF7, 0xBD, 0xBD, 0xC0,
  0x3F, 0x51, 0x11, 0x10, 0xFA, 0xC6, 0x66, 0x3F, 0xE0, 0xFA, 0xC6, 0xE1,
  0xCF, 0xC0, 0x19, 0xDE, 0xBF, 0xFC, 0x60, 0x7A, 0x1C, 0xF1, 0xCF, 0xC0,
  0x7B, 0x35, 0xFD, 0xBD, 0xE0, 0xF8, 0xC6, 0x63, 0x11, 0x80, 0x7A, 0xDE,
  0xED, 0xED, 0xE0, 0x76, 0xF6, 0xF7, 0x8D, 0xC0, 0x70, 0x70, 0x70, 0x1C,
  0x09, 0xB0, 0x70, 0x80, 0xF8, 0x3E, 0xC3, 0x86, 0xEC, 0x00, 0xF4, 0xCC,
  0xC0, 0x31, 0x80, 0x3E, 0x63, 0x5D, 0xF5, 0xF5, 0x5E, 0x62, 0x1C, 0x38,
  0x71, 0xA3, 0x67, 0xDF, 0xB1, 0x80, 0xF6, 0xF7, 0xED, 0xFF, 0xC0, 0x3D,
  0xA4, 0x30, 0x41, 0xA3, 0x80, 0xF6, 0xF7, 0xBD, 0xFF, 0xC0, 0xFC, 0xCF,
  0xCF, 0xF0, 0xFC, 0xCE, 0xCC, 0xC0, 0x3D, 0x94, 0x37, 0x6D, 0xB3, 0xC0,
  0xCE, 0x73, 0xFC, 0xE7, 0x20, 0xF6, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33,
  0x32, 0xE0, 0xDF, 0xBD, 0xEF, 0x6F, 0x60, 0xCC, 0xCC, 0xCF, 0xF0, 0xC7,
  0xDF, 0xBD, 0x5B, 0xB7, 0x64, 0x80, 0xCF, 0xBE, 0xEF, 0xBE, 0x79, 0xC0,
  0x7C, 0xDD, 0x1E, 0x36, 0x6D, 0x8F, 0x00, 0xF7, 0xF7, 0xEE, 0x63, 0x00,
  0x7C, 0xDD, 0x1E, 0x36, 0x6D, 0x8F, 0x06, 0x06, 0xF6, 0xF7, 0xEF, 0x6B,
  0x60, 0x7E, 0x58, 0xF1, 0xEF, 0xC0, 0xF9, 0x8C, 0x63, 0x18, 0xC0, 0xDE,
  0xF7, 0xBD, 0xED, 0xC0, 0xCF, 0x36, 0xDA, 0x78, 0xE3, 0x00, 0xCC, 0xE6,
  0xD7, 0x6F, 0xB7, 0x73, 0xB8, 0xCC, 0xCD, 0xE3, 0x8C, 0x79, 0xBC, 0xC0,
  0xCD, 0xE7, 0x8C, 0x30, 0xC3, 0x00, 0xF8, 0xCC, 0x66, 0x7F, 0xE0, 0xEA,
  0xAB, 0xC0, 0xC4, 0x66, 0x23, 0x10, 0xED, 0xB6, 0xDF, 0xE0, 0x23, 0x95,
  0xB8, 0x80, 0xF8, 0xE4, 0x33, 0xC7, 0xFD, 0xB4, 0x84, 0x29, 0xE9, 0xCF,
  0xDE, 0x33, 0xF1, 0x86, 0xBC, 0x08, 0x4A, 0xFC, 0xE5, 0xED, 0x33, 0xF3,
  0xF4, 0xBC, 0x37, 0x7F, 0x66, 0x66, 0x2B, 0xF3, 0x97, 0xB4, 0x2F, 0x84,
  0x2D, 0xED, 0xCE, 0x73, 0xFF, 0x55, 0x55, 0x70, 0x84, 0x27, 0x6A, 0x7A,
  0xD3, 0xFF, 0xB6, 0xFF, 0x9B, 0x9B, 0x9B, 0x9B, 0xB7, 0xA7, 0x39, 0xCC,
  0x31, 0xEC, 0xB3, 0x59, 0xE0, 0xA7, 0xA7, 0x3F, 0x7A, 0x10, 0x2B, 0xF3,
  0x97, 0xB4, 0x21, 0xBF, 0x49, 0x00, 0x2F, 0xE7, 0x9F, 0x67, 0xF6, 0x67,
  0x70, 0x9C, 0xE7, 0x3F, 0xFC, 0xCF, 0x25, 0x9E, 0x70, 0xC0, 0xD9, 0xDB,
  0x5F, 0x5F, 0x76, 0x76, 0xCD, 0xE7, 0x1C, 0x7B, 0x70, 0xCF, 0x25, 0x9E,
  0x70, 0xC3, 0x38, 0xFF, 0x36, 0x4F, 0x36, 0x6E, 0xE6, 0x67, 0x30, 0xFF,
  0xC0, 0xE6, 0x67, 0x36, 0x6E, 0xC0, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Black10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 3, 0, -7 },
  { 3, 4, 2, 5, 1, -7 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 9, 7, 9, 0, -7 },
  { 24, 7, 7, 7, 0, -7 },
  { 31, 1, 2, 3, 1, -7 },
  { 32, 3, 9, 3, 0, -7 },
  { 36, 3, 9, 3, 0, -7 },
  { 40, 5, 5, 5, 0, -8 },
  { 44, 5, 5, 6, 0, -6 },
  { 48, 2, 2, 3, 0, -1 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 2, 2, 3, 0, -2 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 5, 7, 6, 0, -7 },
  { 60, 4, 7, 6, 0, -7 },
  { 64, 5, 7, 6, 0, -7 },
  { 69, 5, 7, 6, 0, -7 },
  { 74, 5, 7, 6, 0, -7 },
  { 79, 5, 7, 6, 0, -7 },
  { 84, 5, 7, 6, 0, -7 },
  { 89, 5, 7, 6, 0, -7 },
  { 94, 5, 7, 6, 0, -7 },
  { 99, 5, 7, 6, 0, -7 },
  { 104, 2, 6, 3, 0, -6 },
  { 106, 2, 7, 3, 0, -6 },
  { 108, 5, 5, 6, 0, -6 },
  { 112, 5, 3, 6, 0, -5 },
  { 114, 5, 5, 6, 0, -6 },
  { 118, 5, 7, 5, 0, -7 },
  { 123, 8, 8, 8, 0, -7 },
  { 131, 7, 7, 7, 0, -7 },
  { 138, 5, 7, 6, 1, -7 },
  { 143, 6, 7, 6, 0, -7 },
  { 149, 5, 7, 7, 1, -7 },
  { 154, 4, 7, 5, 1, -7 },
  { 158, 4, 7, 5, 1, -7 },
  { 162, 6, 7, 7, 0, -7 },
  { 168, 5, 7, 7, 1, -7 },
  { 173, 4, 7, 4, 0, -7 },
  { 177, 4, 9, 3, -1, -7 },
  { 182, 5, 7, 6, 1, -7 },
  { 187, 4, 7, 5, 1, -7 },
  { 191, 7, 7, 9, 1, -7 },
  { 198, 6, 7, 8, 1, -7 },
  { 204, 7, 7, 7, 0, -7 },
  { 211, 5, 7, 6, 1, -7 },
  { 216, 7, 9, 7, 0, -7 },
  { 224, 5, 7, 6, 1, -7 },
  { 229, 5, 7, 5, 0, -7 },
  { 234, 5, 7, 5, 0, -7 },
  { 239, 5, 7, 7, 1, -7 },
  { 244, 6, 7, 6, 0, -7 },
  { 250, 9, 7, 10, 0, -7 },
  { 258, 6, 7, 6, 0, -7 },
  { 264, 6, 7, 6, 0, -7 },
  { 270, 5, 7, 6, 0, -7 },
  { 275, 2, 9, 3, 1, -7 },
  { 278, 4, 7, 4, 0, -7 },
  { 282, 3, 9, 3, 0, -7 },
  { 286, 5, 5, 5, 0, -7 },
  { 290, 5, 1, 5, 0, 1 },
  { 291, 3, 2, 4, 0, -8 },
  { 292, 5, 6, 6, 0, -6 },
  { 296, 5, 8, 6, 1, -8 },
  { 301, 5, 6, 5, 0, -6 },
  { 305, 5, 8, 6, 0, -8 },
  { 310, 5, 6, 6, 0, -6 },
  { 314, 4, 8, 4, 0, -8 },
  { 318, 5, 8, 6, 0, -6 },
  { 323, 5, 8, 6, 1, -8 },
  { 328, 1, 8, 3, 1, -8 },
  { 329, 2, 10, 3, 0, -8 },
  { 332, 5, 8, 6, 1, -8 },
  { 337, 1, 8, 3, 1, -8 },
  { 338, 8, 6, 9, 1, -6 },
  { 344, 5, 6, 6, 1, -6 },
  { 348, 6, 6, 6, 0, -6 },
  { 353, 5, 8, 6, 1, -6 },
  { 358, 5, 8, 6, 0, -6 },
  { 363, 3, 6, 4, 1, -6 },
  { 366, 4, 6, 5, 0, -6 },
  { 369, 4, 7, 4, 0, -7 },
  { 373, 5, 6, 6, 1, -6 },
  { 377, 6, 6, 6, 0, -6 },
  { 382, 8, 6, 8, 0, -6 },
  { 388, 6, 6, 6, 0, -6 },
  { 393, 6, 8, 6, 0, -6 },
  { 399, 4, 6, 5, 0, -6 },
  { 402, 4, 9, 4, 0, -7 },
  { 407, 1, 10, 5, 2, -8 },
  { 409, 4, 9, 4, 0, -7 },
  { 414, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Black10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK10PT7B_H_
