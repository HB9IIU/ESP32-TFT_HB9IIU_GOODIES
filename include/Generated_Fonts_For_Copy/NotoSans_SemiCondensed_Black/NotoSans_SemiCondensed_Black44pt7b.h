#ifndef _NOTOSANS_SEMICONDENSED_BLACK44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x7F, 0x7F, 0xBF, 0xDF, 0xFF, 0xF7, 0xF9, 0xF8,
  0x10, 0xFF, 0x3F, 0xFF, 0xC7, 0xF7, 0xF1, 0xFD, 0xFC, 0x7F, 0x7F, 0x1F,
  0xDF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E, 0x1F, 0x9F, 0x87, 0xE7,
  0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0,
  0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F,
  0x80, 0x07, 0xC3, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x00,
  0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xF9, 0xE1, 0x8F, 0xE7,
  0x80, 0x3F, 0x9E, 0x00, 0x7F, 0x78, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xEF, 0xF0, 0x07, 0x9F, 0xD0, 0x1E,
  0x7F, 0x60, 0x79, 0xFD, 0xF9, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0x04, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x80,
  0x1F, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xF0, 0x03, 0xFB, 0xF8,
  0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x7E, 0x00, 0x3F, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x7E, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE1,
  0xF8, 0x00, 0x3F, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x03,
  0xF1, 0xF9, 0xF8, 0x7F, 0x07, 0xEF, 0xE7, 0xE7, 0xFE, 0x1F, 0xFF, 0x3F,
  0x3F, 0xFC, 0x7F, 0xFC, 0xFC, 0xFF, 0xF8, 0xFF, 0xE7, 0xE7, 0xFF, 0xE1,
  0xFF, 0x1F, 0x9F, 0x9F, 0xC1, 0xF0, 0xFC, 0x7E, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x8F, 0xC0,
  0x03, 0xF0, 0x7E, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0xFC, 0x00, 0x7E, 0x07,
  0xE3, 0xF0, 0x01, 0xF8, 0x1F, 0x9F, 0xC0, 0x0F, 0xC0, 0x7F, 0xFE, 0x00,
  0x3F, 0x00, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0x83, 0xFC, 0x1F, 0xFF,
  0x87, 0xFC, 0x3F, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0xE7, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0x9F, 0xFF, 0xF0, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC3,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xEF, 0xFC, 0x03, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x08, 0x0F, 0x81, 0x38, 0x7C, 0x39, 0xFB, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFB, 0xF8, 0x3F, 0x9F,
  0xE0, 0xFC, 0x7E, 0x01, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x9F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x3F, 0xBF, 0xDF, 0xEF,
  0xFF, 0xFB, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xF1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F,
  0xBF, 0xC3, 0xFD, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1,
  0xFE, 0xFF, 0x0F, 0xF3, 0xFC, 0xFF, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xDF, 0xE7, 0xCF, 0xF1,
  0xC7, 0xF8, 0x43, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xE1,
  0xFF, 0x1C, 0x07, 0xF8, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0x81,
  0xFF, 0x10, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x80,
  0x7F, 0xFF, 0x00, 0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F,
  0xCF, 0xF0, 0x7F, 0x1F, 0xE0, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x30, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC7,
  0xE0, 0x7F, 0x3F, 0xE1, 0xFD, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0x7F,
  0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x87,
  0xFC, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFC,
  0xFF, 0x9F, 0xE1, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x7F, 0x87, 0xF9, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x87, 0xFB, 0xFC,
  0x0F, 0xEF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x1F,
  0xF7, 0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFE, 0xFE, 0x0F, 0xF3, 0xF8, 0x06, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x18, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1F, 0xDF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x04, 0x00, 0x0C, 0x0F, 0xE7, 0xF9,
  0xFF, 0x7F, 0xDF, 0xF7, 0xF8, 0xFE, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xC0, 0xFF, 0x20, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x0F, 0xC3,
  0xFF, 0xE7, 0xE7, 0xE1, 0xFF, 0xF9, 0xF9, 0xF8, 0xFF, 0xFE, 0x3E, 0x7C,
  0x7F, 0xFF, 0x8F, 0xBF, 0x1F, 0x87, 0xE3, 0xFF, 0xCF, 0xE1, 0xF8, 0xFF,
  0xE3, 0xF0, 0x7E, 0x3F, 0xF8, 0xFC, 0x1F, 0x8F, 0xFE, 0x3F, 0x07, 0xE3,
  0xFF, 0x8F, 0xC1, 0xF8, 0xFF, 0xE3, 0xF0, 0x7E, 0x3E, 0xF8, 0xFC, 0x1F,
  0x8F, 0xBE, 0x3F, 0x0F, 0xE7, 0xEF, 0xC7, 0xFF, 0xFF, 0xF3, 0xF1, 0xFF,
  0xFF, 0xFC, 0xFC, 0x3F, 0xF7, 0xFE, 0x1F, 0x87, 0xFC, 0xFF, 0x07, 0xE0,
  0x7C, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x38, 0x00, 0xFF, 0xE1, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xF0,
  0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE,
  0x07, 0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x7F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xF8, 0x1C, 0x7F, 0xE0, 0x08, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x0C, 0x7F, 0xF1, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFC, 0x3F, 0xF9, 0xFE, 0x07, 0xFE,
  0xFF, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x0F, 0xFB, 0xFC, 0x0F, 0xFD, 0xFE,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE0, 0x38, 0x7F, 0xE0, 0x02, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7,
  0xFC, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0xE0, 0x3F, 0xCF, 0xFF, 0x3F,
  0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0xCF,
  0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0,
  0xFF, 0x1F, 0xF0, 0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xEF, 0xF8,
  0x0F, 0xF7, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFB,
  0xFC, 0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xC0, 0xFF, 0x9F,
  0xE0, 0x7F, 0xCF, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xFB, 0xFC, 0x03, 0xFE,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xF7, 0xFF, 0xEF, 0xC0, 0xFF,
  0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xFE, 0xFE, 0x1F, 0xBF, 0xFF, 0xBF, 0x87,
  0xEF, 0xFF, 0xE7, 0xE1, 0xFB, 0xFF, 0xF9, 0xFC, 0x7E, 0xFF, 0xFE, 0x7F,
  0x3F, 0x3F, 0xFF, 0x8F, 0xCF, 0xCF, 0xFF, 0xE3, 0xF3, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F,
  0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xE0,
  0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0x83, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xEF, 0xF0, 0xFF, 0xFE, 0xFF, 0x8F, 0xFF,
  0xE7, 0xF8, 0xFF, 0xFE, 0x7F, 0xCF, 0xFF, 0xE3, 0xFC, 0xFF, 0xFE, 0x3F,
  0xEF, 0xFF, 0xE1, 0xFE, 0x7F, 0xFE, 0x1F, 0xF7, 0xFF, 0xE0, 0xFF, 0x7F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC,
  0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xE7,
  0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xF1, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x7F, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x07,
  0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC,
  0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01,
  0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x07, 0xFC,
  0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFC, 0x3F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0x7F,
  0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x87,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFE,
  0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0xCF, 0xF0,
  0x1F, 0xF7, 0xF8, 0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xF8, 0x3C, 0xFF, 0x00, 0x4F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0x03, 0xFE, 0x7F, 0xF7, 0xFF,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF7, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00,
  0x7F, 0x9F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF9,
  0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xDF, 0xE0, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF8, 0x07, 0xF9,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0x8F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFF,
  0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xFF, 0x87, 0xF8, 0x1F,
  0xE1, 0xFF, 0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0xFC, 0x7F, 0x80, 0xFE, 0x3F,
  0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xCF, 0xCF, 0xF0, 0x0F, 0xF3, 0xF3, 0xF3,
  0xFC, 0x03, 0xFC, 0xFC, 0xFC, 0xFF, 0x00, 0x7F, 0x7F, 0x3F, 0xBF, 0x80,
  0x1F, 0xDF, 0x87, 0xEF, 0xE0, 0x07, 0xF7, 0xE1, 0xFB, 0xF8, 0x01, 0xFD,
  0xF8, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF3, 0xFC, 0x03, 0xFE, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFD, 0xFE, 0x00,
  0xFF, 0x9F, 0xF0, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xF9, 0xFF,
  0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE,
  0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F,
  0xC7, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF8, 0x3F,
  0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xF8, 0x7F, 0x81,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFC, 0x3F, 0xDF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF7, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF, 0xCF, 0xFE, 0x3F, 0x0F, 0xF0,
  0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0x03, 0xFC, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xBF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xE3, 0xFE, 0xFF, 0x07, 0xFB,
  0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFB, 0xFC, 0x1F,
  0xEF, 0xF8, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xBF, 0xF0, 0xFC, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x7F,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFC, 0x0C, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x0B, 0xFF, 0x07, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0x83, 0xFC, 0x3F, 0xCF, 0xF1,
  0xFF, 0xBF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFE, 0x7F,
  0x0F, 0xE1, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x0C, 0xFF, 0xEF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x01,
  0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xD8,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xC7, 0xF1, 0xFF, 0xBF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xBF, 0xC7, 0xFE, 0xFF, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x70, 0x0F, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x10,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x0F, 0x03, 0xF9, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xBF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x3E, 0x3F, 0x9F, 0xFF,
  0xF7, 0xFB, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xC0, 0x03,
  0xE0, 0x3F, 0x81, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87,
  0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x03, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0x07,
  0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F,
  0xC0, 0xFE, 0x7F, 0xC0, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x9F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03,
  0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x7C, 0x1F, 0x8F, 0xF8, 0x3F, 0xE3, 0xF3, 0xFF,
  0xCF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF1, 0xFF,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xE0,
  0x7F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF,
  0x07, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F,
  0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFE, 0x0F, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0x03, 0xF1, 0xFF, 0x0F, 0xCF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFC,
  0x00, 0x78, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFC, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x03,
  0xF1, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xBF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xE3, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F,
  0xEF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF8,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xEF, 0xFE,
  0x3F, 0x9F, 0xF0, 0xFF, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xC7, 0xF1, 0xFF, 0xBF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xBF, 0xC7, 0xFE, 0xFF, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0x39, 0xFC, 0x04, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE1, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xF7, 0xF3, 0xFF, 0x9F,
  0xC7, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F,
  0xCF, 0xF0, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFB, 0xFC,
  0x1F, 0xF0, 0x3F, 0x9F, 0xE0, 0xFF, 0xC1, 0xFC, 0xFF, 0x0F, 0xFE, 0x1F,
  0xE3, 0xF8, 0x7F, 0xF0, 0xFF, 0x1F, 0xC3, 0xFF, 0x87, 0xF0, 0xFF, 0x1F,
  0x7C, 0x3F, 0x87, 0xF8, 0xFB, 0xF3, 0xFC, 0x1F, 0xCF, 0xDF, 0x9F, 0xE0,
  0xFE, 0x7E, 0xFC, 0xFE, 0x07, 0xF3, 0xF7, 0xE7, 0xF0, 0x3F, 0x9F, 0xBF,
  0x3F, 0x80, 0xFE, 0xFC, 0xFD, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F,
  0xFE, 0x3F, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF,
  0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF,
  0x9F, 0xE0, 0xFF, 0x8F, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC0, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xFD, 0xFF, 0x03, 0xFC, 0x7F, 0x83,
  0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFD, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3,
  0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFE, 0x00, 0x0E, 0x00, 0x0B, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xD0, 0x07, 0xFC,
  0x80, 0x03, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Black44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 32, 12, 2, -31 },
  { 37, 18, 11, 22, 2, -31 },
  { 62, 26, 31, 27, 1, -31 },
  { 163, 22, 36, 24, 1, -33 },
  { 262, 38, 32, 40, 1, -32 },
  { 414, 32, 32, 33, 1, -32 },
  { 542, 8, 11, 12, 2, -31 },
  { 553, 12, 39, 15, 2, -32 },
  { 612, 13, 39, 15, 1, -32 },
  { 676, 21, 20, 23, 1, -33 },
  { 729, 21, 21, 24, 2, -26 },
  { 785, 10, 12, 13, 1, -6 },
  { 800, 12, 7, 14, 1, -15 },
  { 811, 9, 9, 12, 2, -8 },
  { 822, 19, 32, 19, 0, -32 },
  { 898, 21, 32, 24, 2, -32 },
  { 982, 17, 31, 24, 2, -31 },
  { 1048, 21, 32, 24, 1, -32 },
  { 1132, 21, 32, 24, 1, -32 },
  { 1216, 23, 31, 24, 1, -31 },
  { 1306, 20, 31, 24, 2, -31 },
  { 1384, 22, 32, 24, 1, -32 },
  { 1472, 21, 31, 24, 2, -31 },
  { 1554, 22, 32, 24, 1, -32 },
  { 1642, 22, 32, 24, 1, -32 },
  { 1730, 9, 26, 13, 2, -25 },
  { 1760, 10, 31, 13, 1, -25 },
  { 1799, 21, 24, 24, 2, -28 },
  { 1862, 21, 15, 24, 2, -23 },
  { 1902, 21, 24, 24, 2, -28 },
  { 1965, 20, 33, 21, 0, -32 },
  { 2048, 34, 35, 37, 2, -32 },
  { 2197, 29, 32, 29, 0, -32 },
  { 2313, 23, 31, 28, 3, -31 },
  { 2403, 23, 32, 26, 2, -32 },
  { 2495, 25, 31, 30, 3, -31 },
  { 2592, 17, 31, 22, 3, -31 },
  { 2658, 17, 31, 22, 3, -31 },
  { 2724, 26, 32, 30, 2, -32 },
  { 2828, 25, 31, 31, 3, -31 },
  { 2925, 16, 31, 18, 1, -31 },
  { 2987, 14, 41, 14, -3, -31 },
  { 3059, 25, 31, 28, 3, -31 },
  { 3156, 19, 31, 23, 3, -31 },
  { 3230, 34, 31, 40, 3, -31 },
  { 3362, 28, 31, 34, 3, -31 },
  { 3471, 28, 32, 32, 2, -32 },
  { 3583, 22, 31, 26, 3, -31 },
  { 3669, 29, 39, 32, 2, -32 },
  { 3811, 25, 31, 28, 3, -31 },
  { 3908, 20, 32, 23, 2, -32 },
  { 3988, 22, 31, 24, 1, -31 },
  { 4074, 25, 31, 31, 3, -31 },
  { 4171, 28, 31, 28, 0, -31 },
  { 4280, 42, 31, 42, 0, -31 },
  { 4443, 28, 31, 29, 0, -31 },
  { 4552, 27, 31, 27, 0, -31 },
  { 4657, 23, 31, 25, 1, -31 },
  { 4747, 11, 39, 14, 2, -32 },
  { 4801, 19, 32, 19, 0, -32 },
  { 4877, 11, 39, 14, 1, -32 },
  { 4931, 24, 21, 23, 0, -32 },
  { 4994, 22, 5, 22, 0, 3 },
  { 5008, 13, 7, 17, 2, -34 },
  { 5020, 22, 25, 25, 1, -25 },
  { 5089, 22, 33, 26, 3, -33 },
  { 5180, 19, 25, 22, 2, -25 },
  { 5240, 22, 33, 26, 2, -33 },
  { 5331, 21, 25, 25, 2, -25 },
  { 5397, 17, 34, 17, 1, -34 },
  { 5470, 22, 36, 26, 2, -25 },
  { 5569, 22, 33, 27, 3, -33 },
  { 5660, 9, 34, 13, 2, -34 },
  { 5699, 13, 45, 13, -2, -34 },
  { 5773, 24, 33, 27, 3, -33 },
  { 5872, 8, 33, 13, 3, -33 },
  { 5905, 35, 25, 41, 3, -25 },
  { 6015, 22, 25, 27, 3, -25 },
  { 6084, 22, 25, 26, 2, -25 },
  { 6153, 22, 36, 26, 3, -25 },
  { 6252, 22, 36, 26, 2, -25 },
  { 6351, 16, 25, 19, 3, -25 },
  { 6401, 17, 25, 21, 2, -25 },
  { 6455, 16, 29, 19, 1, -29 },
  { 6513, 22, 24, 27, 3, -24 },
  { 6579, 25, 24, 25, 0, -24 },
  { 6654, 37, 24, 37, 0, -24 },
  { 6765, 25, 24, 25, 0, -24 },
  { 6840, 25, 35, 25, 0, -24 },
  { 6950, 19, 24, 21, 1, -24 },
  { 7007, 16, 39, 18, 1, -32 },
  { 7085, 5, 44, 21, 8, -34 },
  { 7113, 16, 39, 18, 1, -32 },
  { 7191, 21, 9, 24, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Black44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK44PT7B_H_
