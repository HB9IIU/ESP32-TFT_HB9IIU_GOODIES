#ifndef _NOTOSANS_SEMICONDENSED_BLACK37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0xFF, 0xFF, 0xFE, 0xF8,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xBF,
  0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF8,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x0F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1F,
  0x00, 0x78, 0xF8, 0x07, 0xC7, 0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x3E, 0x3C, 0x01, 0xF1, 0xE0,
  0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x3F, 0xFC, 0x3F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFC, 0xE1, 0x3F, 0x38,
  0x0F, 0xCE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x0E, 0xFC, 0x03, 0x9F, 0x40,
  0xEF, 0xDE, 0x3B, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0x80, 0xFF, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x00, 0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x7F, 0xF0,
  0x3E, 0x00, 0xFF, 0xF0, 0x3E, 0x00, 0xF9, 0xF0, 0x7C, 0x00, 0xF9, 0xF8,
  0x7C, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF9, 0xF9,
  0xF0, 0x00, 0xF9, 0xF9, 0xF0, 0x00, 0xF9, 0xF3, 0xE3, 0xF0, 0xFF, 0xF3,
  0xE7, 0xFC, 0x7F, 0xF7, 0xCF, 0xFC, 0x7F, 0xE7, 0xCF, 0xFE, 0x3F, 0xCF,
  0x9F, 0xBE, 0x0F, 0x0F, 0x9F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x7C,
  0x1F, 0x1F, 0x00, 0x7C, 0x1F, 0xBE, 0x00, 0xF8, 0x0F, 0xFE, 0x00, 0xF8,
  0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xF8, 0x3F, 0xF8, 0x7F, 0x0F, 0xFF, 0x8F,
  0xE3, 0xFF, 0xFB, 0xF8, 0x7F, 0x7F, 0xFF, 0x1F, 0xCF, 0xFF, 0xE3, 0xF8,
  0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0x0F, 0xE0, 0xFF, 0xC1, 0xFE, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xEF, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x7C, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F,
  0xC7, 0xE3, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x04, 0x3E, 0x1F, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0xC1, 0xFB, 0xF1, 0xF8,
  0xFC, 0x3C, 0x78, 0x04, 0x10, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x7E, 0x1F, 0xDF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F,
  0x7F, 0x1F, 0x9F, 0xCF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xE3, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFE, 0x79, 0xFC, 0x63,
  0xF8, 0x47, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xC3, 0xF8, 0xE0, 0x7E, 0x10,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0x83, 0xF8, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xF7, 0xE0, 0x7F, 0xFC, 0x1F, 0xBF, 0x83,
  0xE7, 0xF0, 0xFC, 0xFE, 0x3F, 0x1F, 0xC7, 0xC3, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x83, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x84, 0x07, 0xEF, 0xE3, 0xF7, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD,
  0xF8, 0x3F, 0x7F, 0x1F, 0xDF, 0xCF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF0,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xCF, 0xE7, 0xE1, 0xFD, 0xF8, 0x7E, 0x7F,
  0x1F, 0x9F, 0xEF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xBF, 0x9F, 0xC7, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xEF, 0xF3, 0xFB, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xEF, 0xC3, 0xF3, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x39, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF,
  0xF7, 0xC0, 0x1C, 0x7E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0xFC, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0,
  0xFE, 0x40, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x87, 0xE1, 0xFE,
  0x3E, 0x3E, 0x3F, 0xFD, 0xF1, 0xE3, 0xFF, 0xE7, 0xDF, 0x1F, 0xFF, 0x3E,
  0xF9, 0xF8, 0xF9, 0xF7, 0x8F, 0x87, 0xCF, 0xBC, 0x78, 0x3E, 0x7F, 0xE7,
  0xC1, 0xF3, 0xFF, 0x3E, 0x0F, 0x9F, 0xF9, 0xF0, 0xF8, 0xFF, 0xC7, 0x87,
  0xC7, 0x9E, 0x3E, 0x3F, 0x7C, 0xF1, 0xFF, 0xFF, 0xE7, 0xC7, 0xFF, 0xFE,
  0x3E, 0x1F, 0xCF, 0xE0, 0xF8, 0x78, 0x1C, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x02, 0x00, 0x7F, 0x81, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE,
  0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE3, 0xFC, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xF7,
  0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0x87, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xE0, 0xFE, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xF0, 0x63, 0xF8, 0x02, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x04, 0xFF,
  0xCF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xC3, 0xFE, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xEF, 0xC1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0x01, 0x8F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF7, 0xF8, 0x1F, 0xBF, 0xF1,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x7F, 0xF8, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE8, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xC7,
  0xF8, 0x00, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xBF, 0x03, 0xF9, 0xF8, 0x3F,
  0x8F, 0xC3, 0xFC, 0x7E, 0x1F, 0xC3, 0xF1, 0xFC, 0x1F, 0x9F, 0xE0, 0xFC,
  0xFE, 0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F, 0x07, 0xE3,
  0xF8, 0x3F, 0x1F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xFC, 0x7E, 0x0F, 0xE3,
  0xF0, 0x7F, 0x9F, 0x81, 0xFC, 0xFC, 0x0F, 0xF7, 0xE0, 0x3F, 0xC0, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xBE, 0x07, 0xFF, 0xFF, 0xE0, 0xFB, 0xFF, 0xFF, 0x0F, 0xBF, 0xFF,
  0xF0, 0xFB, 0xFF, 0xDF, 0x0F, 0xBF, 0xFD, 0xF1, 0xF3, 0xFF, 0xDF, 0x9F,
  0x3F, 0xFC, 0xF9, 0xF3, 0xFF, 0xCF, 0xBF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF,
  0xCF, 0xFE, 0x3F, 0xFC, 0x7F, 0xE3, 0xFF, 0xC7, 0xFC, 0x3F, 0xFC, 0x7F,
  0xC3, 0xFF, 0xC7, 0xFC, 0x3F, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xF8, 0x3F,
  0xFC, 0x3F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFB, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xF7, 0xF1, 0xFF, 0xEF, 0xE3, 0xFF, 0xCF, 0xE7, 0xFF, 0x9F, 0xCF, 0xFF,
  0x1F, 0xDF, 0xFE, 0x3F, 0xBF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0xFF, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xF8, 0x3F, 0xCF, 0xFD,
  0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x1F, 0xEF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC3, 0xFB, 0xF3, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x01, 0xFC, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE,
  0xFF, 0x01, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xEF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7E, 0x1F, 0xE3, 0xF0, 0x7F,
  0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x0F, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x9F, 0x81, 0xFC, 0xFC, 0x0F, 0xF7,
  0xE0, 0x3F, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xF0, 0x71, 0xF8, 0x04, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xBF, 0xBF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFB,
  0xF0, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE,
  0x7F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC7, 0xF0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xEF, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xEF, 0xC0,
  0x7F, 0x01, 0xFD, 0xFC, 0x0F, 0xE0, 0x3F, 0x3F, 0x81, 0xFE, 0x07, 0xE7,
  0xF0, 0x3F, 0xC1, 0xFC, 0x7E, 0x0F, 0xF8, 0x3F, 0x8F, 0xC1, 0xFF, 0x07,
  0xE1, 0xFC, 0x3F, 0xE0, 0xFC, 0x3F, 0x87, 0xFE, 0x3F, 0x83, 0xF1, 0xFF,
  0xC7, 0xF0, 0x7E, 0x3E, 0xF8, 0xFE, 0x0F, 0xC7, 0xDF, 0x1F, 0x81, 0xFC,
  0xFB, 0xE3, 0xF0, 0x1F, 0x9F, 0x7E, 0x7E, 0x03, 0xF7, 0xE7, 0xDF, 0xC0,
  0x7E, 0xFC, 0xFB, 0xF0, 0x0F, 0xDF, 0x1F, 0x7E, 0x01, 0xFB, 0xE3, 0xEF,
  0xC0, 0x1F, 0xFC, 0x7D, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x1F, 0xE7, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xFC, 0x7F, 0x81, 0xFC,
  0x7F, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xF9,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x03, 0xF8, 0xFE, 0x07,
  0xF1, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0xFB, 0xE0, 0x0F, 0xBF, 0x01, 0xF1, 0xF0, 0x1F, 0x1F,
  0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xE7, 0xC0,
  0x3E, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC3, 0x87, 0xF0, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xFF, 0xC7, 0xFF, 0xF3,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0x9F, 0x1F, 0xC7,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF1, 0xE0, 0xFE, 0xFF, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFE, 0x3F, 0xBF, 0x83,
  0xF7, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xBF, 0xC7, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xF7, 0xFC, 0x7E, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF1, 0xFC, 0x08, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x04, 0xFF, 0x0E, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x3C, 0x7F,
  0x0F, 0xEF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFE, 0x1F, 0xDF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0xFE, 0xFE, 0x1F, 0xDF, 0xE7, 0xFB,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xDF, 0x87, 0xE1, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFE, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x04, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF8, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x01, 0xFC, 0xFC, 0x7F, 0xDF, 0x9F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFC, 0x1F,
  0xDF, 0xC3, 0xFB, 0xF8, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFC, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFB, 0x00, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF1, 0xE0, 0xFE, 0xFF,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x38, 0xFF,
  0xFF, 0xFF, 0xEF, 0xC4, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0x40, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xEF, 0xF9, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xF7, 0xF0, 0xFF, 0x3F, 0x87, 0xF1, 0xFC, 0x7F,
  0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xFB, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xBF, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xE7, 0xF0,
  0x7F, 0x3F, 0x83, 0xFD, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x07, 0xC3,
  0xF3, 0xFC, 0x7F, 0xCF, 0xDF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0x83,
  0xF8, 0x7F, 0xFE, 0x0F, 0xE1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC,
  0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07,
  0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF,
  0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE,
  0x0F, 0xC1, 0xFC, 0x00, 0x3C, 0x1F, 0x9F, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0x3F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F,
  0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E,
  0xFC, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x3C, 0x1F, 0x9F, 0xE3,
  0xF7, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xC7, 0xF7,
  0xF0, 0x7E, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xF7, 0xF8, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xE7, 0xE1, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0xFC,
  0x7F, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xC3, 0xFB,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7E, 0xFC, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFC, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0xDF,
  0xFF, 0x7E, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0xF8,
  0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xDF, 0xC3, 0xBF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x00,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE1, 0x3F,
  0xFC, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFE, 0xFC, 0xFF, 0xDF, 0x8F, 0xE3, 0xF0, 0xFE, 0x03, 0xFB, 0xF0,
  0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFE, 0xFE, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x0F, 0xF0, 0xFE, 0xFC, 0x1F, 0xE1, 0xF9, 0xFC, 0x7F, 0xC3,
  0xF3, 0xF8, 0xFF, 0x87, 0xE3, 0xF1, 0xFF, 0x1F, 0xC7, 0xE3, 0xDF, 0x3F,
  0x0F, 0xCF, 0xBE, 0x7E, 0x1F, 0xDF, 0x7C, 0xFC, 0x1F, 0xBE, 0xF9, 0xF8,
  0x3F, 0x7D, 0xF7, 0xE0, 0x7E, 0xF9, 0xEF, 0xC0, 0xFD, 0xE3, 0xFF, 0x80,
  0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF9, 0xFC, 0x7F,
  0x8F, 0xE3, 0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x7F, 0x03, 0xFB,
  0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x9F, 0xC1, 0xFD, 0xFE, 0x0F, 0xF0,
  0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE3, 0xF0,
  0x7E, 0x1F, 0xC7, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0xCF, 0xC0,
  0x7E, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x1F, 0xC1, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFC, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x01,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFC, 0x1F, 0xE0, 0xFC, 0x00, 0x08, 0x00, 0x4F, 0xF0, 0x1F, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x07, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Black37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 26, 10, 2, -26 },
  { 24, 15, 9, 19, 2, -26 },
  { 41, 21, 26, 23, 1, -26 },
  { 110, 18, 30, 20, 1, -28 },
  { 178, 32, 27, 34, 1, -27 },
  { 286, 27, 27, 27, 1, -27 },
  { 378, 6, 9, 10, 2, -26 },
  { 385, 11, 33, 13, 1, -27 },
  { 431, 10, 33, 13, 1, -27 },
  { 473, 17, 17, 19, 1, -28 },
  { 510, 17, 18, 21, 2, -22 },
  { 549, 8, 10, 11, 1, -5 },
  { 559, 10, 6, 12, 1, -13 },
  { 567, 7, 6, 10, 2, -6 },
  { 573, 16, 27, 16, 0, -27 },
  { 627, 18, 27, 20, 1, -27 },
  { 688, 15, 26, 20, 1, -26 },
  { 737, 18, 27, 20, 1, -27 },
  { 798, 18, 27, 20, 1, -27 },
  { 859, 19, 26, 20, 1, -26 },
  { 921, 17, 26, 20, 2, -26 },
  { 977, 18, 27, 20, 1, -27 },
  { 1038, 18, 26, 20, 1, -26 },
  { 1097, 18, 27, 20, 1, -27 },
  { 1158, 18, 27, 20, 1, -27 },
  { 1219, 7, 21, 11, 2, -21 },
  { 1238, 8, 26, 11, 1, -21 },
  { 1264, 18, 19, 21, 1, -23 },
  { 1307, 17, 14, 21, 2, -20 },
  { 1337, 17, 19, 21, 2, -23 },
  { 1378, 17, 27, 17, 0, -27 },
  { 1436, 29, 30, 31, 1, -27 },
  { 1545, 25, 26, 25, 0, -26 },
  { 1627, 19, 26, 23, 3, -26 },
  { 1689, 19, 27, 22, 2, -27 },
  { 1754, 20, 26, 25, 3, -26 },
  { 1819, 14, 26, 19, 3, -26 },
  { 1865, 14, 26, 19, 3, -26 },
  { 1911, 21, 27, 25, 2, -27 },
  { 1982, 21, 26, 26, 3, -26 },
  { 2051, 13, 26, 15, 1, -26 },
  { 2094, 13, 34, 12, -3, -26 },
  { 2150, 21, 26, 24, 3, -26 },
  { 2219, 15, 26, 19, 3, -26 },
  { 2268, 28, 26, 34, 3, -26 },
  { 2359, 23, 26, 28, 3, -26 },
  { 2434, 23, 27, 27, 2, -27 },
  { 2512, 18, 26, 22, 3, -26 },
  { 2571, 24, 33, 27, 2, -27 },
  { 2670, 21, 26, 23, 3, -26 },
  { 2739, 18, 27, 20, 1, -27 },
  { 2800, 18, 26, 20, 1, -26 },
  { 2859, 21, 26, 26, 2, -26 },
  { 2928, 24, 26, 24, 0, -26 },
  { 3006, 35, 26, 35, 0, -26 },
  { 3120, 24, 26, 24, 0, -26 },
  { 3198, 23, 26, 23, 0, -26 },
  { 3273, 19, 26, 21, 1, -26 },
  { 3335, 9, 33, 12, 2, -27 },
  { 3373, 16, 27, 16, 0, -27 },
  { 3427, 9, 33, 12, 1, -27 },
  { 3465, 20, 17, 20, 0, -26 },
  { 3508, 19, 5, 19, 0, 2 },
  { 3520, 12, 6, 14, 1, -28 },
  { 3529, 18, 21, 21, 1, -21 },
  { 3577, 19, 28, 22, 2, -28 },
  { 3644, 17, 21, 19, 1, -21 },
  { 3689, 19, 28, 22, 1, -28 },
  { 3756, 19, 21, 21, 1, -21 },
  { 3806, 14, 28, 14, 1, -28 },
  { 3855, 19, 30, 22, 1, -21 },
  { 3927, 19, 28, 23, 2, -28 },
  { 3994, 7, 29, 11, 2, -29 },
  { 4020, 11, 38, 11, -2, -29 },
  { 4073, 21, 28, 23, 2, -28 },
  { 4147, 7, 28, 11, 2, -28 },
  { 4172, 30, 21, 34, 2, -21 },
  { 4251, 19, 21, 23, 2, -21 },
  { 4301, 19, 21, 22, 1, -21 },
  { 4351, 19, 30, 22, 2, -21 },
  { 4423, 19, 30, 22, 1, -21 },
  { 4495, 14, 21, 16, 2, -21 },
  { 4532, 15, 21, 18, 1, -21 },
  { 4572, 14, 25, 16, 1, -25 },
  { 4616, 19, 20, 23, 2, -20 },
  { 4664, 21, 20, 21, 0, -20 },
  { 4717, 31, 20, 31, 0, -20 },
  { 4795, 21, 20, 21, 0, -20 },
  { 4848, 21, 29, 21, 0, -20 },
  { 4925, 15, 20, 17, 1, -20 },
  { 4963, 13, 33, 15, 1, -27 },
  { 5017, 5, 36, 18, 6, -28 },
  { 5040, 13, 33, 15, 1, -27 },
  { 5094, 18, 7, 21, 1, -17 },
};

const GFXfont NotoSans_SemiCondensed_Black37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK37PT7B_H_
