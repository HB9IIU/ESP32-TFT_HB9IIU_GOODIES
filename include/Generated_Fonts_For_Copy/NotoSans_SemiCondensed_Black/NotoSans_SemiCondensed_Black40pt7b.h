#ifndef _NOTOSANS_SEMICONDENSED_BLACK40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0xFE, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7C, 0x3F, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0xC1, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC1, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF3, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFE, 0xF1, 0xCF, 0xCF, 0x00, 0xFE, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xF7, 0xF8, 0x0F, 0x3F, 0x70,
  0xF7, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xF8, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x3E, 0x00, 0xFF, 0xF8, 0x1F, 0x80, 0x3F, 0x3E, 0x07,
  0xC0, 0x0F, 0xCF, 0xC3, 0xF0, 0x03, 0xE3, 0xF0, 0xF8, 0x00, 0xF8, 0xFC,
  0x7E, 0x00, 0x3E, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF3, 0xE0, 0xC0, 0xFC, 0xF9, 0xF8, 0xFE, 0x1F, 0xFE, 0x7C, 0x7F, 0xC7,
  0xFF, 0xBF, 0x3F, 0xF8, 0xFF, 0xCF, 0x9F, 0xFF, 0x1F, 0xE7, 0xE7, 0xEF,
  0xC3, 0xE1, 0xF1, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x7C, 0x00, 0x3E, 0x1F,
  0x1F, 0x00, 0x1F, 0x87, 0xC7, 0xC0, 0x07, 0xC1, 0xF1, 0xF0, 0x03, 0xF0,
  0x7C, 0x7C, 0x00, 0xF8, 0x1F, 0x1F, 0x00, 0x7E, 0x07, 0xEF, 0xC0, 0x1F,
  0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xE0, 0x07, 0xFC, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x87, 0xF0, 0x7F, 0xF8, 0x3F, 0x87, 0xFF,
  0xE3, 0xFC, 0x3F, 0xFF, 0x9F, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xCF, 0xFF,
  0xF1, 0xFE, 0x3F, 0xFF, 0x0F, 0xF0, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0x83,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0xC0, 0x7F, 0xE1,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF0,
  0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1,
  0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x04,
  0x1F, 0x04, 0xF3, 0xEF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF8, 0xFC, 0x0F, 0x1E, 0x00, 0xC1, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x9F, 0xCF,
  0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0xFE, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7, 0xF0,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7F, 0x9F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0xFF, 0x3C, 0xFF, 0x18, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xCF, 0xF9, 0xE0, 0xFF, 0x18,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0x0F, 0xF8, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFB, 0xFC, 0x1F, 0xDF, 0xE0, 0xFC,
  0xFF, 0x0F, 0xC7, 0xF8, 0x7E, 0x3F, 0xC7, 0xE1, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xEF, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x30, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x3E,
  0x07, 0xEF, 0xF8, 0x7E, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F,
  0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0x8F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF9, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x1F, 0xEF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0x9F, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xF7, 0xF9, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0x7E, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC3, 0x3F, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7E, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x3F, 0x3F, 0x9F, 0xEF, 0xF7,
  0xFB, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x9F, 0xCF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E,
  0x3F, 0x1F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x70, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xC1, 0xFC, 0x80, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0x0F,
  0xC0, 0xF8, 0x3E, 0x7E, 0x1F, 0xFE, 0xF9, 0xF0, 0xFF, 0xF9, 0xF7, 0xC7,
  0xFF, 0xE7, 0xFE, 0x3F, 0x9F, 0x9F, 0xF8, 0xFC, 0x7E, 0x7F, 0xE7, 0xE1,
  0xF9, 0xFF, 0x9F, 0x87, 0xC7, 0xFE, 0x7C, 0x1F, 0x1F, 0xF9, 0xF0, 0x7C,
  0x7F, 0xE7, 0xC1, 0xF1, 0xFF, 0x9F, 0x07, 0xC7, 0xFE, 0x7E, 0x3F, 0x1F,
  0xF8, 0xFF, 0xFF, 0xFB, 0xE3, 0xFF, 0xFF, 0xCF, 0xC7, 0xFD, 0xFF, 0x1F,
  0x0F, 0xE3, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x10, 0x07, 0xFC, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xDF, 0x80,
  0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x87, 0x8F, 0xF8, 0x04, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x09, 0xFF, 0x01,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0x83, 0xFE, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xEF, 0xE1, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFC, 0x1E, 0x3F, 0xE0, 0x04, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F,
  0xDF, 0xF0, 0x3F, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0xCF, 0xF8,
  0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x1F, 0xE7, 0xF0,
  0x3F, 0xCF, 0xE0, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x1F,
  0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0xFF, 0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF1, 0xFE, 0x0F,
  0xE3, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0xFE,
  0x0F, 0xF1, 0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xE7, 0xF0, 0x1F, 0xEF, 0xE0,
  0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF7, 0xE0, 0xFB, 0xFF, 0xEF,
  0xC1, 0xF7, 0xFF, 0xDF, 0x87, 0xEF, 0xFF, 0x9F, 0x0F, 0xDF, 0xFF, 0x3F,
  0x1F, 0x3F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFC, 0xFC, 0xFC, 0xFF, 0xF8, 0xFD,
  0xF1, 0xFF, 0xF1, 0xFB, 0xE3, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0x0F, 0xFC, 0x3F, 0xFE, 0x1F, 0xF8,
  0x7F, 0xFC, 0x1F, 0xF0, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0x83,
  0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xC0, 0xFC, 0x0F, 0xE0, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0x7F, 0x0F, 0xFF, 0xBF, 0xC7, 0xFF, 0xCF,
  0xE3, 0xFF, 0xE7, 0xF9, 0xFF, 0xF1, 0xFC, 0xFF, 0xF8, 0xFF, 0x7F, 0xFC,
  0x3F, 0xBF, 0xFE, 0x1F, 0xDF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF,
  0x8F, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x07,
  0xF9, 0xFF, 0x07, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE,
  0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01,
  0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0x8F,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE3, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xF3, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0x87, 0xF8, 0x7F,
  0x0F, 0xF0, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xE7, 0xF0,
  0x3F, 0xEF, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xF1, 0xF3, 0xF8, 0x04, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x7F, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F,
  0x8F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xFD,
  0xFC, 0x03, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F,
  0x80, 0xFE, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x0F, 0xE3,
  0xF8, 0x1F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xFF,
  0x07, 0xF0, 0xFE, 0x0F, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0xF8, 0x7F, 0x07,
  0xF1, 0xFF, 0xE3, 0xF8, 0x1F, 0xC7, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xBE,
  0x3F, 0x80, 0xFC, 0x7C, 0xF8, 0xFE, 0x03, 0xF9, 0xF3, 0xF3, 0xF0, 0x0F,
  0xEF, 0xCF, 0xDF, 0xC0, 0x3F, 0xBF, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x7D,
  0xFC, 0x01, 0xFB, 0xE1, 0xF7, 0xF0, 0x07, 0xEF, 0x87, 0xDF, 0x80, 0x1F,
  0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0x3F, 0xCF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0xFE,
  0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC7,
  0xF0, 0x0F, 0xE7, 0xF8, 0x07, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0x7E, 0x7E, 0x03,
  0xF3, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0E, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0x3F, 0x1F, 0xE3,
  0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x40, 0xFF, 0x3F, 0x0F,
  0xEF, 0xFC, 0xFE, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF9, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFE,
  0xFF, 0xCF, 0xC7, 0xF0, 0x00, 0x20, 0x03, 0xFF, 0x83, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF3, 0xFF, 0xFB, 0xFE, 0x39, 0xFE, 0x04, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0x01, 0x7F, 0xEF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x10,
  0xFF, 0x0F, 0xCF, 0xF3, 0xFF, 0x7F, 0x3F, 0xF7, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0x7F, 0x3F, 0xF7, 0xF0, 0xFC, 0x3F, 0x00, 0x40, 0x00, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x5F, 0xF0, 0x39, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xC0, 0x00, 0x60, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xC3, 0xFF, 0x87, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xFB, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x8F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0xFE, 0x7F, 0x3F, 0xF7, 0xF3, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFB, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xF7, 0xF3, 0xFE, 0xFF, 0x0F, 0xCF, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE8, 0x00, 0xFE, 0xF8, 0x3F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xA0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x40, 0xFE, 0x7F, 0x8F,
  0xEF, 0xFC, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x3C,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xEF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFB, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F,
  0xCF, 0xF0, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x40, 0x7E, 0x3F,
  0xC1, 0xFE, 0x3F, 0x3F, 0xFB, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0x1F, 0xF0, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF,
  0xF8, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF,
  0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0xC1, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0x83,
  0xFF, 0xFC, 0x1F, 0xC1, 0xFE, 0x00, 0x04, 0x0F, 0xC7, 0xF8, 0xFC, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0x1F, 0xEF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF7, 0xF9, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x00, 0x04, 0x0F, 0xC3, 0xF8, 0xFE, 0xFF, 0xCF, 0xEF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xEF, 0xF8, 0xFF, 0x3F, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0x00, 0x00, 0xFE, 0x7F, 0x3F, 0xF7, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFB, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x3F, 0xF7, 0xF3, 0xFE, 0xFF, 0x0F, 0xCF, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x0D, 0xF8, 0x7F, 0xF1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0xFE, 0x0F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF3, 0xF8, 0x19, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF8, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xFD, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF,
  0xBF, 0x3F, 0xFB, 0xF0, 0xFE, 0x1F, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xF9,
  0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F,
  0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F,
  0x3F, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x3F, 0xBF, 0x83, 0xFC, 0x1F, 0xDF, 0xC3, 0xFF, 0x0F, 0xEF, 0xE1,
  0xFF, 0x87, 0xF3, 0xF0, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0xE3, 0xF8, 0xFE,
  0x3F, 0xF1, 0xFC, 0x7F, 0x3F, 0xF8, 0xFE, 0x1F, 0x9F, 0x7E, 0x7E, 0x0F,
  0xCF, 0xBF, 0x7F, 0x07, 0xF7, 0xCF, 0xBF, 0x83, 0xFB, 0xE7, 0xDF, 0xC0,
  0xFF, 0xF3, 0xEF, 0xC0, 0x7F, 0xF9, 0xF7, 0xE0, 0x3F, 0xF8, 0xFF, 0xF0,
  0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0xFF, 0x07, 0xF8, 0xFF,
  0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0x9F, 0xE0, 0xFF, 0x1F, 0xE1,
  0xFC, 0x3F, 0xC7, 0xF8, 0x3F, 0xDF, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE,
  0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F,
  0x8F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x4F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0x03, 0xFF,
  0x07, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xE0, 0x3C, 0x00, 0x3E,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xE0, 0x3F, 0xF4, 0x00, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_Black40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 29, 11, 2, -29 },
  { 30, 16, 11, 20, 2, -29 },
  { 52, 23, 29, 25, 1, -29 },
  { 136, 20, 32, 22, 1, -30 },
  { 216, 34, 29, 36, 1, -29 },
  { 340, 29, 29, 30, 1, -29 },
  { 446, 7, 11, 11, 2, -29 },
  { 456, 11, 35, 14, 2, -29 },
  { 505, 11, 35, 14, 1, -29 },
  { 554, 19, 18, 21, 1, -30 },
  { 597, 19, 20, 22, 2, -24 },
  { 645, 9, 12, 12, 1, -6 },
  { 659, 11, 6, 13, 1, -14 },
  { 668, 8, 7, 11, 2, -7 },
  { 675, 17, 29, 17, 0, -29 },
  { 737, 20, 29, 22, 1, -29 },
  { 810, 16, 29, 22, 2, -29 },
  { 868, 19, 29, 22, 1, -29 },
  { 937, 19, 29, 22, 1, -29 },
  { 1006, 21, 29, 22, 1, -29 },
  { 1083, 18, 29, 22, 2, -29 },
  { 1149, 20, 29, 22, 1, -29 },
  { 1222, 19, 29, 22, 2, -29 },
  { 1291, 20, 29, 22, 1, -29 },
  { 1364, 20, 29, 22, 1, -29 },
  { 1437, 8, 22, 11, 2, -22 },
  { 1459, 9, 28, 12, 1, -22 },
  { 1491, 18, 21, 22, 2, -25 },
  { 1539, 19, 14, 22, 2, -21 },
  { 1573, 19, 21, 22, 2, -25 },
  { 1623, 18, 29, 19, 0, -29 },
  { 1689, 30, 32, 34, 2, -29 },
  { 1809, 27, 29, 27, 0, -29 },
  { 1907, 20, 29, 25, 3, -29 },
  { 1980, 21, 29, 24, 2, -29 },
  { 2057, 22, 29, 27, 3, -29 },
  { 2137, 16, 29, 20, 3, -29 },
  { 2195, 16, 29, 20, 3, -29 },
  { 2253, 23, 29, 27, 2, -29 },
  { 2337, 23, 29, 28, 3, -29 },
  { 2421, 14, 29, 16, 1, -29 },
  { 2472, 13, 38, 13, -3, -29 },
  { 2534, 23, 29, 26, 3, -29 },
  { 2618, 17, 29, 21, 3, -29 },
  { 2680, 31, 29, 36, 3, -29 },
  { 2793, 25, 29, 31, 3, -29 },
  { 2884, 25, 29, 29, 2, -29 },
  { 2975, 19, 29, 24, 3, -29 },
  { 3044, 26, 36, 29, 2, -29 },
  { 3161, 23, 29, 25, 3, -29 },
  { 3245, 18, 29, 21, 2, -29 },
  { 3311, 20, 29, 22, 1, -29 },
  { 3384, 22, 29, 28, 3, -29 },
  { 3464, 26, 29, 26, 0, -29 },
  { 3559, 38, 29, 38, 0, -29 },
  { 3697, 26, 29, 26, 0, -29 },
  { 3792, 25, 29, 25, 0, -29 },
  { 3883, 20, 29, 22, 1, -29 },
  { 3956, 10, 36, 13, 2, -29 },
  { 4001, 17, 29, 17, 0, -29 },
  { 4063, 10, 36, 13, 1, -29 },
  { 4108, 21, 19, 21, 0, -29 },
  { 4158, 20, 4, 20, 0, 3 },
  { 4168, 12, 7, 16, 2, -31 },
  { 4179, 20, 23, 23, 1, -23 },
  { 4237, 20, 30, 24, 2, -30 },
  { 4312, 17, 23, 20, 2, -23 },
  { 4361, 20, 30, 24, 2, -30 },
  { 4436, 19, 23, 23, 2, -23 },
  { 4491, 15, 31, 15, 1, -31 },
  { 4550, 20, 33, 24, 2, -23 },
  { 4633, 20, 30, 25, 2, -30 },
  { 4708, 8, 31, 12, 2, -31 },
  { 4739, 12, 41, 12, -2, -31 },
  { 4801, 22, 30, 24, 2, -30 },
  { 4884, 8, 30, 12, 2, -30 },
  { 4914, 33, 23, 37, 2, -23 },
  { 5009, 20, 23, 25, 2, -23 },
  { 5067, 20, 23, 24, 2, -23 },
  { 5125, 20, 33, 24, 2, -23 },
  { 5208, 20, 33, 24, 2, -23 },
  { 5291, 15, 23, 17, 2, -23 },
  { 5335, 17, 23, 19, 1, -23 },
  { 5384, 15, 27, 17, 1, -27 },
  { 5435, 20, 22, 25, 2, -22 },
  { 5490, 23, 22, 23, 0, -22 },
  { 5554, 33, 22, 34, 0, -22 },
  { 5645, 23, 22, 23, 0, -22 },
  { 5709, 23, 32, 23, 0, -22 },
  { 5801, 17, 22, 19, 1, -22 },
  { 5848, 14, 36, 16, 1, -29 },
  { 5911, 5, 40, 19, 7, -31 },
  { 5936, 14, 36, 16, 1, -29 },
  { 5999, 19, 8, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Black40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK40PT7B_H_
