#ifndef _NOTOSANS_SEMICONDENSED_BLACK24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0x9C, 0x00, 0x3B, 0xFF, 0xF0,
  0xF3, 0xFC, 0xFF, 0x3D, 0xCF, 0x73, 0xDC, 0xF0, 0x07, 0x38, 0x1C, 0xE0,
  0x77, 0x03, 0x9C, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC3, 0xBC, 0x0E, 0xE0,
  0x73, 0x8F, 0xFF, 0xFF, 0xFF, 0x1C, 0xE0, 0x77, 0x81, 0xDC, 0x0E, 0x70,
  0x39, 0xC0, 0x06, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0xFD, 0xCC, 0xBD, 0x87,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x83, 0xF0, 0x6F, 0x8D, 0xFF, 0xFF, 0xFE,
  0xFF, 0x80, 0xC0, 0x18, 0x00, 0x3E, 0x07, 0x83, 0xF8, 0x38, 0x1D, 0xC3,
  0x80, 0xEF, 0x1C, 0x0F, 0x39, 0xC0, 0x79, 0xCE, 0x01, 0xDE, 0xE1, 0x0E,
  0xF7, 0x7E, 0x7F, 0x73, 0xF9, 0xF3, 0xBD, 0xC0, 0x39, 0xCE, 0x01, 0xCE,
  0x70, 0x1C, 0x73, 0x80, 0xE3, 0x9C, 0x0E, 0x1F, 0xE0, 0x70, 0x7E, 0x07,
  0x01, 0xE0, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0x3C, 0x07, 0x9E,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x1E, 0x7F, 0x9F, 0x3F, 0xEF, 0xBE,
  0xFF, 0x9E, 0x7F, 0xCF, 0x1F, 0xC7, 0xCF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0x9F, 0x80, 0xFF, 0xF7, 0x77, 0x1E, 0x78, 0xF3, 0xC7, 0x8F, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC0, 0xF0, 0xF0, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x9E, 0x00, 0x0F, 0x00,
  0x70, 0x47, 0x17, 0x7F, 0x7F, 0xFF, 0xFF, 0x0F, 0x81, 0xF8, 0x3D, 0xC3,
  0x9E, 0x08, 0x80, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x7B, 0xFD, 0xEF, 0x7B, 0x80,
  0xFF, 0xFF, 0xC0, 0x77, 0xFF, 0xE0, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x81, 0xE0, 0xF0, 0x00, 0x3F, 0x8F, 0xF9, 0xFF, 0x7D, 0xFF, 0x9F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x9E, 0xF7, 0xDF,
  0xF1, 0xFE, 0x1F, 0x80, 0x07, 0xC3, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0x7C, 0x9F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC0, 0x1F, 0xC7, 0xFE, 0xFF, 0xF7, 0xFF, 0x31, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF0, 0x7F, 0x9F, 0xFB, 0xFF, 0xB1, 0xF0, 0x1E, 0x07,
  0x87, 0xF1, 0xF8, 0x3F, 0x87, 0xF8, 0x0F, 0x80, 0xF0, 0x3F, 0xCF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x77, 0x87, 0xBC, 0x39, 0xE3, 0xCF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x7F, 0xCF, 0xF9, 0xFF,
  0x3F, 0xE7, 0x80, 0xF0, 0x1F, 0xE7, 0xFE, 0xFF, 0xE4, 0xFC, 0x07, 0x80,
  0xF0, 0x1F, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x0F, 0xE3, 0xFE, 0x3F,
  0xE7, 0xC0, 0x78, 0x0F, 0x00, 0xF7, 0xCF, 0xFE, 0xFF, 0xEF, 0x9E, 0xF1,
  0xFF, 0x1F, 0xF1, 0xEF, 0xBE, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x3F, 0x87,
  0xFC, 0xFF, 0xEF, 0x9E, 0xF1, 0xE7, 0xBE, 0x7F, 0xC3, 0xF8, 0x3F, 0x87,
  0xFC, 0xFB, 0xEF, 0x1E, 0xF1, 0xFF, 0x1E, 0xFF, 0xE7, 0xFC, 0x3F, 0x80,
  0x3F, 0x8F, 0xFB, 0xFF, 0x7D, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xDF, 0xFF,
  0xEF, 0xFC, 0xF7, 0x80, 0xF0, 0x3E, 0x0F, 0x9F, 0xF3, 0xFC, 0x7E, 0x00,
  0xF7, 0xFE, 0xE0, 0x00, 0x00, 0x03, 0xBF, 0xF7, 0x00, 0xFF, 0xFE, 0xE0,
  0x00, 0x00, 0x03, 0xDF, 0xEF, 0x7B, 0xDC, 0x00, 0x20, 0x1C, 0x0F, 0x87,
  0xF3, 0xF9, 0xFC, 0x3E, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0x80, 0x30,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x78,
  0x7F, 0x3F, 0x9F, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x7F, 0x9F, 0xF9, 0xFF,
  0xB1, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x07, 0xFC, 0x03, 0xFF,
  0xC1, 0xE0, 0xF8, 0xF0, 0x0E, 0x79, 0xF9, 0xDC, 0xFF, 0x7E, 0x7D, 0xDF,
  0x9C, 0x77, 0xEF, 0x1D, 0xFB, 0xCF, 0x7E, 0xF3, 0xDF, 0x9C, 0xF7, 0xE7,
  0xFF, 0xBC, 0xFB, 0xC7, 0x00, 0x00, 0xF0, 0x08, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x3E, 0x3C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x78, 0x1E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFF, 0x8F, 0xFE, 0xFF, 0xEF, 0x3F, 0xF1, 0xFF, 0x1F, 0xFF, 0xEF,
  0xFC, 0xFF, 0xCF, 0xFE, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFE, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xCF, 0xFC, 0xFC, 0xE7, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC1,
  0x3F, 0xF8, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD,
  0xFF, 0xEF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC,
  0x3F, 0xE1, 0xFF, 0x1F, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x9F, 0x8E, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x83, 0xFE, 0x0F,
  0x7C, 0x3D, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x78, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0xFF, 0xFE, 0xFC, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE7, 0xCF, 0x3E,
  0x7B, 0xE3, 0xDE, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xE7, 0xCF,
  0x3E, 0x78, 0xFB, 0xC7, 0xDE, 0x1F, 0xF0, 0xF8, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFC, 0xEF,
  0xF7, 0x3B, 0xFD, 0xDE, 0xFF, 0x7F, 0xBF, 0xDF, 0xCF, 0xF3, 0xF3, 0xFC,
  0xFC, 0xFF, 0x3E, 0x3F, 0xCF, 0x8F, 0xF1, 0xE3, 0xC0, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xFD, 0xE3, 0xFF, 0xE7, 0xFB, 0xCF,
  0xF7, 0xDF, 0xE7, 0xBF, 0xCF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xF3,
  0xF7, 0xC3, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC1, 0xF7, 0xC3, 0xEF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF0, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x9F,
  0xFF, 0xFF, 0xFB, 0xFE, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0xF8,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x3E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x87, 0xFE, 0x3F, 0xF9,
  0xE7, 0xCF, 0x1F, 0x78, 0xFB, 0xC7, 0x9F, 0xFC, 0xFF, 0xC7, 0xFC, 0x3F,
  0xE1, 0xEF, 0x8F, 0x3E, 0x78, 0xF3, 0xC7, 0xDE, 0x1E, 0xF0, 0xF8, 0x3F,
  0xCF, 0xFF, 0xFF, 0x7C, 0xEF, 0x01, 0xF0, 0x3F, 0x83, 0xFC, 0x3F, 0xC3,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFC, 0x1F, 0xC0, 0xF8, 0x3F, 0xF0, 0x7D, 0xF0, 0xFB, 0xE1,
  0xE7, 0xC7, 0xC7, 0x8F, 0x8F, 0x9F, 0x1F, 0x3C, 0x1E, 0xF8, 0x3D, 0xF0,
  0x7B, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0xF8, 0x7C, 0x3E, 0xF0, 0xF8, 0x79, 0xE1, 0xF0, 0xF3, 0xC3, 0xE1,
  0xE7, 0x8F, 0xC7, 0xC7, 0x9F, 0xCF, 0x0F, 0x3B, 0x9E, 0x1E, 0x77, 0x3C,
  0x3C, 0xEE, 0x78, 0x7B, 0xDD, 0xF0, 0x7F, 0xBF, 0xC0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x7C, 0x7C, 0x3C, 0x7C, 0x3E, 0xF8, 0x1E, 0xF8,
  0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0x78, 0x7C, 0x7C, 0x7C, 0x3E, 0xF8, 0x3F,
  0xF8, 0x3E, 0xF0, 0xF9, 0xF1, 0xE1, 0xE7, 0xC3, 0xEF, 0x03, 0xDE, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFF, 0xF0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x3F,
  0x01, 0xFC, 0x0E, 0xE0, 0xE7, 0x87, 0x1C, 0x78, 0xF3, 0x83, 0xBC, 0x1E,
  0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x78, 0x02, 0x0F, 0xF9, 0xFF, 0x9F, 0xF2,
  0x1E, 0x03, 0xCF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F, 0xC7, 0xFF, 0xFF, 0xEE,
  0xF9, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x8F, 0xFE, 0xFF,
  0xEF, 0xFF, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0x3C, 0x02, 0x07, 0xF7, 0xFD, 0xFF, 0xF8, 0xBE,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0xCD, 0xFF, 0x7F, 0xC7, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xF3, 0xEF, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF9, 0xF7, 0xFF, 0x7F,
  0xF3, 0xEF, 0x06, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xF8, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x27, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F,
  0xC7, 0xE3, 0xF8, 0xF8, 0x3C, 0x1F, 0xEF, 0xFB, 0xFE, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x08, 0x03,
  0xEF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x8F, 0xF9, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF8, 0x1F, 0xFF, 0xEF,
  0xFE, 0xFF, 0xC3, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x8F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x27, 0xFE, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x08, 0x7C, 0xF8, 0xF0, 0x00,
  0x0F, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xFF, 0xFF, 0x7E, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE3, 0xEF, 0x9F, 0x3E, 0x78, 0xFB, 0xE3, 0xFF, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0x9F, 0x3E, 0x7C, 0xF8, 0xFB, 0xE3,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x81, 0x0F, 0x7E, 0x7C, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9,
  0xF9, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF,
  0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F,
  0x00, 0x8F, 0x7E, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x02, 0x03, 0xFC,
  0x7F, 0xE7, 0xFE, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F,
  0xF9, 0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0x00, 0x8F, 0x7E, 0xFF, 0xEF, 0xFF,
  0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xBC, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x08, 0x03, 0xEF, 0x7F, 0xF7, 0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x8F, 0xF9, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0x79, 0xFD, 0xFF, 0xFF, 0xFF,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x08, 0x1F,
  0xEF, 0xFB, 0xFE, 0xF0, 0xBF, 0x0F, 0xF1, 0xFE, 0x1F, 0x81, 0xFC, 0x7F,
  0xFE, 0xFF, 0xBF, 0xC0, 0x1C, 0x0E, 0x07, 0x0F, 0xFF, 0xFF, 0xFC, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE9, 0xFC, 0x7E, 0x3F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x9F, 0x7F, 0xF7, 0xF7, 0x3E, 0x70, 0xF8, 0x7D, 0xE1, 0xE7, 0x8F, 0x9F,
  0x3C, 0x3C, 0xF0, 0xF7, 0xC3, 0xDE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0xF8, 0xF7, 0x9F, 0x9F, 0x79, 0xF9,
  0xE7, 0x9F, 0x9E, 0x79, 0xFD, 0xE3, 0xDF, 0xDE, 0x3F, 0xDD, 0xC3, 0xF9,
  0xFC, 0x3F, 0x9F, 0xC1, 0xF9, 0xFC, 0x1F, 0x9F, 0x81, 0xF8, 0xF8, 0x1F,
  0x0F, 0x80, 0xFC, 0xF9, 0xF3, 0xC3, 0xDF, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xCF, 0x1F, 0x3E, 0xF8,
  0x7C, 0xF8, 0x7D, 0xE1, 0xE7, 0x8F, 0x9F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xDE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x7F,
  0xCF, 0xF9, 0xFF, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F,
  0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x1F, 0x3F, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7C, 0xF8, 0xF0, 0xFC, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3F,
  0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0xF8, 0xF8, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1F, 0x0F, 0x3F, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0xF8, 0xF8, 0xF0, 0x38, 0x3F, 0xEF, 0xFF,
  0xEF, 0xF8, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_Black24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 17, 7, 1, -17 },
  { 12, 10, 6, 12, 1, -17 },
  { 20, 14, 17, 15, 0, -17 },
  { 50, 11, 19, 13, 1, -18 },
  { 77, 21, 17, 22, 0, -17 },
  { 122, 17, 17, 18, 1, -17 },
  { 159, 4, 6, 7, 1, -17 },
  { 162, 7, 22, 8, 1, -18 },
  { 182, 7, 22, 8, 0, -18 },
  { 202, 12, 11, 12, 0, -18 },
  { 219, 11, 11, 13, 1, -14 },
  { 235, 5, 7, 7, 1, -4 },
  { 240, 6, 3, 8, 1, -8 },
  { 243, 5, 4, 7, 1, -4 },
  { 246, 10, 17, 10, 0, -17 },
  { 268, 11, 17, 13, 1, -17 },
  { 292, 10, 17, 13, 1, -17 },
  { 314, 12, 17, 13, 0, -17 },
  { 340, 11, 17, 13, 1, -17 },
  { 364, 13, 17, 13, 0, -17 },
  { 392, 11, 17, 13, 1, -17 },
  { 416, 12, 17, 13, 1, -17 },
  { 442, 11, 17, 13, 1, -17 },
  { 466, 12, 17, 13, 1, -17 },
  { 492, 11, 17, 13, 1, -17 },
  { 516, 5, 13, 7, 1, -13 },
  { 525, 5, 16, 7, 1, -13 },
  { 535, 11, 13, 13, 1, -15 },
  { 553, 11, 9, 13, 1, -13 },
  { 566, 11, 13, 13, 1, -15 },
  { 584, 11, 17, 11, 0, -17 },
  { 608, 18, 19, 20, 1, -17 },
  { 651, 16, 17, 16, 0, -17 },
  { 685, 12, 17, 15, 2, -17 },
  { 711, 13, 17, 14, 1, -17 },
  { 739, 13, 17, 16, 2, -17 },
  { 767, 9, 17, 12, 2, -17 },
  { 787, 9, 17, 12, 2, -17 },
  { 807, 14, 17, 16, 1, -17 },
  { 837, 13, 17, 17, 2, -17 },
  { 865, 8, 17, 10, 1, -17 },
  { 882, 8, 22, 8, -2, -17 },
  { 904, 13, 17, 15, 2, -17 },
  { 932, 10, 17, 13, 2, -17 },
  { 954, 18, 17, 22, 2, -17 },
  { 993, 15, 17, 18, 2, -17 },
  { 1025, 15, 17, 18, 1, -17 },
  { 1057, 11, 17, 14, 2, -17 },
  { 1081, 16, 21, 18, 1, -17 },
  { 1123, 13, 17, 15, 2, -17 },
  { 1151, 11, 17, 13, 1, -17 },
  { 1175, 12, 17, 13, 1, -17 },
  { 1201, 13, 17, 17, 2, -17 },
  { 1229, 15, 17, 15, 0, -17 },
  { 1261, 23, 17, 23, 0, -17 },
  { 1310, 16, 17, 16, 0, -17 },
  { 1344, 15, 17, 15, 0, -17 },
  { 1376, 12, 17, 13, 1, -17 },
  { 1402, 6, 22, 8, 1, -18 },
  { 1419, 10, 17, 10, 0, -17 },
  { 1441, 6, 22, 8, 0, -18 },
  { 1458, 13, 11, 13, 0, -17 },
  { 1476, 12, 2, 12, 0, 2 },
  { 1479, 7, 3, 9, 1, -18 },
  { 1482, 11, 14, 14, 1, -14 },
  { 1502, 12, 18, 14, 1, -18 },
  { 1529, 10, 14, 12, 1, -14 },
  { 1547, 12, 18, 14, 1, -18 },
  { 1574, 12, 14, 14, 1, -14 },
  { 1595, 10, 18, 9, 0, -18 },
  { 1618, 12, 20, 14, 1, -14 },
  { 1648, 12, 18, 15, 1, -18 },
  { 1675, 5, 19, 7, 1, -19 },
  { 1687, 7, 25, 7, -1, -19 },
  { 1709, 14, 18, 15, 1, -18 },
  { 1741, 5, 18, 7, 1, -18 },
  { 1753, 20, 14, 22, 1, -14 },
  { 1788, 12, 14, 15, 1, -14 },
  { 1809, 12, 14, 14, 1, -14 },
  { 1830, 12, 20, 14, 1, -14 },
  { 1860, 12, 20, 14, 1, -14 },
  { 1890, 9, 14, 10, 1, -14 },
  { 1906, 10, 14, 11, 1, -14 },
  { 1924, 9, 16, 10, 0, -16 },
  { 1942, 12, 13, 15, 1, -13 },
  { 1962, 14, 13, 14, 0, -13 },
  { 1985, 20, 13, 20, 0, -13 },
  { 2018, 14, 13, 14, 0, -13 },
  { 2041, 14, 19, 14, 0, -13 },
  { 2075, 11, 13, 11, 0, -13 },
  { 2093, 8, 21, 10, 1, -17 },
  { 2114, 3, 23, 11, 4, -18 },
  { 2123, 8, 21, 10, 1, -17 },
  { 2144, 11, 5, 13, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Black24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK24PT7B_H_
