#ifndef _NOTOSANS_SEMICONDENSED_BLACK62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x7F, 0xCF, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE3, 0xFC, 0x0E, 0x00, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xEF, 0xFC, 0x3F, 0xF7, 0xFE, 0x1F,
  0xFB, 0xFF, 0x0F, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0x83, 0xFF, 0x7F, 0xC1,
  0xFF, 0xBF, 0xE0, 0xFF, 0xDF, 0xF0, 0x7F, 0xEF, 0xF8, 0x1F, 0xE7, 0xFC,
  0x0F, 0xF3, 0xFE, 0x07, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x3F, 0x0F, 0x8F, 0xFC, 0xFC,
  0x06, 0x3F, 0xE3, 0xF0, 0x00, 0xFF, 0xCF, 0xC0, 0x03, 0xFF, 0x3F, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xF3, 0xFF, 0x00, 0x0F, 0xC7, 0xFC, 0x00, 0x3F, 0x1F,
  0xF6, 0x00, 0xFC, 0x7F, 0xDF, 0x03, 0xF3, 0xFF, 0x7F, 0x8F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC7, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xC7, 0xF8, 0x1F,
  0xE0, 0x1F, 0xF1, 0xFE, 0x3F, 0xE1, 0xFF, 0xE0, 0x7F, 0xCF, 0xF8, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xFF,
  0x1F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F,
  0xE0, 0x3F, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0x80, 0x3F, 0x03, 0xFE, 0x1F,
  0xE1, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x87, 0xFC,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x0C, 0x07, 0xF8, 0x0C, 0x7E, 0x1F, 0xE1,
  0xF9, 0xFF, 0x3F, 0x3F, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF7,
  0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0x87, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x07, 0xFC, 0x7F, 0xEF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0,
  0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0xDF, 0xFC, 0x0F,
  0xFE, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF,
  0x8F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xDF, 0xFC, 0xFF, 0xCF, 0xFE, 0x3F, 0xC7, 0xFF, 0x0F, 0xC3, 0xFF, 0x83,
  0xC1, 0xFF, 0xC0, 0xC0, 0xFF, 0xE0, 0x40, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xF0, 0x7E, 0x01, 0xFF, 0xE0, 0x78,
  0x03, 0xFF, 0xC0, 0xC0, 0x07, 0xFF, 0x80, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xC0, 0xF0, 0x0F, 0xFF,
  0x83, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0x7F, 0xF0, 0x03, 0xFE, 0x7F, 0xF0,
  0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFC, 0x7F, 0xF0, 0x0F, 0xF8, 0xFF, 0xF0,
  0x1F, 0xF8, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0xF0,
  0x7F, 0xE0, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1E,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF6, 0x00, 0x07, 0xFF, 0xBE,
  0x00, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xA0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xC1, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x0C, 0x00, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x9F, 0xFF, 0x07,
  0xFE, 0xFF, 0xFE, 0x3F, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF7,
  0xFF, 0x83, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F,
  0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF,
  0x87, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xFF,
  0xC7, 0xFF, 0x07, 0xFF, 0xBF, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFB,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0xF1, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0x07, 0xFF, 0x9F, 0xF8,
  0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x1E, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0E, 0x03, 0xFC, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xC1, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0xF0, 0x07, 0x80,
  0xFF, 0x0F, 0xFC, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF9, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0xFF, 0x1F, 0x00, 0x7F,
  0xF1, 0xC0, 0x07, 0xFF, 0x10, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0, 0x3F,
  0xFF, 0xF1, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xF1, 0xFE, 0x3F, 0xC0, 0xFF,
  0xFF, 0xF0, 0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0xFF, 0x7F, 0x87, 0xFC,
  0x0F, 0xF0, 0xFF, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x7F, 0x8F, 0xF8,
  0x0F, 0xF0, 0x7F, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0,
  0x1F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFE, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFE, 0x7F, 0x07, 0xF8, 0x3F, 0xF1, 0xFE, 0x7F, 0x87, 0xFE,
  0x7F, 0xFB, 0xFC, 0x7F, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x83, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0xFD, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF,
  0xF9, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x87, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x7F,
  0xFB, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0,
  0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0,
  0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0,
  0xFF, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x7C, 0x3F, 0xFE,
  0x00, 0x18, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x02, 0x3F, 0xFE, 0x00, 0x0C, 0x3F, 0xFF,
  0x80, 0x7C, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x0F,
  0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xEF, 0xFF,
  0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x3F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x0F, 0x03, 0xFF, 0xF0, 0x00,
  0x30, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF8,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xFC, 0x00, 0x7F, 0xF3,
  0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0xFC, 0x07,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x87, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xF0,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0x8F,
  0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC,
  0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x7F,
  0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0,
  0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x07, 0xFB, 0xFF,
  0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF,
  0xFF, 0xDF, 0xF8, 0x0F, 0xFB, 0xFF, 0xFF, 0xCF, 0xF8, 0x0F, 0xF7, 0xFF,
  0xFF, 0xEF, 0xF8, 0x1F, 0xF7, 0xFF, 0xFF, 0xEF, 0xF8, 0x1F, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xE7, 0xFF,
  0xFF, 0xE7, 0xFC, 0x3F, 0xE7, 0xFF, 0xFF, 0xE7, 0xFC, 0x3F, 0xE7, 0xFF,
  0xFF, 0xE3, 0xFE, 0x3F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFE, 0x7F, 0xC7, 0xFF,
  0xFF, 0xE3, 0xFE, 0x7F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0xC7, 0xFF,
  0xFF, 0xE1, 0xFF, 0x7F, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF7, 0xFF, 0x01,
  0xFF, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0xFF,
  0x9F, 0xFC, 0x0F, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFE, 0x7F, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xE7, 0xFF, 0xFF, 0xC1, 0xFF, 0xCF, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0xFF,
  0xFF, 0x03, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0xC0,
  0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x0F, 0xFF,
  0xBF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xDF, 0xFE, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFF, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x03,
  0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE1, 0xFF, 0xFB, 0xFF,
  0xC0, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xDF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0,
  0x1F, 0xFD, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x87,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x7F, 0xF8,
  0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xBF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF1, 0xFF,
  0xC0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xFC,
  0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x01,
  0xF8, 0xFF, 0xE0, 0x01, 0x87, 0xFF, 0x00, 0x04, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xCF,
  0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xF8, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x2F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x7F, 0xC1,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xDF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F,
  0xF7, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0xFF, 0x0F, 0xFE, 0x00,
  0x7F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xCF,
  0xF8, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x1F, 0xE7, 0xFF, 0x00,
  0x0F, 0xFC, 0xFF, 0x07, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC1, 0xFF,
  0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x01, 0xFF,
  0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFD,
  0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0xFC, 0x0F, 0x00,
  0xFF, 0xF0, 0x20, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFC, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF9, 0xFF,
  0xF0, 0x7F, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0x8F, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFE,
  0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x80, 0xFF, 0xEF, 0xFF,
  0x03, 0xFF, 0xDF, 0xFF, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0xF8, 0x7F, 0xFC, 0x01, 0x87,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x02, 0x7F, 0xF8, 0x00,
  0x47, 0xFF, 0xC0, 0x3C, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x5C, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0xE0, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0xF3,
  0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xF7, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xCF, 0xFF, 0xDF, 0xFF, 0x07, 0xFF, 0xBF, 0xFC, 0x07, 0xFF,
  0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF,
  0x80, 0xFF, 0xEF, 0xFF, 0x83, 0xFF, 0xDF, 0xFF, 0x9F, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xBF, 0xF0, 0x7F, 0xFE, 0x7F, 0xE0, 0x7F, 0xF8,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF9,
  0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0x7F, 0xEF,
  0xFE, 0x00, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x30, 0xFF, 0xF8, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x84, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0x9F, 0xF8, 0x3F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0x7F, 0xE3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF8, 0x7F, 0xFD, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0xC0, 0x7F,
  0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0x7F,
  0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xF9, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xFE, 0x07, 0xFF,
  0x9F, 0xFC, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0xC0, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC8, 0x00, 0x03, 0xFF, 0x9C, 0x00, 0x0F,
  0xFF, 0x3F, 0x80, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF9,
  0xFF, 0xF8, 0x7F, 0xF7, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xC3, 0xFE, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xE1, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x7F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xF8,
  0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE7,
  0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xFC,
  0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x7F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0xFE,
  0x01, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0x87, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF8, 0xFF, 0xFB,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F,
  0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x0F,
  0xFF, 0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x1F, 0xFF,
  0x07, 0xFE, 0x7F, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xF0, 0xFF, 0xFB, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xEF,
  0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0,
  0x3F, 0xFD, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xC1, 0xFF, 0xCF, 0xFF,
  0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0x03, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x1F,
  0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0x7F, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF8, 0x7F, 0xFD, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0xC0,
  0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xBF, 0xF8, 0x07, 0xFF,
  0x7F, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xF9, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xEF, 0xFE, 0x07,
  0xFF, 0x9F, 0xFC, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0xC0, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0xFE, 0x7F, 0xF0,
  0x0E, 0x3F, 0xF8, 0x01, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0x40, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xC3, 0xFE, 0x0F, 0xFE, 0x07, 0xFC,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0x80,
  0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xF8,
  0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xE7, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x1F,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xE0, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xDF, 0xE1,
  0xFF, 0x81, 0xFF, 0x8F, 0xFB, 0xFC, 0x7F, 0xF0, 0x3F, 0xF1, 0xFE, 0x7F,
  0x8F, 0xFC, 0x07, 0xFF, 0x3F, 0xCF, 0xF1, 0xFF, 0x80, 0xFF, 0xE7, 0xF9,
  0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0xBF,
  0xE3, 0xFC, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x7F, 0xBF, 0xF0, 0x07, 0xFE,
  0xFF, 0x0F, 0xF7, 0xFE, 0x00, 0x7F, 0xDF, 0xE1, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFB, 0xFC, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x83, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE,
  0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xFC, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xDF, 0xFF,
  0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFD,
  0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F,
  0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF,
  0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x01,
  0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xC7, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x04, 0x7F, 0xF8, 0x00, 0x13, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xEC, 0x00,
  0x1F, 0xFF, 0x20, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Black62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 12, 45, 18, 3, -44 },
  { 69, 25, 16, 32, 3, -44 },
  { 119, 36, 44, 38, 1, -44 },
  { 317, 30, 51, 34, 2, -47 },
  { 509, 54, 46, 56, 1, -45 },
  { 820, 44, 46, 46, 2, -45 },
  { 1073, 11, 16, 17, 3, -44 },
  { 1095, 18, 56, 22, 2, -46 },
  { 1221, 18, 56, 22, 1, -46 },
  { 1347, 30, 29, 32, 1, -47 },
  { 1456, 29, 30, 34, 3, -37 },
  { 1565, 13, 18, 18, 2, -9 },
  { 1595, 17, 9, 20, 1, -21 },
  { 1615, 12, 12, 18, 3, -11 },
  { 1633, 27, 46, 27, 0, -45 },
  { 1789, 30, 46, 34, 2, -45 },
  { 1962, 25, 44, 34, 2, -44 },
  { 2100, 31, 45, 34, 1, -45 },
  { 2275, 30, 46, 34, 2, -45 },
  { 2448, 32, 44, 34, 1, -44 },
  { 2624, 29, 45, 34, 3, -44 },
  { 2788, 30, 46, 34, 2, -45 },
  { 2961, 30, 44, 34, 2, -44 },
  { 3126, 30, 46, 34, 2, -45 },
  { 3299, 30, 46, 34, 2, -45 },
  { 3472, 12, 36, 18, 3, -35 },
  { 3526, 13, 44, 18, 2, -35 },
  { 3598, 30, 33, 34, 2, -39 },
  { 3722, 29, 22, 34, 3, -33 },
  { 3802, 29, 33, 34, 3, -39 },
  { 3922, 28, 46, 29, 0, -45 },
  { 4083, 48, 50, 53, 2, -45 },
  { 4383, 42, 44, 42, 0, -44 },
  { 4614, 32, 44, 39, 4, -44 },
  { 4790, 32, 46, 37, 3, -45 },
  { 4974, 35, 44, 42, 4, -44 },
  { 5167, 25, 44, 32, 4, -44 },
  { 5305, 25, 44, 31, 4, -44 },
  { 5443, 36, 46, 43, 3, -45 },
  { 5650, 36, 44, 44, 4, -44 },
  { 5848, 21, 44, 25, 2, -44 },
  { 5964, 20, 58, 20, -4, -44 },
  { 6109, 36, 44, 40, 4, -44 },
  { 6307, 27, 44, 33, 4, -44 },
  { 6456, 48, 44, 56, 4, -44 },
  { 6720, 39, 44, 48, 4, -44 },
  { 6935, 39, 46, 45, 3, -45 },
  { 7160, 31, 44, 37, 4, -44 },
  { 7331, 40, 56, 45, 3, -45 },
  { 7611, 36, 44, 39, 4, -44 },
  { 7809, 29, 46, 33, 2, -45 },
  { 7976, 31, 44, 34, 1, -44 },
  { 8147, 35, 45, 43, 4, -44 },
  { 8344, 40, 44, 40, 0, -44 },
  { 8564, 58, 44, 59, 1, -44 },
  { 8883, 40, 44, 40, 0, -44 },
  { 9103, 38, 44, 38, 0, -44 },
  { 9312, 31, 44, 35, 2, -44 },
  { 9483, 15, 56, 20, 3, -46 },
  { 9588, 27, 46, 27, 0, -45 },
  { 9744, 15, 56, 20, 1, -46 },
  { 9849, 33, 29, 33, 0, -44 },
  { 9969, 31, 7, 31, 0, 4 },
  { 9997, 20, 9, 24, 2, -47 },
  { 10020, 30, 36, 36, 2, -35 },
  { 10155, 31, 48, 37, 4, -47 },
  { 10341, 28, 36, 31, 2, -35 },
  { 10467, 31, 48, 37, 2, -47 },
  { 10653, 31, 36, 35, 2, -35 },
  { 10793, 24, 47, 24, 1, -47 },
  { 10934, 31, 50, 37, 2, -35 },
  { 11128, 31, 47, 38, 4, -47 },
  { 11311, 12, 48, 19, 3, -48 },
  { 11383, 18, 63, 19, -3, -48 },
  { 11525, 34, 47, 38, 4, -47 },
  { 11725, 11, 47, 19, 4, -47 },
  { 11790, 50, 35, 57, 4, -35 },
  { 12009, 31, 35, 38, 4, -35 },
  { 12145, 32, 36, 37, 2, -35 },
  { 12289, 31, 50, 37, 4, -35 },
  { 12483, 31, 50, 37, 2, -35 },
  { 12677, 22, 35, 27, 4, -35 },
  { 12774, 25, 36, 29, 2, -35 },
  { 12887, 23, 42, 26, 1, -41 },
  { 13008, 31, 35, 38, 4, -34 },
  { 13144, 35, 34, 35, 0, -34 },
  { 13293, 51, 34, 52, 1, -34 },
  { 13510, 35, 34, 36, 0, -34 },
  { 13659, 35, 49, 35, 0, -34 },
  { 13874, 27, 34, 29, 1, -34 },
  { 13989, 23, 55, 25, 1, -45 },
  { 14148, 8, 61, 30, 11, -47 },
  { 14209, 22, 55, 25, 2, -45 },
  { 14361, 30, 12, 34, 2, -28 },
};

const GFXfont NotoSans_SemiCondensed_Black62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK62PT7B_H_
