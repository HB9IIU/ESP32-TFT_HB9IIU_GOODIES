#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_SemiCondensed_Black
// Headers: 67

#include "NotoSans_SemiCondensed_Black6pt7b.h"
#include "NotoSans_SemiCondensed_Black7pt7b.h"
#include "NotoSans_SemiCondensed_Black8pt7b.h"
#include "NotoSans_SemiCondensed_Black9pt7b.h"
#include "NotoSans_SemiCondensed_Black10pt7b.h"
#include "NotoSans_SemiCondensed_Black11pt7b.h"
#include "NotoSans_SemiCondensed_Black12pt7b.h"
#include "NotoSans_SemiCondensed_Black13pt7b.h"
#include "NotoSans_SemiCondensed_Black14pt7b.h"
#include "NotoSans_SemiCondensed_Black15pt7b.h"
#include "NotoSans_SemiCondensed_Black16pt7b.h"
#include "NotoSans_SemiCondensed_Black17pt7b.h"
#include "NotoSans_SemiCondensed_Black18pt7b.h"
#include "NotoSans_SemiCondensed_Black19pt7b.h"
#include "NotoSans_SemiCondensed_Black20pt7b.h"
#include "NotoSans_SemiCondensed_Black21pt7b.h"
#include "NotoSans_SemiCondensed_Black22pt7b.h"
#include "NotoSans_SemiCondensed_Black23pt7b.h"
#include "NotoSans_SemiCondensed_Black24pt7b.h"
#include "NotoSans_SemiCondensed_Black25pt7b.h"
#include "NotoSans_SemiCondensed_Black26pt7b.h"
#include "NotoSans_SemiCondensed_Black27pt7b.h"
#include "NotoSans_SemiCondensed_Black28pt7b.h"
#include "NotoSans_SemiCondensed_Black29pt7b.h"
#include "NotoSans_SemiCondensed_Black30pt7b.h"
#include "NotoSans_SemiCondensed_Black31pt7b.h"
#include "NotoSans_SemiCondensed_Black32pt7b.h"
#include "NotoSans_SemiCondensed_Black33pt7b.h"
#include "NotoSans_SemiCondensed_Black34pt7b.h"
#include "NotoSans_SemiCondensed_Black35pt7b.h"
#include "NotoSans_SemiCondensed_Black36pt7b.h"
#include "NotoSans_SemiCondensed_Black37pt7b.h"
#include "NotoSans_SemiCondensed_Black38pt7b.h"
#include "NotoSans_SemiCondensed_Black39pt7b.h"
#include "NotoSans_SemiCondensed_Black40pt7b.h"
#include "NotoSans_SemiCondensed_Black41pt7b.h"
#include "NotoSans_SemiCondensed_Black42pt7b.h"
#include "NotoSans_SemiCondensed_Black43pt7b.h"
#include "NotoSans_SemiCondensed_Black44pt7b.h"
#include "NotoSans_SemiCondensed_Black45pt7b.h"
#include "NotoSans_SemiCondensed_Black46pt7b.h"
#include "NotoSans_SemiCondensed_Black47pt7b.h"
#include "NotoSans_SemiCondensed_Black48pt7b.h"
#include "NotoSans_SemiCondensed_Black49pt7b.h"
#include "NotoSans_SemiCondensed_Black50pt7b.h"
#include "NotoSans_SemiCondensed_Black51pt7b.h"
#include "NotoSans_SemiCondensed_Black52pt7b.h"
#include "NotoSans_SemiCondensed_Black53pt7b.h"
#include "NotoSans_SemiCondensed_Black54pt7b.h"
#include "NotoSans_SemiCondensed_Black55pt7b.h"
#include "NotoSans_SemiCondensed_Black56pt7b.h"
#include "NotoSans_SemiCondensed_Black57pt7b.h"
#include "NotoSans_SemiCondensed_Black58pt7b.h"
#include "NotoSans_SemiCondensed_Black59pt7b.h"
#include "NotoSans_SemiCondensed_Black60pt7b.h"
#include "NotoSans_SemiCondensed_Black61pt7b.h"
#include "NotoSans_SemiCondensed_Black62pt7b.h"
#include "NotoSans_SemiCondensed_Black63pt7b.h"
#include "NotoSans_SemiCondensed_Black64pt7b.h"
#include "NotoSans_SemiCondensed_Black65pt7b.h"
#include "NotoSans_SemiCondensed_Black66pt7b.h"
#include "NotoSans_SemiCondensed_Black67pt7b.h"
#include "NotoSans_SemiCondensed_Black68pt7b.h"
#include "NotoSans_SemiCondensed_Black69pt7b.h"
#include "NotoSans_SemiCondensed_Black70pt7b.h"
#include "NotoSans_SemiCondensed_Black71pt7b.h"
#include "NotoSans_SemiCondensed_Black72pt7b.h"
