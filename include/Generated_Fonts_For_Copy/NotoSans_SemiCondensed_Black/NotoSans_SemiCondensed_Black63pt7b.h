#ifndef _NOTOSANS_SEMICONDENSED_BLACK63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0xF0, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFD, 0xFF, 0x87, 0xFF, 0x7F,
  0xE1, 0xFF, 0xDF, 0xF8, 0x7F, 0xE7, 0xFE, 0x1F, 0xF9, 0xFF, 0x87, 0xFE,
  0x7F, 0xE0, 0xFF, 0x9F, 0xF8, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03,
  0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0xF8,
  0xFE, 0x3F, 0xF1, 0xF0, 0x18, 0x7F, 0xE3, 0xE0, 0x00, 0xFF, 0xC7, 0xC0,
  0x01, 0xFF, 0x8F, 0x80, 0x03, 0xFF, 0x9F, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xEF, 0xFE, 0x00,
  0x07, 0xCF, 0xFC, 0x00, 0x0F, 0x8F, 0xFE, 0x00, 0x1F, 0x1F, 0xF3, 0x00,
  0x3E, 0x3F, 0xE7, 0xC0, 0x7C, 0xFF, 0xCF, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC7, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x7F, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0xF0,
  0xFF, 0x01, 0xF0, 0x03, 0xFE, 0x3F, 0xE3, 0xFE, 0x0F, 0xFC, 0x07, 0xFC,
  0x7F, 0xC7, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x3F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0x8F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC7,
  0xFC, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xE0, 0x03, 0x00, 0x7F, 0x87, 0xFC, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xE7, 0xFC,
  0xFF, 0x9F, 0xF3, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x08, 0x07, 0xF8, 0x02, 0x3C, 0x0F, 0xE0, 0x79, 0xFE, 0x3F, 0x9F,
  0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xCF,
  0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF9, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF,
  0x87, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x83, 0xFF,
  0x8F, 0xFE, 0x07, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFE,
  0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0x7F, 0xF7,
  0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8,
  0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xE0,
  0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xDF, 0xFE,
  0x7F, 0xCF, 0xFF, 0x3F, 0xC7, 0xFF, 0x8F, 0xC3, 0xFF, 0xC3, 0xC1, 0xFF,
  0xE0, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xE3, 0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0xE0, 0xF8, 0x01, 0xFF,
  0xC0, 0xE0, 0x03, 0xFF, 0x80, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8,
  0x0F, 0xFF, 0x83, 0x80, 0x1F, 0xFE, 0x08, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xD0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0x9F, 0xFC,
  0x00, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xC3, 0xFF,
  0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x60, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x9F, 0xFF,
  0x03, 0xFF, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xF8, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF,
  0xC0, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xCF,
  0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFE, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xCF,
  0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xCF, 0xFF,
  0x03, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0x7F, 0xF0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0x7F,
  0xE0, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0x80, 0x3F, 0x87, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x87, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0xF0, 0x0F, 0xE1, 0xFF,
  0x9F, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF9,
  0xFF, 0x87, 0xF8, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x9F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x7F, 0xF1, 0xE0, 0x07, 0xFF, 0x08,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xE3, 0xFC, 0x3F, 0xC1,
  0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xE1, 0xFE, 0x1F, 0xEF, 0xF0,
  0x7F, 0xC0, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFB, 0xFC,
  0x3F, 0xC0, 0x7F, 0xC3, 0xFD, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF,
  0x87, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFF, 0x01, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xF7,
  0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xF9, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC,
  0xFF, 0x0F, 0xF8, 0x7F, 0xF3, 0xFC, 0x7F, 0x87, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xF8, 0x3F, 0xFF, 0xBF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x3C,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xBF, 0xF0,
  0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xC7, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x7F,
  0xFB, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xDF, 0xFE, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFC, 0x0F, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xE0, 0x03, 0x83, 0xFF, 0xE0, 0x00, 0x43,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x87, 0xFF, 0xE0, 0x01, 0xC3, 0xFF,
  0xFC, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0xCF, 0xFF, 0x00,
  0x7F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF,
  0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF,
  0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF,
  0xCF, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0x83, 0xFF, 0xF8, 0x00, 0x30, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x07,
  0xFF, 0x7F, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xFE,
  0x00, 0x7F, 0xF3, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0xFF,
  0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xF8,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xFC,
  0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFD,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xCF, 0xFF,
  0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x1F,
  0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0xF7, 0xFC, 0x07,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x81,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xE0,
  0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xFF, 0xFF, 0xCF, 0xFC,
  0x3F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F,
  0xE7, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xF7, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFB, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0xDF, 0xFE, 0x07,
  0xFF, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE7, 0xFF, 0x87, 0xFF, 0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0xFF, 0xE0, 0x7F, 0xFB,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xFF, 0xF1, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x03, 0xFF,
  0xDF, 0xFE, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xBF, 0xFC, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x01, 0xFF, 0xEF, 0xFF,
  0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x87, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF1,
  0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0xFE, 0x1F, 0xFE, 0x00, 0x78,
  0x7F, 0xF0, 0x00, 0x41, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xBF, 0x00, 0x1F, 0xFE, 0xFF, 0xC1, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE,
  0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xFC, 0x03,
  0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x9F, 0xFE, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x03, 0xFF, 0xE7,
  0xFF, 0xC0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x00,
  0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF8,
  0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE7,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x87, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xEF, 0xF0,
  0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFD, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE1,
  0xFF, 0x3F, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xF8,
  0x01, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0x9F,
  0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xF8, 0x00, 0xFF,
  0xE7, 0xFC, 0x3F, 0xE7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x87, 0xFC, 0xFF,
  0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFE,
  0x1F, 0xF3, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0xE0, 0x00,
  0x7F, 0xEF, 0xF0, 0x3F, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF7, 0xFF, 0x80, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x03, 0xFF, 0xEF,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0xFF, 0xF0,
  0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xF0, 0x3F, 0xFC, 0x07, 0x00, 0x3F, 0xF8, 0x08, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFD, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0x1F, 0xFF, 0xE7, 0xFE,
  0x3F, 0xFF, 0x07, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x03, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF8, 0xFF, 0xF0, 0x7F, 0xF3,
  0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF9, 0xFF, 0xFC, 0x3F, 0xF1,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x38, 0x7F, 0xFC, 0x00,
  0x87, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x02, 0x7F, 0xFC,
  0x00, 0x67, 0xFF, 0xE0, 0x3E, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF,
  0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF,
  0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF,
  0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF,
  0x7F, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE,
  0x7F, 0xF8, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x18, 0x3F, 0xFE, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF,
  0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x07, 0xFF,
  0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF,
  0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF,
  0x7F, 0xFC, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xC7, 0xFF,
  0x01, 0xFF, 0x87, 0xFF, 0x00, 0x18, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x20, 0x00, 0x0F, 0xFF, 0x38, 0x00, 0x1F, 0xFE,
  0x3F, 0x80, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF9,
  0xFF, 0xF8, 0x7F, 0xF7, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0x07,
  0xFC, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7,
  0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xA1, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFB,
  0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF,
  0x8F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x8F,
  0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFE,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF,
  0x80, 0x7F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xEF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xE1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFE, 0x3F, 0xFF, 0xC7, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x7F, 0xFB,
  0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE,
  0x7F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x1F,
  0xFF, 0x87, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xE1, 0xFF, 0xCF,
  0xFF, 0x83, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0x01, 0xC0, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0x07, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF,
  0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF,
  0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF,
  0x07, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0x18, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xEF,
  0xFD, 0xFF, 0xDF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x3E, 0x3F, 0xF8,
  0x01, 0x8F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x01, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xE3, 0xFE, 0x1F, 0xFF, 0x87, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF7,
  0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F,
  0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xFC, 0x00,
  0x3F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFE, 0x7F,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFC,
  0x7F, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xFB, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xBF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFB,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xBF, 0xC3, 0xFF, 0x81, 0xFF, 0x87,
  0xFB, 0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0xFF, 0xBF, 0xE3, 0xFF, 0x01, 0xFF,
  0xCF, 0xF9, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0x1F, 0xE7, 0xFF, 0x00,
  0xFF, 0xCF, 0xF1, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0x1F, 0xF7, 0xFE,
  0x00, 0xFF, 0xCF, 0xF1, 0xFF, 0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0x1F, 0xF7,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x0F,
  0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0,
  0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0xDF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x7F,
  0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFC, 0x03,
  0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF,
  0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x10,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x37, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xEC, 0x00, 0x0F, 0xFF, 0x20, 0x00, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Black63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 12, 46, 18, 3, -45 },
  { 70, 26, 16, 32, 3, -45 },
  { 122, 37, 45, 39, 1, -45 },
  { 331, 31, 52, 34, 2, -48 },
  { 533, 55, 47, 57, 1, -46 },
  { 857, 45, 47, 47, 2, -46 },
  { 1122, 11, 16, 17, 3, -45 },
  { 1144, 19, 56, 22, 2, -46 },
  { 1277, 18, 56, 22, 1, -46 },
  { 1403, 30, 30, 32, 1, -48 },
  { 1516, 29, 31, 35, 3, -38 },
  { 1629, 13, 18, 19, 2, -9 },
  { 1659, 17, 10, 20, 2, -22 },
  { 1681, 12, 12, 18, 3, -11 },
  { 1699, 27, 47, 27, 0, -46 },
  { 1858, 31, 47, 35, 2, -46 },
  { 2041, 25, 45, 35, 3, -45 },
  { 2182, 31, 46, 35, 1, -46 },
  { 2361, 30, 47, 35, 2, -46 },
  { 2538, 33, 45, 35, 1, -45 },
  { 2724, 29, 46, 35, 3, -45 },
  { 2891, 31, 47, 35, 2, -46 },
  { 3074, 31, 45, 35, 2, -45 },
  { 3249, 31, 47, 35, 2, -46 },
  { 3432, 31, 47, 35, 2, -46 },
  { 3615, 12, 36, 18, 3, -35 },
  { 3669, 13, 44, 18, 2, -35 },
  { 3741, 30, 34, 35, 2, -40 },
  { 3869, 29, 22, 35, 3, -33 },
  { 3949, 29, 34, 35, 3, -40 },
  { 4073, 28, 47, 29, 0, -46 },
  { 4238, 49, 51, 53, 2, -46 },
  { 4551, 42, 45, 42, 0, -45 },
  { 4788, 33, 45, 40, 4, -45 },
  { 4974, 33, 47, 38, 3, -46 },
  { 5168, 36, 45, 43, 4, -45 },
  { 5371, 25, 45, 32, 4, -45 },
  { 5512, 25, 45, 32, 4, -45 },
  { 5653, 36, 47, 43, 3, -46 },
  { 5865, 36, 45, 45, 4, -45 },
  { 6068, 22, 45, 26, 2, -45 },
  { 6192, 21, 59, 21, -5, -45 },
  { 6347, 37, 45, 40, 4, -45 },
  { 6556, 27, 45, 33, 4, -45 },
  { 6708, 49, 45, 57, 4, -45 },
  { 6984, 40, 45, 48, 4, -45 },
  { 7209, 40, 47, 46, 3, -46 },
  { 7444, 31, 45, 37, 4, -45 },
  { 7619, 41, 57, 46, 3, -46 },
  { 7912, 36, 45, 40, 4, -45 },
  { 8115, 30, 47, 34, 2, -46 },
  { 8292, 32, 45, 34, 1, -45 },
  { 8472, 36, 46, 44, 4, -45 },
  { 8679, 41, 45, 41, 0, -45 },
  { 8910, 59, 45, 60, 1, -45 },
  { 9242, 41, 45, 41, 0, -45 },
  { 9473, 39, 45, 39, 0, -45 },
  { 9693, 32, 45, 35, 2, -45 },
  { 9873, 16, 57, 20, 3, -46 },
  { 9987, 27, 47, 27, 0, -46 },
  { 10146, 16, 57, 20, 1, -46 },
  { 10260, 34, 30, 33, 0, -45 },
  { 10388, 32, 8, 32, 0, 4 },
  { 10420, 19, 10, 25, 3, -48 },
  { 10444, 31, 36, 36, 2, -35 },
  { 10584, 31, 49, 38, 4, -48 },
  { 10774, 28, 36, 32, 2, -35 },
  { 10900, 32, 49, 38, 2, -48 },
  { 11096, 32, 36, 36, 2, -35 },
  { 11240, 24, 48, 24, 1, -48 },
  { 11384, 32, 50, 38, 2, -35 },
  { 11584, 31, 48, 39, 4, -48 },
  { 11770, 12, 49, 19, 4, -49 },
  { 11844, 19, 64, 19, -3, -49 },
  { 11996, 34, 48, 38, 4, -48 },
  { 12200, 11, 48, 19, 4, -48 },
  { 12266, 50, 35, 58, 4, -35 },
  { 12485, 31, 35, 39, 4, -35 },
  { 12621, 33, 36, 37, 2, -35 },
  { 12770, 31, 50, 38, 4, -35 },
  { 12964, 32, 50, 38, 2, -35 },
  { 13164, 23, 35, 27, 4, -35 },
  { 13265, 26, 36, 30, 2, -35 },
  { 13382, 24, 43, 27, 1, -42 },
  { 13511, 31, 36, 39, 4, -35 },
  { 13651, 36, 35, 36, 0, -35 },
  { 13809, 52, 35, 53, 1, -35 },
  { 14037, 36, 35, 36, 0, -35 },
  { 14195, 36, 50, 36, 0, -35 },
  { 14420, 27, 35, 29, 1, -35 },
  { 14539, 22, 57, 26, 2, -46 },
  { 14696, 8, 62, 30, 11, -48 },
  { 14758, 22, 57, 26, 2, -46 },
  { 14915, 30, 12, 35, 2, -28 },
};

const GFXfont NotoSans_SemiCondensed_Black63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK63PT7B_H_
