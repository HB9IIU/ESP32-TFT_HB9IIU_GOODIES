#ifndef _NOTOSANS_SEMICONDENSED_BLACK25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xE0, 0x03, 0xFF, 0xFB,
  0x80, 0xFB, 0xFE, 0xFF, 0x3D, 0xCF, 0x73, 0xDC, 0x77, 0x1C, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF7, 0x8F, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x0E, 0x70, 0x1C, 0xE3, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC3, 0x9C,
  0x07, 0x38, 0x0E, 0x70, 0x3D, 0xE0, 0x73, 0x80, 0x06, 0x00, 0x60, 0x3F,
  0xE7, 0xFE, 0xFF, 0xEF, 0x66, 0xF6, 0x0F, 0xE0, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0x07, 0xF0, 0x6F, 0xE6, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x06,
  0x00, 0x60, 0x1E, 0x03, 0x80, 0xFC, 0x1E, 0x07, 0xF8, 0x70, 0x1C, 0xE3,
  0xC0, 0x73, 0x8E, 0x03, 0xCE, 0x78, 0x07, 0x39, 0xC0, 0x1C, 0xEF, 0x3C,
  0x7F, 0xB9, 0xF8, 0xFD, 0xEF, 0xF1, 0xE7, 0x3B, 0xC0, 0x3D, 0xE7, 0x00,
  0xE7, 0x9C, 0x07, 0x9E, 0x70, 0x1C, 0x39, 0xC0, 0xF0, 0xFF, 0x03, 0x83,
  0xF8, 0x1E, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xF3,
  0xC0, 0x7C, 0xF0, 0x0F, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x8F,
  0x9F, 0xF3, 0xCF, 0xFF, 0xF3, 0xEF, 0xFC, 0xF1, 0xFE, 0x3E, 0x3F, 0x8F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xF7, 0xF0, 0xFF, 0xFC, 0xE7,
  0x39, 0xC0, 0x1E, 0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x7C, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0, 0xF8, 0x3C,
  0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF8, 0x07, 0x00, 0x70, 0x07,
  0x06, 0x73, 0x7F, 0xF7, 0xFF, 0xBF, 0xE1, 0xF8, 0x1D, 0xC3, 0xDE, 0x18,
  0xC0, 0x88, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7B, 0xDF, 0xEF, 0x7B,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x01, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x1F, 0x83, 0xFC, 0x7F,
  0xE7, 0xFE, 0xF9, 0xEF, 0x9F, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0x7F, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x07,
  0xC3, 0xF1, 0xFC, 0xFF, 0x7F, 0xFF, 0xF7, 0x7C, 0x9F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x1F, 0x87,
  0xFC, 0xFF, 0xEF, 0xFE, 0x61, 0xE4, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xC0,
  0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0x8F, 0xFC, 0xFF, 0xE7, 0xFE, 0x41, 0xE0, 0x1E, 0x03, 0xE3,
  0xFC, 0x3F, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xCF, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F,
  0x07, 0xF8, 0x7F, 0xC3, 0xBE, 0x3D, 0xF3, 0xCF, 0x9E, 0x7D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07, 0x80, 0x7F, 0x07, 0xFC, 0x7F, 0xEF,
  0xFE, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xF7, 0xEF, 0xFE, 0xFF, 0xC7,
  0xF8, 0x07, 0xE1, 0xFE, 0x3F, 0xE7, 0xFE, 0x78, 0x0F, 0x80, 0xF3, 0x8F,
  0x7E, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xF7,
  0xFE, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x87, 0xFE, 0x7F, 0xEF,
  0xBE, 0xF9, 0xFF, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x83, 0xFC, 0x7F, 0xEF,
  0x9F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0x7F, 0xE3, 0xFC, 0x1F, 0x07,
  0xFC, 0x7F, 0xEF, 0xFE, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x7E, 0xF3, 0xCF, 0x01, 0xE0, 0x1E, 0x4F, 0xE7, 0xFC, 0x7F, 0x87,
  0xE0, 0x77, 0xFF, 0xF3, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xBC, 0x77, 0xFF,
  0xF3, 0x00, 0x00, 0x00, 0x1E, 0xF7, 0xFB, 0xDE, 0xE0, 0x00, 0x10, 0x07,
  0x01, 0xF0, 0x7F, 0x1F, 0xE7, 0xF0, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xFE,
  0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0xF0,
  0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0x0F, 0xE7, 0xF8, 0xFE,
  0x0F, 0x80, 0xC0, 0x08, 0x00, 0x3F, 0x9F, 0xFB, 0xFF, 0xBF, 0xF4, 0x1E,
  0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0xF8, 0x1F, 0x03, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1E, 0x01, 0xE3, 0x82, 0x1C, 0xE3, 0xF9, 0xDC, 0xFF, 0x3F, 0xBC,
  0xE7, 0xE7, 0x1C, 0xFC, 0xE3, 0x9F, 0x9C, 0x73, 0xF3, 0x8E, 0x7E, 0x7B,
  0xFF, 0xEF, 0xFF, 0x9C, 0xF9, 0xE3, 0xC0, 0x00, 0x3C, 0x02, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xE0, 0x3C, 0xF8, 0x1E,
  0x3C, 0x1F, 0x1E, 0x0F, 0x8F, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1,
  0xFF, 0xFC, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x07, 0xC0, 0xFF, 0x87, 0xFF,
  0x3F, 0xFD, 0xFF, 0xEF, 0x1F, 0x78, 0x7B, 0xC7, 0xDF, 0xFC, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFD, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xDF, 0xFE, 0xFF,
  0xE7, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0xFF, 0xE7, 0xC1, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x05, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0x7F, 0x80, 0xFF, 0x03, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFE, 0xF1, 0xFB, 0xC3, 0xEF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFB, 0xC7, 0xEF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F,
  0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC7, 0xE0,
  0x8F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF,
  0xC1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xF8, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFF,
  0xFE, 0xFC, 0x60, 0xF0, 0x7F, 0xC3, 0xEF, 0x0F, 0xBC, 0x7C, 0xF3, 0xE3,
  0xCF, 0x8F, 0x7C, 0x3D, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3E, 0xF8,
  0xF3, 0xE3, 0xC7, 0xCF, 0x1F, 0x3C, 0x3E, 0xF0, 0xFB, 0xC1, 0xF0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0x7F, 0xF8, 0xEF, 0xF7, 0x3D, 0xFE, 0xF7, 0xBF, 0xDE, 0xE7,
  0xFB, 0xDC, 0xFF, 0x3F, 0x9F, 0xE7, 0xF3, 0xFC, 0xFC, 0x7F, 0x8F, 0x8F,
  0xF1, 0xF1, 0xFE, 0x3C, 0x3C, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFB, 0xCF, 0xF7, 0xDF, 0xE7, 0xBF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFC, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C,
  0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7C, 0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0xF1, 0xF3, 0xC7,
  0xCF, 0x1F, 0x3C, 0x7C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x3D, 0xF0, 0xF3,
  0xE3, 0xCF, 0x8F, 0x1F, 0x3C, 0x7C, 0xF0, 0xFB, 0xC1, 0xF0, 0x1F, 0xC7,
  0xFF, 0x7F, 0xEF, 0xFE, 0xF8, 0x4F, 0x80, 0xFC, 0x07, 0xF0, 0x7F, 0xC3,
  0xFE, 0x0F, 0xE0, 0x3E, 0x01, 0xF8, 0x1E, 0xFF, 0xEF, 0xFE, 0xFF, 0xC7,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xE1, 0xEF, 0xFF, 0x9F, 0xFE, 0x7F, 0xF0, 0x7F, 0x00,
  0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3E,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0xF8, 0x3C, 0x1F, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x1E, 0x78, 0x7E, 0x3E,
  0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3C, 0x3C, 0x7E, 0x3C, 0x3C, 0xFF, 0x3C,
  0x3C, 0xFF, 0x7C, 0x3E, 0xEF, 0x7C, 0x1E, 0xE7, 0x78, 0x1F, 0xE7, 0x78,
  0x1F, 0xE7, 0x78, 0x1F, 0xE7, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x7C, 0x3E, 0x3E, 0x7C,
  0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0x78, 0x3E, 0x7C,
  0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x7D, 0xF1, 0xF1,
  0xE3, 0xE3, 0xE7, 0x83, 0xDF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xF0,
  0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F,
  0x01, 0xFC, 0x0E, 0xE0, 0xF7, 0x87, 0x1C, 0x78, 0xF3, 0xC3, 0x9C, 0x1F,
  0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3C, 0x1E, 0x0F, 0x1F,
  0xC7, 0xFE, 0x3F, 0xE3, 0x1F, 0x01, 0xF0, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xE7, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7D, 0xE3, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xBC, 0xF8, 0x0F, 0xC7, 0xFD, 0xFF, 0x3F, 0xEF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xFF, 0x3F, 0xE3, 0xFC, 0x3F, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xEF, 0x7F, 0xF7, 0xFF, 0xFF,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0xDF, 0x7F,
  0xF7, 0xFF, 0x3E, 0x70, 0x1F, 0x83, 0xFE, 0x7F, 0xE7, 0x9F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0xFC, 0x27, 0xFE, 0x3F, 0xE1,
  0xFE, 0x0F, 0xC7, 0xF3, 0xFC, 0xF9, 0x3E, 0x0F, 0xEF, 0xFB, 0xFE, 0xFF,
  0x8F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0x1E, 0x77, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xFD, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF8,
  0x0F, 0x7F, 0xF7, 0xFE, 0x7F, 0xE3, 0xF8, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7D, 0xF3, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3E, 0x7F, 0xDE, 0x60, 0x3D, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0x1E, 0x7C, 0x78, 0x60, 0x03, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xFF, 0xFF, 0xFE, 0xF8,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE1, 0xFF, 0x8F,
  0xBE, 0x7C, 0xF9, 0xF3, 0xEF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x8F, 0xDF, 0x3E, 0x7C, 0xF8, 0xFB, 0xE3, 0xEF, 0x87, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF3, 0xE3,
  0xE7, 0xBF, 0xBF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xCF, 0x8F, 0xFC,
  0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7,
  0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7C, 0xF3,
  0xE7, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7C, 0x1F, 0x81,
  0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xDF, 0x7C, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0xF3, 0xE7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x7D, 0xF3, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x77, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFD, 0xF7, 0xFF,
  0x7F, 0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xE7, 0xF7, 0xFF, 0xDF, 0xEF, 0xCF, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x80, 0x3F, 0x1F, 0xFF, 0xFB, 0xC6, 0xF8, 0x3F, 0x87,
  0xF8, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0xFF, 0xFF, 0xBF, 0xC0, 0x0E, 0x07,
  0x81, 0xE0, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0xF3, 0xFC, 0x7F, 0x0F, 0xC0, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xDF, 0x7E, 0xFF, 0xF7, 0xFF, 0x9F, 0xBC, 0xF8, 0x7F, 0xE1, 0xF7, 0x87,
  0x9F, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0xF8, 0xFB, 0xC7,
  0xC7, 0xDE, 0x3F, 0x3C, 0xF3, 0xF9, 0xE7, 0xDD, 0xCF, 0x1E, 0xEE, 0xF8,
  0xF7, 0x77, 0x87, 0xBB, 0xFC, 0x3F, 0xDF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0xFC, 0x7D, 0xF3,
  0xE3, 0xCF, 0x8F, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0x3E, 0x7C, 0xFB, 0xE1, 0xF0, 0xF8, 0x7F,
  0xE1, 0xF7, 0x87, 0x9F, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xEF, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x8F, 0xC7, 0xE7, 0xC3, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x7E, 0x3E, 0x1F, 0x0F, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x83, 0xF1, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1F, 0xC7, 0xE3, 0xF3, 0xF9, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x1F, 0x1F, 0x8F, 0x87, 0x80, 0x7C, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F,
  0x80, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Black25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 18, 7, 1, -18 },
  { 13, 10, 7, 13, 1, -18 },
  { 22, 15, 18, 15, 0, -18 },
  { 56, 12, 20, 14, 1, -19 },
  { 86, 22, 18, 23, 0, -18 },
  { 136, 18, 18, 19, 1, -18 },
  { 177, 5, 7, 7, 1, -18 },
  { 182, 7, 22, 9, 1, -18 },
  { 202, 8, 22, 9, 0, -18 },
  { 224, 12, 12, 13, 0, -19 },
  { 242, 12, 12, 14, 1, -15 },
  { 260, 5, 7, 7, 1, -4 },
  { 265, 6, 4, 8, 1, -9 },
  { 268, 5, 4, 7, 1, -4 },
  { 271, 11, 18, 11, 0, -18 },
  { 296, 12, 18, 14, 1, -18 },
  { 323, 10, 18, 14, 1, -18 },
  { 346, 12, 18, 14, 1, -18 },
  { 373, 12, 18, 14, 1, -18 },
  { 400, 13, 18, 14, 0, -18 },
  { 430, 12, 18, 14, 1, -18 },
  { 457, 12, 18, 14, 1, -18 },
  { 484, 12, 18, 14, 1, -18 },
  { 511, 12, 18, 14, 1, -18 },
  { 538, 12, 18, 14, 1, -18 },
  { 565, 5, 14, 7, 1, -14 },
  { 574, 5, 17, 7, 1, -14 },
  { 585, 12, 14, 14, 1, -16 },
  { 606, 12, 9, 14, 1, -13 },
  { 620, 12, 14, 14, 1, -16 },
  { 641, 11, 18, 12, 0, -18 },
  { 666, 19, 20, 21, 1, -18 },
  { 714, 17, 18, 17, 0, -18 },
  { 753, 13, 18, 16, 2, -18 },
  { 783, 13, 18, 15, 1, -18 },
  { 813, 14, 18, 17, 2, -18 },
  { 845, 10, 18, 13, 2, -18 },
  { 868, 10, 18, 13, 2, -18 },
  { 891, 15, 18, 17, 1, -18 },
  { 925, 14, 18, 18, 2, -18 },
  { 957, 8, 18, 10, 1, -18 },
  { 975, 8, 24, 8, -2, -18 },
  { 999, 14, 18, 16, 2, -18 },
  { 1031, 10, 18, 13, 2, -18 },
  { 1054, 19, 18, 23, 2, -18 },
  { 1097, 15, 18, 19, 2, -18 },
  { 1131, 16, 18, 18, 1, -18 },
  { 1167, 12, 18, 15, 2, -18 },
  { 1194, 16, 22, 18, 1, -18 },
  { 1238, 14, 18, 16, 2, -18 },
  { 1270, 12, 18, 13, 1, -18 },
  { 1297, 12, 18, 14, 1, -18 },
  { 1324, 14, 18, 17, 2, -18 },
  { 1356, 16, 18, 16, 0, -18 },
  { 1392, 24, 18, 24, 0, -18 },
  { 1446, 16, 18, 16, 0, -18 },
  { 1482, 15, 18, 15, 0, -18 },
  { 1516, 12, 18, 14, 1, -18 },
  { 1543, 6, 22, 8, 1, -18 },
  { 1560, 11, 18, 11, 0, -18 },
  { 1585, 6, 22, 8, 1, -18 },
  { 1602, 13, 12, 13, 0, -18 },
  { 1622, 13, 3, 13, 0, 2 },
  { 1627, 8, 4, 10, 1, -19 },
  { 1631, 12, 14, 14, 1, -14 },
  { 1652, 13, 19, 15, 1, -19 },
  { 1683, 11, 14, 13, 1, -14 },
  { 1703, 12, 19, 15, 1, -19 },
  { 1732, 12, 14, 14, 1, -14 },
  { 1753, 10, 19, 10, 0, -19 },
  { 1777, 12, 20, 15, 1, -14 },
  { 1807, 13, 19, 15, 1, -19 },
  { 1838, 5, 19, 8, 1, -19 },
  { 1850, 7, 25, 8, -1, -19 },
  { 1872, 14, 19, 15, 1, -19 },
  { 1906, 5, 19, 8, 1, -19 },
  { 1918, 21, 14, 23, 1, -14 },
  { 1955, 13, 14, 15, 1, -14 },
  { 1978, 13, 14, 15, 1, -14 },
  { 2001, 13, 20, 15, 1, -14 },
  { 2034, 12, 20, 15, 1, -14 },
  { 2064, 9, 14, 11, 2, -14 },
  { 2080, 10, 14, 12, 1, -14 },
  { 2098, 10, 17, 11, 0, -17 },
  { 2120, 13, 14, 15, 1, -14 },
  { 2143, 14, 14, 14, 0, -14 },
  { 2168, 21, 14, 21, 0, -14 },
  { 2205, 14, 14, 14, 0, -14 },
  { 2230, 14, 20, 14, 0, -14 },
  { 2265, 10, 14, 12, 1, -14 },
  { 2283, 9, 22, 10, 1, -18 },
  { 2308, 4, 25, 12, 4, -19 },
  { 2321, 9, 22, 10, 1, -18 },
  { 2346, 12, 5, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Black25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK25PT7B_H_
