#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC28PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x80, 0x00, 0x00, 0x40, 0x78, 0x7C, 0x3E, 0x1E, 0x00,
  0x7B, 0xFC, 0xFF, 0x3F, 0xCE, 0xF3, 0xB9, 0xEE, 0x78, 0x01, 0xCE, 0x01,
  0xCE, 0x03, 0x9C, 0x03, 0x9C, 0x03, 0x9C, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0xFF, 0xFC, 0xFF,
  0xFC, 0x1C, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x73, 0x80, 0x73,
  0x80, 0x00, 0x40, 0x01, 0x00, 0x3F, 0x83, 0xFF, 0x1F, 0xF8, 0x7A, 0xE1,
  0xC8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x2F, 0x10, 0xBC, 0x7F, 0xF1, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x1E, 0x03, 0x87, 0xE0, 0xE1, 0xFC,
  0x3C, 0x7B, 0x87, 0x0E, 0x71, 0xC1, 0xCE, 0x38, 0x39, 0xCE, 0x07, 0x3B,
  0xC0, 0xEE, 0x73, 0xDF, 0xDD, 0xFF, 0xF7, 0xBF, 0xBC, 0xEF, 0x70, 0x39,
  0xCE, 0x07, 0x39, 0xC1, 0xC7, 0x38, 0x79, 0xE7, 0x0E, 0x3D, 0xC3, 0x83,
  0xF8, 0x70, 0x7E, 0x1C, 0x07, 0x80, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE7, 0xC7, 0xF3, 0xC7, 0xFD, 0xE7, 0x9F, 0xE7, 0xCF, 0xF3,
  0xE3, 0xF1, 0xF1, 0xF8, 0xF9, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xF7,
  0xC0, 0x7F, 0xBD, 0xEF, 0x73, 0x80, 0x07, 0xC1, 0xC0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0x04, 0x00, 0x78, 0x07, 0x06, 0x70,
  0x77, 0x1F, 0xFF, 0x7F, 0xF0, 0xFF, 0x3F, 0x07, 0xF8, 0x7B, 0xC3, 0x3C,
  0x11, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x78, 0x7F, 0x7F, 0xFF, 0x23,
  0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x7D, 0xE3,
  0xCF, 0x3E, 0x7D, 0xE3, 0xCF, 0x1E, 0x78, 0xF7, 0xC7, 0xBC, 0x3D, 0xE3,
  0xEF, 0x1F, 0x78, 0xF3, 0xC7, 0x9E, 0x78, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0,
  0x7C, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xE3, 0xFD, 0xFF, 0x9F, 0xF1,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0E, 0x3C, 0x10, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xF1,
  0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x07, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xBF,
  0x08, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x0F, 0xE0, 0x3E, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x20, 0x7C, 0xE7, 0xE3, 0xFF,
  0x8F, 0xFC, 0x3F, 0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0x9E, 0x1E,
  0x78, 0x71, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x20, 0x7C, 0xF7, 0xE3, 0xFF, 0x8F, 0xFC,
  0x3F, 0xC0, 0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F, 0x11, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x78, 0x7F, 0xE7, 0xFF, 0x3F, 0x7D, 0xF3, 0xEF, 0x1F, 0x78,
  0xFB, 0xC7, 0x9E, 0x3C, 0xFB, 0xE7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x3F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC7, 0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x87, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0x0F, 0xFC, 0x7C, 0xF1, 0xE3, 0xCF, 0x0F,
  0x3C, 0x3C, 0xF9, 0xF1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7F,
  0x87, 0xFE, 0x3E, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF1, 0xEF, 0x00, 0x78, 0x07, 0x80, 0x7C, 0xCF,
  0xC7, 0xFC, 0x3F, 0xC1, 0xFC, 0x00, 0x04, 0x3C, 0x79, 0xF1, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x07, 0x9F, 0x3E, 0x78, 0x01, 0x03, 0xC1, 0xE1,
  0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0xF0, 0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E,
  0x0F, 0xF1, 0xFC, 0x3F, 0x83, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x01,
  0xFE, 0x03, 0xF0, 0x07, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0x80,
  0x3F, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x0F, 0xF1,
  0xFE, 0x3F, 0xC1, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x1F, 0x8F, 0xF8, 0xFF,
  0x9D, 0xF2, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0x1F, 0x07, 0x80, 0xF1, 0xC0, 0x0E,
  0x70, 0xF9, 0xCE, 0x7F, 0xBB, 0x9F, 0xF3, 0x73, 0x9C, 0xFC, 0xE3, 0x9F,
  0x9C, 0x73, 0xF3, 0x8E, 0x7E, 0x73, 0x8D, 0xCE, 0x73, 0xB9, 0xFF, 0xE7,
  0x3E, 0xF8, 0xE3, 0x8E, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x1C, 0x03,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xDE, 0x03, 0xDE, 0x03, 0xDE, 0x07,
  0x9E, 0x07, 0x9E, 0x0F, 0x1E, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0xF8, 0x1F, 0x0F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF8, 0x7B, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x8F, 0x8F, 0x3E,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xE1, 0xE7, 0xC3, 0xC7, 0x8F, 0x8F, 0x9F,
  0x1E, 0x3C, 0x7C, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0x03,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xF0, 0x87, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x10, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x3E, 0x1F,
  0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C,
  0x3E, 0x3C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x78, 0xF8, 0x7F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F,
  0x04, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x02, 0x78, 0xFC, 0xF9,
  0xFC, 0xF9, 0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x0F, 0x87, 0x87, 0x83, 0xC3,
  0xC1, 0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x3E,
  0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x83, 0xC3, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1F,
  0x0F, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x83, 0xFC,
  0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0x87, 0x87, 0x83, 0xC7,
  0xC1, 0xE7, 0xC1, 0xF3, 0xC0, 0xF3, 0xE0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xEF, 0x81,
  0xF7, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x7C, 0x3E, 0x3E, 0x1E, 0x0F,
  0x00, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x7F,
  0xEF, 0xFB, 0xFF, 0x7F, 0xE0, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x1F, 0xC3, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F,
  0x87, 0xF1, 0xFE, 0x1D, 0xC7, 0xF8, 0xF7, 0x3F, 0xC3, 0xDC, 0xEF, 0x0F,
  0x77, 0xBC, 0x3D, 0xDC, 0xF1, 0xE7, 0xF7, 0x87, 0x9F, 0x9E, 0x1E, 0x7E,
  0x78, 0x79, 0xF1, 0xE1, 0xE7, 0xC7, 0x8F, 0x1F, 0x3C, 0x3C, 0x78, 0xF0,
  0x0F, 0x81, 0xE1, 0xF0, 0x78, 0x3F, 0x0F, 0x07, 0xE1, 0xE1, 0xFC, 0x3C,
  0x3F, 0x87, 0x07, 0xF9, 0xE0, 0xFF, 0x3C, 0x1D, 0xE7, 0x87, 0xBC, 0xF0,
  0xF3, 0xBC, 0x1E, 0x7F, 0x83, 0xCF, 0xF0, 0xF1, 0xFE, 0x1E, 0x3F, 0xC3,
  0xC3, 0xF0, 0x78, 0x7E, 0x0F, 0x0F, 0xC3, 0xC1, 0xF8, 0x78, 0x3F, 0x00,
  0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xBE, 0x3E, 0x1F, 0x3E, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF1,
  0xF3, 0xE3, 0xE3, 0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x7F, 0xF8, 0xFF,
  0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xBE, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F,
  0x78, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C,
  0xF8, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xF1, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E,
  0x7C, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xDE, 0x0F, 0xBC, 0x1F, 0x7C,
  0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xF3, 0xE3, 0xE7, 0xC3, 0xC0, 0x03, 0xF8,
  0x3F, 0xF1, 0xFF, 0x87, 0xFE, 0x1E, 0x10, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x30, 0x78, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0xFB, 0xFF,
  0xBF, 0xFD, 0xFF, 0xE0, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x00, 0x1F, 0x0F, 0x1E, 0x1F, 0x1E, 0x1F,
  0x3E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x7C, 0x3C,
  0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0xF8, 0x78, 0xF8, 0xF8,
  0xF8, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0xF8, 0x3E,
  0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x3C,
  0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0xF8, 0x78, 0x3F, 0xE1, 0xE1, 0xFF, 0x07, 0x87, 0xBC, 0x3E, 0x1E, 0xF0,
  0xF8, 0xFB, 0xC7, 0xE3, 0xCF, 0x1F, 0x9F, 0x3C, 0xFE, 0x78, 0xF3, 0xB9,
  0xE3, 0xCE, 0xEF, 0x8F, 0x7B, 0xBC, 0x3D, 0xCE, 0xF0, 0xFF, 0x3F, 0x83,
  0xFD, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0xF8, 0xF8,
  0x1F, 0x3E, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xE0, 0x1E, 0x3C, 0x07,
  0xC7, 0x81, 0xF0, 0xF0, 0x7C, 0x1F, 0x00, 0xF8, 0x7D, 0xE1, 0xE7, 0x8F,
  0x9E, 0x3C, 0x79, 0xF1, 0xF7, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0xF3, 0xCF,
  0x3C, 0xF1, 0xC7, 0x1E, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x8F, 0x3C, 0xF3,
  0xC7, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x07,
  0xF0, 0x3B, 0xC3, 0xCE, 0x3C, 0x71, 0xC3, 0x9E, 0x1E, 0xE0, 0x7F, 0x03,
  0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0xF9, 0xE3, 0x8F, 0x06, 0x00, 0xF9,
  0xCF, 0xFE, 0x7F, 0xF7, 0xCF, 0xBC, 0x7B, 0xE3, 0xDE, 0x1E, 0xF0, 0xF7,
  0x8F, 0xBC, 0x79, 0xE3, 0xCF, 0xBE, 0x7F, 0xF3, 0xF7, 0x0F, 0x38, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x79, 0x81, 0xEF, 0x87,
  0xFE, 0x1F, 0xF8, 0xF9, 0xF3, 0xC7, 0xCF, 0x1F, 0x3C, 0x78, 0xF1, 0xE7,
  0x87, 0x9E, 0x3E, 0x78, 0xF1, 0xF7, 0xCF, 0xFE, 0x3F, 0xF8, 0xE7, 0xC0,
  0x03, 0x81, 0xFC, 0x7F, 0x9F, 0xE7, 0xC4, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x99, 0xFF, 0x1F, 0xE1, 0xF8, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0xCF, 0x07, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0xF9, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E,
  0x3C, 0x7C, 0x78, 0xF0, 0xF1, 0xE1, 0xF7, 0xC3, 0xFF, 0x87, 0xFE, 0x07,
  0xDC, 0x00, 0x01, 0x80, 0xFE, 0x1F, 0xF3, 0xFF, 0x78, 0xF7, 0x8F, 0xF9,
  0xFF, 0xFE, 0xFF, 0xCF, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x4F, 0xFC, 0x7F,
  0xC3, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x00, 0x3F, 0x71, 0xFF,
  0xC7, 0xFF, 0x3E, 0x7C, 0xF1, 0xE7, 0xC7, 0x9F, 0x1E, 0x78, 0x79, 0xE3,
  0xE7, 0x8F, 0x1E, 0x3C, 0x7D, 0xF1, 0xFF, 0xC7, 0xFE, 0x0F, 0x78, 0x01,
  0xE0, 0x07, 0x88, 0x3C, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x79, 0x81, 0xFF,
  0x87, 0xFE, 0x1F, 0xFC, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE7, 0x87, 0x9E, 0x3E, 0x78, 0xF1, 0xE3, 0xCF, 0x8F, 0x3C, 0x7C, 0xF1,
  0xE0, 0x02, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0x00,
  0x20, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x70, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x8F, 0x8F, 0x3E, 0x1E, 0xF8,
  0x79, 0xE0, 0xF7, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7, 0xC7, 0x8F, 0x8F, 0x0F, 0x00, 0x0F,
  0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x00, 0x00,
  0x60, 0xC0, 0xEF, 0xDF, 0x87, 0x7F, 0xFC, 0x3F, 0xFF, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xC7,
  0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x7C, 0x78, 0xF3,
  0xC7, 0x8F, 0x9E, 0x3C, 0x78, 0x00, 0x60, 0x77, 0xE1, 0xDF, 0x87, 0xFF,
  0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xE1, 0xE7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x78, 0x03, 0x80, 0xFE,
  0x3F, 0xE3, 0xFF, 0x7C, 0xF7, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF1, 0xFF, 0x1E, 0xFB, 0xEF, 0xFC, 0x7F, 0x83, 0xF0, 0x01, 0x30, 0x1D,
  0xF8, 0x3B, 0xF0, 0x7F, 0xE1, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x8F, 0x1E,
  0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xF1, 0xE3, 0xC3, 0xEF, 0x8F, 0xFE, 0x1F,
  0xFC, 0x3D, 0xF0, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0xFD, 0xCF, 0xFE, 0x7F, 0xF7,
  0xCF, 0xBC, 0x7B, 0xE3, 0xDE, 0x1E, 0xF0, 0xF7, 0x8F, 0xBC, 0x79, 0xE3,
  0xCF, 0xBE, 0x7F, 0xF3, 0xFF, 0x0F, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x02, 0x71, 0xCE, 0x1D, 0xE1,
  0xFE, 0x3F, 0xC3, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x07, 0x01, 0xFF, 0x3F, 0xE3,
  0xFE, 0x3C, 0x43, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x7C, 0xC7, 0xCF, 0xF8, 0xFF, 0x8F, 0xE0, 0x0E, 0x03, 0x81, 0xE0, 0x79,
  0x7F, 0x9F, 0xEF, 0xF8, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E,
  0x0F, 0x03, 0xC8, 0xFE, 0x3F, 0x87, 0xE0, 0x3C, 0x79, 0xE3, 0xDF, 0x1E,
  0xF1, 0xF7, 0x8F, 0x3C, 0x79, 0xE3, 0xDF, 0x1E, 0xF1, 0xF7, 0x8F, 0x3C,
  0x79, 0xF7, 0xCF, 0xFE, 0x7F, 0xF1, 0xF7, 0x00, 0xF0, 0xFF, 0x1E, 0xF1,
  0xEF, 0x3C, 0xF3, 0xCF, 0x7C, 0xF7, 0x8F, 0x78, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x78, 0x00, 0xF1, 0xF3, 0xFE, 0x7C, 0x7B,
  0xCF, 0x8F, 0x7B, 0xF3, 0xCF, 0x7E, 0x79, 0xEF, 0xDE, 0x3B, 0xBB, 0xC7,
  0x77, 0x78, 0xEE, 0xFE, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x00, 0x1F, 0x3E, 0x3E, 0x78, 0x3D,
  0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x81, 0xEF, 0x07, 0xDF, 0x0F, 0x1E, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x87,
  0xFC, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x47, 0xFC, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0xF0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x7E, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x00, 0x7C, 0x07, 0xC0, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x03, 0xF0, 0x3E, 0x01, 0xE0, 0x7E, 0x0F, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x7E,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xE8, 0x04, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 20, 7, 0, -20 },
  { 24, 10, 7, 12, 3, -20 },
  { 33, 16, 20, 15, 0, -20 },
  { 73, 14, 23, 14, 0, -21 },
  { 114, 19, 20, 22, 2, -20 },
  { 162, 17, 20, 17, 0, -20 },
  { 205, 5, 7, 7, 3, -20 },
  { 210, 10, 24, 8, 1, -20 },
  { 240, 10, 24, 8, -2, -20 },
  { 270, 12, 13, 13, 2, -22 },
  { 290, 13, 14, 14, 1, -17 },
  { 313, 7, 8, 7, -2, -4 },
  { 320, 8, 3, 9, 0, -9 },
  { 323, 5, 5, 7, 0, -5 },
  { 327, 15, 20, 11, -1, -20 },
  { 365, 13, 20, 14, 1, -20 },
  { 398, 11, 20, 14, 2, -20 },
  { 426, 14, 20, 14, -1, -20 },
  { 461, 14, 20, 14, 0, -20 },
  { 496, 14, 20, 14, 0, -20 },
  { 531, 14, 20, 14, 0, -20 },
  { 566, 13, 20, 14, 1, -20 },
  { 599, 14, 20, 14, 1, -20 },
  { 634, 14, 20, 14, 0, -20 },
  { 669, 13, 20, 14, 0, -20 },
  { 702, 7, 16, 7, 0, -16 },
  { 716, 9, 20, 7, -2, -16 },
  { 739, 13, 14, 14, 1, -17 },
  { 762, 13, 9, 14, 1, -14 },
  { 777, 13, 14, 14, 1, -17 },
  { 800, 11, 20, 11, 1, -20 },
  { 828, 19, 22, 21, 1, -20 },
  { 881, 16, 20, 15, -2, -20 },
  { 921, 15, 20, 15, 0, -20 },
  { 959, 15, 20, 14, 1, -20 },
  { 997, 16, 20, 16, 0, -20 },
  { 1037, 14, 20, 13, 0, -20 },
  { 1072, 14, 20, 12, 0, -20 },
  { 1107, 16, 20, 16, 1, -20 },
  { 1147, 17, 20, 17, 0, -20 },
  { 1190, 13, 20, 10, -1, -20 },
  { 1223, 13, 26, 8, -4, -20 },
  { 1266, 17, 20, 15, 0, -20 },
  { 1309, 11, 20, 12, 0, -20 },
  { 1337, 22, 20, 22, 0, -20 },
  { 1392, 19, 20, 18, 0, -20 },
  { 1440, 16, 20, 17, 1, -20 },
  { 1480, 15, 20, 14, 0, -20 },
  { 1518, 16, 25, 17, 1, -20 },
  { 1568, 15, 20, 15, 0, -20 },
  { 1606, 14, 20, 13, 0, -20 },
  { 1641, 13, 20, 13, 2, -20 },
  { 1674, 16, 20, 16, 1, -20 },
  { 1714, 15, 20, 15, 2, -20 },
  { 1752, 22, 20, 22, 2, -20 },
  { 1807, 19, 20, 14, -2, -20 },
  { 1855, 14, 20, 14, 2, -20 },
  { 1890, 15, 20, 13, -1, -20 },
  { 1928, 12, 25, 8, -1, -20 },
  { 1966, 6, 20, 11, 3, -20 },
  { 1981, 12, 25, 8, -2, -20 },
  { 2019, 13, 13, 13, 0, -20 },
  { 2041, 11, 3, 10, -3, 2 },
  { 2046, 6, 4, 9, 4, -21 },
  { 2049, 13, 16, 14, 1, -16 },
  { 2075, 14, 21, 14, 0, -21 },
  { 2112, 11, 16, 12, 1, -16 },
  { 2134, 15, 21, 14, 1, -21 },
  { 2174, 12, 16, 13, 1, -16 },
  { 2198, 15, 28, 9, -3, -21 },
  { 2251, 14, 23, 14, 0, -16 },
  { 2292, 14, 21, 14, 0, -21 },
  { 2329, 8, 22, 7, 0, -22 },
  { 2351, 12, 29, 7, -4, -22 },
  { 2395, 15, 21, 14, 0, -21 },
  { 2435, 9, 21, 7, 0, -21 },
  { 2459, 21, 16, 21, 0, -16 },
  { 2501, 14, 16, 14, 0, -16 },
  { 2529, 12, 16, 14, 1, -16 },
  { 2553, 15, 23, 14, -1, -16 },
  { 2597, 13, 23, 14, 1, -16 },
  { 2635, 12, 16, 10, 0, -16 },
  { 2659, 12, 16, 11, 0, -16 },
  { 2683, 10, 19, 10, 1, -19 },
  { 2707, 13, 15, 14, 1, -15 },
  { 2732, 12, 15, 13, 2, -15 },
  { 2755, 19, 15, 19, 2, -15 },
  { 2791, 15, 15, 13, -1, -15 },
  { 2820, 16, 22, 13, -2, -15 },
  { 2864, 13, 15, 11, -1, -15 },
  { 2889, 12, 24, 10, 0, -20 },
  { 2925, 4, 27, 12, 4, -21 },
  { 2939, 12, 24, 10, -2, -20 },
  { 2975, 13, 5, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC28PT7B_H_
