#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC24PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE0, 0x00,
  0x0E, 0x3C, 0x78, 0xF0, 0x7B, 0xB9, 0xDD, 0xEE, 0xEE, 0x77, 0x38, 0x03,
  0xB8, 0x1C, 0xC0, 0x73, 0x01, 0x9C, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x83,
  0x38, 0x1C, 0xC0, 0x77, 0x0F, 0xFF, 0x3F, 0xFC, 0x39, 0x80, 0xCE, 0x03,
  0x38, 0x1C, 0xC0, 0x77, 0x00, 0x00, 0x80, 0x18, 0x0F, 0xF1, 0xFE, 0x1F,
  0xE3, 0xF2, 0x3F, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x5C, 0x05,
  0xC4, 0x5C, 0x7F, 0xCF, 0xF8, 0x7F, 0x00, 0x80, 0x08, 0x00, 0x1E, 0x0E,
  0x1F, 0x86, 0x1D, 0xC7, 0x0E, 0xE7, 0x06, 0x73, 0x87, 0x3B, 0x83, 0x99,
  0x89, 0xDD, 0xDF, 0x7D, 0xDF, 0xBE, 0xCC, 0xC0, 0xEE, 0x60, 0xE7, 0x70,
  0x73, 0x38, 0x71, 0x9C, 0x30, 0xDC, 0x38, 0x7E, 0x38, 0x1E, 0x00, 0x07,
  0xE0, 0x3F, 0xC0, 0xEF, 0x07, 0x9C, 0x1E, 0xF0, 0x7F, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0x9C, 0xFE, 0xF7, 0xBF, 0xBC, 0xFE, 0xF1, 0xF3, 0xC7, 0x8F,
  0xFF, 0x1F, 0xFC, 0x3E, 0x78, 0x7B, 0x9C, 0xEE, 0x70, 0x07, 0x83, 0x83,
  0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x83, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x80, 0x07, 0x03, 0x81,
  0xC0, 0xF0, 0x78, 0x3C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70,
  0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x80, 0x0E, 0x03,
  0x86, 0xE3, 0xF7, 0xFF, 0xC7, 0xF3, 0xE3, 0xDC, 0x77, 0x09, 0xC0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x3B, 0xDC, 0xEF, 0x70, 0x7E, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x1C, 0xF7, 0x9E, 0xE3,
  0xFC, 0x77, 0x8E, 0xF1, 0xDC, 0x7B, 0x8F, 0x71, 0xCE, 0x79, 0xCF, 0x3F,
  0xC7, 0xF0, 0x7C, 0x00, 0x07, 0x87, 0xC7, 0xE7, 0xEF, 0xF3, 0xF9, 0x3C,
  0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x00,
  0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x18, 0xF0, 0x87, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF,
  0x8F, 0xF8, 0xFF, 0xC0, 0x0F, 0xC1, 0xFE, 0x1F, 0xF1, 0x0F, 0x00, 0xE0,
  0x1E, 0x03, 0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0x03, 0xC0, 0x1C, 0x03, 0xC8,
  0x3C, 0xFF, 0x8F, 0xF8, 0xFE, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0xFE, 0x1D, 0xC1, 0x9C, 0x3B, 0xC7, 0x3C, 0x63, 0x8F, 0xFE,
  0xFF, 0xEF, 0xFE, 0x07, 0x80, 0x70, 0x07, 0x00, 0x0F, 0xF0, 0xFF, 0x1F,
  0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0x83, 0xFC, 0x3F, 0xC0, 0x3C, 0x01,
  0xC0, 0x1C, 0x03, 0xC8, 0x3C, 0xFF, 0x8F, 0xF8, 0xFE, 0x00, 0x07, 0xE1,
  0xFC, 0x7F, 0x9E, 0x03, 0x80, 0xF0, 0x1D, 0xE7, 0xFE, 0xFF, 0xDE, 0x7B,
  0xCF, 0x71, 0xEE, 0x3D, 0xEF, 0x3F, 0xE3, 0xF8, 0x7E, 0x00, 0x3F, 0xF3,
  0xFF, 0x7F, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0xE1, 0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0xF1, 0xCE, 0x1F, 0xE1, 0xF8,
  0x1F, 0x83, 0xFC, 0x7B, 0xCF, 0x1C, 0xF1, 0xCF, 0x1C, 0xFF, 0xC7, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xFE, 0x1F, 0xE3, 0xCE, 0x38, 0xF7, 0x8F, 0x79,
  0xE7, 0x9E, 0x7F, 0xE3, 0xFE, 0x1D, 0xC0, 0x1C, 0x03, 0xC0, 0x78, 0xFF,
  0x0F, 0xE0, 0xFC, 0x00, 0x1C, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x01, 0xCF,
  0x3C, 0xF0, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3,
  0xC7, 0x0E, 0x38, 0x70, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xF1, 0xF8,
  0x3C, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x18, 0x03, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0xF8, 0x7E, 0x3F, 0x1F, 0x83, 0xC0, 0x60, 0x00,
  0x3F, 0x3F, 0xDF, 0xE8, 0x70, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E,
  0x00, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xFE,
  0x1E, 0x0F, 0x1C, 0x07, 0x38, 0xF3, 0x73, 0xFB, 0x67, 0x33, 0xE6, 0x73,
  0xEE, 0x73, 0xCE, 0x73, 0xCC, 0x67, 0xCC, 0xE6, 0xCF, 0xFE, 0xCF, 0x7C,
  0xE0, 0x00, 0xE0, 0x00, 0x78, 0x60, 0x3F, 0xE0, 0x0F, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x1E,
  0x70, 0xF3, 0x87, 0xFC, 0x7F, 0xE3, 0xFF, 0x3C, 0x39, 0xE1, 0xFE, 0x0F,
  0xF0, 0x78, 0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x3C, 0xF1, 0xC7, 0x8E, 0x3C,
  0xF3, 0xC7, 0xFC, 0x3F, 0xC1, 0xFF, 0x1E, 0x3C, 0xF1, 0xE7, 0x8F, 0x38,
  0xF1, 0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xE2,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x88, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x87,
  0xFE, 0x3C, 0xF1, 0xC7, 0x8E, 0x1C, 0xF0, 0xE7, 0x8F, 0x3C, 0x79, 0xC3,
  0xDE, 0x1E, 0xF1, 0xE7, 0x8F, 0x3D, 0xF1, 0xFF, 0x1F, 0xF0, 0xFE, 0x00,
  0x0F, 0xF1, 0xFF, 0x1F, 0xE1, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xFC,
  0x3F, 0xC3, 0xFC, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7F, 0x8F, 0xF8,
  0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x1F, 0xE1, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xFC, 0x3F, 0xC3, 0xF8, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xC7, 0xFE, 0x7C, 0x23, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x3E, 0xF3, 0xF7, 0x9F, 0xBC, 0x3D, 0xE1, 0xCF,
  0x0E, 0x7C, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x0E, 0x1E, 0x3C, 0x3C,
  0x78, 0x70, 0xF1, 0xE1, 0xC3, 0xC3, 0x87, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF1, 0xE1, 0xE3, 0xC3, 0x87, 0x8F, 0x0F, 0x1E, 0x1C, 0x3C,
  0x78, 0x78, 0xF0, 0xE0, 0x0F, 0xE3, 0xFC, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F,
  0x87, 0xF8, 0xFF, 0x00, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0xE0, 0xFC, 0x0F,
  0x80, 0x0E, 0x3E, 0x3C, 0x78, 0x79, 0xE0, 0xF7, 0x81, 0xCF, 0x03, 0xBC,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xDE, 0x07,
  0xBC, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xF1, 0xE0, 0x0E, 0x0F, 0x07,
  0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE7, 0xF1, 0xDC, 0xFE,
  0x3B, 0xBB, 0x87, 0x77, 0x71, 0xEF, 0xDE, 0x3D, 0xFB, 0xC7, 0x3E, 0x70,
  0xE7, 0xCE, 0x1C, 0xF1, 0xC7, 0x9E, 0x78, 0xF3, 0xCF, 0x00, 0x0F, 0x0F,
  0x1F, 0x0F, 0x1F, 0x0E, 0x1F, 0x8E, 0x1F, 0x8E, 0x1F, 0x9E, 0x3F, 0x9E,
  0x3B, 0xDC, 0x3B, 0xDC, 0x39, 0xDC, 0x79, 0xFC, 0x79, 0xFC, 0x71, 0xF8,
  0x71, 0xF8, 0x70, 0xF8, 0xF0, 0xF8, 0xF0, 0xF0, 0x07, 0xE0, 0x7F, 0x87,
  0xFE, 0x78, 0xF7, 0xC7, 0xBC, 0x1D, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE1, 0xEF, 0x0F, 0x78, 0xF1, 0xFF, 0x8F, 0xF8, 0x3F, 0x00,
  0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x3C, 0xF1, 0xC7, 0x8E, 0x3C, 0xF1, 0xE7,
  0x9E, 0x3F, 0xF1, 0xFF, 0x1F, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0xF7, 0xC7,
  0xBC, 0x1D, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xEF,
  0x0F, 0x78, 0xF1, 0xFF, 0x8F, 0xF8, 0x3F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0xE0, 0xFF, 0x87, 0xFC, 0x3C, 0xF1, 0xC7, 0x8E,
  0x3C, 0xF3, 0xC7, 0xBE, 0x3F, 0xE1, 0xFE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC,
  0x3C, 0xE1, 0xC7, 0x9E, 0x3C, 0xF1, 0xE0, 0x0F, 0xE1, 0xFF, 0x1F, 0xE3,
  0xC2, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3C, 0x03, 0xCC, 0x7C, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xFB,
  0xFF, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x3C, 0xF0,
  0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x79, 0xE1, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xC3, 0xCF, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x8F, 0xFC, 0x1F,
  0xE0, 0x3F, 0x00, 0xF0, 0x7F, 0x87, 0xBC, 0x39, 0xE3, 0xCF, 0x1E, 0x79,
  0xE3, 0xCF, 0x1E, 0x70, 0xF7, 0x87, 0xB8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0xF0, 0xE1, 0xFE, 0x3C, 0x3B,
  0xC7, 0x8F, 0x79, 0xF1, 0xCE, 0x3E, 0x79, 0xC7, 0xCF, 0x39, 0xF9, 0xC7,
  0x3F, 0x78, 0xEE, 0xEE, 0x1D, 0xDF, 0xC3, 0xBB, 0xF8, 0x7E, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x00,
  0x1E, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xDE,
  0x07, 0xBC, 0x1E, 0x38, 0x3C, 0x78, 0xF0, 0xF0, 0xF0, 0xFF, 0x1E, 0x71,
  0xC7, 0x3C, 0x73, 0x87, 0xF8, 0x7F, 0x07, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x00, 0x0F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x11, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC0, 0x0F, 0xC3, 0xF0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0xC3, 0xF0, 0xFC, 0x00, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x0E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0xC7, 0x1C, 0x07, 0xC3, 0xF0, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x07, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x03, 0x80, 0x70,
  0x1E, 0x07, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xC7, 0x70, 0xEE, 0x1F, 0x83,
  0x80, 0xFF, 0xFF, 0xC0, 0xFB, 0xCE, 0x1E, 0xE7, 0xFD, 0xFF, 0xBC, 0xFF,
  0x1D, 0xE3, 0xBC, 0xF7, 0x1E, 0xE3, 0xDC, 0xF3, 0xFE, 0x7D, 0xC7, 0xB8,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xDE, 0x3F, 0xE3, 0xFF,
  0x3C, 0xF3, 0x8F, 0x38, 0xF7, 0x8E, 0x79, 0xE7, 0x9E, 0x79, 0xCF, 0xFC,
  0xFF, 0x8E, 0xF0, 0x1F, 0xCF, 0xE7, 0xF9, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x3C, 0x4F, 0xE3, 0xF8, 0x7E, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE1, 0xEE, 0x3F, 0xE7, 0xFE, 0x79, 0xEF, 0x1C, 0xF1,
  0xCF, 0x3C, 0xE3, 0xCE, 0x3C, 0xE7, 0x8F, 0xF8, 0xFF, 0x87, 0xB8, 0x1F,
  0x8F, 0xF7, 0x9D, 0xC7, 0xF3, 0xFF, 0xEF, 0xF3, 0xF0, 0xE0, 0x38, 0x0F,
  0xF3, 0xFC, 0x7F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0x80, 0x3C,
  0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x0B, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x71, 0xFF, 0x3F, 0xF3,
  0xCF, 0x78, 0xE7, 0x8E, 0x79, 0xE7, 0x1E, 0x71, 0xE7, 0x3C, 0x7F, 0xC7,
  0xFC, 0x3F, 0xC0, 0x38, 0x03, 0x88, 0x78, 0xFF, 0x0F, 0xE0, 0x7C, 0x00,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xFE, 0x3F, 0xE3, 0xFF,
  0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x8E, 0x79, 0xE7, 0x1E, 0x71, 0xCF, 0x1C,
  0xF3, 0xCF, 0x3C, 0x0E, 0x3C, 0x78, 0x00, 0x03, 0x8F, 0x1E, 0x3C, 0x70,
  0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xE0, 0x01, 0xC0, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0xBC, 0x3F, 0x0F, 0x83,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x3C, 0xF3,
  0xC7, 0xBC, 0x3B, 0xC1, 0xFC, 0x0F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x8F, 0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xC3,
  0x8F, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xE0, 0x1F,
  0xEF, 0x8E, 0xFF, 0xE3, 0xFF, 0xFC, 0xF3, 0xCF, 0x38, 0xE3, 0x8E, 0x38,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xE7, 0x9C, 0x71, 0xCF, 0x1C, 0x73,
  0xCF, 0x3C, 0xF3, 0xCF, 0x00, 0x1F, 0xE3, 0xBE, 0x3F, 0xF3, 0xCF, 0x38,
  0xE3, 0x8E, 0x78, 0xE7, 0x9E, 0x71, 0xE7, 0x1C, 0xF1, 0xCF, 0x3C, 0xF3,
  0xC0, 0x1F, 0x8F, 0xF7, 0xFD, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3,
  0xF9, 0xEF, 0xFB, 0xFC, 0x7E, 0x00, 0x0F, 0xF0, 0xEF, 0x87, 0xFE, 0x3C,
  0xF1, 0xC7, 0x8E, 0x3C, 0xF1, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x9F, 0xF8,
  0xFF, 0x87, 0xF8, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x00, 0x1E, 0xE7, 0xFD, 0xFF, 0xBC, 0xFF, 0x1D, 0xE3, 0xBC, 0xF7, 0x1E,
  0xE3, 0xDC, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x00, 0x1D, 0xCE, 0xE3, 0xF8, 0xFA, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0xCF, 0xE3,
  0xD9, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3C, 0x07, 0xA1, 0xCF, 0xF3, 0xFC,
  0xFC, 0x00, 0x0C, 0x1C, 0x1C, 0x7F, 0xFF, 0xFF, 0x78, 0x78, 0x70, 0x70,
  0xF0, 0xF0, 0xF0, 0xFC, 0xFC, 0x7C, 0x38, 0xEF, 0x3D, 0xE7, 0xB8, 0xF7,
  0x1D, 0xE3, 0xBC, 0xF7, 0x9E, 0xE3, 0xDC, 0xF3, 0xFE, 0x7F, 0xC7, 0xB8,
  0xF1, 0xFE, 0x39, 0xCF, 0x39, 0xE7, 0x78, 0xEF, 0x1D, 0xC3, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF3, 0xE7, 0xF9, 0xF3, 0xBC, 0xF3,
  0xDE, 0xF9, 0xCF, 0x7C, 0xE7, 0xF6, 0xE3, 0xFB, 0x71, 0xF9, 0xF8, 0xFD,
  0xF8, 0x7E, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x00, 0x1E, 0x78,
  0xF7, 0x87, 0xBC, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x81, 0xFE, 0x1E, 0xF0, 0xF3, 0x8F, 0x1E, 0x00, 0x1E, 0x3C, 0x38, 0xF0,
  0xE7, 0x83, 0x9E, 0x0E, 0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x2F, 0x80,
  0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x01, 0xE0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xFE, 0x7F, 0xCF, 0xF8,
  0x03, 0xC1, 0xF0, 0xF8, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x3C, 0x1E,
  0x0F, 0x03, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0xC0,
  0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0F, 0x07, 0xC1,
  0xE3, 0xF1, 0xE1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x3E, 0x1E, 0x0C, 0x00,
  0x20, 0x3F, 0xCF, 0xFF, 0xE7, 0xF8, 0x18,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 9, 6, 10, 2, -17 },
  { 23, 14, 17, 13, 0, -17 },
  { 53, 12, 19, 12, 0, -18 },
  { 82, 17, 17, 19, 1, -17 },
  { 119, 14, 17, 15, 0, -17 },
  { 149, 5, 6, 6, 2, -17 },
  { 153, 9, 21, 7, 0, -17 },
  { 177, 9, 22, 7, -2, -18 },
  { 202, 10, 10, 11, 2, -18 },
  { 215, 11, 11, 12, 1, -14 },
  { 231, 5, 6, 6, -1, -3 },
  { 235, 7, 3, 7, 0, -8 },
  { 238, 4, 4, 6, 0, -4 },
  { 240, 13, 17, 10, -1, -17 },
  { 268, 11, 17, 12, 1, -17 },
  { 292, 9, 17, 12, 2, -17 },
  { 312, 13, 17, 12, -1, -17 },
  { 340, 12, 17, 12, 0, -17 },
  { 366, 12, 17, 12, 0, -17 },
  { 392, 12, 17, 12, 0, -17 },
  { 418, 11, 17, 12, 1, -17 },
  { 442, 12, 17, 12, 1, -17 },
  { 468, 12, 17, 12, 0, -17 },
  { 494, 12, 17, 12, 0, -17 },
  { 520, 6, 13, 6, 0, -13 },
  { 530, 7, 16, 6, -1, -13 },
  { 544, 11, 12, 12, 1, -15 },
  { 561, 11, 7, 12, 1, -12 },
  { 571, 11, 12, 12, 1, -15 },
  { 588, 9, 17, 9, 1, -17 },
  { 608, 16, 19, 18, 1, -17 },
  { 646, 13, 17, 13, -1, -17 },
  { 674, 13, 17, 13, 0, -17 },
  { 702, 12, 17, 12, 1, -17 },
  { 728, 13, 17, 14, 0, -17 },
  { 756, 12, 17, 11, 0, -17 },
  { 782, 12, 17, 11, 0, -17 },
  { 808, 13, 17, 14, 1, -17 },
  { 836, 15, 17, 14, 0, -17 },
  { 868, 11, 17, 9, -1, -17 },
  { 892, 12, 22, 7, -4, -17 },
  { 925, 15, 17, 13, 0, -17 },
  { 957, 9, 17, 10, 0, -17 },
  { 977, 19, 17, 18, 0, -17 },
  { 1018, 16, 17, 15, 0, -17 },
  { 1052, 13, 17, 15, 1, -17 },
  { 1080, 13, 17, 12, 0, -17 },
  { 1108, 13, 21, 15, 1, -17 },
  { 1143, 13, 17, 13, 0, -17 },
  { 1171, 12, 17, 11, 0, -17 },
  { 1197, 11, 17, 11, 2, -17 },
  { 1221, 14, 17, 14, 1, -17 },
  { 1251, 13, 17, 13, 2, -17 },
  { 1279, 19, 17, 19, 2, -17 },
  { 1320, 15, 17, 12, -1, -17 },
  { 1352, 12, 17, 12, 2, -17 },
  { 1378, 13, 17, 11, -1, -17 },
  { 1406, 10, 21, 7, -1, -17 },
  { 1433, 6, 17, 10, 2, -17 },
  { 1446, 10, 21, 7, -2, -17 },
  { 1473, 11, 11, 11, 0, -17 },
  { 1489, 9, 2, 9, -2, 2 },
  { 1492, 5, 3, 8, 3, -18 },
  { 1494, 11, 13, 12, 1, -13 },
  { 1512, 12, 18, 12, 0, -18 },
  { 1539, 10, 13, 10, 1, -13 },
  { 1556, 12, 18, 12, 1, -18 },
  { 1583, 10, 13, 11, 1, -13 },
  { 1600, 13, 24, 8, -3, -18 },
  { 1639, 12, 19, 12, 0, -13 },
  { 1668, 12, 18, 12, 0, -18 },
  { 1695, 7, 18, 6, 0, -18 },
  { 1711, 10, 24, 6, -3, -18 },
  { 1741, 13, 18, 12, 0, -18 },
  { 1771, 7, 18, 6, 0, -18 },
  { 1787, 18, 13, 18, 0, -13 },
  { 1817, 12, 13, 12, 0, -13 },
  { 1837, 10, 13, 12, 1, -13 },
  { 1854, 13, 19, 12, -1, -13 },
  { 1885, 11, 19, 12, 1, -13 },
  { 1912, 10, 13, 9, 0, -13 },
  { 1929, 10, 13, 10, 0, -13 },
  { 1946, 8, 16, 8, 1, -16 },
  { 1962, 11, 13, 12, 1, -13 },
  { 1980, 11, 13, 11, 1, -13 },
  { 1998, 17, 13, 17, 1, -13 },
  { 2026, 13, 13, 11, -1, -13 },
  { 2048, 14, 19, 11, -2, -13 },
  { 2082, 11, 13, 10, -1, -13 },
  { 2100, 10, 21, 8, 0, -17 },
  { 2127, 3, 23, 10, 4, -18 },
  { 2136, 9, 21, 8, -1, -17 },
  { 2160, 11, 5, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC24PT7B_H_
