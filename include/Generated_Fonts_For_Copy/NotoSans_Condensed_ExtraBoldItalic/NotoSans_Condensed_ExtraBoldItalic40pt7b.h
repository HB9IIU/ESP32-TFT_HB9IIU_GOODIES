#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC40PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x7E, 0xFC,
  0xFD, 0xF9, 0xFB, 0xE3, 0xE7, 0xC7, 0xDF, 0x9F, 0xBE, 0x3E, 0x7C, 0x7C,
  0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0,
  0x01, 0xF1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00,
  0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3E, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1,
  0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x8F, 0x80, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80,
  0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xB1, 0x83, 0xE6, 0x00, 0x7C, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x6F, 0x80, 0x1D, 0xF1, 0x03, 0x3E, 0x38, 0x6F,
  0xC7, 0xEF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0xFF, 0x00, 0xF8, 0x1F, 0xF0, 0x1F, 0x03, 0xFF, 0x81, 0xE0,
  0x3E, 0xF8, 0x3E, 0x07, 0xCF, 0x83, 0xC0, 0x7C, 0xF8, 0x7C, 0x07, 0x8F,
  0x8F, 0x80, 0x78, 0xF8, 0xF0, 0x0F, 0x8F, 0x1F, 0x00, 0xF8, 0xF1, 0xE0,
  0x0F, 0x9F, 0x3E, 0x18, 0xF9, 0xF7, 0xCF, 0xEF, 0xBE, 0x79, 0xFF, 0xFF,
  0xEF, 0xBF, 0xF7, 0xFC, 0xF3, 0xFF, 0x7F, 0x9E, 0x7C, 0xF1, 0xE3, 0xE7,
  0x8F, 0x00, 0x3C, 0xF8, 0xF0, 0x07, 0xCF, 0x8F, 0x00, 0xF8, 0xF8, 0xF0,
  0x0F, 0x0F, 0x1F, 0x01, 0xF0, 0xF1, 0xF0, 0x1E, 0x0F, 0x1E, 0x03, 0xE0,
  0xF3, 0xE0, 0x7C, 0x0F, 0xFC, 0x07, 0x80, 0xFF, 0xC0, 0xF8, 0x07, 0xF8,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xE3,
  0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0x0F, 0xFE, 0x7E, 0x1F, 0xFE, 0x7E, 0x3F, 0x7F, 0xFC, 0x7E, 0x7F,
  0xFC, 0x7E, 0x3F, 0xF8, 0xFE, 0x3F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFC, 0x1F,
  0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFC, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF,
  0xBF, 0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x06, 0x1E, 0x03, 0xCF, 0x01, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE1, 0xFE, 0x01, 0xFF,
  0x03, 0xFF, 0xC1, 0xFB, 0xE0, 0x78, 0xF8, 0x1C, 0x7C, 0x04, 0x38, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xE3,
  0xF1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x00, 0x7F, 0xF7, 0xFE, 0x7F, 0xE7,
  0xFE, 0xFF, 0xE0, 0x08, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF,
  0x07, 0xFF, 0xC3, 0xFB, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x8F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFD, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0,
  0xFD, 0xF8, 0x7F, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFE,
  0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0xFF,
  0xFB, 0xF7, 0xE7, 0x3F, 0x08, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0x7F, 0x03, 0x83, 0xF0, 0x30, 0x3F, 0x02, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0x1F, 0xC0, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x20, 0x0F, 0xE6, 0x03, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xEF, 0x80, 0x3D, 0xF8, 0x07, 0xDF, 0x80, 0xF9, 0xF8, 0x0F, 0x1F, 0x81,
  0xE1, 0xF0, 0x3E, 0x3F, 0x07, 0xC3, 0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x80, 0x3F, 0x8E, 0x07, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE,
  0x0F, 0xF0, 0x43, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x70, 0x1F, 0xBF, 0x83, 0xEF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFD, 0xFC, 0x7F, 0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF,
  0xC1, 0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xC3, 0xF3, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFE,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7E, 0x0F,
  0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFB, 0xF8, 0x7F, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x7F, 0x3F,
  0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF7,
  0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF7, 0xE0, 0xFD,
  0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0xCF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x87, 0xF7, 0xE0, 0xF9, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x3F, 0x87, 0xE0, 0xFC,
  0x1F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x81, 0xFF, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0xF9, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE7,
  0x8F, 0xCC, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00,
  0x1F, 0x0F, 0x07, 0xF8, 0xF1, 0xE1, 0xFF, 0xCF, 0x3E, 0x3F, 0xF8, 0xF3,
  0xC7, 0xE7, 0x8F, 0x3C, 0x78, 0x78, 0xF7, 0x8F, 0x8F, 0x8F, 0x78, 0xF0,
  0xF0, 0xF7, 0x8F, 0x0F, 0x0F, 0x79, 0xF0, 0xF1, 0xEF, 0x1E, 0x1F, 0x1E,
  0xF1, 0xE1, 0xE1, 0xEF, 0x1E, 0x3E, 0x3C, 0xF1, 0xF3, 0xE7, 0xCF, 0x1F,
  0xFF, 0xF8, 0xF0, 0xFE, 0xFF, 0x0F, 0x8F, 0xCF, 0xE0, 0xF8, 0x10, 0x18,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x02, 0x00, 0x3F,
  0xC7, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7D,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0x9F, 0x80,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x9F, 0xE0, 0x7E,
  0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x83, 0xF1, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x87, 0xF8,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xBC, 0x1F, 0xE0, 0x43, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8,
  0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F,
  0x81, 0xFC, 0x7E, 0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x07,
  0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0xDF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x81, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xF7, 0xC1, 0xFE, 0x03, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x7F, 0xCF, 0xE3, 0xFF, 0x3F, 0x0F, 0xFC, 0xFC, 0x3F, 0xF3,
  0xF0, 0xFF, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0xC3, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x81,
  0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0,
  0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x7E,
  0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F,
  0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x03, 0xFC,
  0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC,
  0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xBC, 0x1F, 0xFC, 0x0F, 0xBE, 0x3E, 0xFC, 0x0F, 0xBE,
  0x3E, 0xF8, 0x1F, 0xBE, 0x3F, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE,
  0x7D, 0xF8, 0x1F, 0x3E, 0xF9, 0xF0, 0x1F, 0x3E, 0xFB, 0xF0, 0x3F, 0x3F,
  0xF3, 0xF0, 0x3F, 0x3F, 0xF3, 0xF0, 0x3F, 0x3F, 0xE3, 0xF0, 0x3E, 0x3F,
  0xE3, 0xE0, 0x3E, 0x3F, 0xC7, 0xE0, 0x7E, 0x3F, 0xC7, 0xE0, 0x7E, 0x3F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x87, 0xE0, 0x7C, 0x3F, 0x87, 0xC0, 0xFC, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00,
  0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x07, 0xE0, 0x7F, 0xC0, 0xFC, 0x0F,
  0xF8, 0x1F, 0x81, 0xFF, 0x03, 0xE0, 0x3F, 0xF0, 0xFC, 0x0F, 0xFE, 0x1F,
  0x81, 0xFF, 0xC3, 0xF0, 0x3E, 0xF8, 0x7E, 0x07, 0xDF, 0x0F, 0x80, 0xFB,
  0xF3, 0xF0, 0x3F, 0x7E, 0x7E, 0x07, 0xE7, 0xCF, 0xC0, 0xFC, 0xF9, 0xF0,
  0x1F, 0x1F, 0xBE, 0x03, 0xE3, 0xFF, 0xC0, 0xFC, 0x7F, 0xF8, 0x1F, 0x87,
  0xFF, 0x03, 0xF0, 0xFF, 0xC0, 0x7C, 0x1F, 0xF8, 0x0F, 0x83, 0xFF, 0x03,
  0xF0, 0x3F, 0xE0, 0x7E, 0x07, 0xFC, 0x0F, 0xC0, 0xFF, 0x01, 0xF0, 0x1F,
  0xE0, 0x7E, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF,
  0xE1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0x03, 0xF7,
  0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F,
  0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F,
  0x8F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0,
  0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xDF, 0xE1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0x03,
  0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0,
  0x3F, 0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x83, 0xF3, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xFC,
  0x1F, 0xCF, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xE0, 0xC0, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0xC0, 0x7F, 0x0F, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F,
  0x81, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x83,
  0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1,
  0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC,
  0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFD, 0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFB, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x3F, 0x7C, 0x07, 0xE0, 0x7E, 0x7C, 0x07, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0,
  0xFC, 0xFC, 0x0F, 0xE0, 0xFC, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC, 0x1F, 0xE1,
  0xF8, 0xFC, 0x1F, 0xE1, 0xF8, 0xFC, 0x3F, 0xE3, 0xF0, 0xFC, 0x3F, 0xE3,
  0xF0, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0x7F, 0xC7, 0xE0, 0xFC, 0x7B, 0xC7,
  0xE0, 0xFC, 0xFB, 0xC7, 0xC0, 0xFC, 0xFF, 0xCF, 0xC0, 0xFD, 0xF7, 0xCF,
  0xC0, 0xFD, 0xF7, 0xDF, 0x80, 0xFF, 0xF7, 0xDF, 0x80, 0xFF, 0xE7, 0xDF,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7E,
  0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x7E, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E,
  0xFE, 0x0F, 0xDF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x1F, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0x78, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x7C, 0x03,
  0xDF, 0x80, 0x7F, 0xE0, 0x0F, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFC, 0xFE, 0x7E, 0x7E, 0x3E, 0x1F, 0x0F, 0x03, 0xF3, 0xF0,
  0x7F, 0xBE, 0x0F, 0xFB, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0xFC,
  0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x1F,
  0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xBE, 0x03, 0xF3, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xCF, 0x80, 0xFD, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0,
  0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x7F,
  0x0F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFB, 0xFE, 0x0F, 0x9F, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFC, 0x10, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x18, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xF3, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFB, 0xE0, 0x1F, 0x9F,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x8F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFD, 0xF8, 0x3E, 0x7E, 0x3F, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x02, 0x3F, 0x87, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xC8, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x07, 0xFB, 0xE0, 0x3F, 0xEF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F,
  0x1F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x02,
  0x00, 0xFC, 0x0F, 0x8F, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xCF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7E, 0x00, 0x00, 0xE0, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x3F,
  0x0F, 0xE0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7E, 0x7E,
  0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF7,
  0xE0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF8,
  0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x0F, 0x8F, 0xC3, 0xF0, 0x7D, 0xFE,
  0x7F, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F,
  0x87, 0xE1, 0xF8, 0xF8, 0x3F, 0x0F, 0xCF, 0xC3, 0xF0, 0x7C, 0x7E, 0x1F,
  0x87, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF9, 0xF8, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF0, 0x7C, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F,
  0x87, 0xE1, 0xF9, 0xF8, 0x3E, 0x0F, 0xCF, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x87, 0xE0, 0x0F, 0x8F, 0xC1, 0xF7, 0xF8, 0x3E, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xE3, 0xF3, 0xF0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFC, 0xFC, 0x7F, 0x3F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x1F, 0x7F, 0x80, 0xFB, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xF8,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x0F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xF7, 0xF8, 0x1F, 0x9F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xF0,
  0x7F, 0xBE, 0x0F, 0xFB, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0xFC,
  0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0x8F, 0x0F, 0x9F, 0x0F, 0xBF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xDE, 0x3F,
  0x82, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x80, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0x8F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xBE, 0x03, 0xF3, 0xE0,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFB, 0xF0, 0x7E, 0x7C, 0x3F, 0x1F,
  0x0F, 0xC7, 0xC7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x3F, 0x07, 0xCF,
  0x81, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x83, 0xFF, 0xC3, 0xF8, 0x7E, 0xFC, 0x3F, 0x87,
  0xEF, 0xC7, 0xF8, 0x7C, 0xFC, 0x7F, 0x8F, 0xCF, 0xC7, 0xF8, 0xFC, 0xFC,
  0xFF, 0x9F, 0x8F, 0xCF, 0x79, 0xF8, 0xFD, 0xFF, 0x9F, 0x0F, 0xDF, 0xFB,
  0xF0, 0xFD, 0xEF, 0xBE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F,
  0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xC3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0xFE,
  0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03,
  0xE1, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xF0, 0x03,
  0xE3, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x18, 0x00, 0x5F, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xE8, 0x07, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 29, 11, 0, -29 },
  { 45, 15, 11, 17, 4, -29 },
  { 66, 23, 29, 22, 0, -29 },
  { 150, 19, 32, 19, 1, -30 },
  { 226, 28, 29, 32, 2, -29 },
  { 328, 24, 29, 24, 0, -29 },
  { 415, 7, 11, 10, 4, -29 },
  { 425, 14, 35, 12, 1, -29 },
  { 487, 14, 35, 12, -3, -29 },
  { 549, 17, 18, 18, 3, -31 },
  { 588, 17, 20, 20, 2, -24 },
  { 631, 9, 10, 10, -2, -5 },
  { 643, 12, 5, 12, 0, -13 },
  { 651, 7, 7, 10, 0, -7 },
  { 658, 21, 29, 16, -2, -29 },
  { 735, 18, 29, 19, 1, -29 },
  { 801, 14, 29, 19, 4, -29 },
  { 852, 20, 29, 19, -1, -29 },
  { 925, 19, 29, 19, 0, -29 },
  { 994, 20, 29, 19, 0, -29 },
  { 1067, 20, 29, 19, 0, -29 },
  { 1140, 19, 29, 19, 1, -29 },
  { 1209, 20, 29, 19, 1, -29 },
  { 1282, 20, 29, 19, 0, -29 },
  { 1355, 18, 29, 19, 1, -29 },
  { 1421, 11, 22, 11, 0, -22 },
  { 1452, 13, 27, 11, -2, -22 },
  { 1496, 17, 20, 20, 2, -24 },
  { 1539, 17, 13, 20, 2, -21 },
  { 1567, 17, 20, 20, 2, -24 },
  { 1610, 15, 29, 16, 2, -29 },
  { 1665, 28, 32, 29, 1, -29 },
  { 1777, 21, 29, 22, -2, -29 },
  { 1854, 22, 29, 21, 0, -29 },
  { 1934, 20, 29, 20, 2, -29 },
  { 2007, 22, 29, 23, 0, -29 },
  { 2087, 20, 29, 18, 0, -29 },
  { 2160, 20, 29, 18, 0, -29 },
  { 2233, 22, 29, 23, 2, -29 },
  { 2313, 25, 29, 24, 0, -29 },
  { 2404, 19, 29, 14, -2, -29 },
  { 2473, 19, 38, 11, -6, -29 },
  { 2564, 25, 29, 21, 0, -29 },
  { 2655, 15, 29, 17, 0, -29 },
  { 2710, 32, 29, 31, 0, -29 },
  { 2826, 27, 29, 26, 0, -29 },
  { 2924, 22, 29, 24, 2, -29 },
  { 3004, 21, 29, 21, 0, -29 },
  { 3081, 22, 36, 24, 2, -29 },
  { 3180, 21, 29, 21, 0, -29 },
  { 3257, 20, 29, 18, 0, -29 },
  { 3330, 18, 29, 18, 3, -29 },
  { 3396, 22, 29, 23, 2, -29 },
  { 3476, 20, 29, 21, 4, -29 },
  { 3549, 32, 29, 31, 3, -29 },
  { 3665, 26, 29, 21, -2, -29 },
  { 3760, 19, 29, 20, 4, -29 },
  { 3829, 23, 29, 18, -2, -29 },
  { 3913, 17, 36, 12, -2, -29 },
  { 3990, 9, 29, 16, 4, -29 },
  { 4023, 17, 36, 12, -3, -29 },
  { 4100, 19, 19, 19, 0, -29 },
  { 4146, 16, 4, 15, -4, 3 },
  { 4154, 8, 7, 13, 6, -31 },
  { 4161, 20, 22, 20, 1, -22 },
  { 4216, 20, 30, 20, 0, -30 },
  { 4291, 17, 22, 17, 1, -22 },
  { 4338, 21, 30, 20, 1, -30 },
  { 4417, 18, 22, 19, 1, -22 },
  { 4467, 21, 41, 13, -4, -31 },
  { 4575, 22, 32, 20, -1, -22 },
  { 4663, 19, 30, 21, 0, -30 },
  { 4735, 12, 31, 10, 0, -31 },
  { 4782, 17, 41, 10, -5, -31 },
  { 4870, 22, 30, 20, 0, -30 },
  { 4953, 12, 30, 10, 0, -30 },
  { 4998, 29, 22, 30, 0, -22 },
  { 5078, 19, 22, 21, 0, -22 },
  { 5131, 18, 22, 20, 1, -22 },
  { 5181, 21, 32, 20, -2, -22 },
  { 5265, 20, 32, 20, 1, -22 },
  { 5345, 16, 22, 15, 0, -22 },
  { 5389, 16, 22, 16, 0, -22 },
  { 5433, 13, 27, 14, 2, -27 },
  { 5477, 20, 22, 21, 1, -22 },
  { 5532, 18, 22, 18, 2, -22 },
  { 5582, 28, 22, 28, 2, -22 },
  { 5659, 23, 22, 19, -2, -22 },
  { 5723, 24, 32, 18, -3, -22 },
  { 5819, 18, 22, 16, -1, -22 },
  { 5869, 17, 35, 14, 0, -29 },
  { 5944, 5, 40, 17, 6, -31 },
  { 5969, 16, 35, 14, -2, -29 },
  { 6039, 18, 7, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC40PT7B_H_
