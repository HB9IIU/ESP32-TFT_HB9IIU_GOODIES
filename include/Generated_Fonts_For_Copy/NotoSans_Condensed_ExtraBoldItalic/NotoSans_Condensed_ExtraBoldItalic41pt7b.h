#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC41PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0,
  0x00, 0x7E, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x78, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x8F, 0x80,
  0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3E, 0x3C, 0x00, 0x7C,
  0x78, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x01, 0xE3, 0xE0,
  0x07, 0xC7, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x78, 0x00,
  0xF8, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xB9, 0x83, 0xF6, 0x10, 0x7C, 0xC0, 0x0F,
  0xD8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0D, 0xF8, 0x01,
  0xBF, 0x30, 0x77, 0xE7, 0x0D, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x3E, 0x03,
  0xFC, 0x03, 0xE0, 0x3F, 0xF0, 0x1E, 0x03, 0xFF, 0x81, 0xF0, 0x1F, 0x3C,
  0x1F, 0x01, 0xF1, 0xE0, 0xF0, 0x0F, 0x8F, 0x0F, 0x80, 0x78, 0xF8, 0x78,
  0x03, 0xC7, 0xC7, 0xC0, 0x3E, 0x3E, 0x7C, 0x01, 0xF1, 0xE3, 0xC0, 0x0F,
  0x9F, 0x3E, 0x3E, 0x7C, 0xFB, 0xE7, 0xFB, 0xFF, 0x9F, 0x7F, 0xEF, 0xFD,
  0xF3, 0xFF, 0x7F, 0xCF, 0x3E, 0xF9, 0xFC, 0xF9, 0xE3, 0xC3, 0x8F, 0x9F,
  0x1E, 0x00, 0x7C, 0xF8, 0xF0, 0x07, 0xC7, 0x8F, 0x80, 0x3C, 0x7C, 0x7C,
  0x03, 0xE3, 0xE3, 0xE0, 0x3E, 0x1F, 0x1E, 0x01, 0xE0, 0xF9, 0xF0, 0x1F,
  0x07, 0xCF, 0x80, 0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x07,
  0xFC, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF3, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFE, 0x1F, 0xFC, 0x7E, 0x1F, 0xFE, 0x3F, 0x1F, 0xFF,
  0xBF, 0x0F, 0xDF, 0xDF, 0x8F, 0xC7, 0xFF, 0x87, 0xE3, 0xFF, 0xC7, 0xF0,
  0xFF, 0xC3, 0xF8, 0x7F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0x8F, 0xE0, 0x7F, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8,
  0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x04, 0x3E, 0x07, 0x9F, 0x03, 0xFF,
  0x0D, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0xC3, 0xFC, 0x23,
  0xFE, 0x03, 0xFF, 0x83, 0xFB, 0xE0, 0xF9, 0xF0, 0x38, 0xFC, 0x0C, 0x78,
  0x00, 0x10, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC7,
  0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x80,
  0x3F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFE, 0x1C, 0xFD, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x87,
  0xE7, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF7, 0xF0, 0xFE, 0xFC, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xDF, 0xC3, 0xFB, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF8,
  0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x9F, 0xFF, 0x7F, 0xFC, 0xFD, 0xF8, 0xF3, 0xF1, 0xC7, 0xE1,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0x0F, 0xE0, 0x70, 0x7F, 0x01, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0x07, 0xF0, 0x20,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x88, 0x03, 0xF8, 0xE0, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0xC0,
  0x3C, 0xFC, 0x07, 0x9F, 0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0x81, 0xE1, 0xF8,
  0x3E, 0x1F, 0x87, 0xC3, 0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xE7,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x80, 0x3F, 0x8E, 0x07, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF3, 0xE0, 0x3F, 0xFF, 0x07, 0xEF, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC,
  0xFE, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xE3, 0xF8, 0x7E, 0x7F,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7E, 0x7F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xE7, 0xE0, 0x7E, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0x9F, 0x87, 0xF1, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFE, 0x1F, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xE3, 0xF1, 0xFC, 0x7F, 0x3F, 0x07, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0xBF,
  0x87, 0xF7, 0xF0, 0xFC, 0xFE, 0x3F, 0x9F, 0xCF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0x7E, 0x07, 0xCF, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x81, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x80, 0xF8,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0xC1, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x30, 0x7F, 0x20, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0xFE, 0x01,
  0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x0F, 0x83,
  0xF0, 0xF8, 0xF8, 0x7F, 0xE7, 0xC7, 0x87, 0xFF, 0x1E, 0x7C, 0x7F, 0xF8,
  0xF3, 0xC7, 0xC7, 0xC7, 0x9E, 0x3C, 0x3C, 0x3D, 0xE3, 0xE1, 0xE3, 0xEF,
  0x1E, 0x1F, 0x1E, 0x78, 0xF0, 0xF8, 0xF3, 0xC7, 0x87, 0x87, 0xBE, 0x7C,
  0x3C, 0x7D, 0xE3, 0xE3, 0xE3, 0xCF, 0x1F, 0x1F, 0x3E, 0x78, 0xF9, 0xF9,
  0xE3, 0xC3, 0xFF, 0xFE, 0x1E, 0x1F, 0xFF, 0xE0, 0xF8, 0x7C, 0x7E, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC,
  0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F,
  0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x8F, 0xE0,
  0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC,
  0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xC1, 0x83, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x20,
  0xFF, 0x0E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFC, 0x7F, 0x81, 0xF8, 0x7F,
  0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8,
  0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC,
  0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0xFE, 0x0F, 0xC3, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFC, 0x0C, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xFF, 0x3F, 0x87,
  0xFE, 0x7F, 0x0F, 0xF8, 0xFE, 0x3F, 0xF1, 0xF8, 0x7F, 0xE3, 0xF0, 0xFF,
  0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x81, 0xF8,
  0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F,
  0x07, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF3, 0xF8,
  0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87, 0xDF, 0x01, 0xF7, 0xC3, 0xFF, 0x80,
  0xFB, 0xE3, 0xEF, 0xC0, 0xFD, 0xF1, 0xF7, 0xE0, 0x7E, 0xF9, 0xF3, 0xF0,
  0x3F, 0x7C, 0xFB, 0xF0, 0x1F, 0xBE, 0xFD, 0xF8, 0x0F, 0x9F, 0x7C, 0xFC,
  0x0F, 0xCF, 0xBE, 0x7E, 0x07, 0xE7, 0xFE, 0x3E, 0x03, 0xF3, 0xFF, 0x3F,
  0x01, 0xF9, 0xFF, 0x1F, 0x80, 0xF8, 0xFF, 0x8F, 0xC0, 0xFC, 0x7F, 0x87,
  0xE0, 0x7E, 0x3F, 0xC7, 0xE0, 0x3F, 0x1F, 0xC3, 0xF0, 0x1F, 0x0F, 0xE1,
  0xF8, 0x1F, 0x87, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xE0, 0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0x81, 0xFE, 0x03, 0xF0,
  0x7F, 0xC0, 0xFC, 0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x83, 0xF0, 0x3F, 0xF0,
  0x7E, 0x0F, 0xFE, 0x0F, 0x81, 0xFF, 0xE3, 0xF0, 0x3F, 0xFC, 0x7E, 0x07,
  0xDF, 0x8F, 0xC0, 0xF9, 0xF1, 0xF8, 0x3F, 0x3E, 0x3E, 0x07, 0xE7, 0xEF,
  0xC0, 0xFC, 0xFD, 0xF8, 0x1F, 0x9F, 0xBF, 0x03, 0xE1, 0xF7, 0xE0, 0xFC,
  0x3F, 0xF8, 0x1F, 0x87, 0xFF, 0x03, 0xF0, 0xFF, 0xE0, 0x7E, 0x1F, 0xFC,
  0x0F, 0x81, 0xFF, 0x03, 0xF0, 0x3F, 0xE0, 0x7E, 0x07, 0xFC, 0x0F, 0xC0,
  0xFF, 0x81, 0xF0, 0x0F, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0x7E, 0x3F,
  0x80, 0xFC, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0,
  0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0xFE, 0xFE, 0x01,
  0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F,
  0x9F, 0x80, 0xFE, 0x3F, 0x01, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E,
  0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0x7E, 0x3F, 0x80,
  0xFC, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F,
  0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD,
  0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x9F,
  0x80, 0xFE, 0x3F, 0x01, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F,
  0x87, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC7, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03,
  0xFB, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE,
  0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xE1, 0xC0,
  0xFC, 0x04, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x80, 0x3F, 0x8C, 0x03, 0xF0, 0xF8, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0,
  0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0x0F,
  0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03,
  0xF8, 0x7E, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x7F,
  0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x1F, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8,
  0x0F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8,
  0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFD, 0xF8, 0x07,
  0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x3F,
  0xBF, 0x03, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x1F, 0x8F, 0x81, 0xFC, 0x0F,
  0xC7, 0xC0, 0xFE, 0x0F, 0xE3, 0xE0, 0x7F, 0x07, 0xE1, 0xF0, 0x7F, 0x83,
  0xF0, 0xF8, 0x3F, 0xC3, 0xF0, 0x7C, 0x3F, 0xE1, 0xF8, 0x7E, 0x1F, 0xF0,
  0xFC, 0x3F, 0x0F, 0xF8, 0xFC, 0x1F, 0x8F, 0xFC, 0x7E, 0x0F, 0xC7, 0xFE,
  0x7E, 0x07, 0xE7, 0xDF, 0x3F, 0x03, 0xF3, 0xEF, 0x9F, 0x81, 0xFB, 0xF7,
  0xDF, 0x80, 0xFD, 0xF3, 0xEF, 0xC0, 0x7E, 0xF9, 0xFF, 0xC0, 0x3F, 0xF8,
  0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x7E,
  0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F,
  0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0xFE,
  0xFC, 0x0F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x7F,
  0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF0,
  0x1F, 0x3E, 0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7C, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x3F, 0x1F, 0x0F, 0x01, 0xE1, 0xF0,
  0x7F, 0xBF, 0x0F, 0xFB, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFD, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xCF, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x3F, 0x8F, 0xE7, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFB, 0xF0, 0x3F, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE7, 0x80, 0xFD, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x7F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F,
  0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x07, 0xF3, 0xF0, 0x7F, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x3F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0x9F, 0xE0, 0xF8, 0xFC,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFE, 0x30, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x04, 0x7F, 0x0C, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x01, 0xE3, 0xF0, 0x1F, 0xEF, 0xC0, 0xFF, 0xBF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xF8,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFE, 0x7C,
  0x03, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x7E, 0x0F,
  0xDF, 0xBF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x8F, 0xF3, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x06, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x03, 0xF9, 0xF0,
  0x3F, 0xEF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xDF, 0xE0, 0xFE,
  0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC3, 0xF8, 0x3F, 0x0F, 0xE0, 0xFE, 0x7F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xBF, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x08, 0x03, 0xF0, 0x3C, 0x1F, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0x80,
  0xFD, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F,
  0x1F, 0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xC7, 0xF0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE,
  0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x80, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x17, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x3F,
  0x87, 0xF0, 0xFC, 0x3F, 0x83, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xDF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF8,
  0x1F, 0x8F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x00, 0x07, 0x87, 0x81, 0xF0, 0x3E, 0x7F, 0x9F, 0xE0, 0xFB,
  0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0x9F,
  0xF7, 0xF1, 0xFC, 0x7F, 0x8F, 0xC7, 0xF1, 0xFC, 0x3F, 0x1F, 0x87, 0xF0,
  0xFC, 0x7E, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E,
  0x3F, 0x07, 0xE1, 0xF8, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F,
  0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x0F, 0xC7, 0xE1,
  0xF8, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F, 0x87, 0xE3, 0xF0, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF0, 0x7E, 0x00, 0x07, 0x87, 0x80, 0xF9, 0xFE, 0x0F,
  0xBF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xC3, 0xF1,
  0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xF7, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x7E, 0x0F,
  0xDF, 0x83, 0xF7, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7E, 0xFC, 0x3F, 0xBF, 0x8F, 0xCF, 0xFF, 0xF1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xF1, 0xE0, 0x0F,
  0x9F, 0xC0, 0x3E, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xE7,
  0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7C, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0x1F, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFD, 0xFE, 0x03, 0xF3, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x3F, 0x9F, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFD, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x7F,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xE3, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFB, 0xF0, 0x3F, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x07, 0xC7, 0x87, 0xCF, 0xC3, 0xEF, 0xC1, 0xF7, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE8, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFC, 0x30, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFC, 0x60, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x87,
  0xFF, 0x81, 0xFF, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0xFC, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F,
  0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0xFC, 0x3F, 0x8F, 0xE7,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xDF, 0x07, 0xF9, 0xF0, 0x3F,
  0x1E, 0x00, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x3E, 0x0F, 0xE7,
  0xC1, 0xF8, 0xF8, 0x7F, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x7E, 0x0F,
  0x8F, 0xC1, 0xF3, 0xF0, 0x3E, 0x7E, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F,
  0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0xC3,
  0xFB, 0xE0, 0xFE, 0x1F, 0x9F, 0x0F, 0xF0, 0xFC, 0xF8, 0x7F, 0x8F, 0xC7,
  0xC7, 0xFC, 0x7E, 0x3E, 0x3F, 0xE3, 0xE1, 0xF1, 0xFF, 0x3F, 0x0F, 0x9F,
  0xF1, 0xF8, 0x7C, 0xFF, 0x9F, 0x83, 0xE7, 0xBC, 0xFC, 0x1F, 0x7D, 0xE7,
  0xC0, 0xFB, 0xCF, 0x7E, 0x07, 0xFE, 0x7B, 0xE0, 0x3F, 0xF3, 0xDF, 0x01,
  0xFF, 0x1F, 0xF8, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x07, 0xFC,
  0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFE,
  0x0F, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xBF,
  0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFE, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8,
  0x3F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x03, 0xE0,
  0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF1, 0xFC, 0x03, 0xF1,
  0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xF7,
  0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x5F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3E,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF8, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 29, 11, 0, -29 },
  { 49, 16, 10, 18, 4, -29 },
  { 69, 23, 29, 22, 0, -29 },
  { 153, 19, 33, 20, 1, -31 },
  { 232, 29, 30, 32, 2, -30 },
  { 341, 25, 30, 25, 0, -30 },
  { 435, 8, 10, 10, 4, -29 },
  { 445, 14, 36, 12, 1, -30 },
  { 508, 15, 36, 12, -3, -30 },
  { 576, 17, 18, 19, 3, -31 },
  { 615, 18, 19, 21, 2, -24 },
  { 658, 10, 11, 11, -2, -5 },
  { 672, 12, 6, 13, 0, -14 },
  { 681, 7, 7, 11, 0, -7 },
  { 688, 22, 30, 16, -2, -30 },
  { 771, 19, 30, 20, 1, -30 },
  { 843, 15, 29, 20, 4, -29 },
  { 898, 21, 30, 20, -1, -30 },
  { 977, 20, 30, 20, 0, -30 },
  { 1052, 20, 29, 20, 0, -29 },
  { 1125, 20, 29, 20, 0, -29 },
  { 1198, 20, 30, 20, 1, -30 },
  { 1273, 21, 29, 20, 1, -29 },
  { 1350, 20, 30, 20, 0, -30 },
  { 1425, 19, 30, 20, 1, -30 },
  { 1497, 11, 23, 11, 0, -23 },
  { 1529, 13, 29, 11, -2, -23 },
  { 1577, 18, 20, 21, 2, -25 },
  { 1622, 18, 13, 21, 2, -21 },
  { 1652, 18, 20, 21, 2, -25 },
  { 1697, 16, 30, 16, 2, -30 },
  { 1757, 29, 33, 30, 1, -30 },
  { 1877, 22, 29, 22, -2, -29 },
  { 1957, 22, 29, 22, 0, -29 },
  { 2037, 21, 30, 21, 2, -30 },
  { 2116, 23, 29, 24, 0, -29 },
  { 2200, 20, 29, 18, 0, -29 },
  { 2273, 20, 29, 18, 0, -29 },
  { 2346, 23, 30, 24, 2, -30 },
  { 2433, 26, 29, 24, 0, -29 },
  { 2528, 20, 29, 15, -2, -29 },
  { 2601, 19, 38, 12, -6, -29 },
  { 2692, 26, 29, 22, 0, -29 },
  { 2787, 15, 29, 18, 0, -29 },
  { 2842, 33, 29, 32, 0, -29 },
  { 2962, 27, 29, 26, 0, -29 },
  { 3060, 23, 30, 25, 2, -30 },
  { 3147, 22, 29, 21, 0, -29 },
  { 3227, 23, 37, 25, 2, -30 },
  { 3334, 22, 29, 22, 0, -29 },
  { 3414, 20, 30, 19, 0, -30 },
  { 3489, 18, 29, 18, 3, -29 },
  { 3555, 23, 29, 24, 2, -29 },
  { 3639, 21, 29, 21, 4, -29 },
  { 3716, 33, 29, 32, 3, -29 },
  { 3836, 26, 29, 21, -2, -29 },
  { 3931, 20, 29, 20, 4, -29 },
  { 4004, 23, 29, 18, -2, -29 },
  { 4088, 17, 37, 12, -2, -30 },
  { 4167, 10, 30, 17, 4, -30 },
  { 4205, 17, 37, 12, -3, -30 },
  { 4284, 19, 18, 20, 0, -29 },
  { 4327, 16, 4, 15, -4, 3 },
  { 4335, 8, 6, 13, 6, -31 },
  { 4341, 20, 23, 21, 1, -23 },
  { 4399, 20, 31, 21, 0, -31 },
  { 4477, 17, 23, 17, 1, -23 },
  { 4526, 22, 31, 21, 1, -31 },
  { 4612, 18, 23, 20, 1, -23 },
  { 4664, 23, 41, 13, -5, -31 },
  { 4782, 22, 33, 21, -1, -23 },
  { 4873, 20, 31, 21, 0, -31 },
  { 4951, 12, 31, 11, 0, -31 },
  { 4998, 17, 41, 11, -5, -31 },
  { 5086, 22, 31, 20, 0, -31 },
  { 5172, 13, 31, 11, 0, -31 },
  { 5223, 30, 23, 31, 0, -23 },
  { 5310, 20, 23, 21, 0, -23 },
  { 5368, 18, 23, 21, 1, -23 },
  { 5420, 22, 33, 21, -2, -23 },
  { 5511, 20, 33, 21, 1, -23 },
  { 5594, 17, 23, 15, 0, -23 },
  { 5643, 17, 23, 17, 0, -23 },
  { 5692, 14, 27, 14, 2, -27 },
  { 5740, 20, 23, 21, 1, -23 },
  { 5798, 19, 23, 19, 2, -23 },
  { 5853, 29, 23, 28, 2, -23 },
  { 5937, 23, 23, 19, -2, -23 },
  { 6004, 24, 33, 19, -3, -23 },
  { 6103, 18, 23, 16, -1, -23 },
  { 6155, 17, 35, 14, 0, -29 },
  { 6230, 5, 40, 18, 6, -31 },
  { 6255, 16, 35, 14, -2, -29 },
  { 6325, 18, 7, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC41PT7B_H_
