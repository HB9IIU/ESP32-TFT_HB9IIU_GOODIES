#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC33PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0x7C, 0xFB, 0xE7, 0x9F, 0x3C,
  0xF3, 0xE7, 0x9F, 0x3C, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xC0, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0x8E,
  0x00, 0xF3, 0xC0, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x1E, 0x78,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x78, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x71, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0x71, 0xC0, 0x0E, 0x38, 0x03, 0xCF, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x78, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0x62, 0x1F,
  0x60, 0x1F, 0x40, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xBC, 0x41, 0xBC, 0x61, 0x3C, 0x7B, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0x80, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0F, 0x00, 0x70, 0x3F, 0x01, 0xE0, 0xFF, 0x07, 0x83, 0xFE, 0x0F,
  0x07, 0x9C, 0x3C, 0x0E, 0x38, 0x70, 0x3C, 0xF1, 0xE0, 0x79, 0xE7, 0x80,
  0xF3, 0xCF, 0x01, 0xC7, 0xBC, 0x03, 0x9E, 0x73, 0xF7, 0xFD, 0xEF, 0xFF,
  0xF7, 0xBF, 0xEF, 0xCF, 0x7B, 0xCF, 0x3C, 0xE7, 0x80, 0x73, 0xCF, 0x01,
  0xE7, 0x9E, 0x07, 0x8F, 0x3C, 0x0F, 0x1C, 0x78, 0x3C, 0x39, 0xE0, 0xF0,
  0x73, 0xC1, 0xE0, 0xFF, 0x07, 0x81, 0xFC, 0x1E, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xCF, 0x00, 0x78,
  0xF0, 0x07, 0x9F, 0x00, 0x79, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x1F, 0x1F, 0xF3, 0xE3, 0xFF, 0x3E, 0x7F, 0xFB, 0xC7,
  0xCF, 0xFC, 0x7C, 0xFF, 0x8F, 0x87, 0xF8, 0xF8, 0x7F, 0x0F, 0xC7, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFC, 0xFC, 0x7D, 0xF7,
  0xDE, 0x79, 0xEF, 0xBC, 0xF0, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8,
  0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x04, 0x3C, 0x0C, 0xF0,
  0x7F, 0xC5, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xC4, 0x7F, 0x03, 0xFE,
  0x1F, 0x7C, 0x18, 0xF0, 0x23, 0x80, 0x08, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x7F, 0xDF,
  0xE7, 0xFB, 0xFE, 0x7B, 0xFF, 0xFE, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xE3, 0xE7,
  0xCF, 0x8F, 0x9F, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xFF,
  0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7,
  0xE7, 0xCF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0xF0,
  0x1F, 0x07, 0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0xEF, 0xBE, 0x73, 0xE2,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x38, 0xFC, 0x08,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF,
  0xF0, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x04,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xF8, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x80, 0xFC, 0xC1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xBC, 0x07, 0x7C, 0x0F, 0x7C, 0x1E,
  0x7C, 0x1C, 0x7C, 0x3C, 0x78, 0x78, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFC, 0x10, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x80, 0xFC, 0xC1, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xE2, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x40, 0x7D, 0xF8, 0x7F, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFC, 0xFC, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0xFC, 0xF8, 0xF8, 0xF9, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF,
  0x0F, 0x9F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0xBE, 0x0F, 0xFE,
  0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFC, 0x7C, 0x7C,
  0x7C, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3,
  0xF7, 0xE7, 0xC7, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0xFD, 0xF1,
  0xFB, 0xF7, 0xE7, 0xFF, 0xCF, 0xFF, 0x8F, 0xDF, 0x0F, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F,
  0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC3, 0xF1, 0xF8, 0xF8, 0x7C, 0x00, 0x03, 0xC0,
  0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03,
  0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7E, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3C, 0x00,
  0x60, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFE, 0x7F, 0xF3, 0xDF, 0x90, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0x07, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x87, 0x83,
  0x87, 0x9E, 0x1F, 0xE7, 0x3C, 0xFF, 0x8E, 0xF1, 0xE7, 0x1D, 0xE7, 0x9E,
  0x3B, 0x8E, 0x3C, 0xF7, 0x3C, 0x79, 0xFE, 0x70, 0xE3, 0xB8, 0xE3, 0xC7,
  0x71, 0xC7, 0x9E, 0xE3, 0x8F, 0x39, 0xC7, 0xFF, 0xF3, 0x8F, 0xFF, 0xC7,
  0x8F, 0xBF, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x1F,
  0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x3E, 0x78,
  0x0F, 0x9E, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x01,
  0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x1F,
  0x0F, 0x87, 0xC7, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xC3, 0xF1,
  0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFC, 0x08,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC3, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0x1F, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x1F, 0x87, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x1F, 0x8F,
  0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xFC, 0x3E,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0x81, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0xFE, 0x3E, 0x3F, 0xC7, 0xC7, 0xF8, 0xF8, 0xFF, 0x3F, 0x1F, 0xE7, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x1F, 0x87, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xC1, 0xF8, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x3F, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x3F, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0x07,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x82, 0x3F, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x3E, 0x1F,
  0x81, 0xF1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E,
  0x7C, 0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF,
  0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x07,
  0xC7, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x7B, 0xC1, 0xFF, 0x1F, 0xF0, 0x7B, 0xCF,
  0x7C, 0x1E, 0xF3, 0xDF, 0x0F, 0xBD, 0xF7, 0xC3, 0xEF, 0x79, 0xE0, 0xFB,
  0xDE, 0xF8, 0x3C, 0xFF, 0x3E, 0x1F, 0x3F, 0xCF, 0x87, 0xCF, 0xE3, 0xC1,
  0xF3, 0xF9, 0xF0, 0x7C, 0xFC, 0x7C, 0x1E, 0x3F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC3, 0xE3, 0xE3, 0xE0, 0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7E, 0x07,
  0xC3, 0xF8, 0x1E, 0x0F, 0xF0, 0xF8, 0x3F, 0xC3, 0xE0, 0xFF, 0x0F, 0x83,
  0xFC, 0x3C, 0x1F, 0xF8, 0xF0, 0x7F, 0xE7, 0xC1, 0xEF, 0x9F, 0x07, 0x9E,
  0x7C, 0x1E, 0x79, 0xE0, 0xF9, 0xF7, 0x83, 0xE7, 0xFE, 0x0F, 0x9F, 0xF8,
  0x3C, 0x3F, 0xE1, 0xF0, 0xFF, 0x07, 0xC3, 0xFC, 0x1F, 0x0F, 0xF0, 0x7C,
  0x1F, 0xC1, 0xE0, 0x7F, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x0F,
  0xC7, 0xC1, 0xF9, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F,
  0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E,
  0xFC, 0x0F, 0x9F, 0x83, 0xF1, 0xF0, 0xFC, 0x3F, 0x3F, 0x87, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF8, 0x7D, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0x0F, 0xC7, 0xC1, 0xF9, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0xC0,
  0xFD, 0xF8, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0x9F, 0x83, 0xF1, 0xF0, 0xFC, 0x3F, 0x3F,
  0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0xC7, 0xCF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x3F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF3,
  0xE0, 0xF9, 0xF0, 0x7E, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFE, 0x1F, 0x86, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x80, 0xF8, 0xF1, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x87, 0xC1, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E,
  0x1F, 0x07, 0xC7, 0xE1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE,
  0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xDF,
  0x03, 0xEF, 0x81, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x1E,
  0x07, 0xFE, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xE1, 0xF8, 0x7C, 0xF8,
  0x7E, 0x1F, 0x3E, 0x1F, 0x87, 0xCF, 0x8F, 0xE3, 0xE3, 0xE3, 0xF8, 0xF8,
  0xF1, 0xFE, 0x7C, 0x3C, 0x7F, 0x9F, 0x0F, 0x3F, 0xE7, 0xC3, 0xCF, 0x7B,
  0xE0, 0xF3, 0xDE, 0xF8, 0x3D, 0xE7, 0xBC, 0x0F, 0x79, 0xFF, 0x03, 0xFE,
  0x77, 0xC0, 0xFF, 0x1D, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8,
  0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x1F,
  0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x3F,
  0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7D, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x00, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x1F, 0x0F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xBC, 0x0F, 0x3C, 0x0F, 0x3C,
  0x1E, 0x3C, 0x3E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0xF9, 0xF1, 0xE1, 0xE0, 0x0F, 0xCF, 0x1F, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7E, 0xF0, 0x3C, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x7C,
  0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E,
  0x7C, 0x7C, 0x7F, 0xFC, 0xFF, 0xF8, 0xF7, 0xF0, 0xF3, 0xE0, 0x07, 0xF8,
  0x7F, 0xC7, 0xFE, 0x7F, 0xE3, 0xE1, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x23, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0xBE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x87, 0xCF, 0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xF0, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3E, 0xF0, 0x00, 0x07, 0xF8,
  0x3F, 0xF1, 0xFF, 0xCF, 0xDF, 0x3E, 0x3D, 0xF0, 0xF7, 0xC7, 0xFF, 0xFE,
  0xFF, 0xFB, 0xFF, 0x8F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x4F, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x9F, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0x87,
  0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xF3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0xC7, 0xC7,
  0xC3, 0xE7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0x78, 0x1F, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x86, 0x1F, 0x83, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x7E, 0x1F, 0xFE, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0x07, 0xC1, 0xF0, 0xFC, 0x1E,
  0x03, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83,
  0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0xBF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x3F, 0x1F, 0x1F, 0x87, 0xC7, 0xC1,
  0xF3, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1E, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x00, 0x07, 0xC1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x0F, 0x7E, 0x7E, 0x1F, 0xFE, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x1F, 0x9F, 0x1F, 0x1F, 0x1F,
  0x3E, 0x1F, 0x1F, 0x3E, 0x1E, 0x1F, 0x3E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3E, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x7C, 0x3C,
  0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0x7C, 0xF8, 0x78, 0x7C, 0xF8, 0xF8, 0x7C,
  0x0F, 0x7E, 0x1E, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8,
  0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xEF, 0x87, 0xDF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xEF, 0x8F,
  0x9F, 0x1F, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x03, 0xDF,
  0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xC7, 0xC1, 0xF1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xF1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x1F, 0x87, 0xE7, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xBE, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xCF, 0x1F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7E, 0xF0, 0x7D, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x0F, 0x7C, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x7F,
  0xF1, 0xFF, 0x8F, 0xDC, 0x3E, 0x10, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF2, 0x0F, 0xCF, 0xFE, 0x3F,
  0xF8, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xFE,
  0xFF, 0xDF, 0xFF, 0xFF, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xFC, 0x7F, 0x87, 0xF0, 0x7E, 0x00,
  0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC,
  0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7E, 0xF0,
  0xF8, 0x7F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3E, 0x3E,
  0x7C, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0xFC,
  0x7F, 0xF1, 0xF8, 0xFB, 0xE3, 0xF1, 0xE7, 0xCF, 0xE7, 0xCF, 0x9F, 0xCF,
  0x9F, 0x7F, 0x9E, 0x3E, 0xFF, 0x7C, 0x79, 0xDE, 0xF0, 0xF7, 0xBF, 0xE1,
  0xEF, 0x77, 0xC3, 0xDC, 0xEF, 0x07, 0xF9, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0xC0,
  0x3D, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x01, 0xF1, 0xF0, 0x7E, 0x3E, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE1,
  0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03,
  0xE7, 0xC0, 0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0x3F,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x04, 0x03,
  0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x3F,
  0x00, 0xFE, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x7F, 0x07, 0xF8, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0x80, 0x00, 0x08, 0x02, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xF0, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 13, 9, 14, 3, -24 },
  { 46, 19, 24, 18, 0, -24 },
  { 103, 16, 27, 16, 0, -25 },
  { 157, 23, 24, 26, 2, -24 },
  { 226, 20, 24, 20, 0, -24 },
  { 286, 6, 9, 8, 3, -24 },
  { 293, 11, 29, 10, 1, -24 },
  { 333, 12, 29, 10, -3, -24 },
  { 377, 14, 15, 15, 2, -25 },
  { 404, 15, 16, 17, 1, -20 },
  { 434, 8, 8, 9, -2, -4 },
  { 442, 10, 4, 10, 0, -11 },
  { 447, 6, 5, 9, 0, -5 },
  { 451, 18, 24, 13, -2, -24 },
  { 505, 15, 24, 16, 1, -24 },
  { 550, 12, 24, 16, 3, -24 },
  { 586, 17, 24, 16, -1, -24 },
  { 637, 16, 24, 16, 0, -24 },
  { 685, 16, 24, 16, 0, -24 },
  { 733, 16, 24, 16, 0, -24 },
  { 781, 16, 24, 16, 1, -24 },
  { 829, 17, 24, 16, 1, -24 },
  { 880, 16, 24, 16, 0, -24 },
  { 928, 15, 24, 16, 1, -24 },
  { 973, 9, 18, 9, 0, -18 },
  { 994, 11, 22, 9, -2, -18 },
  { 1025, 15, 16, 17, 1, -20 },
  { 1055, 15, 11, 17, 1, -17 },
  { 1076, 15, 16, 17, 1, -20 },
  { 1106, 13, 24, 13, 1, -24 },
  { 1145, 23, 27, 24, 1, -24 },
  { 1223, 18, 24, 18, -2, -24 },
  { 1277, 18, 24, 18, 0, -24 },
  { 1331, 17, 24, 17, 1, -24 },
  { 1382, 19, 24, 19, 0, -24 },
  { 1439, 16, 24, 15, 0, -24 },
  { 1487, 16, 24, 15, 0, -24 },
  { 1535, 19, 24, 19, 1, -24 },
  { 1592, 21, 24, 20, 0, -24 },
  { 1655, 15, 24, 12, -1, -24 },
  { 1700, 15, 31, 9, -5, -24 },
  { 1759, 21, 24, 18, 0, -24 },
  { 1822, 12, 24, 14, 0, -24 },
  { 1858, 26, 24, 25, 0, -24 },
  { 1936, 22, 24, 21, 0, -24 },
  { 2002, 19, 24, 20, 1, -24 },
  { 2059, 18, 24, 17, 0, -24 },
  { 2113, 19, 30, 20, 1, -24 },
  { 2185, 17, 24, 17, 0, -24 },
  { 2236, 16, 24, 15, 0, -24 },
  { 2284, 14, 24, 15, 3, -24 },
  { 2326, 19, 24, 19, 1, -24 },
  { 2383, 17, 24, 17, 3, -24 },
  { 2434, 26, 24, 26, 3, -24 },
  { 2512, 22, 24, 17, -2, -24 },
  { 2578, 16, 24, 16, 3, -24 },
  { 2626, 18, 24, 15, -1, -24 },
  { 2680, 13, 29, 10, -1, -24 },
  { 2728, 8, 24, 13, 3, -24 },
  { 2752, 13, 29, 10, -2, -24 },
  { 2800, 16, 15, 16, 0, -24 },
  { 2830, 13, 3, 12, -3, 3 },
  { 2835, 7, 5, 11, 5, -25 },
  { 2840, 16, 18, 17, 1, -18 },
  { 2876, 16, 25, 17, 0, -25 },
  { 2926, 13, 18, 14, 1, -18 },
  { 2956, 17, 25, 17, 1, -25 },
  { 3010, 14, 18, 16, 1, -18 },
  { 3042, 18, 33, 11, -4, -25 },
  { 3117, 17, 26, 17, 0, -18 },
  { 3173, 16, 25, 17, 0, -25 },
  { 3223, 10, 25, 9, 0, -25 },
  { 3255, 14, 33, 9, -4, -25 },
  { 3313, 18, 25, 16, 0, -25 },
  { 3370, 10, 25, 9, 0, -25 },
  { 3402, 24, 18, 25, 0, -18 },
  { 3456, 16, 18, 17, 0, -18 },
  { 3492, 15, 18, 17, 1, -18 },
  { 3526, 18, 26, 17, -2, -18 },
  { 3585, 16, 26, 17, 1, -18 },
  { 3637, 14, 18, 12, 0, -18 },
  { 3669, 14, 18, 13, 0, -18 },
  { 3701, 11, 22, 12, 1, -22 },
  { 3732, 16, 18, 17, 1, -18 },
  { 3768, 15, 18, 15, 2, -18 },
  { 3802, 23, 18, 23, 2, -18 },
  { 3854, 19, 18, 15, -2, -18 },
  { 3897, 19, 26, 15, -2, -18 },
  { 3959, 15, 18, 13, -1, -18 },
  { 3993, 14, 29, 11, 0, -24 },
  { 4044, 4, 33, 14, 5, -25 },
  { 4061, 13, 29, 11, -2, -24 },
  { 4109, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC33PT7B_H_
