#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC52PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0x7E, 0x00, 0x38, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x7F, 0x8F,
  0xE7, 0xF8, 0xFE, 0x7F, 0x1F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1,
  0xFC, 0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC,
  0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0xFC, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0xFC, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0xE3, 0x80, 0xFE,
  0x70, 0x40, 0x7F, 0x38, 0x00, 0x3F, 0x98, 0x00, 0x1F, 0xEC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0E, 0xFF, 0x00, 0x07, 0x7F,
  0x88, 0x03, 0xBF, 0xC3, 0x01, 0x9F, 0xC3, 0xE1, 0xCF, 0xE1, 0xFE, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F,
  0xFF, 0x80, 0x7E, 0x00, 0xFC, 0xFC, 0x07, 0xE0, 0x0F, 0xE3, 0xE0, 0x7E,
  0x00, 0x7E, 0x1F, 0x03, 0xF0, 0x03, 0xF1, 0xF8, 0x3F, 0x00, 0x1F, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF1, 0xF8, 0x00,
  0x7E, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC7,
  0xE1, 0xE0, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7, 0xE7, 0xE7, 0xE3, 0xFF, 0x3F,
  0xFF, 0x3F, 0x3F, 0xFD, 0xFF, 0xF3, 0xF3, 0xFF, 0xE7, 0xFF, 0x1F, 0x1F,
  0xBF, 0x3F, 0xF1, 0xF9, 0xF8, 0xFC, 0xFF, 0x1F, 0x8F, 0xC7, 0xE1, 0xC0,
  0xFC, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x0F,
  0x80, 0x07, 0xE1, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x3F, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0xFC, 0x01, 0xF8, 0x0F, 0xCF, 0xC0, 0x0F, 0xC0, 0x7F,
  0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x7F, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x07, 0xF8, 0x1F, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFE, 0x3F, 0xC1, 0xFF, 0xFC, 0x7F, 0x87, 0xFF, 0xFC,
  0xFE, 0x1F, 0xE7, 0xFB, 0xFC, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFE, 0x1F, 0xFF, 0x87, 0xF8, 0x1F, 0xFF, 0x0F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE3, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x20, 0x7E, 0x00, 0xC1, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0xDF, 0x02, 0x7F,
  0xFD, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01,
  0xFF, 0x7E, 0x07, 0xF9, 0xF8, 0x07, 0xC7, 0xF0, 0x0F, 0x1F, 0xE0, 0x18,
  0x3E, 0x00, 0x40, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x3F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x30, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0xFF, 0x03,
  0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F,
  0xF0, 0x7F, 0x1F, 0xF0, 0x7F, 0xBF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xBF, 0xC7, 0xC7, 0xF0, 0x71,
  0xFE, 0x04, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xF3, 0xFF, 0x00,
  0xF8, 0x3F, 0xE0, 0x0E, 0x03, 0xFC, 0x01, 0x80, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xE1, 0xFF, 0x01, 0xC0, 0x7F, 0x80, 0x80, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC4,
  0x00, 0x3F, 0xE3, 0x00, 0x3F, 0xF1, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xBF, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xE3, 0xF8, 0x01,
  0xF9, 0xFE, 0x00, 0xFC, 0x7F, 0x80, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0,
  0x0F, 0xC3, 0xFC, 0x07, 0xE0, 0xFF, 0x01, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x40,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x08,
  0x00, 0xFF, 0x86, 0x00, 0xFF, 0x83, 0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFE, 0x04, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x7F, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F,
  0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03,
  0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0,
  0x7F, 0x87, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x7F, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xEF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xBF, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x81, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3,
  0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0xC3, 0xFE, 0x3F, 0xE7,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFD,
  0xFC, 0x0F, 0xFB, 0xFC, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC0, 0x7E, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1,
  0xF0, 0xFF, 0x0C, 0x07, 0xF1, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0xFE, 0x03, 0xF0, 0x3E, 0x0F, 0xC1, 0xFF, 0xF3, 0xF1, 0xF8, 0x3F,
  0xFE, 0x3F, 0x1F, 0x07, 0xFF, 0xE3, 0xF3, 0xF0, 0xFF, 0xFE, 0x1F, 0x3E,
  0x1F, 0xC7, 0xE1, 0xF7, 0xE1, 0xF8, 0x7C, 0x1F, 0x7C, 0x3F, 0x07, 0xC3,
  0xF7, 0xC3, 0xF0, 0xFC, 0x3E, 0xFC, 0x3E, 0x0F, 0xC3, 0xEF, 0xC7, 0xE0,
  0xF8, 0x3E, 0xF8, 0x7E, 0x0F, 0x83, 0xEF, 0x87, 0xC1, 0xF8, 0x7E, 0xF8,
  0x7C, 0x1F, 0x87, 0xCF, 0x8F, 0xC1, 0xF0, 0x7C, 0xF8, 0xFC, 0x3F, 0x0F,
  0x8F, 0x8F, 0xC3, 0xF1, 0xF8, 0xF8, 0x7E, 0xFF, 0xBF, 0x0F, 0x87, 0xFF,
  0xFF, 0xE0, 0xF8, 0x7F, 0xEF, 0xFE, 0x0F, 0x83, 0xFC, 0xFF, 0x80, 0xF8,
  0x1F, 0x87, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x03, 0xF8, 0x00,
  0x70, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x3F, 0xF0,
  0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE,
  0x07, 0xF8, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x7C,
  0x07, 0xFE, 0x03, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x0C, 0x03, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0x83, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F,
  0x81, 0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x1F, 0xE3, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x10, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0xFC, 0x07, 0xFE, 0x00, 0xC0, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x1F, 0xFF, 0x1F, 0xE0, 0xFF, 0xF8, 0xFF,
  0x07, 0xFF, 0x87, 0xF8, 0x3F, 0xFC, 0x7F, 0xC1, 0xFF, 0xE3, 0xFE, 0x1F,
  0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC,
  0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x03,
  0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03,
  0xFC, 0xFF, 0x80, 0x03, 0xF9, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x07, 0xFF, 0xF0, 0x1F, 0xDF, 0x83, 0xF7,
  0xF0, 0x0F, 0xEF, 0xC3, 0xFB, 0xF8, 0x07, 0xF7, 0xE1, 0xFB, 0xFC, 0x07,
  0xFB, 0xF0, 0xFD, 0xFE, 0x03, 0xF9, 0xF8, 0xFE, 0xFE, 0x01, 0xFC, 0xFC,
  0x7E, 0x7F, 0x00, 0xFE, 0x7E, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0x3F, 0x3F,
  0xC0, 0x7F, 0x9F, 0xBF, 0x9F, 0xE0, 0x3F, 0x8F, 0xDF, 0x8F, 0xE0, 0x1F,
  0xC7, 0xFF, 0xC7, 0xF0, 0x0F, 0xE3, 0xFF, 0xC7, 0xF8, 0x0F, 0xF1, 0xFF,
  0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xF8, 0x7F, 0x80, 0xFF,
  0x0F, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x1F,
  0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xE0,
  0x1F, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFC,
  0x0F, 0xF0, 0x0F, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0x80, 0x7F,
  0x7F, 0x07, 0xF0, 0x0F, 0xEF, 0xE1, 0xFE, 0x01, 0xFD, 0xFC, 0x3F, 0xC0,
  0x3F, 0xBF, 0x87, 0xF0, 0x07, 0xF7, 0xF8, 0xFE, 0x01, 0xFE, 0x7F, 0x1F,
  0xC0, 0x3F, 0x8F, 0xE7, 0xF8, 0x07, 0xF1, 0xFC, 0xFE, 0x00, 0xFE, 0x3F,
  0xDF, 0xC0, 0x3F, 0xC3, 0xFB, 0xF8, 0x07, 0xF8, 0x7F, 0x7F, 0x00, 0xFE,
  0x0F, 0xEF, 0xE0, 0x1F, 0xC1, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0xFF, 0x00,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xFC, 0x03, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xFC, 0x03, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xF0, 0x0F, 0xE0, 0x0F, 0xFC, 0x01, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F,
  0xC3, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x9F,
  0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0,
  0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xDF,
  0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0,
  0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE7,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFE,
  0x3F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFC, 0xFF,
  0x80, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFE, 0x00,
  0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0x7F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF,
  0x80, 0x1F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00,
  0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x9F, 0xF8, 0x1F,
  0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xF3, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03,
  0xFC, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x87, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0x80, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x0E, 0x01, 0xFE, 0x00,
  0x80, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x80,
  0x07, 0xF8, 0x18, 0x03, 0xFE, 0x0F, 0x81, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xF0,
  0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F,
  0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F,
  0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xDF, 0xC0,
  0x01, 0xFB, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x80, 0x3F,
  0xDF, 0xC0, 0x3F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xE0, 0x1F, 0xE7, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xFC,
  0x07, 0xF1, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFF, 0x03, 0xFC,
  0x7F, 0x81, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0xC1, 0xFE, 0x1F, 0xE0,
  0xFF, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0xF8,
  0x7F, 0x83, 0xFC, 0x7F, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0x7E, 0x3F, 0xC0,
  0xFF, 0x1F, 0xBF, 0x1F, 0xC0, 0x7F, 0x9F, 0xFF, 0x9F, 0xE0, 0x3F, 0xCF,
  0xDF, 0xCF, 0xF0, 0x1F, 0xEF, 0xEF, 0xE7, 0xF0, 0x0F, 0xE7, 0xF7, 0xF7,
  0xF8, 0x07, 0xF3, 0xF3, 0xFB, 0xF8, 0x03, 0xFB, 0xF9, 0xFD, 0xFC, 0x01,
  0xFD, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x7F, 0xDF,
  0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE3, 0xF8, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE7, 0xF8,
  0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F,
  0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F,
  0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x87,
  0xF0, 0x0F, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xFB, 0xF8, 0x00, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0xC7, 0xF0, 0x3F, 0xFB, 0xF8, 0x1F,
  0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0x7F, 0x00, 0xFF, 0x9F, 0xC0, 0x1F, 0xC7, 0xF0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x9F, 0x00, 0x3F, 0x9F, 0xE0, 0x3F, 0xDF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3,
  0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x03, 0xFC,
  0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xE0, 0x3F,
  0xC7, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xF3,
  0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF7,
  0xFF, 0x83, 0xF9, 0xFF, 0x81, 0xF8, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFC, 0x08, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x02,
  0x07, 0xFC, 0x78, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xE3, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xFB, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0x00,
  0x3F, 0xF3, 0xF0, 0x01, 0xFE, 0x3F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0x07, 0xF9, 0xFC, 0x3F, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x04, 0x1F, 0xE0, 0x18, 0x3F, 0xF7, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x43, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x87, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0xEF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFD, 0xFC, 0x00, 0xFF, 0xBF,
  0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x08, 0x00, 0xFF, 0x80, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x1F,
  0x80, 0x3F, 0xBF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0x1F, 0xE1, 0xFF,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x11, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0x7F,
  0x87, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xF3, 0xFE,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x8F,
  0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0x0F, 0xCF, 0xF8, 0x7F, 0xC0, 0x7F, 0x7F, 0xF3, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x03, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F,
  0xC1, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC3,
  0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE,
  0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0,
  0x7F, 0x8F, 0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF0, 0xFC, 0x01, 0xF9, 0xFF, 0x00, 0xFD,
  0xFF, 0xC0, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F,
  0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81,
  0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFB, 0xFE, 0x1F, 0xF1, 0xFE, 0x1F,
  0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x03, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE7, 0xFC,
  0x00, 0xFE, 0xFF, 0xE0, 0x0F, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80,
  0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xFC,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xC0, 0x1F, 0xE7, 0xF0, 0x01, 0xFC,
  0x08, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0,
  0x1F, 0xF9, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xBF, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F,
  0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xCF, 0xF0, 0x00, 0x83, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0xF8, 0x1F, 0x8F,
  0xC1, 0xFC, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xC3, 0x83, 0xFC, 0x04, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x40, 0x1F, 0xE3, 0xC1, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x20, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00,
  0x60, 0x00, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3,
  0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC,
  0x7F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x8F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F,
  0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xFC,
  0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFD, 0xF8, 0x0F, 0xFC, 0xFC, 0x03, 0xFC, 0x7E, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0xFE,
  0xFF, 0x07, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0xC1, 0xFC, 0xFE, 0x0F, 0xFC,
  0x3F, 0xCF, 0xE0, 0xFF, 0xC3, 0xFC, 0xFE, 0x1F, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFF, 0xC7, 0xF8, 0xFE, 0x3F, 0xFC, 0x7F, 0x0F, 0xE3, 0xFF, 0xC7, 0xF0,
  0xFE, 0x3E, 0xFC, 0xFE, 0x0F, 0xE7, 0xEF, 0xCF, 0xE0, 0xFE, 0x7E, 0xFD,
  0xFE, 0x0F, 0xE7, 0xCF, 0xDF, 0xC0, 0xFE, 0xFC, 0xF9, 0xFC, 0x0F, 0xEF,
  0xCF, 0xBF, 0x80, 0xFF, 0xF9, 0xFB, 0xF8, 0x0F, 0xFF, 0x9F, 0xBF, 0x80,
  0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF,
  0xE0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE,
  0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xF1, 0xFE, 0x00,
  0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE,
  0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFE, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 16, 38, 14, 0, -37 },
  { 77, 20, 13, 22, 5, -37 },
  { 110, 30, 37, 28, 0, -37 },
  { 249, 25, 43, 25, 1, -40 },
  { 384, 37, 38, 41, 3, -38 },
  { 560, 31, 39, 31, 0, -38 },
  { 712, 10, 13, 13, 5, -37 },
  { 729, 19, 46, 16, 1, -38 },
  { 839, 19, 46, 16, -4, -38 },
  { 949, 22, 24, 24, 4, -40 },
  { 1015, 23, 25, 27, 2, -31 },
  { 1087, 13, 14, 14, -3, -7 },
  { 1110, 14, 7, 16, 1, -17 },
  { 1123, 9, 9, 14, 0, -8 },
  { 1134, 28, 38, 21, -3, -38 },
  { 1267, 24, 39, 25, 1, -38 },
  { 1384, 19, 37, 25, 5, -37 },
  { 1472, 27, 38, 25, -2, -38 },
  { 1601, 25, 39, 25, 0, -38 },
  { 1723, 26, 37, 25, -1, -37 },
  { 1844, 25, 38, 25, 1, -37 },
  { 1963, 25, 39, 25, 2, -38 },
  { 2085, 27, 37, 25, 1, -37 },
  { 2210, 25, 39, 25, 1, -38 },
  { 2332, 24, 39, 25, 1, -38 },
  { 2449, 14, 30, 14, 0, -29 },
  { 2502, 17, 36, 14, -3, -29 },
  { 2579, 23, 26, 27, 2, -32 },
  { 2654, 23, 17, 27, 2, -27 },
  { 2703, 23, 26, 27, 2, -32 },
  { 2778, 20, 39, 20, 2, -38 },
  { 2876, 36, 41, 38, 2, -37 },
  { 3061, 28, 37, 28, -3, -37 },
  { 3191, 28, 37, 28, 0, -37 },
  { 3321, 27, 39, 26, 2, -38 },
  { 3453, 29, 37, 30, 0, -37 },
  { 3588, 26, 37, 23, 0, -37 },
  { 3709, 26, 37, 23, 0, -37 },
  { 3830, 29, 39, 30, 2, -38 },
  { 3972, 32, 37, 31, 0, -37 },
  { 4120, 24, 37, 19, -2, -37 },
  { 4231, 24, 48, 15, -8, -37 },
  { 4375, 32, 37, 28, 0, -37 },
  { 4523, 20, 37, 22, 0, -37 },
  { 4616, 41, 37, 40, 0, -37 },
  { 4806, 35, 37, 33, 0, -37 },
  { 4968, 29, 39, 32, 2, -38 },
  { 5110, 28, 37, 27, 0, -37 },
  { 5240, 29, 47, 32, 2, -38 },
  { 5411, 27, 37, 27, 0, -37 },
  { 5536, 26, 39, 24, 0, -38 },
  { 5663, 23, 37, 23, 4, -37 },
  { 5770, 30, 38, 30, 2, -37 },
  { 5913, 27, 37, 27, 5, -37 },
  { 6038, 41, 37, 40, 4, -37 },
  { 6228, 34, 37, 27, -3, -37 },
  { 6386, 25, 37, 26, 5, -37 },
  { 6502, 29, 37, 23, -2, -37 },
  { 6637, 22, 46, 16, -2, -38 },
  { 6764, 12, 38, 21, 5, -38 },
  { 6821, 22, 46, 16, -4, -38 },
  { 6948, 25, 23, 25, 0, -37 },
  { 7020, 21, 5, 19, -5, 4 },
  { 7034, 11, 8, 17, 7, -40 },
  { 7045, 26, 30, 27, 1, -29 },
  { 7143, 25, 41, 27, 0, -40 },
  { 7272, 22, 30, 22, 1, -29 },
  { 7355, 28, 41, 27, 1, -40 },
  { 7499, 23, 30, 25, 1, -29 },
  { 7586, 29, 52, 17, -6, -40 },
  { 7775, 28, 41, 27, -1, -29 },
  { 7919, 25, 40, 27, 0, -40 },
  { 8044, 16, 40, 14, 0, -40 },
  { 8124, 23, 52, 14, -7, -40 },
  { 8274, 28, 40, 26, 0, -40 },
  { 8414, 16, 40, 13, 0, -40 },
  { 8494, 38, 29, 40, 0, -29 },
  { 8632, 25, 29, 27, 0, -29 },
  { 8723, 24, 30, 26, 1, -29 },
  { 8813, 28, 41, 27, -3, -29 },
  { 8957, 26, 41, 27, 1, -29 },
  { 9091, 21, 29, 19, 0, -29 },
  { 9168, 21, 30, 21, 0, -29 },
  { 9247, 18, 35, 18, 2, -34 },
  { 9326, 25, 30, 27, 2, -29 },
  { 9420, 24, 29, 24, 3, -29 },
  { 9507, 36, 29, 36, 3, -29 },
  { 9638, 30, 29, 24, -3, -29 },
  { 9747, 31, 41, 24, -4, -29 },
  { 9906, 24, 29, 21, -2, -29 },
  { 9993, 22, 45, 18, 0, -37 },
  { 10117, 6, 52, 23, 8, -40 },
  { 10156, 21, 45, 18, -3, -37 },
  { 10275, 23, 9, 27, 2, -23 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC52PT7B_H_
