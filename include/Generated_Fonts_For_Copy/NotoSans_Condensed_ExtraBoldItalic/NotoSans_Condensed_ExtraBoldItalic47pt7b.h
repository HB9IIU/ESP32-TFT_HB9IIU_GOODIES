#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC47PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0x9F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0xFC, 0x3E,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x80, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFC, 0xC7, 0x03, 0xF3, 0x04, 0x1F, 0xDC, 0x00, 0x7F, 0x70, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x67, 0xF2, 0x01, 0x9F, 0x8C, 0x06, 0x7E, 0x3C, 0x3B,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xFC, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7C,
  0x03, 0xFF, 0xC0, 0x7E, 0x03, 0xF3, 0xE0, 0x3E, 0x01, 0xF1, 0xF0, 0x3E,
  0x00, 0xF8, 0xF8, 0x3F, 0x00, 0xFC, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x1F,
  0x80, 0x3E, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0xCF,
  0xC0, 0x07, 0xC7, 0xC7, 0xC1, 0x83, 0xE3, 0xE7, 0xC7, 0xF9, 0xF3, 0xF7,
  0xE7, 0xFE, 0xFF, 0xF3, 0xE7, 0xFF, 0x7F, 0xF3, 0xF3, 0xFF, 0xFF, 0xF9,
  0xF3, 0xF7, 0xEF, 0xF9, 0xF1, 0xF1, 0xF1, 0xF1, 0xF9, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x7E, 0x00, 0x7C, 0x7E, 0x3F, 0x00,
  0x7C, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x8F, 0xC0,
  0x3F, 0x07, 0xC7, 0xE0, 0x1F, 0x03, 0xE3, 0xE0, 0x1F, 0x01, 0xFB, 0xF0,
  0x1F, 0x80, 0xFF, 0xF0, 0x0F, 0x80, 0x3F, 0xF0, 0x0F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xCF, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x07, 0xF0, 0x7F, 0xF8, 0x7F, 0x0F, 0xFF, 0x8F, 0xE1,
  0xFF, 0xFC, 0xFE, 0x3F, 0xDF, 0xDF, 0xC7, 0xF9, 0xFF, 0xFC, 0x7F, 0x1F,
  0xFF, 0x87, 0xF0, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F,
  0x80, 0xFF, 0x87, 0xFC, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x8F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x06, 0x0F, 0x80, 0xF1, 0xF0, 0x1F, 0xBE, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0x82, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFB, 0xF0, 0xFF, 0x7E, 0x07, 0xC7, 0xE0, 0x70, 0xFC,
  0x06, 0x1E, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0,
  0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x80,
  0x0C, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x30, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1,
  0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F,
  0x9F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x3F, 0xFF, 0xC7, 0xF7, 0xF1, 0xFB, 0xF8, 0x3C, 0xFE, 0x04,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xF9, 0xFE, 0x01, 0xE0, 0xFF, 0x01,
  0xC0, 0xFE, 0x00, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xF8,
  0xFF, 0x80, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE2, 0x00, 0x3F, 0xC6, 0x00,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3E, 0xFE, 0x00,
  0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xC7, 0xF0, 0x1F, 0x0F, 0xC0, 0x7E,
  0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xE0, 0xFE, 0x0F, 0x81, 0xFC, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x40, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1E, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE2,
  0x00, 0x7F, 0xC7, 0x01, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0x81, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0xF8,
  0x07, 0xF7, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF0, 0xFC,
  0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0xBF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF8, 0x3F, 0x87, 0xF8, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F,
  0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0xDF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xF7, 0xF0, 0x3F, 0x9F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x30, 0x00,
  0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xE1, 0xFC, 0x60, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x7F, 0x87, 0xC3, 0xE0,
  0xFF, 0xF3, 0xE3, 0xF0, 0xFF, 0xF1, 0xF1, 0xF0, 0xFF, 0xF8, 0xF9, 0xF8,
  0xFC, 0x7C, 0x7C, 0xF8, 0x7C, 0x3E, 0x3E, 0x7C, 0x7C, 0x3E, 0x1F, 0x7C,
  0x3E, 0x1F, 0x0F, 0xBE, 0x3E, 0x0F, 0x87, 0xDF, 0x1F, 0x07, 0xC3, 0xCF,
  0x8F, 0x87, 0xE3, 0xE7, 0x87, 0xC3, 0xE1, 0xF3, 0xC7, 0xE1, 0xF0, 0xF3,
  0xE3, 0xE1, 0xF8, 0xF9, 0xF1, 0xF8, 0xFC, 0x78, 0xF8, 0x7D, 0xFE, 0xFC,
  0x7C, 0x3F, 0xFF, 0xFC, 0x3E, 0x1F, 0xF7, 0xFC, 0x0F, 0x07, 0xF1, 0xFC,
  0x07, 0xC0, 0xE0, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0x0F, 0xFD, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x9F,
  0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE,
  0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80,
  0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF3, 0xF8, 0x03, 0xFD, 0xFE,
  0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xE3, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8,
  0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x07, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0xFF, 0x81,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0xFF,
  0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFE, 0x7C, 0x0F, 0xF8, 0x08, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x40, 0xFF, 0x81, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xE1, 0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF0,
  0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0x81, 0xFF, 0x0F,
  0xE0, 0x7F, 0x83, 0xF8, 0x7F, 0xC0, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x04, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xF1, 0xF0, 0x3F, 0xE0, 0x0C, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x1F,
  0xFC, 0x7F, 0x07, 0xFF, 0x3F, 0xC3, 0xFF, 0xCF, 0xF0, 0xFF, 0xE3, 0xFC,
  0x3F, 0xF8, 0xFF, 0x0F, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x02, 0x1F, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F,
  0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00,
  0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80,
  0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xBF, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x0F, 0xDF, 0x8F, 0xDF, 0xC0, 0x7E, 0xFC, 0x7E, 0xFE, 0x07,
  0xF3, 0xE7, 0xE7, 0xF0, 0x3F, 0x9F, 0x3F, 0x3F, 0x01, 0xFC, 0xF9, 0xF3,
  0xF8, 0x0F, 0xC7, 0xDF, 0x9F, 0xC0, 0x7E, 0x3E, 0xF8, 0xFE, 0x07, 0xF1,
  0xFF, 0xC7, 0xF0, 0x3F, 0x8F, 0xFE, 0x3F, 0x01, 0xFC, 0x7F, 0xE3, 0xF8,
  0x0F, 0xC3, 0xFF, 0x1F, 0xC0, 0x7E, 0x1F, 0xF0, 0xFE, 0x07, 0xF0, 0xFF,
  0x87, 0xE0, 0x3F, 0x87, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xC3, 0xF8, 0x0F,
  0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x01, 0xFC, 0x07, 0xFC,
  0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x3F, 0xF0, 0x0F, 0xC0, 0x7F, 0xE0,
  0x1F, 0x80, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0x81,
  0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFF, 0x0F, 0xE0, 0x3F, 0xFE, 0x1F,
  0xC0, 0x7F, 0xFC, 0x3F, 0x80, 0xFD, 0xF8, 0x7F, 0x03, 0xFB, 0xF0, 0xFC,
  0x07, 0xF7, 0xF3, 0xF8, 0x0F, 0xCF, 0xE7, 0xF0, 0x1F, 0x8F, 0xCF, 0xE0,
  0x7F, 0x1F, 0x9F, 0x80, 0xFE, 0x3F, 0xBF, 0x01, 0xFC, 0x7F, 0x7E, 0x03,
  0xF0, 0xFF, 0xFC, 0x07, 0xE0, 0xFF, 0xF8, 0x1F, 0xC1, 0xFF, 0xE0, 0x3F,
  0x83, 0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x01, 0xF8,
  0x0F, 0xFE, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0,
  0x7F, 0xE0, 0x3F, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xC7,
  0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3, 0xFC,
  0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xE0, 0x07, 0xF7,
  0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83,
  0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC7, 0xFC, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xE0,
  0x07, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE7, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8,
  0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0x87, 0xFC, 0x1F, 0xCF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0xC0,
  0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xF8, 0x0C, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0x00, 0x1F, 0xC3, 0x80,
  0x7F, 0x87, 0xC1, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F,
  0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x87, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xCF,
  0xE0, 0x1F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8,
  0xFE, 0x03, 0xF8, 0x3F, 0x03, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xFE,
  0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F,
  0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xCF,
  0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xBF, 0x80, 0x7E, 0x01, 0xFD,
  0xFC, 0x07, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xFC,
  0x07, 0xF3, 0xF8, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0xC1, 0xFC, 0x3F, 0x87, 0xFE, 0x0F,
  0xE1, 0xFC, 0x3F, 0xF0, 0xFE, 0x0F, 0xE3, 0xFF, 0x87, 0xF0, 0x7F, 0x1F,
  0xFC, 0x3F, 0x83, 0xF8, 0xFB, 0xE3, 0xF8, 0x1F, 0xCF, 0xFF, 0x1F, 0xC0,
  0xFE, 0x7F, 0xF9, 0xFC, 0x07, 0xE7, 0xEF, 0xCF, 0xE0, 0x3F, 0x3F, 0x7E,
  0x7F, 0x01, 0xF9, 0xFB, 0xF7, 0xF0, 0x0F, 0xDF, 0x9F, 0xBF, 0x80, 0x7E,
  0xFC, 0xFD, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFE,
  0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xE7,
  0xF0, 0x7F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x3F,
  0x9F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xBE, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0x03, 0xF0,
  0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x3F, 0xC7, 0xF0, 0xFC, 0x3F, 0x87, 0xE0, 0xF8,
  0x3F, 0x00, 0xFC, 0x7E, 0x07, 0xFC, 0xFC, 0x1F, 0xFB, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xE1, 0xFE,
  0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF8, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xF7, 0xE0, 0x3F, 0xCF,
  0xC0, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xCF, 0xC0,
  0x3F, 0xBF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xE0, 0x7F, 0x8F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F,
  0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xF7, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xF3, 0xFE, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xE0, 0x83, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0x0F,
  0xF0, 0x60, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0x3F, 0x80, 0x7F, 0xDF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFF, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF8, 0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFB, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xF1, 0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xFB, 0xF8, 0x3F,
  0x9F, 0xC7, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x01, 0x07, 0xF0, 0x38, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x7F, 0xCF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xF7, 0xF0, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0x00, 0x7F, 0x01, 0xFD,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xCF, 0xC0, 0x3F, 0xBF, 0xC0, 0x7E, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x00, 0x00, 0x78, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x03, 0xFC, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x7F,
  0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB,
  0xFC, 0x00, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x3F,
  0x00, 0xFC, 0xFF, 0x1F, 0xF0, 0x1F, 0xBF, 0xF7, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC,
  0x7F, 0xC7, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3,
  0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xF0, 0x1F, 0xBF, 0xF0, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xF8,
  0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7,
  0xF8, 0x7F, 0x3F, 0x83, 0xFB, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07,
  0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0xFE,
  0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x83, 0xF9, 0xFE, 0x3F, 0xC7, 0xFB, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFF, 0x00, 0x7E, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0x7F, 0xE0, 0x3F, 0xBF, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x7E, 0x07, 0xFC, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7E, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE3, 0xE0,
  0xFC, 0xFC, 0x1F, 0xBF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xC7, 0x87, 0xF0, 0x20, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x60, 0x3F, 0x8F, 0x9F,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x60, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0x7E, 0x07, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x3F, 0xEF, 0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xBF,
  0x81, 0xFD, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x9F, 0xC1, 0xFC,
  0xFE, 0x0F, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x1F, 0xF0, 0x7E, 0xFC,
  0x1F, 0xF0, 0xFE, 0xFC, 0x1F, 0xF0, 0xFE, 0xFC, 0x3F, 0xE1, 0xFC, 0xFC,
  0x3F, 0xE1, 0xFC, 0xFC, 0x3F, 0xE1, 0xF8, 0xFC, 0x7F, 0xE3, 0xF8, 0xFC,
  0x7F, 0xE3, 0xF8, 0xFC, 0xFF, 0xE7, 0xF0, 0xFC, 0xFB, 0xE7, 0xF0, 0xFC,
  0xFB, 0xE7, 0xE0, 0xFD, 0xFB, 0xEF, 0xE0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFD,
  0xF3, 0xEF, 0xC0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x80, 0xFF,
  0xE3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE3, 0xFC,
  0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE7,
  0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0x0B, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x03, 0xFC, 0x80,
  0x01, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 35, 13, 0, -34 },
  { 67, 18, 13, 20, 4, -34 },
  { 97, 27, 34, 26, 0, -34 },
  { 212, 22, 39, 23, 1, -36 },
  { 320, 33, 34, 37, 3, -34 },
  { 461, 28, 34, 28, 0, -34 },
  { 580, 9, 13, 11, 4, -34 },
  { 595, 17, 41, 14, 1, -34 },
  { 683, 17, 41, 14, -4, -34 },
  { 771, 19, 21, 22, 4, -36 },
  { 821, 21, 23, 24, 2, -28 },
  { 882, 12, 12, 12, -3, -6 },
  { 900, 13, 7, 14, 1, -16 },
  { 912, 8, 9, 12, 0, -8 },
  { 921, 25, 34, 19, -2, -34 },
  { 1028, 22, 34, 23, 1, -34 },
  { 1122, 18, 34, 23, 4, -34 },
  { 1199, 24, 34, 23, -1, -34 },
  { 1301, 23, 34, 23, 0, -34 },
  { 1399, 23, 34, 23, 0, -34 },
  { 1497, 23, 34, 23, 0, -34 },
  { 1595, 23, 34, 23, 1, -34 },
  { 1693, 24, 34, 23, 1, -34 },
  { 1795, 23, 34, 23, 0, -34 },
  { 1893, 22, 34, 23, 1, -34 },
  { 1987, 12, 27, 13, 0, -26 },
  { 2028, 15, 32, 13, -3, -26 },
  { 2088, 21, 24, 24, 2, -29 },
  { 2151, 21, 15, 24, 2, -24 },
  { 2191, 21, 24, 24, 2, -29 },
  { 2254, 18, 35, 18, 2, -34 },
  { 2333, 33, 38, 35, 1, -34 },
  { 2490, 26, 34, 26, -3, -34 },
  { 2601, 25, 34, 25, 0, -34 },
  { 2708, 24, 34, 24, 2, -34 },
  { 2810, 26, 34, 27, 0, -34 },
  { 2921, 23, 34, 21, 0, -34 },
  { 3019, 23, 34, 21, 0, -34 },
  { 3117, 26, 34, 27, 2, -34 },
  { 3228, 29, 34, 28, 0, -34 },
  { 3352, 22, 34, 17, -2, -34 },
  { 3446, 22, 44, 13, -7, -34 },
  { 3567, 29, 34, 25, 0, -34 },
  { 3691, 18, 34, 20, 0, -34 },
  { 3768, 37, 34, 36, 0, -34 },
  { 3926, 31, 34, 30, 0, -34 },
  { 4058, 26, 34, 29, 2, -34 },
  { 4169, 25, 34, 24, 0, -34 },
  { 4276, 26, 42, 29, 2, -34 },
  { 4413, 25, 34, 25, 0, -34 },
  { 4520, 23, 34, 21, 0, -34 },
  { 4618, 21, 34, 21, 4, -34 },
  { 4708, 27, 34, 27, 2, -34 },
  { 4823, 25, 34, 25, 4, -34 },
  { 4930, 37, 34, 37, 4, -34 },
  { 5088, 31, 34, 24, -3, -34 },
  { 5220, 23, 34, 23, 4, -34 },
  { 5318, 26, 34, 21, -2, -34 },
  { 5429, 20, 42, 14, -2, -34 },
  { 5534, 11, 34, 19, 5, -34 },
  { 5581, 19, 42, 14, -3, -34 },
  { 5681, 22, 22, 22, 0, -34 },
  { 5742, 18, 4, 18, -4, 4 },
  { 5751, 10, 8, 15, 7, -36 },
  { 5761, 23, 26, 24, 1, -26 },
  { 5836, 23, 36, 24, 0, -36 },
  { 5940, 20, 26, 20, 1, -26 },
  { 6005, 25, 36, 24, 1, -36 },
  { 6118, 21, 26, 22, 1, -26 },
  { 6187, 25, 47, 15, -5, -36 },
  { 6334, 25, 37, 24, -1, -26 },
  { 6450, 23, 36, 24, 0, -36 },
  { 6554, 14, 36, 12, 0, -36 },
  { 6617, 20, 47, 12, -6, -36 },
  { 6735, 26, 36, 23, 0, -36 },
  { 6852, 15, 36, 12, 0, -36 },
  { 6920, 35, 26, 36, 0, -26 },
  { 7034, 23, 26, 24, 0, -26 },
  { 7109, 21, 26, 24, 1, -26 },
  { 7178, 25, 37, 24, -2, -26 },
  { 7294, 23, 37, 24, 1, -26 },
  { 7401, 19, 26, 17, 0, -26 },
  { 7463, 19, 26, 19, 0, -26 },
  { 7525, 16, 31, 16, 2, -31 },
  { 7587, 23, 26, 24, 1, -26 },
  { 7662, 21, 26, 21, 3, -26 },
  { 7731, 32, 26, 32, 3, -26 },
  { 7835, 26, 26, 22, -2, -26 },
  { 7920, 27, 37, 22, -3, -26 },
  { 8045, 22, 26, 19, -2, -26 },
  { 8117, 20, 41, 16, 0, -34 },
  { 8220, 6, 47, 20, 7, -36 },
  { 8256, 19, 41, 16, -3, -34 },
  { 8354, 21, 9, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC47PT7B_H_
