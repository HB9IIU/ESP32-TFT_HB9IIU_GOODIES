#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC30PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x38, 0x3C, 0x3E, 0x1F, 0x0F,
  0x00, 0x79, 0xEF, 0x3D, 0xEF, 0x79, 0xEF, 0x3D, 0xE7, 0xB8, 0xE0, 0x01,
  0xE7, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x79, 0xC0, 0x39, 0xE1, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x87, 0x9C, 0x03, 0x8E, 0x01, 0xCF,
  0x07, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x39, 0xC0, 0x3C, 0xE0, 0x1C,
  0x70, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x3C, 0x00, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0xC0, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x87, 0xF7, 0x0F, 0x60, 0x1E,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x01, 0xBC, 0x43, 0x78, 0xC7, 0xF1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x07,
  0xF0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x1E,
  0x0F, 0xE0, 0xE0, 0xFF, 0x0F, 0x07, 0x38, 0x70, 0x79, 0xC7, 0x03, 0x8E,
  0x78, 0x1C, 0xF3, 0x80, 0xE7, 0xBC, 0x07, 0x39, 0xCF, 0x3B, 0xDC, 0xFD,
  0xFD, 0xEF, 0xFF, 0xCE, 0xF7, 0x9C, 0xF7, 0xBC, 0x07, 0x39, 0xE0, 0x71,
  0xCF, 0x07, 0x9E, 0x70, 0x38, 0xF3, 0x83, 0xC7, 0xBC, 0x3C, 0x3F, 0xC1,
  0xC0, 0xFE, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x7C, 0x7F, 0x9F, 0x3F, 0xE7, 0x9F, 0x7F,
  0xE7, 0x9F, 0xF3, 0xE3, 0xFC, 0xF8, 0xFE, 0x3E, 0x1F, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xE7, 0xC0, 0x7B, 0xDF, 0xEF, 0x7B, 0xC0,
  0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1F,
  0x07, 0x83, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x11,
  0xE0, 0xCF, 0x07, 0xF1, 0xFF, 0xFD, 0xFF, 0xE1, 0xFF, 0x1F, 0x81, 0xFE,
  0x1E, 0x70, 0x73, 0xC1, 0x1C, 0x00, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0x1E,
  0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x7F, 0xBF, 0x9F, 0xDF, 0xE0, 0x3B,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xFE, 0x3F, 0xF1, 0xE7, 0x9F, 0x3C,
  0xF1, 0xEF, 0x8F, 0x7C, 0x7B, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xF8,
  0x7F, 0xC3, 0xDE, 0x3E, 0xF1, 0xF7, 0x9F, 0x3F, 0xF9, 0xFF, 0x87, 0xF8,
  0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x7F, 0x1F, 0xE7, 0xFD, 0xFF, 0xBD, 0xE3,
  0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xF8, 0x1F,
  0xF8, 0x7F, 0xF0, 0xF3, 0xE0, 0xC3, 0xC1, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE,
  0x00, 0x00, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xE7, 0xE1, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0x03, 0xF3, 0xFF,
  0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xBC, 0x0E, 0xF8,
  0x3D, 0xF0, 0xF3, 0xC1, 0xC7, 0x87, 0x8F, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFC, 0xFF, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x07,
  0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x87, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x81, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0xC3, 0xFF, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7D, 0xE1, 0xEF, 0xC7, 0xFF, 0x3F, 0xFE,
  0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBC, 0x3C, 0xF1, 0xF3, 0xE7, 0xCF, 0xFE,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xE0,
  0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF1, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x8F,
  0x9E, 0x1F, 0x78, 0x1F, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xFF, 0x0F, 0x9F,
  0x1E, 0x3E, 0x7C, 0x3C, 0xF8, 0x79, 0xF1, 0xF3, 0xF7, 0xC3, 0xFF, 0x87,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x7F, 0xF3, 0xEF,
  0xBE, 0x3D, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0xDF, 0x7E, 0xFF, 0xF7,
  0xFF, 0x9F, 0x78, 0x67, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x3F, 0xF1, 0xFF,
  0x0F, 0xF0, 0x7E, 0x00, 0x06, 0x1F, 0x1F, 0x1F, 0x1E, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x78, 0xF8, 0xF8, 0xF0, 0x01, 0x81, 0xF0,
  0x7C, 0x1F, 0x07, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x3F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x00,
  0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x03, 0xFC, 0x7F,
  0x87, 0xF8, 0x3F, 0x80, 0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x07, 0x81,
  0xFE, 0x7F, 0xE3, 0xFF, 0x39, 0xF2, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xC0, 0xF0, 0x0F, 0x0F, 0x00, 0x38, 0xF1,
  0xF8, 0xE7, 0x1F, 0xE7, 0x79, 0xFF, 0x3B, 0x9E, 0x71, 0xDC, 0xE3, 0x8F,
  0xC7, 0x1C, 0xEE, 0x79, 0xE7, 0x73, 0x8E, 0x3B, 0x9C, 0x73, 0x9C, 0xE7,
  0x9C, 0xE7, 0xFF, 0xC7, 0x1F, 0x7C, 0x38, 0x61, 0xC1, 0xE0, 0x00, 0x07,
  0x80, 0x20, 0x3F, 0x0E, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xEF, 0x01, 0xEF,
  0x03, 0xEF, 0x03, 0xCF, 0x07, 0xCF, 0x07, 0x8F, 0x07, 0x8F, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3E, 0x0F, 0x3E, 0x0F, 0x7C, 0x0F,
  0x7C, 0x0F, 0xF8, 0x0F, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x3F,
  0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x3C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x70,
  0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x8C, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x10, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E,
  0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0xF9,
  0xF0, 0xF8, 0xF8, 0xFC, 0x7C, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF,
  0xC1, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFC, 0xF0, 0xF8, 0x08,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x3F, 0xCF, 0x1F,
  0xCF, 0x8F, 0xE7, 0xC7, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x3E,
  0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0x83,
  0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x83, 0xE0, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0xC0,
  0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x17, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0,
  0x08, 0x00, 0x0F, 0x87, 0xE1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x8F, 0x80,
  0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x0F, 0x01, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0xC0, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xBC,
  0x1F, 0xE7, 0xFC, 0x3F, 0xE7, 0x7C, 0x3D, 0xEF, 0x78, 0x3D, 0xEE, 0x78,
  0x3D, 0xFE, 0x78, 0x7D, 0xFE, 0xF8, 0x7D, 0xFC, 0xF8, 0x79, 0xFC, 0xF0,
  0x78, 0xF8, 0xF0, 0x78, 0xF8, 0xF0, 0xF8, 0xF1, 0xF0, 0xF0, 0xF1, 0xE0,
  0x0F, 0xC0, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xE0, 0xFE, 0x1E, 0x0F, 0xE1,
  0xE1, 0xFE, 0x3E, 0x1F, 0xE3, 0xE1, 0xFF, 0x3C, 0x1E, 0xF3, 0xC1, 0xEF,
  0x3C, 0x3E, 0xF7, 0xC3, 0xCF, 0x78, 0x3C, 0xFF, 0x83, 0xC7, 0xF8, 0x7C,
  0x7F, 0x87, 0x87, 0xF8, 0x78, 0x7F, 0x07, 0x83, 0xF0, 0x78, 0x3F, 0x0F,
  0x83, 0xF0, 0xF0, 0x3F, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xE1, 0xF9, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x7C, 0x0F,
  0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x01, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x1E, 0x7E,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF8, 0xF8, 0x7C, 0xF8,
  0x3E, 0x7C, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x01, 0xFF,
  0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E, 0x3E,
  0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0x3F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E,
  0x1E, 0x3E, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x3C, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0x00, 0xE0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE1, 0xFB, 0xC3,
  0xE1, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x81, 0xF1, 0x83, 0xE3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xE7,
  0xFF, 0xBF, 0xFE, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC3, 0xE3, 0xC1, 0xE3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3C, 0x1E, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0x83,
  0xE3, 0xC1, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xF7,
  0x83, 0xEF, 0x0F, 0x9E, 0x1F, 0x3C, 0x3C, 0x78, 0xF8, 0xF1, 0xE1, 0xE7,
  0xC3, 0xCF, 0x07, 0xBE, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x78, 0x3C,
  0x1F, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x3E, 0x78, 0x7C, 0x3C, 0x78, 0xFC,
  0x3C, 0x78, 0xFC, 0x7C, 0x78, 0xFC, 0x78, 0x79, 0xFC, 0xF8, 0x79, 0xFC,
  0xF0, 0x7B, 0xFC, 0xF0, 0xFB, 0xFD, 0xF0, 0xFF, 0xBD, 0xE0, 0xFF, 0xBF,
  0xE0, 0xF7, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xC3, 0xF0, 0x3C, 0x3E, 0x03, 0xC7, 0xC0, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xBC, 0x00, 0xFB, 0xC0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0, 0x3E, 0x3E,
  0x07, 0xC3, 0xE0, 0xFC, 0x1F, 0x00, 0xF0, 0x7F, 0xE3, 0xEF, 0x8F, 0xBE,
  0x7C, 0x79, 0xF1, 0xEF, 0x87, 0xBC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xF1, 0xE3, 0xC7, 0x87, 0x0F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xF1,
  0xE3, 0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xF7, 0x87, 0x9E, 0x1E, 0x78, 0xF0,
  0xE7, 0x83, 0xDE, 0x0F, 0xF0, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0xF8, 0xF1, 0xE1, 0xE0, 0x07, 0x00, 0x7E, 0xF1, 0xFF, 0xCF, 0xFF, 0x7E,
  0xFD, 0xF1, 0xE7, 0x87, 0xBE, 0x1E, 0xF8, 0xFB, 0xE3, 0xEF, 0x0F, 0x3C,
  0x7C, 0xF1, 0xF3, 0xEF, 0xCF, 0xFE, 0x3F, 0xF8, 0x7D, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xDC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7C, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0x87,
  0xCF, 0x0F, 0x3E, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xE3, 0xFF, 0xCF,
  0xFF, 0x1E, 0xFC, 0x3D, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0x1F, 0xF3, 0xFE,
  0x7E, 0x27, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF8, 0x4F, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x07, 0x3C, 0x1F, 0xBC,
  0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0xFC, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF9, 0xF0, 0xFB, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7D, 0xE0, 0x03, 0xC0, 0x7F, 0x87, 0xFE, 0x7F,
  0xF7, 0xC7, 0xBC, 0x3D, 0xE3, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x7C, 0x23, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x0F, 0xBC, 0x3F, 0xF8, 0xFF, 0xF3, 0xF7, 0xE7, 0xC7, 0x8F, 0x0F, 0x3E,
  0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F, 0x8F, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF8, 0x3E, 0xF0, 0x03, 0xE0, 0x07, 0xC4, 0x0F, 0x0F,
  0x7E, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xDC, 0x0F, 0x7E, 0x1F, 0xFC,
  0x3F, 0xFC, 0x7C, 0xF9, 0xF1, 0xF3, 0xE3, 0xC7, 0x87, 0x8F, 0x1F, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF8, 0xF1, 0xE1, 0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1E,
  0x3E, 0x3C, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x20, 0x00, 0x00, 0x3E,
  0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E,
  0x0F, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x1E, 0x3E,
  0x1E, 0x7C, 0x1E, 0xF8, 0x3E, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7D, 0xF0, 0x79, 0xF0, 0x79, 0xF0, 0xF8, 0xF0,
  0xF8, 0xF8, 0xF0, 0xF8, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C,
  0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x70, 0x70, 0x7B, 0xF7, 0xE1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0x3E, 0x7C, 0xF8, 0xF9, 0xF3, 0xE3,
  0xC7, 0xCF, 0x0F, 0x1F, 0x3C, 0x7C, 0x78, 0xF1, 0xF1, 0xE7, 0xC7, 0x8F,
  0x9F, 0x1E, 0x3E, 0x78, 0xF8, 0xF1, 0xE3, 0xE3, 0xCF, 0x8F, 0x0F, 0x3E,
  0x3C, 0x7C, 0xF0, 0xF1, 0xF0, 0x00, 0x70, 0x3D, 0xF8, 0x7F, 0xF0, 0xFF,
  0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0x1E, 0x1E, 0x3C, 0x7C, 0x78, 0xF9,
  0xF1, 0xE3, 0xE3, 0xC7, 0x87, 0x8F, 0x1F, 0x3E, 0x3E, 0x7C, 0x78, 0xF8,
  0xF0, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x7F, 0xF7, 0xCF, 0xBE, 0x3D, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xEF, 0x1F, 0x7D, 0xF3,
  0xFF, 0x8F, 0xF8, 0x3F, 0x00, 0x00, 0x1C, 0x03, 0xDF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7C, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x3C, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x3E, 0xF1,
  0xFF, 0xCF, 0xFF, 0x7C, 0xFD, 0xF1, 0xE7, 0x87, 0xBE, 0x1E, 0xF8, 0xFB,
  0xC3, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8,
  0x7D, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x71, 0xEF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE3, 0xF0, 0x3E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0x81, 0xFF, 0x1F, 0xF3, 0xFE, 0x3C, 0x23,
  0xC0, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x83, 0xEF,
  0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x7F,
  0xDF, 0xFF, 0xFC, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F,
  0x83, 0xE0, 0xFB, 0x3F, 0xC7, 0xF1, 0xFC, 0x3E, 0x3C, 0xF0, 0xF3, 0xC7,
  0xDF, 0x1F, 0x7C, 0x79, 0xF1, 0xE7, 0x87, 0x9E, 0x3E, 0xF8, 0xFB, 0xE3,
  0xCF, 0x1F, 0x3C, 0x7C, 0xFF, 0xF3, 0xFF, 0xCF, 0xEE, 0x1F, 0x78, 0xF0,
  0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0x1E, 0x79, 0xE3, 0xCF, 0x1E, 0xF8,
  0xF7, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xF1, 0xF0, 0xFF, 0x1F, 0x1F, 0xF3, 0xF1, 0xEF, 0x3F, 0x3E, 0xF3,
  0xF3, 0xCF, 0x7F, 0x3C, 0xF7, 0x77, 0x8F, 0xF7, 0x78, 0xFF, 0x7F, 0x8F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0,
  0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0x0F, 0x8F, 0x83, 0xCF, 0x81, 0xE7, 0x80,
  0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0x81, 0xF3, 0xC1, 0xF1,
  0xF1, 0xF8, 0xF8, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xC0,
  0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x03, 0xBC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x80, 0x3C, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7F, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0xFE, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3F, 0x00, 0xF0, 0x3F,
  0x07, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0xFE, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x7E, 0x07, 0xFF, 0x7F, 0xFF, 0xF9,
  0xFF, 0x81, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 11, 7, 13, 3, -21 },
  { 35, 17, 21, 16, 0, -21 },
  { 80, 15, 25, 14, 0, -23 },
  { 127, 21, 22, 24, 2, -22 },
  { 185, 18, 22, 18, 0, -22 },
  { 235, 5, 7, 7, 3, -21 },
  { 240, 10, 27, 9, 1, -22 },
  { 274, 10, 27, 9, -2, -22 },
  { 308, 13, 14, 14, 2, -23 },
  { 331, 14, 15, 15, 1, -18 },
  { 358, 8, 8, 8, -2, -4 },
  { 366, 9, 4, 9, 0, -10 },
  { 371, 5, 5, 8, 0, -5 },
  { 375, 17, 22, 12, -2, -22 },
  { 422, 13, 22, 14, 1, -22 },
  { 458, 11, 21, 15, 3, -21 },
  { 487, 15, 22, 14, -1, -22 },
  { 529, 15, 22, 14, 0, -22 },
  { 571, 15, 21, 15, 0, -21 },
  { 611, 15, 21, 14, 0, -21 },
  { 651, 14, 22, 14, 1, -22 },
  { 690, 15, 21, 14, 1, -21 },
  { 730, 15, 22, 14, 0, -22 },
  { 772, 13, 22, 14, 1, -22 },
  { 808, 8, 17, 8, 0, -17 },
  { 825, 10, 21, 8, -2, -17 },
  { 852, 14, 15, 15, 1, -18 },
  { 879, 14, 9, 15, 1, -15 },
  { 895, 14, 15, 15, 1, -18 },
  { 922, 12, 22, 12, 1, -22 },
  { 955, 21, 24, 22, 1, -22 },
  { 1018, 16, 21, 16, -2, -21 },
  { 1060, 16, 21, 16, 0, -21 },
  { 1102, 16, 22, 15, 1, -22 },
  { 1146, 17, 21, 17, 0, -21 },
  { 1191, 15, 21, 14, 0, -21 },
  { 1231, 15, 21, 13, 0, -21 },
  { 1271, 17, 22, 18, 1, -22 },
  { 1318, 19, 21, 18, 0, -21 },
  { 1368, 14, 21, 11, -1, -21 },
  { 1405, 14, 28, 9, -5, -21 },
  { 1454, 19, 21, 16, 0, -21 },
  { 1504, 11, 21, 13, 0, -21 },
  { 1533, 24, 21, 23, 0, -21 },
  { 1596, 20, 21, 19, 0, -21 },
  { 1649, 17, 22, 18, 1, -22 },
  { 1696, 16, 21, 15, 0, -21 },
  { 1738, 17, 27, 18, 1, -22 },
  { 1796, 16, 21, 16, 0, -21 },
  { 1838, 15, 22, 14, 0, -22 },
  { 1880, 14, 21, 14, 2, -21 },
  { 1917, 17, 21, 17, 1, -21 },
  { 1962, 15, 21, 16, 3, -21 },
  { 2002, 24, 21, 23, 2, -21 },
  { 2065, 20, 21, 16, -2, -21 },
  { 2118, 14, 21, 15, 3, -21 },
  { 2155, 16, 21, 13, -1, -21 },
  { 2197, 12, 27, 9, -1, -22 },
  { 2238, 7, 22, 12, 3, -22 },
  { 2258, 12, 27, 9, -2, -22 },
  { 2299, 14, 13, 14, 0, -21 },
  { 2322, 12, 3, 11, -3, 2 },
  { 2327, 7, 5, 10, 4, -23 },
  { 2332, 14, 17, 15, 1, -17 },
  { 2362, 15, 23, 15, 0, -23 },
  { 2406, 12, 17, 12, 1, -17 },
  { 2432, 16, 23, 15, 1, -23 },
  { 2478, 13, 17, 14, 1, -17 },
  { 2506, 16, 30, 10, -3, -23 },
  { 2566, 15, 24, 15, 0, -17 },
  { 2611, 15, 23, 15, 0, -23 },
  { 2655, 9, 23, 8, 0, -23 },
  { 2681, 13, 30, 8, -4, -23 },
  { 2730, 16, 23, 15, 0, -23 },
  { 2776, 9, 23, 8, 0, -23 },
  { 2802, 22, 17, 23, 0, -17 },
  { 2849, 15, 17, 15, 0, -17 },
  { 2881, 13, 17, 15, 1, -17 },
  { 2909, 17, 24, 15, -2, -17 },
  { 2960, 14, 24, 15, 1, -17 },
  { 3002, 12, 17, 11, 0, -17 },
  { 3028, 12, 17, 12, 0, -17 },
  { 3054, 10, 20, 11, 1, -20 },
  { 3079, 14, 16, 15, 1, -16 },
  { 3107, 13, 16, 14, 2, -16 },
  { 3133, 20, 16, 21, 2, -16 },
  { 3173, 17, 16, 14, -2, -16 },
  { 3207, 17, 23, 14, -2, -16 },
  { 3256, 14, 16, 12, -1, -16 },
  { 3284, 13, 26, 10, 0, -21 },
  { 3327, 3, 30, 13, 5, -23 },
  { 3339, 12, 26, 10, -2, -21 },
  { 3378, 14, 5, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC30PT7B_H_
