#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC45PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x30, 0x00, 0x3F,
  0x9F, 0x9F, 0x8F, 0xCF, 0xCF, 0xEF, 0xE7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9,
  0xF8, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x3F, 0x3F, 0x1F, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x78, 0x7C, 0x43, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7E, 0xE3, 0x07, 0xE7, 0x08,
  0x3F, 0x30, 0x01, 0xFD, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xBF, 0x80, 0x1D, 0xFC, 0xC0, 0xEF,
  0xE7, 0x06, 0x7E, 0x3F, 0x3F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x03, 0xF8, 0x01, 0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x0F, 0xFC, 0x03,
  0xE0, 0x1F, 0xFC, 0x07, 0xC0, 0x3F, 0x3E, 0x07, 0xC0, 0x3E, 0x3E, 0x0F,
  0x80, 0x3E, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x3E,
  0x00, 0x7C, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0xFC,
  0x00, 0xF8, 0xFC, 0xF8, 0x70, 0xF8, 0xF9, 0xF1, 0xFE, 0x7D, 0xF9, 0xF3,
  0xFE, 0x7F, 0xF3, 0xE7, 0xFF, 0x7F, 0xF7, 0xEF, 0xFF, 0x7F, 0xE7, 0xCF,
  0x9F, 0x3F, 0xCF, 0x9F, 0x9F, 0x06, 0x0F, 0x9F, 0x1F, 0x00, 0x1F, 0x1F,
  0x1F, 0x00, 0x3F, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0xF8, 0x3E, 0x3E, 0x01, 0xF0, 0x3E,
  0x3E, 0x01, 0xF0, 0x3E, 0x7C, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xE1, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE,
  0x7F, 0x1F, 0xFF, 0xCF, 0xC3, 0xFB, 0xFF, 0xF8, 0xFE, 0x3F, 0xFE, 0x1F,
  0xC7, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0xFE, 0x0F, 0xFE, 0x1F, 0xC0, 0xFF,
  0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0xCF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xF7, 0xF8, 0x0F, 0xF8, 0xFF,
  0x80, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x02, 0x0F, 0x80, 0x71, 0xF0, 0x0F, 0xBE, 0x03, 0xFF,
  0xCF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0x82, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFD, 0xF0, 0x3F, 0x3F, 0x03, 0xC7,
  0xE0, 0x38, 0x7E, 0x02, 0x0E, 0x00, 0x01, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x0F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0x3F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF,
  0xE7, 0xFF, 0x7F, 0xF8, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xDF, 0xC1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1,
  0xFD, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F,
  0x81, 0xFD, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0x7F,
  0x1F, 0x3F, 0x87, 0x1F, 0x81, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFE, 0xFF, 0x01, 0xF0, 0xFF, 0x01, 0x81,
  0xFE, 0x02, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3E, 0x7F, 0xC0, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE2, 0x00, 0x3F, 0x8C, 0x01, 0xFE,
  0x3F, 0x7F, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x00,
  0x7D, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x7C, 0xFE, 0x03, 0xE3,
  0xF8, 0x1F, 0x8F, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xFC, 0x1F, 0x87, 0xF0,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x10, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x80, 0x1F, 0xE3, 0x00, 0xFF, 0x0F, 0xCF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x81, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x9F,
  0x80, 0xFE, 0xFF, 0x03, 0xF7, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xF8, 0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE1, 0xF8, 0x7F,
  0x07, 0xE1, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x1F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0xC1, 0xFC,
  0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0x8F, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07,
  0xF3, 0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF8, 0x7F, 0x9F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF9, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8,
  0xFC, 0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x3F, 0xEF, 0xC1, 0xFE, 0xFE, 0x03, 0xE7, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC1, 0x87, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F,
  0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0x78, 0xFE, 0x30, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC1, 0xFE, 0x1E,
  0x0F, 0x87, 0xFF, 0x9F, 0x1F, 0x0F, 0xFF, 0x1F, 0x1F, 0x1F, 0xFF, 0x1F,
  0x3E, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x1F, 0x1F, 0x3C, 0x3E, 0x1E, 0x1F,
  0x7C, 0x7C, 0x3E, 0x1E, 0x7C, 0x7C, 0x3E, 0x1E, 0x78, 0x78, 0x3E, 0x3E,
  0x78, 0xF8, 0x7C, 0x3E, 0x78, 0xF8, 0x7C, 0x3C, 0xF8, 0xF8, 0x7C, 0x7C,
  0xF8, 0xF8, 0xFC, 0x78, 0xF8, 0xF8, 0xFC, 0xF8, 0xF8, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7F, 0xBF, 0xE0, 0xF8, 0x7F, 0x3F, 0xC0, 0x78, 0x1E, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x0C, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01,
  0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x0F, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF9, 0xFF, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0xFF, 0x07, 0xE0, 0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xBE,
  0x07, 0xF8, 0x0C, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x06, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE3,
  0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xC7,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFC, 0x07, 0xF0,
  0xFE, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x87, 0xFC, 0x1F, 0xC7, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFD,
  0xF8, 0x1F, 0xF0, 0x0C, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x1F, 0xFC, 0xFF, 0x0F, 0xFE, 0x7F, 0x87, 0xFF, 0x3F,
  0x87, 0xFF, 0x1F, 0xC3, 0xFF, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFC,
  0x3F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x8F,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0x81,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x80,
  0x3F, 0x8F, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF3,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFF, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x07,
  0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x0F, 0xDF, 0x07, 0xDF, 0x80, 0xFD, 0xF0, 0xFD, 0xF8, 0x0F, 0xDF, 0x0F,
  0xBF, 0x80, 0xFD, 0xF1, 0xFB, 0xF8, 0x1F, 0xDF, 0x1F, 0x3F, 0x01, 0xFD,
  0xF3, 0xF3, 0xF0, 0x1F, 0x9F, 0xBF, 0x7F, 0x01, 0xF9, 0xFB, 0xE7, 0xF0,
  0x1F, 0x9F, 0xFE, 0x7E, 0x03, 0xF9, 0xFF, 0xC7, 0xE0, 0x3F, 0x9F, 0xFC,
  0x7E, 0x03, 0xF1, 0xFF, 0x8F, 0xE0, 0x3F, 0x1F, 0xF8, 0xFE, 0x03, 0xF1,
  0xFF, 0x0F, 0xC0, 0x7F, 0x1F, 0xF0, 0xFC, 0x07, 0xE1, 0xFE, 0x1F, 0xC0,
  0x7E, 0x1F, 0xE1, 0xFC, 0x07, 0xE1, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1,
  0xF8, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x01,
  0xF8, 0x0F, 0xFC, 0x0F, 0xE0, 0x3F, 0xF0, 0x3F, 0x81, 0xFF, 0xC0, 0xFC,
  0x07, 0xFF, 0x83, 0xF0, 0x1F, 0xFE, 0x0F, 0xC0, 0x7F, 0xF8, 0x7F, 0x01,
  0xFF, 0xE1, 0xFC, 0x0F, 0xDF, 0x87, 0xE0, 0x3F, 0x7F, 0x1F, 0x80, 0xFC,
  0xFC, 0xFE, 0x03, 0xF3, 0xF3, 0xF8, 0x1F, 0xCF, 0xCF, 0xC0, 0x7F, 0x3F,
  0xBF, 0x01, 0xF8, 0x7E, 0xFC, 0x07, 0xE1, 0xFB, 0xF0, 0x1F, 0x87, 0xFF,
  0xC0, 0xFE, 0x1F, 0xFE, 0x03, 0xF8, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0,
  0x3F, 0x03, 0xFF, 0x80, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x3F, 0xF0, 0x1F,
  0x80, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xF7, 0xFC, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xE0,
  0x1F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC,
  0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7,
  0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0xFE, 0x03, 0xFC,
  0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0xFF, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE3, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xF7, 0xFC,
  0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xBF, 0x80,
  0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xF3, 0xF8,
  0x07, 0xF9, 0xFC, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F,
  0xC3, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F,
  0xE1, 0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F,
  0x9F, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFC, 0x0C, 0x0F, 0xE0, 0x10,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0x00, 0x7F, 0x0F, 0x03,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F,
  0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x80,
  0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xC0, 0x7F, 0x7E, 0x03, 0xF8, 0x0F, 0xEF,
  0xC0, 0x7F, 0x03, 0xF9, 0xF8, 0x1F, 0xE0, 0x7F, 0x3F, 0x03, 0xFC, 0x0F,
  0xC7, 0xE0, 0xFF, 0x83, 0xF8, 0xFC, 0x1F, 0xF0, 0x7F, 0x1F, 0x83, 0xFE,
  0x1F, 0xC3, 0xF0, 0xFF, 0xC3, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x0F, 0xC7,
  0xFF, 0x1F, 0xC1, 0xF8, 0xFB, 0xE3, 0xF8, 0x3F, 0x1F, 0x7C, 0x7E, 0x07,
  0xE7, 0xEF, 0x9F, 0xC0, 0xFC, 0xF9, 0xF3, 0xF0, 0x1F, 0xBF, 0x3E, 0xFE,
  0x03, 0xF7, 0xE7, 0xDF, 0xC0, 0x7E, 0xF8, 0xFB, 0xF0, 0x0F, 0xFF, 0x1F,
  0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xF0, 0x07, 0xFF,
  0x1F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF0, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x9F, 0x81,
  0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0,
  0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xF8, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07,
  0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC,
  0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0xFD, 0xF8,
  0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x3E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xF8, 0x01, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80,
  0xFF, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0x7C, 0x01, 0xF8, 0xFC,
  0x0F, 0xF3, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x83, 0xF1, 0xFC, 0x1F,
  0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF3, 0xF8, 0x1F, 0x8F,
  0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1,
  0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xCF, 0x80, 0x7E, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0,
  0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F,
  0x9F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x7F, 0xE0, 0xFD, 0xFF,
  0x03, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x21, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x18, 0x7F, 0xCF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xF9, 0xFC, 0x03, 0xFD,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x07,
  0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xEF, 0x80, 0x3F, 0xCF, 0x80, 0x1F, 0x8F, 0x80, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC,
  0x7F, 0x1F, 0x83, 0xF3, 0xF8, 0x3F, 0x3F, 0x07, 0xF7, 0xF0, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x8F, 0xF0, 0x30,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x10, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0xFF, 0x3F, 0x01, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF1, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF7, 0xE0, 0x07, 0xEF,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x80, 0x1F,
  0xC0, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xCF, 0x80, 0x7E, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1,
  0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F,
  0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFE, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x00, 0x00, 0x20, 0x07, 0xE0,
  0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0xC1, 0xF8, 0x3F, 0xC0, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xEF,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xDF, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x7E, 0x03, 0xE7, 0xF8, 0xFF,
  0x81, 0xF7, 0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xC1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE,
  0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x1F,
  0x83, 0xF8, 0xFE, 0x0F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x07,
  0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x1F, 0xC1, 0xF8, 0x3F, 0x8F, 0xE1,
  0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xE3, 0xF8,
  0x3F, 0x07, 0xF1, 0xFC, 0x1F, 0x83, 0xF8, 0xFE, 0x1F, 0xC1, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x1F, 0x3F, 0xC0, 0x7D, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC1,
  0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xF1, 0xFC,
  0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xC7, 0xF3, 0xF8, 0x3F, 0x3F, 0x83, 0xF7, 0xF0, 0x3F, 0x7F, 0x03,
  0xF7, 0xF0, 0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7E, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x1F, 0xCF, 0xF3, 0xFC, 0x7F,
  0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x01, 0xF3, 0xFC, 0x01, 0xF7, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xE7, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0,
  0x3F, 0x9F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0xFC, 0x0F, 0xF3, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0x83,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3,
  0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xF7, 0xE0, 0x1F, 0xBF, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x07, 0xC3, 0xE0, 0xF9, 0xF8, 0x1F, 0x7F, 0x07, 0xEF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0x87, 0x07, 0xF0, 0x40, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE2, 0x01, 0xFC,
  0x78, 0x7F, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF1,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x21, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F,
  0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83,
  0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1,
  0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8,
  0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFE, 0xF8, 0x1F, 0xF3, 0xE0, 0x3F, 0x8F, 0x80, 0xFC, 0x07, 0xFF,
  0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC,
  0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E,
  0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0xC0, 0xFD, 0xF8, 0x07, 0xDF,
  0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x1F, 0xE0, 0xFF, 0xF8, 0x3F, 0xC3, 0xFB, 0xF0, 0xFF, 0x87, 0xF7,
  0xE1, 0xFF, 0x0F, 0xCF, 0xC3, 0xFE, 0x3F, 0x9F, 0x8F, 0xF8, 0x7E, 0x3F,
  0x1F, 0xF1, 0xFC, 0x7E, 0x3F, 0xE3, 0xF0, 0xFC, 0xFF, 0xC7, 0xE1, 0xF9,
  0xFF, 0x9F, 0xC3, 0xF7, 0xDF, 0x3F, 0x07, 0xEF, 0xBE, 0x7E, 0x0F, 0xDF,
  0x7D, 0xF8, 0x1F, 0xFC, 0xFB, 0xF0, 0x3F, 0xF9, 0xF7, 0xE0, 0x7D, 0xF3,
  0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xEF, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFB, 0xF0,
  0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x1F,
  0x80, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF1,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xEF, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x17, 0xFE, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x7F, 0xE8, 0x01, 0xFC,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 33, 12, 0, -32 },
  { 59, 17, 11, 19, 4, -32 },
  { 83, 26, 32, 25, 0, -32 },
  { 187, 21, 37, 22, 1, -34 },
  { 285, 32, 33, 35, 2, -33 },
  { 417, 27, 33, 27, 0, -33 },
  { 529, 9, 11, 11, 4, -32 },
  { 542, 16, 40, 13, 1, -33 },
  { 622, 16, 40, 14, -3, -33 },
  { 702, 19, 21, 21, 3, -35 },
  { 752, 20, 22, 23, 2, -27 },
  { 807, 10, 12, 12, -2, -6 },
  { 822, 13, 6, 14, 0, -15 },
  { 832, 8, 8, 12, 0, -7 },
  { 840, 24, 32, 18, -2, -32 },
  { 936, 21, 33, 22, 1, -33 },
  { 1023, 17, 32, 22, 4, -32 },
  { 1091, 23, 33, 22, -1, -33 },
  { 1186, 22, 33, 22, 0, -33 },
  { 1277, 22, 32, 22, 0, -32 },
  { 1365, 22, 32, 22, 0, -32 },
  { 1453, 22, 33, 22, 1, -33 },
  { 1544, 23, 32, 22, 1, -32 },
  { 1636, 22, 33, 22, 0, -33 },
  { 1727, 21, 33, 22, 1, -33 },
  { 1814, 12, 26, 12, 0, -25 },
  { 1853, 15, 31, 12, -3, -25 },
  { 1912, 20, 23, 23, 2, -28 },
  { 1970, 20, 14, 23, 2, -23 },
  { 2005, 20, 23, 23, 2, -28 },
  { 2063, 17, 34, 18, 2, -33 },
  { 2136, 32, 36, 33, 1, -32 },
  { 2280, 25, 32, 24, -3, -32 },
  { 2380, 24, 32, 24, 0, -32 },
  { 2476, 23, 33, 23, 2, -33 },
  { 2571, 25, 32, 26, 0, -32 },
  { 2671, 22, 32, 20, 0, -32 },
  { 2759, 22, 32, 20, 0, -32 },
  { 2847, 25, 33, 26, 2, -33 },
  { 2951, 28, 32, 27, 0, -32 },
  { 3063, 21, 32, 16, -2, -32 },
  { 3147, 21, 42, 13, -7, -32 },
  { 3258, 28, 32, 24, 0, -32 },
  { 3370, 17, 32, 19, 0, -32 },
  { 3438, 36, 32, 35, 0, -32 },
  { 3582, 30, 32, 29, 0, -32 },
  { 3702, 25, 33, 27, 2, -33 },
  { 3806, 24, 32, 23, 0, -32 },
  { 3902, 25, 41, 27, 2, -33 },
  { 4031, 24, 32, 24, 0, -32 },
  { 4127, 22, 33, 21, 0, -33 },
  { 4218, 20, 32, 20, 4, -32 },
  { 4298, 25, 32, 26, 2, -32 },
  { 4398, 24, 32, 24, 4, -32 },
  { 4494, 35, 32, 35, 4, -32 },
  { 4634, 30, 32, 23, -3, -32 },
  { 4754, 22, 32, 22, 4, -32 },
  { 4842, 25, 32, 20, -2, -32 },
  { 4942, 19, 40, 14, -2, -33 },
  { 5037, 10, 32, 18, 5, -32 },
  { 5077, 18, 40, 14, -3, -33 },
  { 5167, 21, 20, 21, 0, -32 },
  { 5220, 18, 5, 17, -4, 3 },
  { 5232, 10, 7, 14, 6, -34 },
  { 5241, 22, 25, 23, 1, -25 },
  { 5310, 22, 34, 23, 0, -34 },
  { 5404, 19, 25, 19, 1, -25 },
  { 5464, 24, 34, 23, 1, -34 },
  { 5566, 20, 25, 22, 1, -25 },
  { 5629, 25, 45, 14, -5, -34 },
  { 5770, 24, 36, 23, -1, -25 },
  { 5878, 22, 34, 23, 0, -34 },
  { 5972, 14, 35, 12, 0, -35 },
  { 6034, 20, 46, 12, -6, -35 },
  { 6149, 25, 34, 22, 0, -34 },
  { 6256, 14, 34, 12, 0, -34 },
  { 6316, 33, 25, 34, 0, -25 },
  { 6420, 22, 25, 23, 0, -25 },
  { 6489, 20, 25, 23, 1, -25 },
  { 6552, 24, 36, 23, -2, -25 },
  { 6660, 22, 36, 23, 1, -25 },
  { 6759, 19, 25, 16, 0, -25 },
  { 6819, 19, 25, 18, 0, -25 },
  { 6879, 15, 30, 16, 2, -30 },
  { 6936, 22, 25, 23, 1, -25 },
  { 7005, 20, 25, 21, 3, -25 },
  { 7068, 31, 25, 31, 3, -25 },
  { 7165, 25, 25, 21, -2, -25 },
  { 7244, 26, 36, 21, -3, -25 },
  { 7361, 21, 25, 18, -2, -25 },
  { 7427, 19, 39, 16, 0, -32 },
  { 7520, 5, 44, 20, 7, -34 },
  { 7548, 18, 39, 16, -3, -32 },
  { 7636, 20, 8, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC45PT7B_H_
