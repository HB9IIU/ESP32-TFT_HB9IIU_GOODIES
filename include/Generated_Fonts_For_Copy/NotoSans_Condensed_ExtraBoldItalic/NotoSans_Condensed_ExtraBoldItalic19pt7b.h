#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC19PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x1C, 0x70, 0x00, 0x18, 0xE3, 0x80,
  0xEF, 0xDF, 0xB6, 0x6C, 0xC0, 0x06, 0xC1, 0x98, 0x33, 0x06, 0xC3, 0xFE,
  0xFF, 0xC6, 0xC0, 0xD8, 0xFF, 0xDF, 0xF0, 0xD8, 0x33, 0x06, 0x60, 0xD8,
  0x00, 0x02, 0x07, 0xCF, 0xE7, 0xB3, 0x41, 0xE0, 0xF8, 0x3E, 0x0F, 0x05,
  0x93, 0xDF, 0xEF, 0xE0, 0x80, 0x40, 0x18, 0x33, 0xE3, 0x1B, 0x19, 0xD9,
  0x8C, 0xD8, 0x66, 0xC3, 0x6D, 0xFF, 0xFF, 0x76, 0xD8, 0x66, 0xC3, 0x36,
  0x33, 0xB3, 0x8F, 0x18, 0x78, 0x07, 0x01, 0xF0, 0x76, 0x0C, 0xC1, 0xB8,
  0x3E, 0x07, 0x81, 0xF7, 0x7E, 0xFC, 0xFB, 0x9E, 0x73, 0xCF, 0xFC, 0xFB,
  0x80, 0x7F, 0xEC, 0x06, 0x18, 0x70, 0xC3, 0x86, 0x1C, 0x38, 0x60, 0xC3,
  0x87, 0x0E, 0x1C, 0x18, 0x30, 0x70, 0x1C, 0x70, 0xC3, 0x0C, 0x30, 0xC3,
  0x1C, 0x71, 0xC6, 0x38, 0xC7, 0x18, 0xC0, 0x08, 0x0C, 0x4C, 0x7F, 0xFF,
  0x3D, 0x7C, 0x66, 0x24, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x3B, 0x9C, 0xCE, 0x60, 0x7F, 0xE0, 0x7F, 0x80, 0x01, 0xC0, 0x70,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x00, 0x0E, 0x3F, 0x3F, 0x77, 0x67, 0xE7, 0xE7, 0xE7, 0xC7,
  0xCE, 0xCE, 0xFC, 0xFC, 0x78, 0x0E, 0x3C, 0xF3, 0xEF, 0xCB, 0x86, 0x1C,
  0x38, 0x70, 0xE1, 0x87, 0x0E, 0x00, 0x07, 0x03, 0xF1, 0xFC, 0x67, 0x01,
  0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0x7F, 0x3F, 0xC0,
  0x0E, 0x1F, 0xCF, 0xE4, 0x70, 0x38, 0x38, 0x78, 0x7C, 0x07, 0x03, 0x81,
  0xD1, 0xEF, 0xE7, 0xE0, 0x03, 0x81, 0xC1, 0xE1, 0xF0, 0xF0, 0xF8, 0xDC,
  0xEE, 0x67, 0x7F, 0xFF, 0xC1, 0xC0, 0xE0, 0x70, 0x1F, 0x8F, 0xC7, 0xE7,
  0x03, 0x81, 0xF0, 0xFC, 0xFE, 0x07, 0x03, 0x81, 0xD9, 0xEF, 0xE7, 0xE0,
  0x07, 0x8F, 0x8F, 0xCE, 0x07, 0x07, 0x73, 0xF9, 0xFE, 0xE7, 0x73, 0xB3,
  0x9D, 0xCF, 0xC3, 0xC0, 0x3F, 0xCF, 0xF3, 0xFC, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x00, 0x0F, 0x0F,
  0xCF, 0xE7, 0x33, 0xB9, 0xFC, 0x78, 0x7C, 0x77, 0x73, 0xB8, 0xDC, 0xE7,
  0xE3, 0xE0, 0x0E, 0x0F, 0x8F, 0xE7, 0x77, 0x3B, 0x9D, 0xCE, 0xFF, 0x3B,
  0x03, 0x81, 0xD1, 0xCF, 0xC7, 0xC0, 0x11, 0xCE, 0x60, 0x00, 0x00, 0x67,
  0x38, 0x08, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x39, 0xC7, 0x18, 0xE3, 0x00,
  0x01, 0x03, 0x0F, 0x3E, 0xF8, 0xF0, 0x7C, 0x1F, 0x07, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0x3E, 0xF8,
  0xE0, 0x80, 0x3C, 0xFD, 0xFA, 0x70, 0xE3, 0x8E, 0x38, 0x60, 0x00, 0x07,
  0x0E, 0x1C, 0x00, 0x03, 0x80, 0x7F, 0x06, 0x0C, 0x60, 0x76, 0x7D, 0xB7,
  0xEF, 0x36, 0x7B, 0x33, 0xD9, 0xB4, 0xDD, 0xA7, 0xF9, 0x9B, 0x8C, 0x00,
  0x70, 0xC1, 0xFE, 0x01, 0x80, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3,
  0x71, 0xDC, 0x77, 0x39, 0xCF, 0xF7, 0xFD, 0xC7, 0x71, 0xF8, 0x70, 0x1E,
  0x07, 0xF1, 0xFC, 0xE7, 0x39, 0xCE, 0xF3, 0xF9, 0xFC, 0x73, 0x9C, 0xE7,
  0x39, 0x9E, 0xFF, 0x3F, 0x80, 0x07, 0x07, 0xF3, 0xF9, 0xE2, 0x70, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xD8, 0xFE, 0x1F, 0x80, 0x1E,
  0x03, 0xF0, 0x7F, 0x1C, 0xF3, 0x8E, 0x71, 0xCE, 0x3B, 0x8E, 0x71, 0xCE,
  0x39, 0xCE, 0x3F, 0xCF, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0x03,
  0x81, 0xC0, 0xFC, 0xFE, 0x70, 0x38, 0x1C, 0x0F, 0xCF, 0xE7, 0xF0, 0x1F,
  0x8F, 0xC7, 0xE7, 0x03, 0x81, 0xC0, 0xFC, 0xFE, 0x7E, 0x38, 0x1C, 0x0E,
  0x0E, 0x07, 0x00, 0x07, 0x87, 0xF3, 0xFD, 0xE1, 0x70, 0x3C, 0x0E, 0x7F,
  0x9E, 0xE7, 0xB8, 0xEE, 0x3B, 0xCC, 0x7F, 0x0F, 0xC0, 0x1C, 0x71, 0xC7,
  0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xE7, 0xFC, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x38, 0x1F, 0x8F, 0xC3, 0xC1, 0xC0, 0xE0,
  0x70, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x07, 0xE7, 0xE0, 0x03, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC1,
  0xC0, 0xE0, 0x71, 0x78, 0xF8, 0x78, 0x00, 0x1C, 0x71, 0xCE, 0x19, 0xC3,
  0xBC, 0x3B, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0x77, 0x06,
  0x70, 0xE3, 0x8E, 0x38, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0E, 0x38, 0x70,
  0xE1, 0xC3, 0xFF, 0xFF, 0xC0, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF9, 0xF1,
  0xE3, 0xE7, 0xC6, 0xCF, 0x8D, 0xBF, 0x3B, 0x6E, 0x76, 0xD8, 0xEF, 0x71,
  0x9E, 0xE3, 0x39, 0xCE, 0x73, 0x9C, 0xEE, 0x00, 0x1C, 0x38, 0xE1, 0x87,
  0x8C, 0x7C, 0xE3, 0xE7, 0x1B, 0x38, 0xDD, 0x8E, 0xFC, 0x77, 0xE3, 0x9F,
  0x18, 0xF8, 0xC7, 0x8E, 0x3C, 0x71, 0xE0, 0x07, 0x07, 0xE3, 0xFD, 0xE7,
  0x71, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3B, 0xDE, 0xFF, 0x1F,
  0x80, 0x1E, 0x07, 0xE1, 0xFC, 0xE7, 0x39, 0xCE, 0x73, 0xBD, 0xFE, 0x7F,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0x07, 0x07, 0xE3, 0xFD, 0xE7,
  0x71, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3B, 0xDE, 0xFF, 0x1F,
  0x80, 0xE0, 0x38, 0x0F, 0x00, 0x1E, 0x07, 0xE1, 0xFC, 0xE7, 0x39, 0xCE,
  0x73, 0xF9, 0xFE, 0x7E, 0x1D, 0xC7, 0x71, 0x9C, 0xE3, 0xB8, 0xE0, 0x0F,
  0x0F, 0xCF, 0xE7, 0x13, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xA1, 0xDD,
  0xCF, 0xE7, 0xE0, 0x7F, 0xBF, 0xFF, 0xE3, 0x81, 0xC1, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x38, 0xE7, 0x39, 0xC7, 0x38,
  0xE7, 0x1C, 0xE3, 0x9C, 0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x9C, 0x77, 0x8F,
  0xE0, 0xF8, 0x00, 0xE1, 0xF8, 0xEE, 0x3B, 0x9C, 0xE7, 0x3B, 0x8E, 0xE3,
  0xB0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x61, 0x86, 0xC7,
  0x1D, 0x8E, 0x3B, 0x1C, 0xE6, 0x79, 0xCC, 0xF3, 0x1B, 0xEE, 0x36, 0xDC,
  0x6D, 0xF0, 0xFB, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x1E, 0x1E, 0x38, 0x00,
  0x1C, 0x71, 0xCF, 0x1C, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF8, 0x3B, 0x83, 0xB8, 0x73, 0x8E, 0x3C, 0xE3, 0xF3, 0xB9,
  0xDD, 0xCE, 0xE3, 0xE1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07,
  0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x80, 0xE0, 0x38, 0x47, 0xF1, 0xFE, 0x00, 0x0F, 0x0F, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60,
  0x78, 0xF8, 0xCE, 0xEE, 0x66, 0x66, 0x77, 0x77, 0x33, 0x1F, 0x1E, 0x06,
  0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30,
  0xF0, 0xF0, 0x06, 0x03, 0x03, 0x83, 0xE1, 0xB1, 0xD8, 0xCC, 0xC7, 0xE1,
  0x80, 0x7F, 0xFE, 0xEE, 0x70, 0x0C, 0x0F, 0xF3, 0xF9, 0xCE, 0x73, 0x9C,
  0xE6, 0x3B, 0x9C, 0xF7, 0x1F, 0xC7, 0xF0, 0x1C, 0x0C, 0x0E, 0x07, 0x63,
  0xF9, 0xFC, 0xEE, 0xE7, 0x73, 0xB9, 0xDC, 0xFE, 0xEF, 0xF6, 0xF0, 0x06,
  0x1F, 0x3F, 0x70, 0x70, 0x70, 0x60, 0xE0, 0x72, 0x7E, 0x3C, 0x00, 0xE0,
  0x38, 0x07, 0x06, 0xE1, 0xFC, 0x7F, 0x1C, 0xE3, 0x9C, 0x73, 0x8C, 0x73,
  0x9C, 0x7B, 0x87, 0xF0, 0xFE, 0x00, 0x06, 0x0F, 0x8F, 0xEE, 0x77, 0x7B,
  0xF9, 0xF1, 0xC0, 0x71, 0x3F, 0x0F, 0x80, 0x00, 0x80, 0xF0, 0x7C, 0x1C,
  0x06, 0x07, 0xE1, 0xF8, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x3C, 0x0F, 0x01, 0x00, 0x0C, 0x07, 0xF3, 0xF9,
  0xCE, 0x73, 0x9C, 0xE6, 0x3B, 0x9C, 0xF7, 0x1F, 0xC7, 0x70, 0x18, 0x8E,
  0x3F, 0x8F, 0xC0, 0xC0, 0x1C, 0x0C, 0x0E, 0x07, 0x63, 0xF9, 0xFC, 0xEE,
  0xE7, 0x73, 0xB9, 0xDC, 0xDC, 0xEE, 0x77, 0x38, 0x08, 0x71, 0xC0, 0x00,
  0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x00, 0x02, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38,
  0x30, 0xF0, 0xF0, 0xC0, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x39, 0xCE, 0xE3,
  0x71, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0x9C, 0xE7, 0x39, 0xC0, 0x1C, 0x63,
  0x8E, 0x38, 0xE3, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x80, 0x03, 0x18, 0xDF,
  0xF3, 0xFF, 0xCE, 0xE7, 0x73, 0x9D, 0xCE, 0x77, 0x39, 0x98, 0xCE, 0xE7,
  0x3B, 0x9C, 0xEE, 0x73, 0x00, 0x03, 0x1B, 0xCF, 0xE7, 0x77, 0x3B, 0x9D,
  0xCE, 0xE6, 0xE7, 0x73, 0xB9, 0xC0, 0x0C, 0x3E, 0x7F, 0xE7, 0xE7, 0xE7,
  0xC7, 0xC6, 0xEE, 0xFC, 0x78, 0x01, 0x86, 0xF1, 0xFC, 0x77, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x7B, 0x9F, 0xE7, 0xF1, 0xC0, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0x0C, 0x07, 0xF3, 0xF9, 0xCE, 0x73, 0x9C, 0xE6, 0x3B, 0x9C, 0xF7,
  0x1F, 0xC7, 0xF0, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x37, 0x3E,
  0x39, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x0C, 0x3F, 0x7E, 0x70,
  0x78, 0x3C, 0x1E, 0x0E, 0x8E, 0xFC, 0xF8, 0x18, 0xC3, 0x3F, 0xFD, 0xC6,
  0x38, 0xE3, 0x8E, 0x3C, 0xF0, 0x73, 0xB1, 0xB9, 0xDC, 0xEE, 0x77, 0x3B,
  0x39, 0xDC, 0xFE, 0x7F, 0x00, 0xE7, 0xF3, 0xBB, 0x9D, 0xCE, 0xC7, 0xE1,
  0xE0, 0xF0, 0x70, 0x38, 0x00, 0xE7, 0x3F, 0x79, 0xBB, 0xDD, 0xDE, 0xCF,
  0xBE, 0x7D, 0xF3, 0xEF, 0x1E, 0x78, 0xF3, 0x87, 0x1C, 0x00, 0x3D, 0xE3,
  0xF0, 0x7E, 0x0F, 0x80, 0xE0, 0x3C, 0x0F, 0xC1, 0xF8, 0x77, 0x1C, 0x70,
  0x39, 0xE7, 0x38, 0xE6, 0x1D, 0xC1, 0xB0, 0x3E, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x0F, 0x01, 0xE0, 0x30, 0x00, 0x1F, 0x9F, 0xC1,
  0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x7E, 0x7F, 0x00, 0x03, 0x0F, 0x1E,
  0x1C, 0x1C, 0x1C, 0x38, 0x78, 0xF0, 0xF0, 0x30, 0x30, 0x70, 0x70, 0x70,
  0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0x38, 0x78, 0x60, 0xC3,
  0x87, 0x0F, 0x0E, 0x3C, 0xE1, 0xC3, 0x86, 0x1C, 0x78, 0xE0, 0xF9, 0xFF,
  0x8F,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 8, 2, -14 },
  { 17, 11, 14, 10, 0, -14 },
  { 37, 9, 15, 9, 0, -14 },
  { 54, 13, 14, 15, 1, -14 },
  { 77, 11, 14, 11, 0, -14 },
  { 97, 3, 5, 5, 2, -14 },
  { 99, 7, 17, 6, 0, -14 },
  { 114, 6, 17, 6, -1, -14 },
  { 127, 8, 9, 9, 1, -15 },
  { 136, 8, 9, 10, 1, -11 },
  { 145, 5, 6, 5, -1, -3 },
  { 149, 6, 2, 6, 0, -6 },
  { 151, 3, 3, 5, 0, -3 },
  { 153, 10, 14, 8, -1, -14 },
  { 171, 8, 14, 9, 1, -14 },
  { 185, 7, 14, 9, 2, -14 },
  { 198, 10, 14, 9, -1, -14 },
  { 216, 9, 14, 9, 0, -14 },
  { 232, 9, 14, 9, 0, -14 },
  { 248, 9, 14, 9, 0, -14 },
  { 264, 9, 14, 9, 1, -14 },
  { 280, 10, 14, 9, 0, -14 },
  { 298, 9, 14, 9, 0, -14 },
  { 314, 9, 14, 9, 0, -14 },
  { 330, 5, 11, 5, 0, -11 },
  { 337, 6, 14, 5, -1, -11 },
  { 348, 8, 10, 10, 1, -12 },
  { 358, 8, 6, 10, 1, -10 },
  { 364, 8, 10, 10, 1, -12 },
  { 374, 7, 14, 7, 1, -14 },
  { 387, 13, 16, 14, 1, -14 },
  { 413, 10, 14, 10, -1, -14 },
  { 431, 10, 14, 10, 0, -14 },
  { 449, 10, 14, 10, 1, -14 },
  { 467, 11, 14, 11, 0, -14 },
  { 487, 9, 14, 9, 0, -14 },
  { 503, 9, 14, 8, 0, -14 },
  { 519, 10, 14, 11, 1, -14 },
  { 537, 12, 14, 11, 0, -14 },
  { 558, 9, 14, 7, -1, -14 },
  { 574, 9, 18, 5, -3, -14 },
  { 595, 12, 14, 10, 0, -14 },
  { 616, 7, 14, 8, 0, -14 },
  { 629, 15, 14, 15, 0, -14 },
  { 656, 13, 14, 12, 0, -14 },
  { 679, 10, 14, 12, 1, -14 },
  { 697, 10, 14, 10, 0, -14 },
  { 715, 10, 17, 12, 1, -14 },
  { 737, 10, 14, 10, 0, -14 },
  { 755, 9, 14, 9, 0, -14 },
  { 771, 9, 14, 9, 1, -14 },
  { 787, 11, 14, 11, 1, -14 },
  { 807, 10, 14, 10, 2, -14 },
  { 825, 15, 14, 15, 1, -14 },
  { 852, 12, 14, 10, -1, -14 },
  { 873, 9, 14, 9, 2, -14 },
  { 889, 11, 14, 9, -1, -14 },
  { 909, 8, 17, 6, -1, -14 },
  { 926, 4, 14, 8, 2, -14 },
  { 933, 8, 17, 6, -1, -14 },
  { 950, 9, 9, 9, 0, -14 },
  { 961, 8, 2, 7, -2, 1 },
  { 963, 4, 3, 6, 3, -15 },
  { 965, 10, 11, 10, 0, -11 },
  { 979, 9, 14, 10, 0, -14 },
  { 995, 8, 11, 8, 0, -11 },
  { 1006, 11, 14, 10, 0, -14 },
  { 1026, 9, 11, 9, 0, -11 },
  { 1039, 10, 20, 6, -2, -15 },
  { 1064, 10, 16, 10, 0, -11 },
  { 1084, 9, 14, 10, 0, -14 },
  { 1100, 6, 15, 5, 0, -15 },
  { 1112, 8, 20, 5, -2, -15 },
  { 1132, 10, 14, 9, 0, -14 },
  { 1150, 6, 14, 5, 0, -14 },
  { 1161, 14, 11, 14, 0, -11 },
  { 1181, 9, 11, 10, 0, -11 },
  { 1194, 8, 11, 10, 1, -11 },
  { 1205, 10, 16, 10, -1, -11 },
  { 1225, 10, 16, 10, 0, -11 },
  { 1245, 8, 11, 7, 0, -11 },
  { 1256, 8, 11, 8, 0, -11 },
  { 1267, 6, 13, 7, 1, -13 },
  { 1277, 9, 10, 10, 1, -10 },
  { 1289, 9, 10, 9, 1, -10 },
  { 1301, 13, 10, 13, 1, -10 },
  { 1318, 11, 10, 9, -1, -10 },
  { 1332, 11, 15, 9, -1, -10 },
  { 1353, 9, 10, 8, -1, -10 },
  { 1365, 8, 17, 7, 0, -14 },
  { 1382, 2, 19, 8, 3, -15 },
  { 1387, 7, 17, 7, -1, -14 },
  { 1402, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC19PT7B_H_
