#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC9PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0xF4, 0x2B, 0xD5, 0xF6, 0x50, 0x17, 0x66, 0x3B,
  0x64, 0x20, 0xC9, 0xA7, 0xB5, 0xA5, 0x5B, 0x00, 0x13, 0x9C, 0xCF, 0xCB,
  0xE0, 0xE0, 0x2D, 0x2D, 0x26, 0x22, 0x32, 0x22, 0x6C, 0x5D, 0xD0, 0x2F,
  0x22, 0xE0, 0xE0, 0xC0, 0x11, 0x26, 0x4C, 0x80, 0x27, 0x5D, 0xDF, 0x60,
  0x7D, 0xA5, 0x80, 0x27, 0x13, 0x6C, 0xF0, 0x27, 0x16, 0x3B, 0xE0, 0x33,
  0x7B, 0xF2, 0x74, 0x73, 0xBE, 0x19, 0x90, 0xED, 0x79, 0x80, 0x78, 0x8C,
  0x46, 0x60, 0x27, 0x56, 0xF9, 0xE0, 0x27, 0x5D, 0x72, 0xE0, 0x50, 0xC0,
  0x24, 0x07, 0x80, 0x13, 0xE7, 0x10, 0xF0, 0xF0, 0x8C, 0x37, 0x80, 0x27,
  0x36, 0x40, 0xC0, 0x3C, 0xB6, 0xAD, 0x6B, 0xC9, 0x0C, 0x00, 0x18, 0xCA,
  0x77, 0xE4, 0x7A, 0xDC, 0xAD, 0x78, 0x13, 0xD0, 0x8C, 0x61, 0xC0, 0x7A,
  0x52, 0xBD, 0x70, 0x74, 0x74, 0xCE, 0x74, 0x74, 0xCC, 0x11, 0xD0, 0xBD,
  0xED, 0xC0, 0x6D, 0x27, 0x96, 0xDB, 0x40, 0x76, 0x64, 0x4E, 0x32, 0x22,
  0x66, 0x4C, 0x7D, 0x47, 0x1C, 0xF3, 0x40, 0x69, 0x2D, 0xC0, 0x66, 0xDD,
  0xBB, 0x6F, 0x57, 0x80, 0x65, 0xB7, 0x96, 0xDA, 0x60, 0x13, 0xD2, 0x9C,
  0xED, 0xC0, 0x7A, 0xD6, 0xEC, 0x60, 0x13, 0xD2, 0x9C, 0xED, 0xC6, 0x10,
  0x7A, 0xDC, 0xEF, 0x68, 0x27, 0x46, 0x3B, 0xE0, 0xF4, 0x4C, 0x88, 0x6A,
  0x56, 0xBD, 0x38, 0x9D, 0xA9, 0xCC, 0x60, 0xB7, 0x6A, 0xF6, 0xCD, 0x92,
  0x00, 0x3C, 0xE1, 0x0C, 0x7B, 0x20, 0xBA, 0xCC, 0xC8, 0x79, 0x88, 0x8C,
  0x78, 0x69, 0x25, 0x26, 0xAA, 0xD4, 0x31, 0x32, 0x22, 0x2E, 0x25, 0x59,
  0xF0, 0xD0, 0x7A, 0xB5, 0xEF, 0x00, 0x64, 0x75, 0x5D, 0xE0, 0x74, 0xCC,
  0x60, 0x08, 0xDE, 0xAD, 0x6B, 0xC0, 0x75, 0xFC, 0x60, 0x19, 0x9C, 0x42,
  0x31, 0x88, 0xC0, 0x7A, 0xB5, 0xEF, 0x13, 0x80, 0x64, 0x75, 0x5D, 0xB0,
  0x69, 0x25, 0xA0, 0x32, 0x22, 0x26, 0x44, 0xC0, 0x62, 0x16, 0xE6, 0x7A,
  0xC0, 0x69, 0x25, 0xA0, 0x7C, 0xAD, 0x56, 0xAB, 0x40, 0x75, 0x5D, 0xB0,
  0x75, 0xDD, 0x60, 0x75, 0x5D, 0xE8, 0x80, 0x7A, 0xB5, 0xAF, 0x10, 0x80,
  0x74, 0x4C, 0x80, 0x74, 0x62, 0xE0, 0x3D, 0x2D, 0xC0, 0x5A, 0xB5, 0xED,
  0x00, 0xBA, 0xCC, 0x80, 0xAF, 0xAF, 0xBC, 0xB0, 0x5B, 0x98, 0xCB, 0x00,
  0x2C, 0xA3, 0x0C, 0x20, 0x8C, 0x00, 0x72, 0x6C, 0xE0, 0x36, 0x48, 0x44,
  0xC0, 0xFF, 0x80, 0x33, 0x21, 0x26, 0xC0, 0xF9,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 4, 8, 4, 0, -7 },
  { 13, 7, 7, 7, 0, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 2, 2, 2, 1, -6 },
  { 26, 3, 8, 3, 0, -7 },
  { 29, 4, 8, 3, -1, -7 },
  { 33, 3, 4, 4, 1, -7 },
  { 35, 4, 4, 5, 0, -5 },
  { 37, 2, 2, 2, 0, -1 },
  { 38, 3, 1, 3, 0, -3 },
  { 39, 2, 1, 2, 0, -1 },
  { 40, 4, 7, 4, 0, -7 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 3, 6, 4, 1, -6 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 7, 4, 0, -7 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 0, -6 },
  { 65, 5, 7, 4, 0, -7 },
  { 70, 5, 6, 4, 0, -6 },
  { 74, 4, 7, 4, 0, -7 },
  { 78, 4, 7, 4, 0, -7 },
  { 82, 2, 5, 2, 0, -5 },
  { 84, 3, 6, 2, -1, -5 },
  { 87, 4, 5, 5, 0, -6 },
  { 90, 4, 3, 5, 0, -5 },
  { 92, 4, 5, 5, 0, -6 },
  { 95, 4, 7, 4, 0, -7 },
  { 99, 7, 7, 7, 0, -6 },
  { 106, 5, 6, 5, -1, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 5, 7, 5, 0, -7 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 4, 6, 4, 0, -6 },
  { 126, 4, 6, 4, 0, -6 },
  { 129, 5, 7, 5, 0, -7 },
  { 134, 6, 6, 5, 0, -6 },
  { 139, 4, 6, 3, 0, -6 },
  { 142, 4, 8, 3, -1, -6 },
  { 146, 6, 6, 5, 0, -6 },
  { 151, 3, 6, 4, 0, -6 },
  { 154, 7, 6, 7, 0, -6 },
  { 160, 6, 6, 6, 0, -6 },
  { 165, 5, 7, 5, 0, -7 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 5, 9, 5, 0, -7 },
  { 180, 5, 6, 5, 0, -6 },
  { 184, 4, 7, 4, 0, -7 },
  { 188, 4, 6, 4, 1, -6 },
  { 191, 5, 6, 5, 0, -6 },
  { 195, 5, 6, 5, 1, -6 },
  { 199, 7, 6, 7, 1, -6 },
  { 205, 6, 6, 5, -1, -6 },
  { 210, 4, 6, 4, 1, -6 },
  { 213, 5, 6, 4, 0, -6 },
  { 217, 3, 8, 3, 0, -7 },
  { 220, 2, 7, 4, 1, -7 },
  { 222, 4, 8, 3, -1, -7 },
  { 226, 4, 4, 4, 0, -6 },
  { 228, 4, 1, 3, -1, 1 },
  { 229, 2, 2, 3, 1, -7 },
  { 230, 5, 5, 5, 0, -5 },
  { 234, 4, 7, 5, 0, -7 },
  { 238, 4, 5, 4, 0, -5 },
  { 241, 5, 7, 5, 0, -7 },
  { 246, 4, 5, 4, 0, -5 },
  { 249, 5, 9, 3, -1, -7 },
  { 255, 5, 7, 5, 0, -5 },
  { 260, 4, 7, 5, 0, -7 },
  { 264, 3, 7, 2, 0, -7 },
  { 267, 4, 9, 2, -1, -7 },
  { 272, 5, 7, 4, 0, -7 },
  { 277, 3, 7, 2, 0, -7 },
  { 280, 7, 5, 7, 0, -5 },
  { 285, 4, 5, 5, 0, -5 },
  { 288, 4, 5, 5, 0, -5 },
  { 291, 4, 7, 5, 0, -5 },
  { 295, 5, 7, 5, 0, -5 },
  { 300, 4, 5, 3, 0, -5 },
  { 303, 4, 5, 4, 0, -5 },
  { 306, 3, 6, 3, 0, -6 },
  { 309, 5, 5, 5, 0, -5 },
  { 313, 4, 5, 4, 1, -5 },
  { 316, 6, 5, 6, 1, -5 },
  { 320, 5, 5, 4, 0, -5 },
  { 324, 6, 7, 4, -1, -5 },
  { 330, 4, 5, 4, 0, -5 },
  { 333, 4, 7, 3, 0, -6 },
  { 337, 1, 9, 4, 1, -7 },
  { 339, 4, 7, 3, -1, -6 },
  { 343, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC9PT7B_H_
