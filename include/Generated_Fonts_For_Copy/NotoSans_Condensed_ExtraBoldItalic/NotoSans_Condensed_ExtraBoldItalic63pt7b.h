#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC63PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00,
  0x38, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0xE3, 0xFE,
  0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFC,
  0x7F, 0xC3, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFB, 0xC7, 0x80, 0x7F, 0xCF, 0x06, 0x01, 0xFF,
  0x38, 0x00, 0x07, 0xF8, 0xE0, 0x00, 0x1F, 0xF3, 0x80, 0x00, 0x7F, 0xDE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xDF, 0xF8, 0x00, 0x0F, 0x3F, 0xE0, 0x00, 0x3C, 0xFF, 0x04, 0x00, 0xE3,
  0xFC, 0x1C, 0x03, 0x9F, 0xF0, 0x7C, 0x1E, 0x7F, 0xC1, 0xFE, 0x7F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x7F,
  0x00, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0xFE, 0x03, 0x81, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x8F, 0xE1, 0xFC,
  0x7F, 0x1F, 0xFE, 0x3F, 0x9F, 0xE7, 0xF1, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F,
  0x8F, 0xFF, 0xCF, 0xFF, 0xF3, 0xF8, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xCF,
  0xFF, 0xF9, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xFF, 0x1F, 0xC7, 0xF0,
  0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0x38, 0x0F, 0xE3, 0xFC, 0x3F,
  0x80, 0x00, 0xFF, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0x83, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F,
  0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFE,
  0x03, 0xFF, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF,
  0xF1, 0xFF, 0x07, 0xFE, 0xFF, 0xCF, 0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x0C, 0x07, 0xF0, 0x03, 0xC1, 0xFC, 0x00, 0xF8,
  0x7E, 0x00, 0x7F, 0x9F, 0x80, 0xDF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x41, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xF7, 0xF0, 0x1F, 0xF9, 0xFE, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xF0, 0x0F, 0x83, 0xFC, 0x01, 0xC0, 0xFE,
  0x00, 0x10, 0x3E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0x1F, 0xC7, 0xFD, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xCF, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x1F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFF, 0x01,
  0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7,
  0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0,
  0x3F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE,
  0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xF8,
  0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFB, 0xFE, 0x1F,
  0xE7, 0xFC, 0x1F, 0x8F, 0xF8, 0x3C, 0x3F, 0xF0, 0x30, 0x7F, 0xC0, 0x40,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x87, 0xFF, 0x00, 0x3E, 0x03,
  0xFF, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x18, 0x03, 0xFF, 0x00, 0x10, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x1F, 0xFC,
  0x01, 0x80, 0x3F, 0xF8, 0x02, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x84, 0x00, 0x07, 0xFF, 0x08, 0x00, 0x1F, 0xFC, 0x1E, 0x00, 0x7F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xF8,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x3F, 0x9F, 0xF0,
  0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x7F, 0x3F, 0xF0, 0x00, 0xFE, 0x3F, 0xE0,
  0x01, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xF8, 0x3F, 0xE0,
  0x07, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0x83, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x08, 0x00, 0x1F, 0xF8, 0x30,
  0x00, 0xFF, 0xE0, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x7F, 0xC7, 0xF8,
  0x03, 0xFF, 0x7F, 0xF0, 0x0F, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFD, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x8F, 0xFE, 0x07, 0xFE, 0x3F, 0xF8,
  0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x07,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x03, 0xFF,
  0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07,
  0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF,
  0x87, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x8F, 0xFC,
  0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F,
  0xF8, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0xF1,
  0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF7, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0x7F, 0xC0, 0x7F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x81, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x03, 0xF7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0x03, 0xFF, 0x0C,
  0x01, 0xFF, 0x08, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xFF,
  0x87, 0xF0, 0x7F, 0x03, 0xFF, 0xFC, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC7,
  0xF0, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x1F, 0xC1, 0xFF, 0xFF, 0x87, 0xF1,
  0xF8, 0x3F, 0xC3, 0xF8, 0x7F, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF3, 0xF8,
  0x7F, 0x03, 0xF0, 0x7F, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF7, 0xF0, 0xFE,
  0x07, 0xF0, 0x7E, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xE7, 0xE0, 0xFC, 0x07,
  0xE0, 0x7E, 0x7E, 0x1F, 0xC0, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0x0F, 0xE0,
  0xFC, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0x1F, 0xC0, 0xFC,
  0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x1F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x83, 0xFC, 0x3F, 0x0F, 0xC1, 0xFC, 0x7F, 0xC7, 0xF0, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0xFF,
  0x7F, 0xFC, 0x0F, 0xC0, 0xFF, 0xE7, 0xFF, 0x80, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x7F,
  0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF7,
  0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x78, 0x07, 0xFF, 0x80, 0x10, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x02, 0x00, 0xFF, 0xF0, 0x1E, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xCF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xE0,
  0x1F, 0xFF, 0x00, 0x18, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xC7, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFF,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xFE,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x7F, 0x7F, 0xC0, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xF0,
  0x07, 0xFD, 0xFE, 0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0x87, 0xF9, 0xFF,
  0x00, 0x7F, 0xDF, 0xE1, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0xFF, 0x3F,
  0xE0, 0x07, 0xF9, 0xFE, 0x3F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0x9F, 0xE3,
  0xFE, 0x00, 0xFF, 0x9F, 0xE7, 0xF9, 0xFF, 0x80, 0x3F, 0xE3, 0xF9, 0xFC,
  0x7F, 0xC0, 0x0F, 0xF8, 0xFE, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xBF,
  0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFF,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF0, 0x07,
  0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F,
  0xF8, 0x03, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xBF, 0xC1, 0xFF, 0x00,
  0x3F, 0xCF, 0xF8, 0x7F, 0xC0, 0x0F, 0xF3, 0xFE, 0x1F, 0xF0, 0x07, 0xFC,
  0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC,
  0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xCF, 0xF8,
  0x03, 0xFE, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0x03, 0xFC, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xC7,
  0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00,
  0x7F, 0xF7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF8,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xC7, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF,
  0x07, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF8,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xBF,
  0xF8, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xF8, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0x3F,
  0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE,
  0x1F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE,
  0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xE0, 0x0F, 0xFE, 0x01, 0xC0, 0x1F,
  0xF8, 0x00, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x82, 0x00, 0x07, 0xFF, 0x03, 0x00, 0x0F, 0xFC, 0x07,
  0x80, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE0, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0x87, 0xFC, 0x03,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xF7, 0xF8, 0xFF, 0x80,
  0x3F, 0xE3, 0xFD, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x7F, 0x9F, 0xF8,
  0x03, 0xFE, 0x7F, 0x9F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xE7, 0xF9, 0xFF,
  0x00, 0x3F, 0xE7, 0xF9, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x7F, 0xBF,
  0xE0, 0x03, 0xFE, 0xFF, 0x1F, 0xCF, 0xF8, 0x00, 0xFF, 0xFF, 0x87, 0xF7,
  0xFC, 0x00, 0x3F, 0xFF, 0xE1, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x01,
  0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF,
  0x01, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0,
  0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x00,
  0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFC,
  0x03, 0xFF, 0x8F, 0xF0, 0x1F, 0xFE, 0x3F, 0xC0, 0xFF, 0xFD, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x03,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF,
  0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE3,
  0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0,
  0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xFB, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF, 0x00,
  0xFF, 0xE7, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0xBF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE,
  0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x0F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF8,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xE7, 0xFF, 0xC0, 0x3F, 0xC7, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFC, 0x0E, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x04, 0x0F, 0xFC, 0x07,
  0x03, 0xFF, 0xCF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xEF, 0xF8,
  0x03, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE3, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xEF, 0xF0, 0x03,
  0xFF, 0xE7, 0xF8, 0x00, 0xFF, 0xE3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x1F, 0xF8, 0x1F, 0xE3,
  0xFE, 0x03, 0xFC, 0xFF, 0xC0, 0x7F, 0x9F, 0xF0, 0x1F, 0xF7, 0xFE, 0x07,
  0xFE, 0xFF, 0x81, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x10,
  0x7F, 0xE0, 0x1E, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0x9F, 0xE0,
  0x0F, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x8F, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x03,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE,
  0x1F, 0xFC, 0x03, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x04, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xC0, 0x01, 0xFF, 0x80,
  0x78, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0xFF, 0xBF, 0xFC, 0x01, 0xFE, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x01, 0xFF,
  0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x21, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00,
  0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC7, 0xFF, 0x8F, 0xFF, 0x80, 0x7F,
  0x3F, 0xFF, 0x7F, 0xFE, 0x03, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x8F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xE1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0xE0, 0x07,
  0xF1, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF,
  0x81, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF, 0x01,
  0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFE,
  0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xF8,
  0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x03, 0xF8,
  0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0xFC, 0x00, 0x7F, 0xBF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0xC0, 0x07, 0xFC, 0xFF,
  0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC1, 0xFC, 0x01, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0x3F, 0xC0, 0x7F, 0xFD,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF,
  0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF9, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD,
  0xFF, 0x00, 0xFF, 0xEF, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xC0, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xF3, 0xFE, 0x03, 0xFD, 0xFF, 0x80, 0xFF,
  0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF0, 0xFC, 0x0F, 0xFC, 0x06, 0x03, 0xFE, 0x00, 0x80, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x20, 0x03, 0xFF,
  0x0E, 0x00, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xF1, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x01,
  0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F,
  0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07,
  0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x83,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFB, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xBF, 0xC0, 0x7F, 0xFC, 0xFF, 0x00, 0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0x0F,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8,
  0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0xFF,
  0x80, 0x7F, 0x9F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07,
  0xFB, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xEF, 0xF8, 0x3F, 0xFC, 0x0F, 0xF9, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0xFF, 0xF0, 0x7F, 0xC7, 0xFC, 0x3F,
  0xFE, 0x0F, 0xF8, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0x1F, 0xF0, 0xFF, 0xF8,
  0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7, 0xFF, 0xE3, 0xFE,
  0x0F, 0xF1, 0xFD, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xBF, 0x8F, 0xF0, 0x3F,
  0xC7, 0xF7, 0xF3, 0xFE, 0x07, 0xF9, 0xFC, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F,
  0x9F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF3, 0xFB, 0xFE, 0x03, 0xFD, 0xFC, 0xFF,
  0x7F, 0x80, 0x7F, 0xBF, 0x9F, 0xDF, 0xF0, 0x0F, 0xF7, 0xE3, 0xFB, 0xFC,
  0x01, 0xFF, 0xFC, 0x7F, 0x7F, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x87,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x13, 0xFF, 0x80, 0x03,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xEC, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 19, 46, 17, 0, -45 },
  { 111, 24, 16, 27, 6, -45 },
  { 159, 36, 45, 34, 0, -45 },
  { 362, 30, 52, 30, 1, -48 },
  { 557, 45, 47, 50, 3, -46 },
  { 822, 38, 47, 38, 0, -46 },
  { 1046, 12, 16, 15, 6, -45 },
  { 1070, 23, 56, 19, 1, -46 },
  { 1231, 23, 56, 19, -5, -46 },
  { 1392, 26, 28, 29, 5, -48 },
  { 1483, 27, 30, 32, 3, -37 },
  { 1585, 15, 17, 17, -3, -8 },
  { 1617, 17, 8, 19, 1, -21 },
  { 1634, 11, 11, 17, 0, -10 },
  { 1650, 34, 46, 25, -3, -45 },
  { 1846, 28, 47, 30, 2, -46 },
  { 2011, 23, 45, 31, 6, -45 },
  { 2141, 32, 46, 30, -2, -46 },
  { 2325, 31, 47, 30, 0, -46 },
  { 2508, 32, 45, 31, -1, -45 },
  { 2688, 30, 46, 30, 1, -45 },
  { 2861, 30, 47, 30, 2, -46 },
  { 3038, 32, 45, 30, 2, -45 },
  { 3218, 30, 47, 30, 1, -46 },
  { 3395, 29, 47, 30, 1, -46 },
  { 3566, 17, 36, 17, 0, -35 },
  { 3643, 21, 44, 17, -4, -35 },
  { 3759, 27, 32, 32, 3, -39 },
  { 3867, 28, 20, 32, 3, -32 },
  { 3937, 28, 32, 32, 3, -39 },
  { 4049, 24, 47, 25, 3, -46 },
  { 4190, 44, 50, 46, 2, -45 },
  { 4465, 34, 45, 34, -4, -45 },
  { 4657, 34, 45, 34, 0, -45 },
  { 4849, 32, 47, 32, 3, -46 },
  { 5037, 35, 45, 36, 0, -45 },
  { 5234, 31, 45, 28, 0, -45 },
  { 5409, 31, 45, 28, 0, -45 },
  { 5584, 35, 47, 37, 3, -46 },
  { 5790, 39, 45, 37, 0, -45 },
  { 6010, 29, 45, 23, -2, -45 },
  { 6174, 30, 59, 18, -10, -45 },
  { 6396, 39, 45, 33, 0, -45 },
  { 6616, 24, 45, 27, 0, -45 },
  { 6751, 50, 45, 49, 0, -45 },
  { 7033, 42, 45, 40, 0, -45 },
  { 7270, 35, 47, 38, 3, -46 },
  { 7476, 34, 45, 32, 0, -45 },
  { 7668, 35, 57, 38, 3, -46 },
  { 7918, 33, 45, 33, 0, -45 },
  { 8104, 31, 47, 29, 0, -46 },
  { 8287, 28, 45, 28, 5, -45 },
  { 8445, 35, 46, 36, 3, -45 },
  { 8647, 33, 45, 33, 6, -45 },
  { 8833, 50, 45, 49, 5, -45 },
  { 9115, 41, 45, 33, -4, -45 },
  { 9346, 31, 45, 31, 6, -45 },
  { 9521, 34, 45, 28, -2, -45 },
  { 9713, 26, 56, 19, -2, -46 },
  { 9895, 15, 46, 25, 6, -45 },
  { 9982, 27, 56, 19, -5, -46 },
  { 10171, 30, 29, 30, 0, -45 },
  { 10280, 25, 6, 24, -6, 5 },
  { 10299, 13, 10, 20, 9, -48 },
  { 10316, 30, 36, 32, 2, -35 },
  { 10451, 31, 49, 32, 0, -48 },
  { 10641, 26, 36, 26, 2, -35 },
  { 10758, 33, 49, 32, 2, -48 },
  { 10961, 27, 36, 30, 2, -35 },
  { 11083, 34, 63, 20, -7, -48 },
  { 11351, 33, 50, 32, -1, -35 },
  { 11558, 31, 48, 32, 0, -48 },
  { 11744, 19, 48, 16, 0, -48 },
  { 11858, 27, 63, 16, -8, -48 },
  { 12071, 34, 48, 31, 0, -48 },
  { 12275, 19, 48, 16, 0, -48 },
  { 12389, 46, 35, 48, 0, -35 },
  { 12591, 31, 35, 32, 0, -35 },
  { 12727, 28, 36, 32, 2, -35 },
  { 12853, 34, 50, 32, -3, -35 },
  { 13066, 30, 50, 32, 2, -35 },
  { 13254, 26, 35, 23, 0, -35 },
  { 13368, 26, 36, 26, 0, -35 },
  { 13485, 21, 43, 22, 3, -42 },
  { 13598, 30, 36, 32, 2, -35 },
  { 13733, 28, 35, 29, 4, -35 },
  { 13856, 43, 35, 44, 4, -35 },
  { 14045, 35, 35, 29, -3, -35 },
  { 14199, 36, 50, 29, -4, -35 },
  { 14424, 29, 35, 25, -2, -35 },
  { 14551, 26, 55, 22, 0, -45 },
  { 14730, 7, 62, 27, 10, -48 },
  { 14785, 25, 55, 22, -4, -45 },
  { 14957, 28, 11, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC63PT7B_H_
