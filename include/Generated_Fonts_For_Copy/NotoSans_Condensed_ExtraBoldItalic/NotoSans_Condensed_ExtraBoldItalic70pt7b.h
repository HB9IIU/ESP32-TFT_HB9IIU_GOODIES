#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC70PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0x0F, 0xFC, 0xFF, 0xC7, 0xFE, 0x3F,
  0xE1, 0xFF, 0x9F, 0xF8, 0x7F, 0xE7, 0xFE, 0x1F, 0xF9, 0xFF, 0x07, 0xFC,
  0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F,
  0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xC7, 0xE0, 0x0F,
  0xFC, 0xF0, 0x30, 0x03, 0xFE, 0x3C, 0x04, 0x00, 0xFF, 0x8E, 0x00, 0x00,
  0x3F, 0xE3, 0x80, 0x00, 0x0F, 0xF9, 0xE0, 0x00, 0x03, 0xFF, 0x78, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3D, 0xFF, 0xC0,
  0x00, 0x0F, 0x3F, 0xF0, 0x00, 0x03, 0x8F, 0xFC, 0x10, 0x01, 0xE3, 0xFE,
  0x06, 0x00, 0x78, 0xFF, 0x81, 0xE0, 0x1E, 0x7F, 0xE0, 0x7E, 0x07, 0xBF,
  0xF8, 0x1F, 0xF9, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0x00, 0x1F,
  0xE3, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x1E, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0xFE, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF, 0xFF, 0x7F, 0xFF, 0xE3, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xF1, 0xFE, 0x7F,
  0xCF, 0xF7, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF9, 0xFF, 0xF1, 0xFE, 0x3F,
  0xE1, 0xFC, 0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x07, 0x80, 0xFF, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x87,
  0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8,
  0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xC3,
  0xFF, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0,
  0x7F, 0xF3, 0xFF, 0xBF, 0xF8, 0x3F, 0xF8, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC7,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x7F, 0xF8, 0x01, 0xFF,
  0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0x00,
  0xFF, 0x80, 0x07, 0x03, 0xFC, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x03, 0xFE, 0xFF, 0x03, 0x9F, 0xFF, 0xF9, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF9, 0xFE, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0xFE, 0x1F, 0xF8, 0x01, 0xF8, 0x3F, 0xF0, 0x03, 0xC0, 0xFF,
  0x00, 0x06, 0x03, 0xF0, 0x00, 0x08, 0x07, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x7F, 0x81, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFE,
  0x03, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFF,
  0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x07, 0xFF,
  0x3F, 0xF8, 0x07, 0xFE, 0x3F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE,
  0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE,
  0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC,
  0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC,
  0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0x7F, 0xE1, 0xFF, 0x9F, 0xF8,
  0x3F, 0xC7, 0xFE, 0x07, 0xE3, 0xFF, 0x81, 0xF0, 0xFF, 0xC0, 0x30, 0x3F,
  0xF0, 0x08, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0xE0, 0x03, 0xF8, 0x0F, 0xFF, 0x00, 0x1E, 0x00,
  0xFF, 0xF0, 0x01, 0xC0, 0x07, 0xFE, 0x00, 0x08, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x3F, 0xFC, 0x00, 0xE0, 0x07, 0xFF, 0x00, 0x20, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC2, 0x00, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x7F, 0xF8, 0x3C,
  0x00, 0x3F, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0xF8, 0x00, 0x07, 0xFB, 0xFF,
  0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x0F, 0xF3,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0x1F, 0xFC, 0x00, 0x1F,
  0xE3, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xC1, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xF0, 0x03, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x06, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x08, 0x00, 0x0F, 0xFF, 0x03, 0x00,
  0x07, 0xFF, 0xC0, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC1, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0x00, 0x7F,
  0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xFC, 0x03,
  0xFF, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8,
  0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF,
  0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xF7, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFE,
  0x1F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x3F, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x3E, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFE,
  0x3F, 0xFC, 0x3E, 0x03, 0xFF, 0x87, 0x00, 0x3F, 0xF0, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xF1, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x87, 0xF8, 0x1F, 0xFF,
  0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xF0,
  0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF9, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x7F, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x3F, 0x83, 0xFC,
  0x07, 0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE,
  0x03, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE7, 0xF8, 0x7F,
  0x80, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF9, 0xFC, 0x1F,
  0xE0, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x7F, 0x07,
  0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xC1,
  0xFE, 0x3F, 0xF1, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0x01, 0xFC,
  0x07, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFF,
  0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x80,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x30, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x40, 0x07, 0xFF, 0xC0, 0x3C, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0xF8, 0x01, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF, 0x83,
  0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xF9, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xC0, 0x1F, 0xFF, 0x80, 0x03, 0x00, 0x3F, 0xFE, 0x00, 0x02, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFF, 0xF0, 0x7F, 0xF0, 0x20, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xC1, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE1, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xCF, 0xFF,
  0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00,
  0x00, 0x1F, 0xFB, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xF0, 0x01,
  0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC3, 0xFE, 0x7F, 0xE0, 0x03, 0xFE,
  0x7F, 0xC3, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xC3, 0xFC, 0xFF, 0xC0,
  0x07, 0xFE, 0x7F, 0xC7, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xC7, 0xF8,
  0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x7F,
  0xCF, 0xF1, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xDF, 0xF1, 0xFF, 0x80, 0x0F,
  0xFC, 0x7F, 0xDF, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF,
  0x80, 0x0F, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFD,
  0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF3,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xCF,
  0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x1F,
  0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F,
  0xE7, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE1, 0xFF,
  0x9F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFF,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0,
  0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x07, 0xFF, 0xBF, 0xFC,
  0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x01, 0xFF, 0xEF, 0xFF,
  0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xF9, 0xFF,
  0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xE7,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFF,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0,
  0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x07, 0xFF, 0xBF, 0xFC,
  0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x01, 0xFF, 0xEF, 0xFF,
  0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xF9, 0xFF,
  0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFF,
  0xC0, 0x1F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x07, 0xFF,
  0x87, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0x00, 0x3F,
  0xFC, 0x00, 0x40, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x10, 0x00, 0x1F, 0xFC, 0x03, 0x00, 0x03, 0xFF,
  0x80, 0x78, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xCF,
  0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0x87, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x7F, 0xC7, 0xFF, 0x00, 0x7F,
  0xE3, 0xFE, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFD, 0xFE, 0x1F, 0xF8,
  0x01, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xE7, 0xF8,
  0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0x8F, 0xF3, 0xFF, 0x80, 0x0F, 0xF9, 0xFF,
  0x1F, 0xE7, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x3F, 0xCF, 0xFC, 0x00, 0x3F,
  0xEF, 0xF8, 0x7F, 0xBF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0xFF, 0x7F, 0xE0,
  0x00, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF7, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE,
  0x3F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F,
  0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0xC0,
  0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF,
  0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F,
  0xCF, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x0F,
  0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xF3,
  0xFE, 0x01, 0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE1,
  0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFD, 0xFF, 0x80, 0x3F, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x3F, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xDF, 0xFE, 0x00, 0x7F,
  0xEF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x01,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0,
  0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x87,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xF0, 0x0F, 0xF9, 0xFF, 0xF8, 0x03, 0xFE,
  0x3F, 0xFC, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x0C,
  0x07, 0xFF, 0x80, 0x20, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x40, 0x7F, 0xF8, 0x0E,
  0x03, 0xFF, 0xE1, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x83, 0xFF, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xEF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0,
  0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xCF, 0xF0, 0x00, 0x3F, 0xFC, 0x7F,
  0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFC, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0x80,
  0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x30, 0x3F, 0xFC, 0x01, 0xE0, 0x7F,
  0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x02,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x03, 0xFF,
  0xE7, 0xFE, 0x00, 0x3F, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xE0,
  0x00, 0x0E, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x08,
  0x00, 0x07, 0xFE, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0x80, 0x03,
  0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xDF, 0xFF, 0x00, 0x7F, 0xEF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x8F,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x02, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF,
  0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFC, 0x7F,
  0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x1F, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC3,
  0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xFE, 0x01, 0xFF,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0,
  0x3F, 0xF3, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x01,
  0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xE7,
  0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC3, 0xFF, 0x00,
  0x00, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xFC, 0x00, 0x1F, 0xF7,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xF8, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x1F,
  0xF0, 0x07, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xFE,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F,
  0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8,
  0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03,
  0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFD, 0xFF,
  0x80, 0x3F, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x07, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC7,
  0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF7, 0xFF, 0x00, 0xFF, 0xBF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xC0, 0x7F, 0xF0, 0x0E,
  0x03, 0xFF, 0x80, 0x20, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x08, 0x00, 0x3F, 0xF8, 0x70, 0x03, 0xFF,
  0x83, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x30, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xFB, 0xFE, 0x00, 0xFF, 0xFC,
  0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x7F,
  0xCF, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFE, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFE, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF,
  0xCF, 0xF7, 0xF8, 0xFF, 0xC0, 0xFF, 0xCF, 0xF7, 0xF8, 0xFF, 0x80, 0xFF,
  0xCF, 0xF7, 0xF9, 0xFF, 0x80, 0xFF, 0xDF, 0xE7, 0xF9, 0xFF, 0x80, 0xFF,
  0xDF, 0xE7, 0xFB, 0xFF, 0x00, 0xFF, 0x9F, 0xE7, 0xFB, 0xFF, 0x00, 0xFF,
  0xBF, 0xC7, 0xFB, 0xFE, 0x00, 0xFF, 0xBF, 0xC7, 0xFB, 0xFE, 0x00, 0xFF,
  0xBF, 0x87, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF8,
  0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x02, 0x3F, 0xFC, 0x00, 0x05, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFB, 0x00, 0x07, 0xFF, 0xE4, 0x00, 0x03, 0xFF, 0x88,
  0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 22, 51, 19, 0, -50 },
  { 142, 26, 18, 30, 7, -50 },
  { 201, 40, 50, 38, 0, -50 },
  { 451, 34, 57, 34, 1, -53 },
  { 694, 49, 52, 55, 4, -51 },
  { 1013, 42, 52, 42, 0, -51 },
  { 1286, 13, 18, 17, 7, -50 },
  { 1316, 25, 62, 21, 1, -51 },
  { 1510, 25, 62, 21, -5, -51 },
  { 1704, 30, 32, 32, 5, -54 },
  { 1824, 31, 34, 36, 3, -42 },
  { 1956, 17, 18, 18, -4, -9 },
  { 1995, 19, 10, 21, 1, -24 },
  { 2019, 12, 12, 18, 0, -11 },
  { 2037, 38, 52, 28, -4, -51 },
  { 2284, 32, 52, 34, 2, -51 },
  { 2492, 26, 50, 34, 6, -50 },
  { 2655, 36, 51, 34, -2, -51 },
  { 2885, 34, 52, 34, 0, -51 },
  { 3106, 35, 50, 34, -1, -50 },
  { 3325, 34, 51, 34, 1, -50 },
  { 3542, 34, 52, 34, 2, -51 },
  { 3763, 36, 50, 34, 2, -50 },
  { 3988, 34, 52, 34, 1, -51 },
  { 4209, 33, 52, 34, 1, -51 },
  { 4424, 18, 40, 19, 0, -39 },
  { 4514, 22, 48, 19, -4, -39 },
  { 4646, 31, 35, 36, 3, -43 },
  { 4782, 31, 23, 36, 3, -36 },
  { 4872, 31, 35, 36, 3, -43 },
  { 5008, 27, 52, 27, 3, -51 },
  { 5184, 49, 56, 51, 2, -50 },
  { 5527, 38, 50, 38, -4, -50 },
  { 5765, 38, 50, 37, 0, -50 },
  { 6003, 36, 52, 35, 3, -51 },
  { 6237, 39, 50, 40, 0, -50 },
  { 6481, 35, 50, 32, 0, -50 },
  { 6700, 35, 50, 31, 0, -50 },
  { 6919, 39, 52, 41, 3, -51 },
  { 7173, 44, 50, 42, 0, -50 },
  { 7448, 33, 50, 25, -3, -50 },
  { 7655, 33, 65, 20, -11, -50 },
  { 7924, 44, 50, 37, 0, -50 },
  { 8199, 26, 50, 30, 0, -50 },
  { 8362, 56, 50, 54, 0, -50 },
  { 8712, 47, 50, 45, 0, -50 },
  { 9006, 39, 52, 43, 3, -51 },
  { 9260, 38, 50, 36, 0, -50 },
  { 9498, 39, 63, 43, 3, -51 },
  { 9806, 37, 50, 37, 0, -50 },
  { 10038, 35, 52, 32, 0, -51 },
  { 10266, 32, 50, 32, 5, -50 },
  { 10466, 40, 51, 41, 3, -50 },
  { 10721, 37, 50, 37, 6, -50 },
  { 10953, 55, 50, 54, 6, -50 },
  { 11297, 45, 50, 36, -4, -50 },
  { 11579, 35, 50, 35, 6, -50 },
  { 11798, 39, 50, 31, -3, -50 },
  { 12042, 29, 62, 21, -3, -51 },
  { 12267, 16, 52, 28, 7, -51 },
  { 12371, 29, 62, 21, -5, -51 },
  { 12596, 33, 32, 33, 0, -50 },
  { 12728, 28, 7, 26, -7, 5 },
  { 12753, 15, 12, 22, 10, -54 },
  { 12776, 34, 40, 36, 2, -39 },
  { 12946, 34, 54, 36, 0, -53 },
  { 13176, 29, 40, 29, 2, -39 },
  { 13321, 37, 54, 36, 2, -53 },
  { 13571, 31, 40, 33, 2, -39 },
  { 13726, 38, 71, 23, -8, -54 },
  { 14064, 37, 56, 36, -1, -39 },
  { 14323, 34, 53, 36, 0, -53 },
  { 14549, 21, 54, 18, 0, -54 },
  { 14691, 30, 71, 18, -9, -54 },
  { 14958, 38, 53, 35, 0, -53 },
  { 15210, 22, 53, 18, 0, -53 },
  { 15356, 51, 39, 53, 0, -39 },
  { 15605, 34, 39, 36, 0, -39 },
  { 15771, 31, 40, 35, 2, -39 },
  { 15926, 38, 56, 36, -4, -39 },
  { 16192, 34, 56, 36, 2, -39 },
  { 16430, 29, 39, 25, 0, -39 },
  { 16572, 29, 40, 28, 0, -39 },
  { 16717, 23, 47, 25, 3, -46 },
  { 16853, 34, 39, 36, 2, -38 },
  { 17019, 32, 38, 32, 4, -38 },
  { 17171, 48, 38, 48, 4, -38 },
  { 17399, 40, 38, 33, -4, -38 },
  { 17589, 41, 55, 32, -5, -38 },
  { 17871, 32, 38, 28, -2, -38 },
  { 18023, 29, 61, 24, 0, -50 },
  { 18245, 8, 70, 30, 11, -54 },
  { 18315, 28, 61, 24, -4, -50 },
  { 18529, 31, 13, 36, 3, -31 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC70PT7B_H_
