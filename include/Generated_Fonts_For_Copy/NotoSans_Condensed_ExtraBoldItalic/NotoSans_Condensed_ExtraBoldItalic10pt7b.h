#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC10PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0xB0, 0xFA, 0x38, 0xA7, 0xD4, 0xF9, 0x4E, 0x00, 0x11,
  0xDA, 0xC3, 0x1B, 0xCC, 0x40, 0xED, 0x53, 0xC7, 0xF2, 0xEB, 0xB3, 0x00,
  0x39, 0xA7, 0x1F, 0xFB, 0x6F, 0x80, 0xE0, 0x36, 0x44, 0xCC, 0xCC, 0x40,
  0x33, 0x33, 0x32, 0x64, 0xC0, 0x2E, 0xFE, 0xA0, 0x21, 0x3E, 0x42, 0x00,
  0x78, 0xE0, 0x70, 0x0C, 0x21, 0x0C, 0x21, 0x8C, 0x00, 0x3B, 0xD7, 0xBD,
  0x79, 0x80, 0x3E, 0xA6, 0x64, 0x40, 0x7A, 0xC6, 0x66, 0x63, 0xC0, 0x7A,
  0xC4, 0xE1, 0x5B, 0x80, 0x19, 0xCC, 0xAF, 0xF8, 0x80, 0x3B, 0x18, 0xE1,
  0x5B, 0x80, 0x3B, 0x15, 0xFD, 0xE9, 0xC0, 0x78, 0xC4, 0x62, 0x33, 0x00,
  0x7A, 0xDC, 0xED, 0x6B, 0xC0, 0x72, 0xD6, 0xF5, 0x1B, 0x80, 0x4C, 0x05,
  0x80, 0x23, 0x00, 0x06, 0xC0, 0x09, 0xB0, 0x70, 0x80, 0xF8, 0x3E, 0xC3,
  0x86, 0xC8, 0x00, 0x75, 0x36, 0x44, 0xC0, 0x3E, 0xC5, 0x7D, 0x5A, 0xB7,
  0x91, 0x1C, 0x1C, 0x73, 0xCB, 0x3D, 0xBC, 0xC0, 0x7B, 0x56, 0xE5, 0xEF,
  0xC0, 0x3D, 0x84, 0x10, 0xC3, 0x27, 0x00, 0x79, 0xB6, 0xD3, 0x4B, 0x6F,
  0x00, 0x7B, 0x18, 0xE4, 0x63, 0xC0, 0x7B, 0x18, 0xE4, 0x63, 0x00, 0x3D,
  0x94, 0x17, 0xC9, 0x67, 0x80, 0x65, 0xB6, 0xDE, 0x4B, 0x6D, 0x80, 0x72,
  0x66, 0x44, 0xE0, 0x18, 0xC6, 0x21, 0x18, 0xC4, 0xE0, 0x6D, 0xE7, 0x1C,
  0x53, 0x4D, 0x80, 0x66, 0x64, 0x4C, 0xF0, 0x73, 0x77, 0x76, 0x7A, 0x7A,
  0xDE, 0xD6, 0x66, 0xE9, 0xD2, 0xE5, 0xDB, 0x36, 0x00, 0x3D, 0xB4, 0xD3,
  0xCF, 0x67, 0x00, 0x7B, 0x5A, 0xF6, 0x63, 0x00, 0x3D, 0xB4, 0xD3, 0xCF,
  0x67, 0x04, 0x18, 0x7B, 0x5A, 0xF5, 0x6B, 0x60, 0x7B, 0x58, 0xE3, 0x5B,
  0x80, 0xF6, 0x44, 0xCC, 0xC0, 0x6D, 0xB6, 0xD2, 0x4B, 0x67, 0x00, 0x9C,
  0xAD, 0x4A, 0x73, 0x00, 0x93, 0xB2, 0xB6, 0xB4, 0xDC, 0xD8, 0xD8, 0x36,
  0x78, 0x60, 0xC3, 0x8D, 0x33, 0x00, 0xDF, 0xB8, 0xC4, 0x63, 0x00, 0x78,
  0xCC, 0xC4, 0x63, 0xC0, 0x74, 0x44, 0x4C, 0x88, 0xC0, 0xBD, 0x54, 0x31,
  0x13, 0x22, 0x26, 0xE0, 0x31, 0x95, 0xB0, 0xF0, 0xCC, 0x23, 0xD7, 0xBD,
  0x78, 0x23, 0x1C, 0xF5, 0xAF, 0x56, 0x37, 0x4C, 0xD6, 0x0C, 0x22, 0x9E,
  0x5B, 0x6D, 0x3C, 0x33, 0xD7, 0xCC, 0x38, 0x18, 0xCE, 0xE2, 0x11, 0x8C,
  0x66, 0x00, 0x23, 0xD7, 0xBD, 0x78, 0xDC, 0x23, 0x1C, 0xF5, 0xAF, 0x5A,
  0x2C, 0xA4, 0xB6, 0x13, 0x12, 0x22, 0x66, 0x4C, 0x23, 0x18, 0xB7, 0x3B,
  0xDA, 0x2D, 0xA4, 0xB6, 0x12, 0xFD, 0x6A, 0xDD, 0x7A, 0xC0, 0x13, 0xD6,
  0xBD, 0x68, 0x33, 0xD7, 0xBD, 0x38, 0x08, 0xF2, 0xCB, 0x69, 0xE4, 0x30,
  0x23, 0xD7, 0xBD, 0x78, 0xC6, 0x17, 0x44, 0xCC, 0x27, 0x46, 0xBE, 0x26,
  0xF4, 0x4C, 0x60, 0x7A, 0xF7, 0xAF, 0x00, 0xBA, 0xEC, 0xC0, 0xB7, 0xFD,
  0xB6, 0xB0, 0x2C, 0xE3, 0x0E, 0xD8, 0x2C, 0xA3, 0x8C, 0x30, 0x8E, 0x00,
  0x72, 0x6C, 0xE0, 0x32, 0x66, 0xC4, 0x46, 0x20, 0xFF, 0xC0, 0x33, 0x33,
  0x32, 0x6E, 0x80, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 2, 4, 1, -7 },
  { 5, 6, 7, 5, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 7, 7, 8, 1, -7 },
  { 24, 6, 7, 6, 0, -7 },
  { 30, 2, 2, 2, 1, -7 },
  { 31, 4, 9, 3, 0, -7 },
  { 36, 4, 9, 3, -1, -7 },
  { 41, 4, 5, 5, 1, -8 },
  { 44, 5, 5, 5, 0, -6 },
  { 48, 3, 2, 3, -1, -1 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 2, 2, 3, 0, -2 },
  { 51, 6, 7, 4, -1, -7 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 4, 7, 5, 1, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 5, 7, 5, 0, -7 },
  { 96, 5, 7, 5, 0, -7 },
  { 101, 5, 7, 5, 0, -7 },
  { 106, 3, 6, 3, 0, -6 },
  { 109, 4, 7, 3, -1, -6 },
  { 113, 5, 5, 5, 0, -6 },
  { 117, 5, 3, 5, 0, -5 },
  { 119, 5, 5, 5, 0, -6 },
  { 123, 4, 7, 4, 0, -7 },
  { 127, 7, 8, 7, 0, -7 },
  { 134, 6, 7, 5, -1, -7 },
  { 140, 5, 7, 5, 0, -7 },
  { 145, 6, 7, 5, 0, -7 },
  { 151, 6, 7, 6, 0, -7 },
  { 157, 5, 7, 5, 0, -7 },
  { 162, 5, 7, 4, 0, -7 },
  { 167, 6, 7, 6, 0, -7 },
  { 173, 6, 7, 6, 0, -7 },
  { 179, 4, 7, 4, 0, -7 },
  { 183, 5, 9, 3, -2, -7 },
  { 189, 6, 7, 5, 0, -7 },
  { 195, 4, 7, 4, 0, -7 },
  { 199, 8, 7, 8, 0, -7 },
  { 206, 7, 7, 6, 0, -7 },
  { 213, 6, 7, 6, 0, -7 },
  { 219, 5, 7, 5, 0, -7 },
  { 224, 6, 9, 6, 0, -7 },
  { 231, 5, 7, 5, 0, -7 },
  { 236, 5, 7, 5, 0, -7 },
  { 241, 4, 7, 5, 1, -7 },
  { 245, 6, 7, 6, 0, -7 },
  { 251, 5, 7, 5, 1, -7 },
  { 256, 8, 7, 8, 1, -7 },
  { 263, 7, 7, 5, -1, -7 },
  { 270, 5, 7, 5, 1, -7 },
  { 275, 5, 7, 4, 0, -7 },
  { 280, 4, 9, 3, 0, -7 },
  { 285, 2, 7, 4, 1, -7 },
  { 287, 4, 9, 3, -1, -7 },
  { 292, 5, 4, 5, 0, -7 },
  { 295, 4, 1, 4, -1, 1 },
  { 296, 3, 2, 3, 1, -8 },
  { 297, 5, 6, 5, 0, -6 },
  { 301, 5, 8, 5, 0, -8 },
  { 306, 4, 6, 4, 0, -6 },
  { 309, 6, 8, 5, 0, -8 },
  { 315, 5, 6, 5, 0, -6 },
  { 319, 5, 10, 3, -1, -8 },
  { 326, 5, 8, 5, 0, -6 },
  { 331, 5, 8, 5, 0, -8 },
  { 336, 3, 8, 3, 0, -8 },
  { 339, 4, 10, 3, -1, -8 },
  { 344, 5, 8, 5, 0, -8 },
  { 349, 3, 8, 3, 0, -8 },
  { 352, 7, 6, 8, 0, -6 },
  { 358, 5, 6, 5, 0, -6 },
  { 362, 5, 6, 5, 0, -6 },
  { 366, 6, 8, 5, -1, -6 },
  { 372, 5, 8, 5, 0, -6 },
  { 377, 4, 6, 4, 0, -6 },
  { 380, 4, 6, 4, 0, -6 },
  { 383, 4, 7, 4, 0, -7 },
  { 387, 5, 5, 5, 0, -5 },
  { 391, 4, 5, 5, 1, -5 },
  { 394, 6, 5, 7, 1, -5 },
  { 398, 6, 5, 5, -1, -5 },
  { 402, 6, 7, 5, -1, -5 },
  { 408, 4, 5, 4, 0, -5 },
  { 411, 4, 9, 3, 0, -7 },
  { 416, 1, 10, 4, 2, -8 },
  { 418, 4, 9, 3, -1, -7 },
  { 423, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC10PT7B_H_
