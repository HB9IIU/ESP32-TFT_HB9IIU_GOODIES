#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC35PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x0C, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x00,
  0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x7C, 0xF1, 0xE0, 0x00, 0x79, 0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0,
  0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x81, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x23, 0x8F, 0x00, 0x78, 0xE0, 0x07, 0x9E,
  0x00, 0x71, 0xE0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x00, 0x3C,
  0xF0, 0x03, 0x8F, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0x7E,
  0x1F, 0x21, 0x0F, 0xB0, 0x07, 0xD8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x5F, 0x00, 0x6F, 0x88,
  0x37, 0xC7, 0x1B, 0xE3, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0,
  0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x3C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xBC, 0x1E, 0x07, 0x9E, 0x1E,
  0x03, 0xCF, 0x1F, 0x03, 0xC7, 0x8F, 0x01, 0xE3, 0xCF, 0x00, 0xF1, 0xE7,
  0x80, 0x79, 0xE7, 0x80, 0x3C, 0xF7, 0x8F, 0x9E, 0xF3, 0xDF, 0xEF, 0xFB,
  0xCF, 0xF3, 0xF9, 0xEF, 0x3D, 0xF9, 0xE7, 0x9E, 0x01, 0xE7, 0x8F, 0x00,
  0xF3, 0xC7, 0x80, 0xF1, 0xE7, 0x80, 0x78, 0xF3, 0xC0, 0x78, 0x71, 0xE0,
  0x78, 0x38, 0xF0, 0x3C, 0x1E, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07, 0xF8,
  0x1E, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF1, 0xF0,
  0xFF, 0x1F, 0x8F, 0xFC, 0xF8, 0xFF, 0xE7, 0xCF, 0xDF, 0xFC, 0x7C, 0x7F,
  0xE7, 0xE3, 0xFE, 0x3F, 0x0F, 0xF1, 0xF8, 0x7F, 0x0F, 0xC7, 0xF8, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xC7, 0xE0, 0x3E, 0xF9,
  0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0xF0, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x10, 0xF0, 0x73, 0x83, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFC, 0x7F, 0x13, 0xFC, 0x1F, 0x78, 0xFD, 0xE0, 0xE7, 0xC1, 0x0E, 0x00,
  0x20, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x8F, 0x87,
  0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x78, 0x00, 0x7F, 0xDF, 0xF7,
  0xFD, 0xFE, 0xFF, 0x80, 0x19, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xBF, 0x1F, 0x1F, 0x3F, 0x1F, 0x3E,
  0x1F, 0x7E, 0x1F, 0x7E, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0xFC, 0x3E, 0xFC,
  0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8,
  0xF8, 0xFD, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x00,
  0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF9, 0xFF, 0xDF, 0xFE,
  0x7B, 0xE1, 0x9F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x07, 0xDF, 0xC1, 0xC3, 0xF0, 0x20, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0x71, 0xF8,
  0x20, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x27, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x90, 0x0F, 0xCE, 0x1F, 0xC7, 0xFF, 0xE3,
  0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xBE,
  0x03, 0xFE, 0x03, 0xDF, 0x03, 0xCF, 0x81, 0xE7, 0xC1, 0xE7, 0xC1, 0xE3,
  0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x67, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x90, 0x1F, 0xCF, 0x1F, 0xC7, 0xFF, 0xE3,
  0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFE, 0x10, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x7C, 0x1F, 0x7F, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xF3,
  0xF3, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x7E, 0x7C, 0x3F, 0x3E, 0x1F, 0x1F,
  0x1F, 0x8F, 0xCF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E,
  0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0xE0, 0xFD, 0xF8, 0xFC, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F,
  0x3F, 0x0F, 0x9F, 0x87, 0xCF, 0xC7, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE,
  0x3F, 0x3F, 0x3E, 0x3F, 0x3E, 0x1F, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xBE, 0x1F, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x87, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x02, 0x07, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x00, 0x00, 0x80, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF,
  0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8,
  0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0xE3,
  0xFF, 0xCF, 0xFF, 0x1C, 0xFC, 0x41, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x0F, 0x1E, 0x0F,
  0x8F, 0x1E, 0x3F, 0xE7, 0x3C, 0x7F, 0xE7, 0x38, 0xF9, 0xC7, 0x78, 0xF3,
  0xC7, 0x79, 0xE3, 0xC7, 0x71, 0xE3, 0xC7, 0xF3, 0xC3, 0x8F, 0xF3, 0xC7,
  0x8F, 0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x9E, 0xF3, 0xCF, 0xBC, 0xF3, 0xFF,
  0xFC, 0xF1, 0xFB, 0xF8, 0xF0, 0xF1, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x01,
  0xF3, 0xC0, 0x3E, 0x78, 0x0F, 0xCF, 0x01, 0xF1, 0xE0, 0x3E, 0x3C, 0x0F,
  0x87, 0x81, 0xF0, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0xFC, 0xFE, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x87, 0xC3, 0xF1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC3, 0xF0, 0xF8,
  0x7E, 0x3F, 0x1F, 0xC7, 0xC7, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0x78, 0x3F, 0x81, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x02, 0x07, 0xF3, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x3F,
  0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3E, 0x1F, 0x03,
  0xE1, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3E, 0x0F, 0xC3, 0xE0,
  0xFC, 0x3E, 0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xF3, 0xC1, 0xFC, 0x04, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x27, 0xE3,
  0xFC, 0x7E, 0x3F, 0xC7, 0xC3, 0xFC, 0x7C, 0x7F, 0xCF, 0xC0, 0xFC, 0xFC,
  0x0F, 0x8F, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xBF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x03, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0xB8, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x1F,
  0x07, 0xE0, 0x7C, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F,
  0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0,
  0x1F, 0x8F, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xF7,
  0xC1, 0xF7, 0x9F, 0xF8, 0x1F, 0x79, 0xEF, 0x81, 0xF7, 0xBE, 0xF8, 0x3E,
  0x7B, 0xCF, 0x83, 0xE7, 0xBC, 0xF8, 0x3E, 0x7F, 0x9F, 0x03, 0xE7, 0xF9,
  0xF0, 0x3C, 0x7F, 0x9F, 0x07, 0xC7, 0xF1, 0xF0, 0x7C, 0x7F, 0x3F, 0x07,
  0xC7, 0xE3, 0xE0, 0x7C, 0x7E, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C,
  0x7E, 0x00, 0x07, 0xF0, 0x3E, 0x0F, 0xE0, 0x7C, 0x1F, 0xC0, 0xF8, 0x3F,
  0x81, 0xF0, 0xFF, 0x07, 0xC1, 0xFF, 0x0F, 0x83, 0xFE, 0x1F, 0x07, 0xFC,
  0x3E, 0x0F, 0xF8, 0x7C, 0x3E, 0xF9, 0xF0, 0x7D, 0xF3, 0xE0, 0xFB, 0xE7,
  0xC1, 0xF7, 0xCF, 0x83, 0xC7, 0x9E, 0x0F, 0x8F, 0xFC, 0x1F, 0x1F, 0xF8,
  0x3E, 0x3F, 0xF0, 0x7C, 0x7F, 0xE0, 0xF0, 0x7F, 0x83, 0xE0, 0xFF, 0x07,
  0xC1, 0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x7C, 0x07, 0xE0, 0xF8,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE7, 0xE1, 0xFC, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03,
  0xF3, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0,
  0x3E, 0x7C, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0x7C,
  0x0F, 0xC7, 0xE1, 0xF8, 0x7F, 0x7F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F,
  0x0F, 0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0x8F, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xE7, 0xE1, 0xFC, 0x3F, 0x1F, 0x83, 0xF3, 0xF0,
  0x3F, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xE1, 0xF8, 0x7F, 0x7F, 0x87, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0xDF, 0xC3, 0xF1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE3, 0xF1, 0xF9, 0xFC,
  0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0x80, 0x01, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFC, 0x10, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x18, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xF3, 0xF0,
  0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1,
  0xF1, 0xF8, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x3F,
  0x0F, 0xDF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F,
  0x3E, 0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F,
  0x8F, 0xC1, 0xE3, 0xE0, 0x79, 0xF8, 0x1E, 0x7C, 0x07, 0x9F, 0x01, 0xEF,
  0x80, 0x7B, 0xE0, 0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x1F,
  0x03, 0xFF, 0x03, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0x7C, 0x1F, 0x83, 0xEF,
  0x83, 0xF0, 0xFD, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC3, 0xE7, 0xC7, 0xF8,
  0xF8, 0xF8, 0xFF, 0x1F, 0x1F, 0x1F, 0xE7, 0xE3, 0xE7, 0xBC, 0xF8, 0x7C,
  0xFF, 0x9F, 0x0F, 0xBF, 0xF7, 0xC1, 0xF7, 0xBE, 0xF8, 0x3F, 0xF7, 0xFF,
  0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0x9F, 0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFC,
  0x7F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0,
  0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x03,
  0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x1F,
  0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xF8, 0x07,
  0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0xFE, 0x0F, 0xDF, 0x0F, 0xCF, 0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xE1,
  0xF3, 0xF0, 0xF9, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1F, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0x8F, 0x07, 0xC7, 0x83,
  0xC3, 0xE3, 0xC1, 0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x80, 0xFC, 0xF9, 0xF1, 0xF1, 0xE3, 0xC0, 0x01, 0x00,
  0x03, 0xF7, 0xC3, 0xFB, 0xE3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8,
  0xFC, 0xF8, 0x7E, 0x7C, 0x3E, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x07, 0xCF,
  0x87, 0xE7, 0xC3, 0xE3, 0xE3, 0xF1, 0xF9, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC,
  0x1F, 0xDE, 0x07, 0xCF, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x10, 0x0F, 0xBE,
  0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xCF, 0xC3, 0xE7,
  0xE3, 0xF3, 0xF1, 0xF1, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC,
  0x3C, 0xFC, 0x00, 0x00, 0xE0, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0x3F, 0xF8,
  0xFC, 0x27, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x81, 0x3F, 0x18, 0xFF, 0xE1, 0xFF, 0x87, 0xFE,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x08, 0x7C, 0x07, 0xEF, 0x81,
  0xFD, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x0F, 0xC3, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C,
  0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3F, 0x3F, 0x07, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xEF, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x60, 0x07, 0xF0, 0x3F,
  0xF0, 0xFF, 0xF3, 0xF7, 0xE7, 0xC7, 0xDF, 0x8F, 0xBE, 0x1F, 0x7D, 0xFF,
  0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x08, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0xFD, 0xF0, 0x7F, 0x7C, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE7, 0xE3, 0xF1,
  0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xE1, 0xFB, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7D, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x82, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x10, 0x0F, 0xBF, 0x07, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7E, 0x3F, 0x3E, 0x1F,
  0x1F, 0x0F, 0x8F, 0x87, 0xCF, 0xC3, 0xE7, 0xE3, 0xF3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0xFC, 0x7E, 0x7C, 0x3F, 0x3E, 0x1F, 0x00, 0x03, 0x80,
  0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x87, 0xE1, 0xF1, 0xF8, 0x7E, 0x7E, 0x0F, 0x9F, 0x81, 0xF3,
  0xE0, 0x3E, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0x00, 0x00, 0x08, 0x06, 0x03, 0xCF, 0xCF, 0xE0, 0xF7, 0xF7, 0xF8, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xE7, 0xF3, 0xF1, 0xF1, 0xF8, 0xFC,
  0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3,
  0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3F, 0x3F, 0x1F, 0x0F, 0x8F,
  0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x00, 0x0C, 0x07, 0x9F, 0x83, 0xDF,
  0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x3F,
  0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xE1, 0xF9,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F,
  0x80, 0x00, 0x40, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E,
  0x3E, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xFC, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x02, 0x00, 0x79, 0xF0, 0x0F, 0x7F,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xCF, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xE1, 0xF8, 0x7C,
  0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFB, 0xF8, 0x1F, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0x00, 0x03, 0xF7, 0xC3, 0xFB, 0xE3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9,
  0xF9, 0xF8, 0xFC, 0xF8, 0x7E, 0x7C, 0x3E, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F,
  0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF9, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xDF, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0x0C, 0x3C, 0xF0, 0xF7, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xE1, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x80, 0x1F, 0xE1, 0xFF, 0xC7, 0xFF, 0x3F, 0xF8, 0xF8, 0x23, 0xF0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x30, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x03, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x1F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x3F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xFC, 0x8F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x1F, 0x0F, 0x8F,
  0x87, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF9, 0xF8, 0xFC,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x8F, 0xCF, 0x87,
  0xC7, 0xC7, 0xE3, 0xF3, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xBC, 0x0F,
  0x9E, 0x00, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF0, 0x79, 0xF0, 0x7B, 0xE0, 0x7B, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x7E, 0x1F, 0xF8, 0xFE, 0x3E, 0xF8, 0xFE,
  0x3E, 0xF8, 0xFE, 0x7E, 0xF9, 0xFE, 0x7C, 0xF9, 0xFE, 0x7C, 0xF9, 0xDE,
  0xF8, 0xFB, 0xDE, 0xF8, 0xFB, 0xDC, 0xF0, 0xFF, 0x9D, 0xF0, 0xFF, 0xBD,
  0xF0, 0xFF, 0xBD, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x7C, 0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xBE, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F,
  0x00, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F,
  0x8F, 0xC0, 0xF8, 0xF8, 0x07, 0x8F, 0x80, 0x79, 0xF0, 0x07, 0x9F, 0x00,
  0x7B, 0xE0, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0F,
  0xF0, 0x1F, 0x80, 0x3C, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x20, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x1F, 0x80,
  0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3E,
  0x03, 0xF8, 0x1F, 0xE0, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x08, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFE, 0x80, 0x38,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 25, 9, 0, -25 },
  { 36, 14, 9, 15, 3, -25 },
  { 52, 20, 25, 19, 0, -25 },
  { 115, 17, 29, 17, 0, -27 },
  { 177, 25, 25, 28, 2, -25 },
  { 256, 21, 25, 21, 0, -25 },
  { 322, 7, 9, 9, 3, -25 },
  { 330, 12, 31, 10, 1, -25 },
  { 377, 13, 32, 11, -3, -26 },
  { 429, 14, 16, 16, 3, -27 },
  { 457, 15, 17, 18, 2, -21 },
  { 489, 9, 10, 9, -2, -5 },
  { 501, 10, 5, 11, 0, -12 },
  { 508, 6, 6, 9, 0, -6 },
  { 513, 19, 25, 14, -2, -25 },
  { 573, 16, 25, 17, 1, -25 },
  { 623, 13, 25, 17, 3, -25 },
  { 664, 18, 25, 17, -1, -25 },
  { 721, 17, 25, 17, 0, -25 },
  { 775, 17, 25, 17, 0, -25 },
  { 829, 17, 25, 17, 0, -25 },
  { 883, 17, 25, 17, 1, -25 },
  { 937, 18, 25, 17, 1, -25 },
  { 994, 17, 25, 17, 0, -25 },
  { 1048, 16, 25, 17, 1, -25 },
  { 1098, 9, 20, 9, 0, -20 },
  { 1121, 11, 25, 9, -2, -20 },
  { 1156, 16, 17, 18, 1, -21 },
  { 1190, 16, 11, 18, 1, -18 },
  { 1212, 15, 17, 18, 2, -21 },
  { 1244, 14, 25, 14, 1, -25 },
  { 1288, 24, 28, 26, 1, -25 },
  { 1372, 19, 25, 19, -2, -25 },
  { 1432, 19, 25, 19, 0, -25 },
  { 1492, 19, 25, 18, 1, -25 },
  { 1552, 20, 25, 20, 0, -25 },
  { 1615, 17, 25, 16, 0, -25 },
  { 1669, 17, 25, 15, 0, -25 },
  { 1723, 20, 25, 20, 1, -25 },
  { 1786, 22, 25, 21, 0, -25 },
  { 1855, 16, 25, 13, -1, -25 },
  { 1905, 17, 33, 10, -6, -25 },
  { 1976, 22, 25, 19, 0, -25 },
  { 2045, 13, 25, 15, 0, -25 },
  { 2086, 28, 25, 27, 0, -25 },
  { 2174, 23, 25, 22, 0, -25 },
  { 2246, 20, 25, 21, 1, -25 },
  { 2309, 19, 25, 18, 0, -25 },
  { 2369, 20, 31, 21, 1, -25 },
  { 2447, 18, 25, 18, 0, -25 },
  { 2504, 17, 25, 16, 0, -25 },
  { 2558, 15, 25, 16, 3, -25 },
  { 2605, 19, 25, 20, 2, -25 },
  { 2665, 18, 25, 18, 3, -25 },
  { 2722, 27, 25, 27, 3, -25 },
  { 2807, 23, 25, 18, -2, -25 },
  { 2879, 17, 25, 17, 3, -25 },
  { 2933, 19, 25, 16, -1, -25 },
  { 2993, 14, 31, 11, -1, -25 },
  { 3048, 8, 25, 14, 4, -25 },
  { 3073, 15, 31, 11, -3, -25 },
  { 3132, 17, 16, 17, 0, -25 },
  { 3166, 14, 3, 13, -3, 3 },
  { 3172, 7, 6, 11, 5, -27 },
  { 3178, 17, 20, 18, 1, -20 },
  { 3221, 17, 27, 18, 0, -27 },
  { 3279, 14, 20, 15, 1, -20 },
  { 3314, 19, 27, 18, 1, -27 },
  { 3379, 15, 20, 17, 1, -20 },
  { 3417, 19, 35, 11, -4, -27 },
  { 3501, 18, 28, 18, 0, -20 },
  { 3564, 17, 27, 18, 0, -27 },
  { 3622, 11, 27, 9, 0, -27 },
  { 3660, 15, 35, 9, -4, -27 },
  { 3726, 19, 27, 17, 0, -27 },
  { 3791, 11, 27, 9, 0, -27 },
  { 3829, 26, 20, 27, 0, -20 },
  { 3894, 17, 20, 18, 0, -20 },
  { 3937, 16, 20, 18, 1, -20 },
  { 3977, 19, 28, 18, -2, -20 },
  { 4044, 17, 28, 18, 1, -20 },
  { 4104, 14, 20, 13, 0, -20 },
  { 4139, 14, 20, 14, 0, -20 },
  { 4174, 12, 23, 12, 1, -23 },
  { 4209, 17, 19, 18, 1, -19 },
  { 4250, 16, 19, 16, 2, -19 },
  { 4288, 24, 19, 24, 2, -19 },
  { 4345, 20, 19, 16, -2, -19 },
  { 4393, 20, 27, 16, -2, -19 },
  { 4461, 16, 19, 14, -1, -19 },
  { 4499, 15, 31, 12, 0, -25 },
  { 4558, 5, 35, 15, 5, -27 },
  { 4580, 14, 31, 12, -2, -25 },
  { 4635, 16, 6, 18, 1, -15 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC35PT7B_H_
