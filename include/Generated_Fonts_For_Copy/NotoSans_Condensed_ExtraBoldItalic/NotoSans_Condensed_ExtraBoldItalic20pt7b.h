#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC20PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x1C, 0x70, 0x00, 0x38, 0xF3, 0x80,
  0x7F, 0xEE, 0xEE, 0xEC, 0xCC, 0x06, 0xE1, 0xD8, 0x33, 0x06, 0x63, 0xFE,
  0xFF, 0xC6, 0x60, 0xD8, 0xFF, 0xDF, 0xF8, 0xDC, 0x3B, 0x06, 0x60, 0xDC,
  0x00, 0x02, 0x01, 0xE1, 0xFC, 0xFE, 0x3C, 0x8F, 0x03, 0xC0, 0x7C, 0x0F,
  0x02, 0xE8, 0xB9, 0xBE, 0xFF, 0x1F, 0x81, 0x00, 0x40, 0x3C, 0x39, 0xF1,
  0xC6, 0xC6, 0x3B, 0x30, 0xCD, 0xC3, 0x36, 0x6F, 0xBF, 0xDE, 0xDB, 0x06,
  0xEC, 0x3B, 0x30, 0xCC, 0xC6, 0x37, 0x18, 0xF8, 0xC1, 0xC0, 0x0F, 0x81,
  0xFC, 0x1D, 0xC1, 0xDC, 0x1F, 0x81, 0xF0, 0x1E, 0x73, 0xE7, 0x77, 0xEE,
  0x7E, 0xE3, 0xCF, 0x7C, 0xFF, 0xC7, 0xDE, 0x7E, 0xEE, 0xC0, 0x0F, 0x1C,
  0x1C, 0x38, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0,
  0x60, 0x60, 0x70, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06,
  0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0xF0, 0x0E, 0x26, 0x1F,
  0x3F, 0xF1, 0xF9, 0xE1, 0xD8, 0x4E, 0x04, 0x00, 0x18, 0x0C, 0x06, 0x03,
  0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x3B, 0x9C, 0xCE, 0x60,
  0x7D, 0xFF, 0x80, 0xEF, 0xE0, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x00, 0x1F, 0x1F, 0x9C, 0xEE, 0x7E, 0x3F, 0x1F, 0x9D, 0xCE, 0xE7, 0x63,
  0xB3, 0x9F, 0xCF, 0xC3, 0xC0, 0x0E, 0x7D, 0xFF, 0xED, 0xCB, 0x87, 0x0E,
  0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x00, 0x0F, 0xC3, 0xF8, 0x77, 0x84, 0xF0,
  0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xC7, 0xF9,
  0xFF, 0x00, 0x1F, 0x8F, 0xF1, 0x3C, 0x07, 0x03, 0x87, 0xC1, 0xE0, 0x7C,
  0x07, 0x81, 0xE0, 0x73, 0x3C, 0xFE, 0x3F, 0x00, 0x03, 0xC0, 0xE0, 0x78,
  0x3E, 0x1F, 0x86, 0xE3, 0x71, 0xDC, 0x67, 0x3F, 0xEF, 0xF8, 0x38, 0x0E,
  0x03, 0x80, 0x1F, 0xC7, 0xF1, 0x80, 0xE0, 0x38, 0x0F, 0xC7, 0xF0, 0x9E,
  0x03, 0x80, 0xE0, 0x73, 0x3C, 0xFE, 0x3F, 0x00, 0x01, 0x07, 0xC7, 0xE7,
  0x07, 0x03, 0x83, 0xB9, 0xFE, 0xE7, 0x73, 0xB9, 0xDC, 0xEE, 0xE7, 0xF1,
  0xF0, 0x7F, 0xDF, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x00, 0x1F, 0x87, 0xF3, 0x9C, 0xE7,
  0x3B, 0x87, 0xE1, 0xE0, 0xFC, 0x77, 0xB8, 0xEE, 0x3B, 0x9C, 0x7F, 0x1F,
  0x80, 0x02, 0x07, 0xE3, 0xF8, 0xEE, 0x79, 0xDC, 0xF7, 0x39, 0xFE, 0x7F,
  0x8E, 0xE0, 0x70, 0x1C, 0x9E, 0x3F, 0x0F, 0x80, 0x39, 0xCE, 0x00, 0x00,
  0x00, 0xE7, 0xB8, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x39, 0xC7, 0x18,
  0xE3, 0x00, 0x01, 0x83, 0xC7, 0xCF, 0x8F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0x80, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x3E,
  0x07, 0xC0, 0x78, 0x7C, 0xF9, 0xF0, 0xE0, 0x40, 0x00, 0x7E, 0x7F, 0x47,
  0x06, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x07,
  0xE0, 0x79, 0xE3, 0x81, 0x9C, 0xE6, 0x67, 0xCF, 0xB3, 0x3C, 0xCD, 0xB6,
  0x66, 0xD9, 0x9B, 0x66, 0xCD, 0xFF, 0x33, 0x30, 0xC0, 0x01, 0xC2, 0x07,
  0xF8, 0x03, 0x80, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0x60, 0xEC, 0x19, 0x87,
  0x30, 0xE6, 0x3F, 0xC7, 0xF9, 0xFF, 0xB8, 0x7F, 0x0F, 0xC1, 0xC0, 0x1F,
  0xC3, 0xFC, 0x77, 0x9C, 0x73, 0x9C, 0x7F, 0x8F, 0xC3, 0xFC, 0x73, 0xCE,
  0x39, 0xCF, 0x3F, 0xCF, 0xF1, 0xFC, 0x00, 0x0F, 0xCF, 0xF3, 0xC9, 0xE0,
  0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xD8, 0x7E, 0x0F,
  0x80, 0x1F, 0x83, 0xF8, 0x77, 0x9C, 0x73, 0x8E, 0x71, 0xCE, 0x3B, 0xC7,
  0x71, 0xEE, 0x39, 0xCF, 0x3F, 0xCF, 0xF1, 0xF8, 0x00, 0x1F, 0xC7, 0xF1,
  0xC0, 0xE0, 0x38, 0x0F, 0xC3, 0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xF8,
  0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xE1, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0xF1,
  0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0x0F, 0xE3, 0xF8,
  0xF1, 0x3C, 0x07, 0x01, 0xE0, 0x39, 0xF7, 0x3E, 0xE1, 0xDC, 0x73, 0x8E,
  0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x87, 0x38,
  0xE3, 0xFE, 0x3F, 0xE7, 0xFE, 0x71, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xF1,
  0xCE, 0x3C, 0x1F, 0xC7, 0xE0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x7E, 0x3F, 0x80, 0x03, 0x81, 0xC0, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0,
  0x71, 0x78, 0xF8, 0x78, 0x00, 0x1C, 0x71, 0xCE, 0x1D, 0xC3, 0xBC, 0x3B,
  0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x87, 0x38, 0xE3,
  0x8E, 0x3C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70,
  0x70, 0x7F, 0xFE, 0xFE, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7E, 0x36, 0x6C, 0x76, 0xFC, 0x76, 0xDC, 0x77, 0xDC,
  0x77, 0x9C, 0x67, 0x98, 0xE7, 0x38, 0xE7, 0x38, 0x1E, 0x38, 0xF1, 0xC7,
  0x8E, 0x7C, 0x73, 0xF7, 0x1F, 0xB8, 0xDD, 0xCE, 0xEE, 0x73, 0x63, 0x9F,
  0x1C, 0xF8, 0xC7, 0xCE, 0x1E, 0x70, 0xE0, 0x02, 0x01, 0xF8, 0xFF, 0x1C,
  0xF7, 0x8E, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x3B, 0x87, 0x71, 0xEF,
  0xF8, 0xFE, 0x0F, 0x80, 0x1F, 0xC3, 0xF8, 0x77, 0x9C, 0x73, 0x8E, 0x73,
  0x8F, 0xF3, 0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x00,
  0x02, 0x01, 0xF8, 0xFF, 0x1C, 0xF7, 0x8E, 0xE1, 0xFC, 0x3F, 0x07, 0xE1,
  0xFC, 0x3B, 0x87, 0x71, 0xEF, 0xF8, 0xFE, 0x0F, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x1F, 0x83, 0xF8, 0x77, 0x1C, 0xF3, 0x9C, 0x73, 0x8F, 0xF3, 0xFC,
  0x7F, 0x0E, 0xE1, 0xDC, 0x39, 0xCE, 0x39, 0xC7, 0x80, 0x1F, 0xCF, 0xE3,
  0xD8, 0xE0, 0x38, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xC8, 0x73, 0xFC,
  0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0x38, 0xE7, 0x1D, 0xE3, 0xB8, 0xE7, 0x1C,
  0xE3, 0x9C, 0x77, 0x1E, 0xE3, 0x9C, 0x73, 0x8E, 0x7F, 0x8F, 0xF0, 0xFC,
  0x00, 0xE1, 0xF8, 0xEE, 0x3B, 0x9C, 0xE7, 0x39, 0xCE, 0xE3, 0xB8, 0xFC,
  0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0xE3, 0x8F, 0xC7, 0x1F, 0x9E,
  0x77, 0x3C, 0xEE, 0xFB, 0x99, 0xF7, 0x37, 0xEE, 0x6F, 0xF8, 0xDB, 0xF1,
  0xF7, 0xC3, 0xCF, 0x87, 0x9F, 0x0F, 0x3C, 0x1C, 0x78, 0x00, 0x1C, 0x78,
  0xF7, 0x83, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x1C, 0x01, 0xE0, 0x1F,
  0x80, 0xFC, 0x0E, 0xE0, 0xF7, 0x87, 0x1C, 0x70, 0xE0, 0xE3, 0xF9, 0xEE,
  0x73, 0xB8, 0x6E, 0x1F, 0x07, 0xC1, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x00, 0x1F, 0xE3, 0xFC, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x3F, 0xC7, 0xF9, 0xFF, 0x00, 0x0F,
  0x87, 0x87, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xF0, 0xF8, 0x00, 0xE7, 0x38, 0xC6, 0x31, 0xCE,
  0x73, 0x8C, 0x63, 0x1C, 0x1F, 0x1E, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C,
  0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0xF0, 0xF0, 0x06, 0x03, 0x83,
  0xC3, 0xE1, 0xB1, 0xDD, 0xCE, 0xC3, 0xE1, 0x80, 0xFF, 0xE7, 0x30, 0x1E,
  0xCF, 0xF3, 0xBD, 0xCF, 0x73, 0x9C, 0xE7, 0x3B, 0xCE, 0x77, 0x1F, 0xC7,
  0xB0, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x3B, 0x8F, 0xE3, 0xBC, 0xE7, 0x71,
  0xDC, 0xF7, 0x39, 0xCE, 0xF7, 0xBF, 0xCF, 0xE0, 0x1F, 0x7E, 0x72, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE4, 0xFC, 0x7C, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xE1, 0xFC, 0x7F, 0x8E, 0xF3, 0x9E, 0x73, 0x8E, 0x71, 0xCE, 0x79, 0xC7,
  0x70, 0xFE, 0x1E, 0xC0, 0x1E, 0x7F, 0x73, 0xE7, 0xFF, 0xFE, 0xE0, 0xC0,
  0xE2, 0xFE, 0x7C, 0x03, 0xE0, 0xF8, 0x1C, 0x03, 0x80, 0xF8, 0x3F, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x38, 0x1F, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0xCF, 0xF3, 0xBD, 0xCF,
  0x73, 0x9C, 0xE7, 0x3B, 0xCE, 0xF7, 0x1F, 0xC7, 0xF0, 0x1C, 0x0F, 0x3F,
  0x8F, 0xC1, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x3F, 0x8F, 0xF3, 0xBC,
  0xE7, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0xE3, 0xB9, 0xCE, 0x70, 0x1C, 0x71,
  0x80, 0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x00, 0x03, 0x81,
  0xC0, 0xC0, 0x00, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x7C, 0x3E, 0x1E, 0x00, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x9E, 0x77, 0x8E, 0xE1, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3B, 0x8E, 0x71, 0xCE, 0x39, 0xE0, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x8E,
  0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x00, 0x3F, 0xBC, 0x7F, 0xFC, 0xEF, 0x79,
  0xCE, 0x77, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0xE3, 0x1D, 0xCE,
  0x73, 0x9C, 0xE0, 0x3F, 0x8D, 0xF3, 0xFC, 0xE7, 0x71, 0x9C, 0xE7, 0x39,
  0xCE, 0xE3, 0xB9, 0xCE, 0x70, 0x3E, 0x3F, 0x9D, 0xDC, 0x7E, 0x77, 0x3B,
  0x9D, 0xCE, 0xEE, 0x7F, 0x1F, 0x00, 0x1F, 0xC3, 0xF8, 0x77, 0x8E, 0x73,
  0x8E, 0x73, 0xCE, 0x71, 0xCE, 0x7B, 0xCF, 0xF1, 0xDC, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x1E, 0xCF, 0xF3, 0xBD, 0xCF, 0x73, 0x9C, 0xE7,
  0x3B, 0xCE, 0x77, 0x1F, 0xC7, 0xF0, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38,
  0x3B, 0x3F, 0x3F, 0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x1F,
  0x3F, 0x72, 0x70, 0x7C, 0x3E, 0x1E, 0x0E, 0x8E, 0xFE, 0xFC, 0x18, 0x71,
  0xFF, 0xE7, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0xA7, 0xCF, 0x80, 0x73, 0xB9,
  0xDC, 0xFC, 0x7E, 0x77, 0x3B, 0x9D, 0xCE, 0xEF, 0x7F, 0x3D, 0x80, 0xE3,
  0xF3, 0xF9, 0xDC, 0xEE, 0xE7, 0x71, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x00,
  0xE7, 0x9F, 0x9E, 0xEE, 0xFB, 0xBB, 0xCC, 0xEF, 0x73, 0xFD, 0xCF, 0xB6,
  0x3E, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x38, 0x00, 0x3C, 0xE3, 0xB8, 0x7F,
  0x0F, 0xC0, 0xF0, 0x1E, 0x07, 0xC1, 0xF8, 0x3F, 0x0E, 0x73, 0xCE, 0x00,
  0x38, 0xE7, 0x3C, 0xE7, 0x1C, 0xE1, 0xB8, 0x37, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x1F, 0x8F,
  0xC8, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x70, 0x3F, 0xBF, 0x80, 0x07,
  0x0F, 0x1E, 0x1C, 0x1C, 0x1C, 0x38, 0x78, 0xE0, 0xF0, 0x38, 0x30, 0x70,
  0x70, 0x70, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x1E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x0F, 0x07, 0x1E, 0x38, 0x38,
  0x38, 0x38, 0x70, 0xF0, 0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 8, 5, 9, 2, -14 },
  { 17, 11, 14, 11, 0, -14 },
  { 37, 10, 16, 10, 0, -15 },
  { 57, 14, 14, 16, 1, -14 },
  { 82, 12, 14, 12, 0, -14 },
  { 103, 4, 5, 5, 2, -14 },
  { 106, 8, 17, 6, 0, -14 },
  { 123, 8, 18, 6, -2, -15 },
  { 141, 9, 9, 9, 1, -15 },
  { 152, 9, 10, 10, 1, -12 },
  { 164, 5, 6, 5, -1, -3 },
  { 168, 6, 3, 6, 0, -7 },
  { 171, 4, 3, 5, 0, -3 },
  { 173, 11, 14, 8, -1, -14 },
  { 193, 9, 14, 10, 1, -14 },
  { 209, 7, 14, 10, 2, -14 },
  { 222, 11, 14, 10, -1, -14 },
  { 242, 10, 14, 10, 0, -14 },
  { 260, 10, 14, 10, 0, -14 },
  { 278, 10, 14, 10, 0, -14 },
  { 296, 9, 15, 10, 1, -15 },
  { 313, 10, 14, 10, 1, -14 },
  { 331, 10, 14, 10, 0, -14 },
  { 349, 10, 15, 10, 0, -15 },
  { 368, 5, 11, 5, 0, -11 },
  { 375, 6, 14, 5, -1, -11 },
  { 386, 9, 10, 10, 1, -12 },
  { 398, 9, 6, 10, 1, -10 },
  { 405, 9, 10, 10, 1, -12 },
  { 417, 8, 14, 8, 1, -14 },
  { 431, 14, 16, 15, 1, -14 },
  { 459, 11, 14, 11, -1, -14 },
  { 479, 11, 14, 11, 0, -14 },
  { 499, 10, 14, 10, 1, -14 },
  { 517, 11, 14, 11, 0, -14 },
  { 537, 10, 14, 9, 0, -14 },
  { 555, 10, 14, 9, 0, -14 },
  { 573, 11, 14, 12, 1, -14 },
  { 593, 12, 14, 12, 0, -14 },
  { 614, 10, 14, 7, -1, -14 },
  { 632, 9, 18, 6, -3, -14 },
  { 653, 12, 14, 11, 0, -14 },
  { 674, 8, 14, 9, 0, -14 },
  { 688, 16, 14, 15, 0, -14 },
  { 716, 13, 14, 13, 0, -14 },
  { 739, 11, 15, 12, 1, -15 },
  { 760, 11, 14, 10, 0, -14 },
  { 780, 11, 18, 12, 1, -15 },
  { 805, 11, 14, 11, 0, -14 },
  { 825, 10, 14, 9, 0, -14 },
  { 843, 8, 14, 9, 2, -14 },
  { 857, 11, 14, 12, 1, -14 },
  { 877, 10, 14, 10, 2, -14 },
  { 895, 15, 14, 16, 2, -14 },
  { 922, 13, 14, 10, -1, -14 },
  { 945, 10, 14, 10, 2, -14 },
  { 963, 11, 14, 9, -1, -14 },
  { 983, 9, 17, 6, -1, -14 },
  { 1003, 5, 14, 8, 2, -14 },
  { 1012, 8, 17, 6, -1, -14 },
  { 1029, 9, 9, 10, 0, -14 },
  { 1040, 8, 1, 7, -2, 2 },
  { 1041, 4, 3, 6, 3, -15 },
  { 1043, 10, 11, 10, 0, -11 },
  { 1057, 10, 15, 10, 0, -15 },
  { 1076, 8, 11, 8, 1, -11 },
  { 1087, 11, 15, 10, 0, -15 },
  { 1108, 8, 11, 10, 1, -11 },
  { 1119, 11, 20, 6, -2, -15 },
  { 1147, 10, 16, 10, 0, -11 },
  { 1167, 10, 15, 10, 0, -15 },
  { 1186, 6, 15, 5, 0, -15 },
  { 1198, 9, 20, 5, -3, -15 },
  { 1221, 11, 15, 10, 0, -15 },
  { 1242, 6, 15, 5, 0, -15 },
  { 1254, 15, 11, 15, 0, -11 },
  { 1275, 10, 11, 10, 0, -11 },
  { 1289, 9, 11, 10, 1, -11 },
  { 1302, 11, 16, 10, -1, -11 },
  { 1324, 10, 16, 10, 0, -11 },
  { 1344, 8, 11, 7, 0, -11 },
  { 1355, 8, 11, 8, 0, -11 },
  { 1366, 7, 13, 7, 1, -13 },
  { 1378, 9, 11, 10, 1, -11 },
  { 1391, 9, 11, 9, 1, -11 },
  { 1404, 14, 11, 14, 1, -11 },
  { 1424, 11, 11, 9, -1, -11 },
  { 1440, 11, 16, 9, -1, -11 },
  { 1462, 9, 11, 8, -1, -11 },
  { 1475, 8, 17, 7, 0, -14 },
  { 1492, 3, 20, 9, 3, -15 },
  { 1500, 8, 17, 7, -1, -14 },
  { 1517, 9, 4, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC20PT7B_H_
