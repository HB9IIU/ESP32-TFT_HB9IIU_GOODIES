#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC44PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x04, 0x00, 0x3F, 0x3F, 0xBF,
  0x9F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF1, 0xF1, 0xF8,
  0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF0, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF0, 0x0F, 0x8F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xE1, 0xE0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFD, 0xE0, 0xFC, 0xC2,
  0x07, 0xE6, 0x00, 0x3F, 0x30, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x77, 0xE0, 0x03, 0xBF, 0x10, 0x19,
  0xF8, 0xE0, 0xCF, 0xC7, 0xC6, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x10, 0x07, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x1F, 0xFC, 0x07,
  0xC0, 0x1F, 0xFC, 0x07, 0xC0, 0x3E, 0x7C, 0x0F, 0x80, 0x3E, 0x7C, 0x1F,
  0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x7C, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x7E,
  0x00, 0x7C, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0xF8,
  0x00, 0xF8, 0xF9, 0xF1, 0xF8, 0xF9, 0xFB, 0xF3, 0xFC, 0x7F, 0xF3, 0xE7,
  0xFE, 0x7F, 0xF7, 0xCF, 0xFE, 0x7F, 0xE7, 0xDF, 0xBE, 0x3F, 0xCF, 0x9F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x1E, 0x00, 0x3E, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0xF8, 0x3E,
  0x3E, 0x00, 0xF8, 0x3E, 0x7C, 0x01, 0xF0, 0x3C, 0x7C, 0x01, 0xF0, 0x3E,
  0xFC, 0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x07, 0xC0, 0x1F,
  0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x7F,
  0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0x07, 0xFF, 0x1F,
  0xC3, 0xFF, 0xC7, 0xE1, 0xFF, 0xFB, 0xF8, 0xFE, 0xFE, 0xFE, 0x7F, 0x3F,
  0xFF, 0x1F, 0xC7, 0xFF, 0xC7, 0xE1, 0xFF, 0xE3, 0xF8, 0x3F, 0xF0, 0xFE,
  0x0F, 0xFC, 0x3F, 0x81, 0xFE, 0x0F, 0xF1, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3,
  0xFC, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x02, 0x0F, 0x80, 0x71, 0xF0, 0x1F, 0xBC,
  0x13, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFB, 0xF0, 0x3E, 0x3F,
  0x03, 0xC7, 0xE0, 0x10, 0xF0, 0x00, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xC7,
  0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3,
  0xE0, 0x3F, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xF8, 0x3E,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xE7, 0xF0, 0xFC, 0x3F, 0x1F,
  0xC3, 0xF1, 0xF8, 0x3F, 0x3F, 0x83, 0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF7,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x7E,
  0x7E, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFC, 0xFE, 0x1F,
  0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0x7E, 0xFC, 0x79, 0xFC, 0x31, 0xFC, 0x21,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3E, 0x3F, 0xC0, 0xF0, 0x7F, 0x01,
  0x81, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0E, 0x0F, 0xE0,
  0x40, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE4, 0x00,
  0xFE, 0x3E, 0x3F, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7E, 0x00,
  0xF9, 0xF8, 0x03, 0xEF, 0xE0, 0x1F, 0x3F, 0x80, 0xF8, 0xFC, 0x03, 0xE3,
  0xF0, 0x1F, 0x0F, 0xC0, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0xC0, 0x3F, 0xC3, 0xE3, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x1C, 0x03, 0xFB, 0xF8, 0x1F, 0xBF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8,
  0xFE, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0xDF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xEF, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xFD, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0x0F,
  0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3,
  0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x3F, 0x83, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF0,
  0x7F, 0x3F, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF3, 0xFB, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFE, 0xFC, 0x0F, 0xCF, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x83, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x80, 0x7E, 0x07, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0x7C, 0x03, 0x00, 0x00, 0x10, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF9, 0xFF, 0xFC, 0x70, 0xFE, 0x20, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0xFC,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x70, 0x3E, 0x1F, 0x07,
  0xFE, 0x7C, 0x7C, 0x3F, 0xFC, 0xF8, 0xF8, 0xFF, 0xF8, 0xF3, 0xE1, 0xF9,
  0xE1, 0xE7, 0xC7, 0xC7, 0xC3, 0xCF, 0x0F, 0x0F, 0x8F, 0xBE, 0x3E, 0x1F,
  0x1F, 0x7C, 0x78, 0x3C, 0x3E, 0xF1, 0xF0, 0xF8, 0x79, 0xE3, 0xE1, 0xF0,
  0xF3, 0xC7, 0xC3, 0xE3, 0xEF, 0x8F, 0x87, 0x87, 0x9F, 0x1F, 0x1F, 0x1F,
  0x3E, 0x3E, 0x7E, 0x3C, 0x7C, 0x7F, 0xFF, 0xF8, 0xF8, 0xFF, 0xFF, 0xE1,
  0xF0, 0xFE, 0x7F, 0x81, 0xE0, 0xF8, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x06, 0x00, 0x0F,
  0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0xBE, 0x00, 0x1F,
  0xBE, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80,
  0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF0,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC7,
  0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x07, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFE, 0x1C,
  0x0F, 0xF8, 0x08, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x02, 0x03, 0xFF, 0x7C, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0x9F, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE0,
  0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x0F, 0xF0, 0x3F, 0x0F, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFC, 0x1C, 0x0F, 0xF0, 0x04, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x0F, 0xFE, 0xFF, 0x0F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE,
  0x1F, 0xFC, 0xFE, 0x1F, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFF, 0x07, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x11, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0xC0, 0x3F, 0x0F, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0xBF,
  0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0x7C, 0x1F, 0x7E, 0x07, 0xEF, 0x87, 0xFF, 0xC0, 0xFD, 0xF0, 0xFB, 0xF0,
  0x1F, 0xBE, 0x1F, 0x7E, 0x03, 0xF7, 0xC7, 0xEF, 0xC0, 0xFE, 0xF8, 0xFB,
  0xF8, 0x1F, 0x9F, 0x3F, 0x7E, 0x03, 0xF3, 0xE7, 0xCF, 0xC0, 0x7E, 0x7D,
  0xF9, 0xF8, 0x0F, 0xCF, 0xBE, 0x7F, 0x03, 0xF9, 0xFF, 0xCF, 0xE0, 0x7E,
  0x3F, 0xF1, 0xF8, 0x0F, 0xC7, 0xFE, 0x3F, 0x01, 0xF8, 0xFF, 0x87, 0xE0,
  0x3F, 0x1F, 0xF1, 0xFC, 0x0F, 0xE3, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x87,
  0xE0, 0x3F, 0x0F, 0xF0, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0x81, 0xFC, 0x3F,
  0x87, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x1F,
  0xF0, 0x0F, 0xC0, 0xFF, 0x80, 0xFE, 0x07, 0xFC, 0x07, 0xE0, 0x3F, 0xE0,
  0x3F, 0x01, 0xFF, 0x81, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0xFE,
  0x07, 0xFF, 0x07, 0xE0, 0x3F, 0xFC, 0x3F, 0x03, 0xF7, 0xE1, 0xF8, 0x1F,
  0xBF, 0x0F, 0xC0, 0xFD, 0xF8, 0xFE, 0x07, 0xEF, 0xC7, 0xE0, 0x3F, 0x3F,
  0x3F, 0x03, 0xF9, 0xF9, 0xF8, 0x1F, 0x8F, 0xCF, 0xC0, 0xFC, 0x7E, 0xFC,
  0x07, 0xE3, 0xFF, 0xE0, 0x3F, 0x0F, 0xFF, 0x03, 0xF8, 0x7F, 0xF8, 0x1F,
  0x83, 0xFF, 0xC0, 0xFC, 0x1F, 0xFC, 0x07, 0xE0, 0xFF, 0xE0, 0x3F, 0x03,
  0xFF, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0x80, 0xFF, 0xC0, 0xFC, 0x07, 0xFC,
  0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC,
  0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8,
  0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7E, 0x3F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE3, 0xF0,
  0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x9F, 0x03, 0xF8, 0x08, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0xC0, 0x1F, 0xC3, 0xC0, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE8, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0,
  0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0,
  0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0x7E, 0x00,
  0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F,
  0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x7F, 0x3F, 0x01, 0xFC, 0x0F, 0xE7, 0xE0,
  0x7F, 0x81, 0xF8, 0xFC, 0x0F, 0xF0, 0x7F, 0x1F, 0x83, 0xFE, 0x0F, 0xC3,
  0xF0, 0x7F, 0xC3, 0xF8, 0x7E, 0x0F, 0xF8, 0x7F, 0x0F, 0xC3, 0xFF, 0x0F,
  0xC1, 0xF8, 0x7F, 0xE3, 0xF8, 0x3F, 0x1F, 0xFC, 0x7E, 0x07, 0xE3, 0xFF,
  0x9F, 0xC0, 0xFC, 0xFF, 0xF3, 0xF8, 0x1F, 0x9F, 0xFE, 0x7E, 0x03, 0xF3,
  0xEF, 0xDF, 0xC0, 0x7E, 0xFD, 0xF3, 0xF0, 0x0F, 0xDF, 0x3E, 0x7E, 0x01,
  0xFF, 0xE7, 0xDF, 0xC0, 0x3F, 0xFC, 0xFB, 0xF0, 0x07, 0xDF, 0x1F, 0x7E,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x1F, 0x83,
  0xF8, 0x7E, 0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x3E,
  0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x01, 0xF3, 0xF0,
  0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0x9F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3E,
  0x00, 0x60, 0x00, 0x0F, 0xE3, 0xF0, 0x7F, 0xDF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF1, 0x80, 0x3F, 0x3F, 0x01,
  0xFB, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xCF,
  0xE1, 0xFC, 0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x07, 0xF1, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7E,
  0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC3, 0xF8, 0xFF, 0x3F, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE3, 0xF7, 0xFE, 0x1F, 0xBF, 0xE0, 0xF8, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFC, 0x10, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x43, 0xFC, 0x70, 0x7F, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x41, 0xFC,
  0x03, 0xF9, 0xF8, 0x07, 0xFD, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x87, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xDF, 0x80, 0x1F, 0x9F, 0x80,
  0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3F, 0xDF, 0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xE1, 0xFD,
  0xFD, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x8F, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x3F, 0x01, 0xFF, 0x7E,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF1, 0xFC,
  0x0F, 0xE1, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xF0,
  0x3F, 0xDF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x80, 0x1F, 0xC0, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x05, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x80, 0x3F, 0x3F, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xCF, 0xE1, 0xFC, 0x3F, 0x1F, 0xC1, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x1F, 0xC1,
  0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F,
  0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC0, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x23, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0x07, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x0F, 0xCF,
  0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xBF, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x00, 0x80, 0x10, 0x07, 0xCF, 0xE0, 0xFE, 0x07, 0xDF,
  0xF3, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xF3, 0xFE, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0x83,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x3F, 0x87, 0xF0, 0x7E, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0x07, 0xF0, 0xFE, 0x3F, 0x07, 0xE0, 0xFC, 0x7F, 0x07,
  0xE0, 0xFC, 0x7F, 0x0F, 0xE0, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7E, 0x0F,
  0xC1, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF8, 0xFC, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x80, 0x3E, 0x3F, 0x01,
  0xF7, 0xFC, 0x1F, 0xBF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xCF,
  0xE1, 0xFC, 0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F,
  0x07, 0xF1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0xFE,
  0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0,
  0xFE, 0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC0,
  0x00, 0x38, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xC7, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF7, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF,
  0xE3, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x03, 0xE7, 0xF0, 0x07, 0xDF, 0xF0,
  0x1F, 0xBF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x3F, 0x81,
  0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0,
  0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x3F,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xDF, 0xE0,
  0x3F, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xF3, 0xF0, 0x7F, 0xCF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF8,
  0x1F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x81, 0xF1, 0xF0, 0x7C, 0xFC, 0x3F, 0x7E, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xE2, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xF8, 0x10, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC8, 0x07, 0xE3, 0x83, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xFF, 0xDF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF8, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7F, 0x10, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x87,
  0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE0,
  0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xBE, 0x07, 0xFC, 0xF8, 0x0F, 0xE7, 0xE0, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8,
  0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC1,
  0xFF, 0xF0, 0xFF, 0x07, 0xEF, 0xC3, 0xFC, 0x3F, 0xBF, 0x0F, 0xF0, 0xFC,
  0xFC, 0x7F, 0xC7, 0xF3, 0xF1, 0xFF, 0x1F, 0x8F, 0xCF, 0xFC, 0x7E, 0x3F,
  0x3F, 0xF3, 0xF8, 0xFC, 0xFF, 0xCF, 0xC3, 0xF7, 0xDF, 0x3F, 0x0F, 0xDF,
  0x7D, 0xF8, 0x3F, 0x7D, 0xF7, 0xE0, 0xFB, 0xE7, 0xFF, 0x03, 0xEF, 0x9F,
  0xFC, 0x0F, 0xBC, 0x7B, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFE,
  0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0xC3, 0xFE, 0x00,
  0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x81, 0xF8, 0x7F, 0x80, 0xFE, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xF3, 0xF0, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF7, 0xF0,
  0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 32, 12, 0, -31 },
  { 57, 17, 11, 19, 4, -31 },
  { 81, 25, 31, 24, 0, -31 },
  { 178, 21, 36, 21, 1, -33 },
  { 273, 32, 32, 35, 2, -32 },
  { 401, 26, 32, 27, 0, -32 },
  { 505, 8, 11, 11, 4, -31 },
  { 516, 16, 39, 13, 1, -32 },
  { 594, 15, 39, 13, -3, -32 },
  { 668, 19, 20, 20, 3, -34 },
  { 716, 19, 21, 22, 2, -26 },
  { 766, 10, 12, 12, -2, -6 },
  { 781, 13, 6, 13, 0, -15 },
  { 791, 8, 8, 12, 0, -7 },
  { 799, 23, 32, 18, -2, -32 },
  { 891, 20, 32, 21, 1, -32 },
  { 971, 16, 31, 21, 4, -31 },
  { 1033, 22, 32, 21, -1, -32 },
  { 1121, 21, 32, 21, 0, -32 },
  { 1205, 22, 31, 21, 0, -31 },
  { 1291, 22, 31, 21, 0, -31 },
  { 1377, 21, 32, 21, 1, -32 },
  { 1461, 23, 31, 21, 1, -31 },
  { 1551, 22, 32, 21, 0, -32 },
  { 1639, 20, 32, 21, 1, -32 },
  { 1719, 12, 26, 12, 0, -25 },
  { 1758, 15, 31, 12, -3, -25 },
  { 1817, 19, 22, 22, 2, -27 },
  { 1870, 19, 15, 22, 2, -23 },
  { 1906, 19, 22, 22, 2, -27 },
  { 1959, 17, 32, 17, 2, -32 },
  { 2027, 31, 36, 32, 1, -32 },
  { 2167, 24, 32, 24, -3, -32 },
  { 2263, 24, 31, 24, 0, -31 },
  { 2356, 23, 32, 22, 2, -32 },
  { 2448, 25, 31, 25, 0, -31 },
  { 2545, 22, 31, 20, 0, -31 },
  { 2631, 22, 31, 19, 0, -31 },
  { 2717, 24, 32, 26, 2, -32 },
  { 2813, 27, 31, 26, 0, -31 },
  { 2918, 21, 31, 16, -2, -31 },
  { 3000, 21, 41, 13, -7, -31 },
  { 3108, 27, 31, 23, 0, -31 },
  { 3213, 17, 31, 19, 0, -31 },
  { 3279, 35, 31, 34, 0, -31 },
  { 3415, 29, 31, 28, 0, -31 },
  { 3528, 24, 32, 27, 2, -32 },
  { 3624, 24, 31, 23, 0, -31 },
  { 3717, 24, 39, 27, 2, -32 },
  { 3834, 23, 31, 23, 0, -31 },
  { 3924, 22, 32, 20, 0, -32 },
  { 4012, 20, 31, 20, 3, -31 },
  { 4090, 25, 31, 25, 2, -31 },
  { 4187, 23, 31, 23, 4, -31 },
  { 4277, 35, 31, 34, 3, -31 },
  { 4413, 29, 31, 23, -3, -31 },
  { 4526, 22, 31, 22, 4, -31 },
  { 4612, 25, 31, 20, -2, -31 },
  { 4709, 19, 39, 13, -2, -32 },
  { 4802, 11, 32, 18, 4, -32 },
  { 4846, 18, 39, 13, -3, -32 },
  { 4934, 21, 20, 21, 0, -31 },
  { 4987, 17, 4, 16, -4, 3 },
  { 4996, 9, 7, 14, 6, -34 },
  { 5004, 22, 25, 22, 1, -25 },
  { 5073, 21, 33, 22, 0, -33 },
  { 5160, 18, 25, 18, 1, -25 },
  { 5217, 24, 33, 22, 1, -33 },
  { 5316, 19, 25, 21, 1, -25 },
  { 5376, 24, 45, 14, -5, -34 },
  { 5511, 24, 36, 23, -1, -25 },
  { 5619, 21, 33, 23, 0, -33 },
  { 5706, 13, 34, 11, 0, -34 },
  { 5762, 19, 45, 11, -6, -34 },
  { 5869, 24, 33, 22, 0, -33 },
  { 5968, 14, 33, 11, 0, -33 },
  { 6026, 32, 25, 34, 0, -25 },
  { 6126, 21, 25, 23, 0, -25 },
  { 6192, 20, 25, 22, 1, -25 },
  { 6255, 23, 36, 22, -2, -25 },
  { 6359, 22, 36, 22, 1, -25 },
  { 6458, 18, 25, 16, 0, -25 },
  { 6515, 18, 25, 18, 0, -25 },
  { 6572, 15, 29, 15, 2, -29 },
  { 6627, 22, 24, 23, 1, -24 },
  { 6693, 20, 24, 20, 3, -24 },
  { 6753, 30, 24, 30, 3, -24 },
  { 6843, 25, 24, 21, -2, -24 },
  { 6918, 26, 35, 20, -3, -24 },
  { 7032, 21, 24, 17, -2, -24 },
  { 7095, 18, 38, 15, 0, -31 },
  { 7181, 5, 44, 19, 7, -34 },
  { 7209, 18, 38, 15, -3, -31 },
  { 7295, 19, 7, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC44PT7B_H_
