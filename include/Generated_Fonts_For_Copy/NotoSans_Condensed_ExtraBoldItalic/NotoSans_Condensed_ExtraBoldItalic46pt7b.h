#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC46PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0xE0,
  0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x40,
  0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7F, 0x3F,
  0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87,
  0xC3, 0xE3, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x03, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF0, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x0F, 0x8F,
  0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xB3, 0xC0, 0xFC, 0xC2, 0x07, 0xF7,
  0x00, 0x1F, 0xDC, 0x00, 0x7F, 0x60, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x06, 0xFE, 0x00, 0x19, 0xF8, 0x00, 0x67,
  0xE3, 0x03, 0x9F, 0x8F, 0x0E, 0xFE, 0x3F, 0xBF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0x00,
  0x7C, 0x03, 0xFF, 0xC0, 0x7C, 0x01, 0xF7, 0xE0, 0x7E, 0x01, 0xF9, 0xF0,
  0x3E, 0x00, 0xF8, 0xF8, 0x3E, 0x00, 0xFC, 0x7C, 0x1F, 0x00, 0x7C, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x8F, 0x80, 0x0F, 0x8F,
  0x8F, 0x80, 0x0F, 0xC7, 0xC7, 0xC0, 0x07, 0xE3, 0xE7, 0xC7, 0xE1, 0xF3,
  0xE7, 0xE7, 0xFC, 0xFB, 0xF3, 0xE7, 0xFE, 0x7F, 0xF3, 0xE7, 0xFF, 0xBF,
  0xFB, 0xF3, 0xFF, 0xCF, 0xF9, 0xF3, 0xF3, 0xE3, 0xF1, 0xF9, 0xF1, 0xF0,
  0x00, 0xF9, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0xFC, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x8F,
  0x80, 0x3E, 0x0F, 0xC7, 0xC0, 0x3F, 0x07, 0xE7, 0xC0, 0x1F, 0x01, 0xF7,
  0xE0, 0x1F, 0x80, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0xF0, 0x0F, 0x80, 0x1F,
  0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0xBF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x7F, 0x07, 0xFF, 0x0F, 0xE0, 0xFF, 0xF8, 0xFE, 0x1F, 0xFF, 0x9F,
  0xC3, 0xFF, 0xFD, 0xFC, 0x3F, 0x9F, 0xFF, 0x87, 0xF1, 0xFF, 0xF8, 0x7F,
  0x0F, 0xFF, 0x0F, 0xE0, 0xFF, 0xF0, 0xFE, 0x07, 0xFE, 0x0F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xF0, 0x0F, 0xF8,
  0x7F, 0x80, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3E, 0x1F, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x02,
  0x0F, 0xC0, 0x30, 0xFC, 0x03, 0xCF, 0x80, 0x7F, 0xF8, 0x67, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xBE, 0x07, 0xFB, 0xF0, 0x3F, 0x3F, 0x01, 0xE1,
  0xF8, 0x06, 0x1F, 0x00, 0x41, 0xC0, 0x00, 0x10, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x00, 0x3F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x7F, 0xF8, 0x08, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xCF, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE,
  0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0,
  0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x3F, 0x9F, 0xC1, 0xFD, 0xFC, 0x0F, 0xEF,
  0xE0, 0x7F, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xBF, 0x1F, 0xBF, 0x87, 0x9F, 0xC3,
  0x8F, 0xE0, 0x87, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFC, 0x7F, 0x80, 0xE0, 0x7F, 0x01, 0x80, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x38, 0x1F, 0xC0, 0x40, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF2, 0x00, 0x3F, 0x8C, 0x01, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x07,
  0xDF, 0x80, 0x1F, 0x7F, 0x00, 0x7C, 0xFE, 0x01, 0xF9, 0xF8, 0x03, 0xE3,
  0xF0, 0x0F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7C, 0x3F, 0x81, 0xF0, 0x7E,
  0x07, 0xE1, 0xFC, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x10, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE1, 0x00, 0x3F, 0xC3, 0x80, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x38, 0x03,
  0xF9, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xDF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0x9F, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x10, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x3F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x9F, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0x7F,
  0x03, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x7F, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F,
  0xC3, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC3, 0xFC, 0xFE, 0x1F, 0xE7, 0xF1, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xEF, 0xC0, 0xFE, 0xFE, 0x01, 0xC7, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0xC1, 0xEF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x3F, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0xE0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x18,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF1, 0xC1, 0xFC,
  0x40, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x70,
  0x1F, 0x0F, 0x81, 0xFF, 0x8F, 0x0F, 0x87, 0xFF, 0x8F, 0x1F, 0x0F, 0xFF,
  0x8F, 0x1F, 0x1F, 0xDF, 0x8F, 0x3E, 0x1F, 0x1F, 0x0F, 0x3E, 0x3E, 0x1F,
  0x0F, 0x3C, 0x3E, 0x1F, 0x0F, 0x7C, 0x7C, 0x1F, 0x1F, 0x7C, 0x7C, 0x3E,
  0x1F, 0x78, 0x7C, 0x3E, 0x1F, 0x78, 0xF8, 0x3E, 0x1E, 0x78, 0xF8, 0x3E,
  0x3E, 0xF8, 0xF8, 0x7C, 0x3C, 0xF8, 0xF8, 0x7C, 0x7C, 0xF8, 0xFC, 0xFC,
  0xF8, 0xF8, 0x7F, 0xFF, 0xF8, 0xF8, 0x7F, 0xFF, 0xF0, 0xF8, 0x3F, 0x9F,
  0xE0, 0x7C, 0x1E, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0C, 0x00, 0x1F, 0xFB, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF,
  0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF9,
  0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xF9,
  0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xE1, 0xFE, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE1,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x18, 0x0F, 0xF0, 0x08, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x81, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x9F, 0xF8, 0x0F,
  0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFC,
  0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xFE, 0x0F, 0xE1, 0xFF,
  0x03, 0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x01, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xE0, 0x3F, 0xE0, 0x08,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0xF1, 0xFC,
  0x3F, 0xF8, 0xFF, 0x0F, 0xFE, 0x3F, 0xC3, 0xFF, 0x8F, 0xF0, 0xFF, 0xE3,
  0xF8, 0x7F, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF8,
  0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x87, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80,
  0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC,
  0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFE,
  0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x7E, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x7E, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0x7E, 0x3F, 0x7F,
  0x01, 0xFB, 0xF1, 0xFB, 0xF0, 0x0F, 0xDF, 0x8F, 0x9F, 0x80, 0xFE, 0xFC,
  0xFD, 0xFC, 0x07, 0xF7, 0xE7, 0xCF, 0xE0, 0x3F, 0xBF, 0x7E, 0x7F, 0x01,
  0xF9, 0xFB, 0xE3, 0xF0, 0x0F, 0xCF, 0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0xF9,
  0xFC, 0x07, 0xF3, 0xFF, 0x8F, 0xE0, 0x3F, 0x1F, 0xFC, 0x7E, 0x01, 0xF8,
  0xFF, 0xC3, 0xF0, 0x0F, 0xC3, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xC1, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x07, 0xFC, 0x03, 0xF0,
  0x1F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0xE0, 0x3F, 0x80,
  0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x83, 0xF8, 0x0F,
  0xFF, 0x07, 0xF0, 0x1F, 0xFE, 0x0F, 0xC0, 0x3F, 0xFE, 0x1F, 0x80, 0x7F,
  0xFC, 0x7F, 0x01, 0xFD, 0xF8, 0xFE, 0x03, 0xF3, 0xF1, 0xFC, 0x07, 0xE7,
  0xE3, 0xF0, 0x0F, 0xCF, 0xE7, 0xE0, 0x3F, 0x9F, 0xDF, 0xC0, 0x7F, 0x1F,
  0xBF, 0x80, 0xFE, 0x3F, 0x7F, 0x01, 0xF8, 0x7F, 0xFC, 0x03, 0xF0, 0xFF,
  0xF8, 0x0F, 0xE0, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0xE0, 0x3F, 0x03, 0xFF,
  0x80, 0x7E, 0x07, 0xFF, 0x00, 0xFC, 0x0F, 0xFE, 0x03, 0xF8, 0x0F, 0xFC,
  0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x3F, 0xE0, 0x1F, 0x80, 0x7F, 0xC0,
  0x7F, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x7F,
  0x80, 0x3F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x7F, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xE3, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F,
  0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x87, 0xF8, 0x1F, 0xCF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F,
  0xE3, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF,
  0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF,
  0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x03, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE,
  0x0F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x1F, 0xDF, 0xE0,
  0x3F, 0x8F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x8F, 0xF0,
  0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF8,
  0x7F, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFE, 0x1E, 0x07, 0xF8, 0x08, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x80, 0x1F, 0xE1, 0x80, 0x3F, 0x83,
  0xC0, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F,
  0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03,
  0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x1F, 0xE0, 0x7E, 0x1F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x7F,
  0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x01,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0xFE, 0x03, 0xF8, 0x0F, 0xEF,
  0xE0, 0x3F, 0x80, 0xFE, 0xFE, 0x07, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x81,
  0xFC, 0xFE, 0x0F, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x83, 0xF8, 0xFE, 0x0F,
  0xF8, 0x3F, 0x8F, 0xC1, 0xFF, 0x87, 0xF0, 0xFC, 0x1F, 0xF8, 0x7F, 0x0F,
  0xC3, 0xFF, 0x8F, 0xE0, 0xFC, 0x3F, 0xF8, 0xFE, 0x0F, 0xC3, 0xFF, 0x8F,
  0xE0, 0xFC, 0x7F, 0xF9, 0xFC, 0x0F, 0xC7, 0xDF, 0x9F, 0xC0, 0xFC, 0xFD,
  0xF9, 0xF8, 0x0F, 0xCF, 0xDF, 0xBF, 0x80, 0xFD, 0xF9, 0xFB, 0xF8, 0x0F,
  0xDF, 0x9F, 0x7F, 0x00, 0xFD, 0xF1, 0xF7, 0xF0, 0x0F, 0xFF, 0x1F, 0x7E,
  0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE,
  0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x7F, 0x00,
  0xFE, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x3E, 0x00, 0xFC,
  0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x7C,
  0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0xFC,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFE,
  0x7F, 0x9F, 0xC7, 0xE3, 0xF0, 0xFC, 0x3E, 0x00, 0x70, 0x00, 0x03, 0xF8,
  0xFC, 0x1F, 0xFB, 0xF0, 0x3F, 0xF7, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xF9, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F,
  0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xF3, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xF7, 0xE0, 0x3F, 0xCF, 0xC0, 0x3F, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC7, 0x00, 0x7F, 0x7F, 0x01, 0xFB, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF1, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x9F, 0xE1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x7F, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFD, 0xFF, 0xC3, 0xF3, 0xFE, 0x0F, 0xC7, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xF8, 0x61, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x83, 0x0F, 0xF9,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x38, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x7F, 0xDF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xCF, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF9, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xF7, 0xE0, 0x07,
  0xE3, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xC3, 0xF3, 0xF8, 0x3F, 0x3F,
  0x83, 0xF3, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x08, 0xFF, 0x03, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xB0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x8F, 0xC0, 0x3F, 0xEF, 0xC0, 0x3F, 0xF7, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xFC,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xF7, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x04, 0x00, 0xFE, 0x03, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC7, 0x80, 0x7F, 0x7F, 0x01, 0xFB,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF,
  0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83,
  0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x1F,
  0xE0, 0xFE, 0x1F, 0xE0, 0x7E, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xEF, 0xF0, 0x07, 0xF7,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0x01,
  0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8,
  0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x01, 0xF9,
  0xFC, 0x1F, 0xC0, 0x7C, 0xFF, 0x9F, 0xF8, 0x1F, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xBF, 0xF3, 0xFC,
  0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x07,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x87, 0xE0, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x83, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x1F, 0xC7, 0xF0,
  0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x83, 0xF0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0xC0,
  0x1F, 0x9F, 0xC0, 0x7C, 0xFF, 0x81, 0xF7, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0x9F, 0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7E, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0,
  0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x80, 0x00, 0x3E, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0x9F, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xDF,
  0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0xF8, 0x1F,
  0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0xBF, 0x83, 0xF9, 0xFC,
  0x3F, 0xC7, 0xF3, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x01, 0xF9, 0xFC,
  0x01, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xE1, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xF7, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xBF, 0xE0, 0x3F, 0x9F, 0x80,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xF8, 0xFC, 0x0F, 0xFB, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xF9, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xF3, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xFC,
  0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0xFD, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xE4, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xF0, 0x60, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x40, 0x3F, 0x8F, 0x0F, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x07,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE,
  0x43, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xFB, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFB, 0xF0, 0x1F, 0xF7, 0xE0, 0x1F, 0x8F, 0x80, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x03, 0xF9, 0xF8, 0x1F, 0xCF, 0xC1, 0xFC,
  0x7E, 0x0F, 0xE3, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xE3,
  0xF8, 0x3F, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFE, 0x01,
  0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x1F, 0xE0, 0xFF, 0xF8, 0x3F, 0xC1,
  0xFF, 0xF0, 0x7F, 0x87, 0xF7, 0xE1, 0xFF, 0x0F, 0xEF, 0xC3, 0xFE, 0x1F,
  0x9F, 0x8F, 0xFC, 0x7F, 0x3F, 0x1F, 0xF8, 0xFC, 0x7E, 0x3F, 0xF3, 0xF8,
  0xFC, 0xFB, 0xE7, 0xF1, 0xF9, 0xF7, 0xCF, 0xC3, 0xF7, 0xEF, 0xBF, 0x87,
  0xEF, 0x9F, 0x7E, 0x0F, 0xDF, 0x7E, 0xFC, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F,
  0xF9, 0xF7, 0xE0, 0x7F, 0xF3, 0xEF, 0xC0, 0xFF, 0xC7, 0xFF, 0x01, 0xFF,
  0x8F, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0xFF, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x17, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0x80, 0x3F, 0xE8, 0x00, 0x78,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 34, 12, 0, -33 },
  { 61, 18, 12, 20, 4, -33 },
  { 88, 26, 33, 25, 0, -33 },
  { 196, 22, 38, 22, 1, -35 },
  { 301, 33, 33, 36, 2, -33 },
  { 438, 28, 33, 28, 0, -33 },
  { 554, 9, 12, 11, 4, -33 },
  { 568, 16, 40, 14, 1, -33 },
  { 648, 17, 41, 14, -4, -34 },
  { 736, 20, 21, 21, 3, -35 },
  { 789, 20, 22, 23, 2, -27 },
  { 844, 11, 12, 12, -2, -6 },
  { 861, 13, 6, 14, 0, -15 },
  { 871, 8, 9, 12, 0, -8 },
  { 880, 24, 33, 18, -2, -33 },
  { 979, 21, 33, 22, 1, -33 },
  { 1066, 17, 33, 22, 4, -33 },
  { 1137, 23, 33, 22, -1, -33 },
  { 1232, 22, 33, 22, 0, -33 },
  { 1323, 23, 33, 22, 0, -33 },
  { 1418, 23, 33, 22, 0, -33 },
  { 1513, 23, 33, 22, 1, -33 },
  { 1608, 24, 33, 22, 1, -33 },
  { 1707, 23, 33, 22, 0, -33 },
  { 1802, 21, 33, 22, 1, -33 },
  { 1889, 12, 27, 12, 0, -26 },
  { 1930, 15, 32, 12, -3, -26 },
  { 1990, 20, 23, 23, 2, -28 },
  { 2048, 20, 15, 23, 2, -24 },
  { 2086, 20, 23, 23, 2, -28 },
  { 2144, 18, 34, 18, 2, -33 },
  { 2221, 32, 37, 34, 1, -33 },
  { 2369, 25, 33, 25, -3, -33 },
  { 2473, 25, 33, 25, 0, -33 },
  { 2577, 24, 33, 23, 2, -33 },
  { 2676, 26, 33, 26, 0, -33 },
  { 2784, 23, 33, 21, 0, -33 },
  { 2879, 23, 33, 20, 0, -33 },
  { 2974, 26, 33, 27, 2, -33 },
  { 3082, 29, 33, 27, 0, -33 },
  { 3202, 22, 33, 17, -2, -33 },
  { 3293, 22, 43, 13, -7, -33 },
  { 3412, 29, 33, 24, 0, -33 },
  { 3532, 17, 33, 20, 0, -33 },
  { 3603, 37, 33, 35, 0, -33 },
  { 3756, 31, 33, 29, 0, -33 },
  { 3884, 26, 33, 28, 2, -33 },
  { 3992, 25, 33, 24, 0, -33 },
  { 4096, 26, 41, 28, 2, -33 },
  { 4230, 24, 33, 24, 0, -33 },
  { 4329, 23, 33, 21, 0, -33 },
  { 4424, 20, 33, 21, 4, -33 },
  { 4507, 26, 33, 27, 2, -33 },
  { 4615, 24, 33, 24, 4, -33 },
  { 4714, 36, 33, 36, 4, -33 },
  { 4863, 30, 33, 24, -3, -33 },
  { 4987, 23, 33, 23, 4, -33 },
  { 5082, 26, 33, 21, -2, -33 },
  { 5190, 19, 41, 14, -2, -33 },
  { 5288, 10, 33, 19, 5, -33 },
  { 5330, 19, 41, 14, -3, -33 },
  { 5428, 22, 21, 22, 0, -33 },
  { 5486, 18, 4, 17, -4, 4 },
  { 5495, 9, 7, 15, 7, -35 },
  { 5503, 23, 26, 24, 1, -26 },
  { 5578, 22, 35, 23, 0, -35 },
  { 5675, 19, 26, 19, 1, -26 },
  { 5737, 25, 35, 24, 1, -35 },
  { 5847, 20, 26, 22, 1, -26 },
  { 5912, 25, 46, 15, -5, -35 },
  { 6056, 25, 37, 24, -1, -26 },
  { 6172, 22, 35, 24, 0, -35 },
  { 6269, 14, 35, 12, 0, -35 },
  { 6331, 20, 46, 12, -6, -35 },
  { 6446, 25, 35, 23, 0, -35 },
  { 6556, 14, 35, 12, 0, -35 },
  { 6618, 34, 26, 35, 0, -26 },
  { 6729, 22, 26, 24, 0, -26 },
  { 6801, 21, 26, 23, 1, -26 },
  { 6870, 24, 37, 23, -2, -26 },
  { 6981, 23, 37, 24, 1, -26 },
  { 7088, 19, 26, 17, 0, -26 },
  { 7150, 19, 26, 19, 0, -26 },
  { 7212, 15, 31, 16, 2, -31 },
  { 7271, 23, 25, 24, 1, -25 },
  { 7343, 21, 25, 21, 3, -25 },
  { 7409, 31, 25, 32, 3, -25 },
  { 7506, 26, 25, 21, -2, -25 },
  { 7588, 27, 36, 21, -3, -25 },
  { 7710, 22, 25, 18, -2, -25 },
  { 7779, 19, 40, 16, 0, -33 },
  { 7874, 6, 45, 20, 7, -35 },
  { 7908, 19, 40, 16, -3, -33 },
  { 8003, 20, 8, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC46PT7B_H_
