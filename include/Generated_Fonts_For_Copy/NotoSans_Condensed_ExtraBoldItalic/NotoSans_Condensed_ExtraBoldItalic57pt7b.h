#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC57PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xE3, 0xFC, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x87,
  0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F,
  0x83, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0xE7, 0xC0, 0x7F, 0x9C, 0x30, 0x1F, 0xE7,
  0x00, 0x03, 0xFC, 0xE0, 0x00, 0x7F, 0x9C, 0x00, 0x0F, 0xFB, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0E, 0xFF,
  0x80, 0x01, 0xCF, 0xF0, 0x00, 0x39, 0xFE, 0x10, 0x07, 0x3F, 0xC3, 0x00,
  0xE7, 0xF8, 0x78, 0x39, 0xFE, 0x1F, 0xE7, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x3F,
  0x00, 0x3F, 0x8F, 0xC0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC3,
  0xF8, 0x00, 0x7E, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F,
  0x9F, 0xC1, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xFC, 0xFE, 0x7F, 0x3F, 0x8F,
  0xFE, 0xFE, 0xFE, 0x3F, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0x3F, 0xFF, 0x7F,
  0xFC, 0xFE, 0x7F, 0xFF, 0x7F, 0xF8, 0xFC, 0x7F, 0x3F, 0x3F, 0xF1, 0xFC,
  0xFE, 0x3F, 0x1F, 0xE1, 0xF8, 0xFC, 0x3F, 0x00, 0x03, 0xF9, 0xFC, 0x3F,
  0x00, 0x07, 0xF1, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x0F,
  0xE1, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8,
  0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x7E, 0x00,
  0x7F, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x03,
  0xF9, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xF8,
  0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xC1, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x8F, 0xF8, 0x7F, 0xFF,
  0xF3, 0xFC, 0x1F, 0xF7, 0xFD, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0x87, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x3F, 0xF0, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x10, 0x3F, 0x80, 0x3C,
  0x3F, 0x80, 0x3E, 0x3F, 0x00, 0x3F, 0xBF, 0x03, 0x7F, 0xFF, 0x7F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0x01, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F,
  0xEF, 0xC0, 0x7F, 0xEF, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0x87, 0xF0, 0x0F,
  0x87, 0xF8, 0x07, 0x07, 0xE0, 0x02, 0x03, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F,
  0x8F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x06, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFD, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC7, 0xFC,
  0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF9, 0xFF, 0x03, 0xFC, 0xFF,
  0x81, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF,
  0xF0, 0x3F, 0xEF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF,
  0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F, 0xE7, 0xF8, 0x3F,
  0xE3, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0xCF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0x9F, 0xF0, 0xF8, 0xFF, 0x03, 0x87, 0xF8, 0x18, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0x7E, 0x0F, 0xF8,
  0x03, 0xC0, 0x7F, 0xC0, 0x0C, 0x03, 0xFE, 0x00, 0x40, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x87, 0xFF,
  0x00, 0xE0, 0x3F, 0xF0, 0x08, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x08, 0x00, 0x1F, 0xF0,
  0xC0, 0x03, 0xFF, 0x0F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x2A, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x7E, 0x7F,
  0x80, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF1, 0xFF, 0x00,
  0x3F, 0x8F, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0x83, 0xFC, 0x01, 0xF8,
  0x1F, 0xE0, 0x1F, 0xC1, 0xFF, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xC1, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x84, 0x00, 0x3F, 0xF0, 0xC0, 0x0F, 0xFC, 0x1E, 0x03, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFE, 0x02, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x78, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF7, 0xFE, 0x3F, 0xF8, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0xFF,
  0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF,
  0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8, 0x3F, 0xE1,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x3F,
  0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF3, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1,
  0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF,
  0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x3F, 0xF3, 0xFE, 0x0F, 0xFC, 0xFF, 0xCF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x20, 0x0F, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0x80, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xC3,
  0xFF, 0x0E, 0x03, 0xFE, 0x10, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x02, 0x00, 0x7E, 0x07, 0xE0,
  0x3F, 0xF8, 0x7E, 0x0F, 0xC0, 0xFF, 0xFC, 0x7E, 0x1F, 0xC1, 0xFF, 0xFC,
  0x3E, 0x1F, 0x83, 0xFF, 0xFC, 0x3E, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0x3F,
  0x07, 0xE1, 0xF8, 0x3E, 0x3F, 0x0F, 0xE1, 0xF8, 0x3E, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x7E, 0x1F, 0x83, 0xF0, 0x7E,
  0x7C, 0x3F, 0x83, 0xF0, 0x7E, 0xFC, 0x3F, 0x03, 0xF0, 0x7C, 0xFC, 0x3F,
  0x03, 0xF0, 0x7C, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0xFC, 0x3F, 0x07, 0xE0,
  0xF8, 0xFC, 0x7F, 0x07, 0xE1, 0xF8, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0xF8,
  0x7F, 0x1F, 0xE3, 0xF0, 0xF8, 0x3F, 0xBF, 0xE7, 0xE0, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFC, 0x3F, 0xFB, 0xFF, 0xC0, 0xFC, 0x1F, 0xF3, 0xFF, 0x80,
  0xFC, 0x0F, 0xE1, 0xFE, 0x00, 0xFC, 0x03, 0x80, 0x78, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F,
  0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x03,
  0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF,
  0x7F, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x7F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0x00, 0xE0, 0x1F, 0xF8, 0x01,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x0C, 0x01, 0xFF, 0xC1, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x0F,
  0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xF8, 0x03,
  0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x07,
  0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0x80, 0x38, 0x07, 0xFF, 0x00,
  0x08, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0xFF,
  0xFC, 0x7F, 0xE0, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF,
  0xF8, 0x7F, 0xC1, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x87, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF0, 0x3F,
  0xF0, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x03, 0xFF, 0xF8, 0x07, 0xFB, 0xF8,
  0x3F, 0xBF, 0xC0, 0x3F, 0xDF, 0xC1, 0xFD, 0xFE, 0x01, 0xFE, 0xFE, 0x1F,
  0xDF, 0xF0, 0x0F, 0xF7, 0xF0, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0x8F, 0xE7,
  0xF8, 0x07, 0xF9, 0xFC, 0x7F, 0x3F, 0xC0, 0x3F, 0xCF, 0xE7, 0xF3, 0xFE,
  0x01, 0xFE, 0x7F, 0x3F, 0x9F, 0xE0, 0x0F, 0xF3, 0xF9, 0xFC, 0xFF, 0x00,
  0xFF, 0x9F, 0xDF, 0xC7, 0xF8, 0x07, 0xF8, 0xFE, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC7, 0xFF, 0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1,
  0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x7F,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFF, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x83, 0xFE,
  0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F,
  0x80, 0x3F, 0xBF, 0xC1, 0xFE, 0x00, 0xFE, 0xFF, 0x07, 0xF8, 0x07, 0xFB,
  0xFC, 0x3F, 0xE0, 0x1F, 0xEF, 0xF0, 0xFF, 0x00, 0x7F, 0x9F, 0xE3, 0xFC,
  0x01, 0xFE, 0x7F, 0x8F, 0xF0, 0x07, 0xF1, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7,
  0xF9, 0xFE, 0x00, 0xFF, 0x0F, 0xF7, 0xF8, 0x03, 0xFC, 0x3F, 0xDF, 0xE0,
  0x0F, 0xF0, 0xFF, 0x7F, 0x80, 0x7F, 0xC3, 0xFD, 0xFE, 0x01, 0xFE, 0x0F,
  0xF7, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF, 0x00,
  0x7F, 0x81, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xE0, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x01,
  0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x01,
  0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01,
  0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07,
  0xFE, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF1, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF,
  0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF,
  0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x07, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xF1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF1, 0xFE,
  0x00, 0x7F, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xF8,
  0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0x03, 0x80, 0x7F, 0xE0, 0x08, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x80, 0x03, 0xFE, 0x04, 0x00,
  0x3F, 0xE0, 0xF0, 0x07, 0xFE, 0x0F, 0xF3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F,
  0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00,
  0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F,
  0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8,
  0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0xE0,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xDF, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE7,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF1, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x7F, 0x80,
  0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xFF, 0x87,
  0xFC, 0x0F, 0xF0, 0xFF, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xFF, 0xE3, 0xFE,
  0x03, 0xFC, 0x7F, 0x7F, 0x1F, 0xF0, 0x1F, 0xE3, 0xFB, 0xF8, 0xFF, 0x00,
  0xFF, 0x1F, 0xDF, 0xCF, 0xF8, 0x07, 0xF9, 0xFC, 0xFE, 0x7F, 0x80, 0x3F,
  0xCF, 0xEF, 0xE3, 0xFC, 0x01, 0xFE, 0xFF, 0x7F, 0x3F, 0xE0, 0x0F, 0xF7,
  0xF3, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0x9F, 0xDF, 0xF0, 0x03, 0xFB, 0xF8,
  0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC7, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xE7, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x3F,
  0xE0, 0x3F, 0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xCF, 0xF8, 0x03,
  0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0,
  0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0,
  0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF3,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFC, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE,
  0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF8, 0x7F,
  0x01, 0xFF, 0xCF, 0xF0, 0x3F, 0xFE, 0xFF, 0x03, 0xFF, 0xEF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x87,
  0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xFC, 0x03, 0xFF,
  0x9F, 0xC0, 0x1F, 0xF9, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x3F,
  0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01,
  0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1,
  0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x3F, 0xE0,
  0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x7F, 0xF8,
  0x0F, 0xE3, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFE, 0x7C, 0x0F,
  0xF8, 0x08, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x20, 0x7F,
  0xC0, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x7F,
  0x80, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x7F, 0xFB, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFD, 0xFC, 0x00, 0x3F, 0xF3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC,
  0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x18, 0x1F, 0xF8, 0x1E, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xD8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xC7, 0xF0, 0x03, 0xFF,
  0xBF, 0xC0, 0x1F, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x07, 0xFE, 0x1F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFE,
  0x7F, 0xC0, 0x00, 0x41, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x80, 0x03, 0xFE, 0x03, 0x80, 0x1F, 0xF0,
  0x0F, 0xE3, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE1,
  0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x80, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x7F, 0x9F, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xFE, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0x9F, 0xFC, 0x7F, 0xF0, 0x0F, 0xEF,
  0xFF, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF,
  0x07, 0xFE, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x81,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x8F,
  0xF8, 0x03, 0xF9, 0xFF, 0xC0, 0x3F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7,
  0xFC, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F,
  0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xF3, 0xFC, 0x0F, 0xF9, 0xFE, 0x0F,
  0xFC, 0xFF, 0x87, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFE,
  0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0xE0, 0x03, 0xFB, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xF3,
  0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xF9, 0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE0,
  0x40, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFC, 0x7F,
  0x00, 0xFF, 0xE7, 0xF0, 0x1F, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xFE, 0x0F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x87,
  0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFB, 0xFC, 0x00, 0xFE, 0x7F, 0xC0, 0x01, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3E, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xDF, 0xF0, 0x3F, 0xBF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFC, 0x1C, 0x1F, 0xF0, 0x08, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x40, 0x0F, 0xF8, 0xE0, 0x1F, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x10, 0x7F,
  0xFE, 0x1F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0,
  0x7F, 0xC7, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3,
  0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xF8, 0x7F,
  0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC1, 0xFF,
  0x87, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0x80, 0xFF, 0xE7, 0xF0,
  0x07, 0xF8, 0xFE, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x1F,
  0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F,
  0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x81, 0xFF, 0x01, 0xFE, 0xFF, 0x07, 0xFE, 0x07, 0xFD, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xF8, 0x1F, 0xE7, 0xF0, 0x7F, 0xF0, 0x7F,
  0x8F, 0xE0, 0xFF, 0xE0, 0xFF, 0x1F, 0xC1, 0xFF, 0xC3, 0xFE, 0x3F, 0x87,
  0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xFF, 0x0F, 0xF0, 0xFE, 0x3F, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7E, 0xFC, 0x7F, 0x87, 0xF8, 0xFD, 0xF9, 0xFE, 0x0F, 0xF3,
  0xFB, 0xF3, 0xFC, 0x1F, 0xE7, 0xEF, 0xE7, 0xF8, 0x3F, 0xDF, 0xDF, 0xDF,
  0xE0, 0x7F, 0xBF, 0xBF, 0xBF, 0xC0, 0xFF, 0x7E, 0x7F, 0x7F, 0x01, 0xFF,
  0xFC, 0xFF, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x07, 0xFF, 0xE3, 0xF7,
  0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x4F, 0xFF, 0x00, 0x37, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFE, 0xC0, 0x07, 0xFF, 0x20, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 18, 42, 15, 0, -41 },
  { 96, 22, 15, 25, 5, -41 },
  { 138, 32, 41, 31, 0, -41 },
  { 302, 27, 46, 27, 1, -43 },
  { 458, 40, 42, 45, 3, -41 },
  { 668, 34, 42, 34, 0, -41 },
  { 847, 11, 15, 14, 5, -41 },
  { 868, 20, 50, 17, 1, -41 },
  { 993, 20, 51, 17, -4, -42 },
  { 1121, 24, 26, 26, 4, -44 },
  { 1199, 25, 28, 29, 3, -34 },
  { 1287, 14, 16, 15, -3, -8 },
  { 1315, 16, 8, 17, 1, -19 },
  { 1331, 10, 10, 15, 0, -9 },
  { 1344, 31, 41, 23, -3, -41 },
  { 1503, 25, 42, 27, 2, -41 },
  { 1635, 21, 41, 28, 5, -41 },
  { 1743, 29, 41, 27, -2, -41 },
  { 1892, 28, 42, 27, 0, -41 },
  { 2039, 29, 41, 28, -1, -41 },
  { 2188, 27, 42, 27, 1, -41 },
  { 2330, 27, 42, 27, 2, -41 },
  { 2472, 30, 41, 27, 1, -41 },
  { 2626, 27, 42, 27, 1, -41 },
  { 2768, 26, 42, 27, 1, -41 },
  { 2905, 15, 33, 15, 0, -32 },
  { 2967, 18, 40, 15, -3, -32 },
  { 3057, 26, 29, 29, 2, -35 },
  { 3152, 26, 18, 29, 2, -29 },
  { 3211, 25, 29, 29, 3, -35 },
  { 3302, 23, 42, 22, 2, -41 },
  { 3423, 40, 46, 42, 2, -41 },
  { 3653, 31, 41, 31, -3, -41 },
  { 3812, 31, 41, 30, 0, -41 },
  { 3971, 30, 42, 29, 2, -41 },
  { 4129, 32, 41, 33, 0, -41 },
  { 4293, 28, 41, 26, 0, -41 },
  { 4437, 28, 41, 25, 0, -41 },
  { 4581, 32, 42, 33, 2, -41 },
  { 4749, 35, 41, 34, 0, -41 },
  { 4929, 26, 41, 21, -2, -41 },
  { 5063, 27, 53, 16, -9, -41 },
  { 5242, 36, 41, 30, 0, -41 },
  { 5427, 21, 41, 25, 0, -41 },
  { 5535, 45, 41, 44, 0, -41 },
  { 5766, 38, 41, 36, 0, -41 },
  { 5961, 32, 42, 35, 2, -41 },
  { 6129, 31, 41, 29, 0, -41 },
  { 6288, 32, 51, 35, 2, -41 },
  { 6492, 30, 41, 30, 0, -41 },
  { 6646, 28, 42, 26, 0, -41 },
  { 6793, 26, 41, 26, 4, -41 },
  { 6927, 32, 42, 33, 3, -41 },
  { 7095, 30, 41, 30, 5, -41 },
  { 7249, 45, 41, 44, 4, -41 },
  { 7480, 37, 41, 29, -3, -41 },
  { 7670, 28, 41, 28, 5, -41 },
  { 7814, 31, 41, 26, -2, -41 },
  { 7973, 23, 50, 17, -2, -41 },
  { 8117, 13, 41, 23, 6, -41 },
  { 8184, 24, 50, 17, -4, -41 },
  { 8334, 27, 26, 27, 0, -41 },
  { 8422, 22, 6, 21, -5, 4 },
  { 8439, 12, 9, 18, 8, -44 },
  { 8453, 28, 33, 29, 1, -32 },
  { 8569, 28, 44, 29, 0, -43 },
  { 8723, 24, 33, 24, 1, -32 },
  { 8822, 31, 44, 29, 1, -43 },
  { 8993, 26, 33, 27, 1, -32 },
  { 9101, 31, 58, 18, -6, -44 },
  { 9326, 30, 46, 29, -1, -32 },
  { 9499, 28, 43, 29, 0, -43 },
  { 9650, 17, 44, 15, 0, -44 },
  { 9744, 24, 58, 15, -7, -44 },
  { 9918, 31, 43, 28, 0, -43 },
  { 10085, 18, 43, 15, 0, -43 },
  { 10182, 42, 32, 43, 0, -32 },
  { 10350, 28, 32, 29, 0, -32 },
  { 10462, 25, 33, 29, 2, -32 },
  { 10566, 31, 46, 29, -3, -32 },
  { 10745, 28, 46, 29, 1, -32 },
  { 10906, 23, 32, 21, 0, -32 },
  { 10998, 23, 33, 23, 0, -32 },
  { 11093, 20, 39, 20, 2, -38 },
  { 11191, 27, 32, 29, 2, -31 },
  { 11299, 26, 31, 26, 3, -31 },
  { 11400, 39, 31, 39, 3, -31 },
  { 11552, 32, 31, 27, -3, -31 },
  { 11676, 33, 45, 26, -4, -31 },
  { 11862, 26, 31, 23, -2, -31 },
  { 11963, 24, 50, 20, 0, -41 },
  { 12113, 7, 57, 25, 9, -44 },
  { 12163, 22, 50, 20, -3, -41 },
  { 12301, 26, 10, 29, 2, -25 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC57PT7B_H_
