#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC27PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0, 0xFB, 0xFC, 0xEF, 0x7B,
  0x9E, 0xE7, 0xB9, 0xCE, 0x70, 0x01, 0xDE, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xC0, 0x73, 0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1C, 0xE0,
  0x73, 0x87, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1C, 0xE0, 0x39,
  0x80, 0xE7, 0x01, 0xCE, 0x00, 0x00, 0x40, 0x06, 0x00, 0x30, 0x0F, 0xF0,
  0xFF, 0x8F, 0xFC, 0x76, 0x43, 0xB0, 0x1F, 0x00, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x01, 0xF8, 0x0B, 0xC8, 0xDE, 0x77, 0xE3, 0xFF, 0x3F, 0xF0,
  0x7E, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0xF0, 0x38,
  0x3F, 0x87, 0x03, 0xB8, 0x70, 0x73, 0x8E, 0x07, 0x39, 0xE0, 0x73, 0x9C,
  0x0F, 0x3B, 0x80, 0xE7, 0x39, 0xCF, 0x77, 0x7E, 0x7E, 0xE7, 0xE7, 0xCE,
  0xE7, 0x11, 0xCE, 0x70, 0x1D, 0xCE, 0x03, 0x9C, 0xE0, 0x71, 0xCE, 0x07,
  0x1C, 0xE0, 0xE1, 0xFC, 0x1E, 0x1F, 0xC1, 0xC0, 0xF8, 0x00, 0xC0, 0x03,
  0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0x38, 0x0E, 0x78, 0x0F, 0x78, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xCF, 0x3F, 0xDE, 0x7B, 0xFE, 0x79,
  0xFC, 0xF1, 0xFC, 0xF0, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F,
  0x3E, 0xFF, 0xBD, 0xEE, 0x73, 0x80, 0x03, 0x83, 0x83, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0x07, 0x01, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F,
  0x07, 0x83, 0xC0, 0x06, 0x00, 0xE1, 0x1C, 0x33, 0x8F, 0xE7, 0xFF, 0xCF,
  0xF8, 0xF9, 0x3F, 0x0F, 0x70, 0xCF, 0x09, 0xC0, 0x20, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x3C, 0xF7, 0x9E, 0x73, 0xCE, 0x38, 0x7F,
  0x7F, 0x7E, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x7E, 0x1F, 0xE1, 0xFF, 0x3C,
  0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0x78, 0xFF, 0x0F, 0xF1, 0xFF, 0x1E, 0xF1,
  0xEF, 0x1E, 0xF3, 0xEF, 0x3C, 0xF7, 0xCF, 0xF8, 0x7F, 0x07, 0xE0, 0x03,
  0xC1, 0xF0, 0xFC, 0xFF, 0x7F, 0xBF, 0xE7, 0x78, 0x9E, 0x07, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x00,
  0xC0, 0x0F, 0xE0, 0xFF, 0x87, 0xFF, 0x0E, 0x7C, 0x10, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0x01, 0x80,
  0x7F, 0x87, 0xFE, 0x3F, 0xF0, 0x87, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xD0, 0x3C,
  0xC3, 0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x3B, 0xC1, 0xDE, 0x1D, 0xE1, 0xCF, 0x1E,
  0x78, 0xE3, 0xDF, 0xFF, 0x7F, 0xFB, 0xFF, 0xC0, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x84, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFA, 0x07, 0x9C, 0xFC, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0, 0x00, 0x60, 0x1F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x30, 0x7F, 0xC3,
  0xFF, 0x3F, 0xF9, 0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x7C, 0xF7,
  0xC7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xC0, 0x3F, 0x83, 0xFE, 0x3F, 0xF1, 0xE7, 0x8F, 0x3C, 0x79,
  0xE3, 0xDE, 0x1F, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xC7, 0xDE, 0x3C, 0x7B,
  0xC3, 0xDE, 0x1E, 0xF9, 0xE3, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x80,
  0x3F, 0x03, 0xFC, 0x3F, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C,
  0xF9, 0xE7, 0xCF, 0xFC, 0x7F, 0xE1, 0xEF, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x87, 0xC7, 0xFC, 0x3F, 0xC1, 0xFC, 0x00, 0x1E, 0x3C, 0xF9, 0xF0, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x9F, 0x3C, 0x00, 0x03, 0x83, 0xC3,
  0xE1, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE1,
  0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0,
  0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x07, 0xF1, 0xFC, 0xFF, 0x0F, 0xC0,
  0xE0, 0x08, 0x00, 0x06, 0x07, 0xF9, 0xFF, 0x1F, 0xF2, 0x1E, 0x03, 0xC0,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0,
  0x3C, 0x0F, 0x0F, 0x00, 0xE3, 0xC0, 0x1C, 0x71, 0xF9, 0xDC, 0x7F, 0x3B,
  0x9C, 0xE7, 0x67, 0x1C, 0xFC, 0xE7, 0x1B, 0x9C, 0xE7, 0x77, 0x1C, 0xEE,
  0xE7, 0x99, 0xDE, 0xFF, 0x39, 0xFF, 0xC7, 0x1C, 0xF0, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xF0, 0xE0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xCF,
  0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF,
  0xFF, 0x9E, 0x0F, 0x3C, 0x1E, 0xF0, 0x3F, 0xE0, 0x78, 0x0F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0xF9, 0xF1, 0xE3, 0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0x1E,
  0x3E, 0x3D, 0xF8, 0x7F, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x40, 0x0F,
  0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0x18, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0xFC, 0xC1, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFB, 0xF1, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3E,
  0x1E, 0x78, 0x7C, 0xF0, 0xF9, 0xE1, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E, 0x3E,
  0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xC7,
  0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x78, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x60,
  0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xF0, 0xC7, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF3, 0xFB, 0xE7, 0xF7, 0xCF, 0xEF, 0x87, 0x9E, 0x0F,
  0x3E, 0x1E, 0x7C, 0x3C, 0x7C, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00,
  0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0,
  0xF8, 0x78, 0x78, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0x87, 0x87, 0xC3, 0xC3, 0xC1, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0x78,
  0x7C, 0x3C, 0x3C, 0x3E, 0x00, 0x0F, 0xF8, 0x7F, 0x81, 0xF8, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x7F, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x0F, 0x87, 0x8F, 0x83, 0xCF, 0x83,
  0xC7, 0x81, 0xE7, 0x80, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xDE, 0x03, 0xCF, 0x01, 0xE7,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3E, 0x00, 0x0F, 0x03,
  0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC1,
  0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xC1, 0xDC, 0x7F, 0x07, 0x73, 0xFC, 0x3D, 0xCE, 0xF0, 0xF7,
  0x7B, 0x83, 0xDD, 0xDE, 0x0F, 0x77, 0x78, 0x79, 0xF9, 0xE1, 0xE7, 0xE7,
  0x87, 0x9F, 0x3C, 0x1E, 0x7C, 0xF0, 0x71, 0xF3, 0xC3, 0xC7, 0x8F, 0x0F,
  0x1E, 0x7C, 0x00, 0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0xF8, 0x38, 0x7F, 0x1E,
  0x1F, 0xC7, 0x87, 0xF1, 0xE1, 0xDC, 0x78, 0x77, 0xBC, 0x3D, 0xEF, 0x0F,
  0x7B, 0xC3, 0xDE, 0xF0, 0xE3, 0xB8, 0x78, 0xFE, 0x1E, 0x3F, 0x87, 0x8F,
  0xE1, 0xE1, 0xF8, 0x70, 0x7C, 0x3C, 0x1F, 0x0F, 0x07, 0xC0, 0x00, 0x60,
  0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE7, 0xC3, 0xCF, 0x07, 0xBE,
  0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xDE, 0x07,
  0xBC, 0x1F, 0x7C, 0x7C, 0xFD, 0xF8, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xE3, 0xE3, 0xC7, 0x87,
  0x8F, 0x0F, 0x1E, 0x3C, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x60, 0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE7, 0xC3, 0xCF,
  0x07, 0xBE, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xDE, 0x07, 0xBC, 0x1F, 0x7C, 0x7C, 0xFD, 0xF8, 0xFF, 0xE1, 0xFF, 0x80,
  0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x9F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7D, 0xE1, 0xE7, 0x87,
  0x9F, 0x1E, 0x7C, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x80, 0x00, 0x80, 0x3F,
  0xC3, 0xFE, 0x3F, 0xF1, 0xF3, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x90, 0x7C, 0xFF,
  0xE7, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x1E,
  0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F,
  0x3E, 0x1E, 0x78, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x87, 0x9E,
  0x1F, 0x3C, 0x3C, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8,
  0x3F, 0xF0, 0xF9, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x78,
  0x3C, 0xF0, 0x7B, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xFC, 0x07, 0x78, 0x0E,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF0,
  0x78, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x3D, 0xE1, 0xF1, 0xEF, 0x1F, 0x9F,
  0x78, 0xFC, 0xF3, 0xCF, 0xE7, 0x9E, 0x7E, 0x78, 0xF3, 0xF3, 0xC7, 0xBF,
  0x9E, 0x3D, 0xDD, 0xE1, 0xFE, 0xEF, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83,
  0xF9, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x00, 0x07, 0x87, 0xC1, 0xE3, 0xE0, 0x7C, 0xF0, 0x0F, 0x7C, 0x03, 0xDE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0x79,
  0xE0, 0x3C, 0x7C, 0x1F, 0x0F, 0x0F, 0x83, 0xC0, 0xF8, 0x7D, 0xE3, 0xE7,
  0x8F, 0x1E, 0x78, 0x79, 0xE1, 0xEF, 0x03, 0xBC, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0x83, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xFC,
  0x3F, 0x87, 0xE0, 0xE3, 0x8E, 0x3C, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x9E,
  0x78, 0xE3, 0x8E, 0x38, 0xF3, 0xCF, 0x07, 0xE0, 0xFC, 0x1F, 0x84, 0xF0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0xFC,
  0x3F, 0x87, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x07,
  0x70, 0x7B, 0x83, 0x9E, 0x3C, 0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xF0, 0x7F,
  0xEF, 0xFF, 0xFF, 0x80, 0xF7, 0xDE, 0x73, 0x80, 0x0F, 0x78, 0xFB, 0xCF,
  0xFC, 0xFB, 0xE7, 0x8F, 0x7C, 0x7B, 0xC3, 0xDE, 0x3C, 0xF1, 0xE7, 0x8F,
  0x3C, 0xF9, 0xE7, 0xCF, 0xFC, 0x7F, 0xE1, 0xEF, 0x00, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0xC3, 0xFE, 0x1F, 0xF9,
  0xFF, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9C, 0x3D, 0xE3, 0xEF, 0x1E, 0x78,
  0xF3, 0xCF, 0xBF, 0xF9, 0xFF, 0x8E, 0x78, 0x00, 0x0F, 0xC3, 0xFC, 0xFF,
  0x3E, 0x67, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x8F, 0xF0, 0xFE, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0xF7, 0x87, 0xDE, 0x3F, 0xF1, 0xF7, 0xC7, 0x8F,
  0x3E, 0x3C, 0xF0, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF,
  0x0F, 0xFC, 0x3F, 0x70, 0x79, 0xC0, 0x07, 0xC1, 0xFE, 0x3F, 0xE7, 0xCF,
  0x78, 0xFF, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x08,
  0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x00, 0x18, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x1E, 0x00, 0x3C, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xBC, 0x3F, 0xF1,
  0xFF, 0x8F, 0xBE, 0x3C, 0x79, 0xF1, 0xE7, 0x87, 0x9E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x9F, 0x1E, 0x7C, 0x7F, 0xE1, 0xFF, 0x83, 0xDE, 0x00, 0x78,
  0x03, 0xC2, 0x0F, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0xC3, 0xFF, 0x1F, 0xF9,
  0xF7, 0xCF, 0x9E, 0x78, 0xF3, 0xC7, 0x9E, 0x7D, 0xE3, 0xCF, 0x1E, 0x78,
  0xF3, 0xC7, 0xBE, 0x79, 0xE3, 0xCF, 0x1E, 0x00, 0x06, 0x0F, 0x0F, 0x0F,
  0x04, 0x00, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0x78, 0x78, 0xF8, 0xF0, 0xF0, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x08,
  0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x8F, 0x8F, 0x3E, 0x1E, 0xF8,
  0x79, 0xE0, 0xF7, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7B, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1F, 0x00, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0x1C, 0xF1, 0xE1, 0xDF,
  0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xDF, 0x3E, 0x78, 0xF3, 0xC7, 0x8F, 0x3C,
  0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7,
  0x8F, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0xF1, 0xE3, 0xC0, 0x1C, 0xF0,
  0xEF, 0xC7, 0xFE, 0x7F, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8E, 0x78,
  0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xEF, 0x1E, 0x78, 0xF3, 0xC7, 0x80, 0x0F,
  0xC1, 0xFE, 0x3F, 0xE7, 0xDF, 0x78, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x0E, 0x78,
  0x3B, 0xF0, 0xFF, 0xC7, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0F,
  0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0xBE, 0x7F, 0xF1, 0xFF, 0x87, 0xBC,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F,
  0x78, 0xFF, 0xCF, 0xFC, 0xFB, 0xE7, 0x8F, 0x7C, 0x7B, 0xC3, 0xDE, 0x3C,
  0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0x8F, 0xFC, 0x7F, 0xE1, 0xEF, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x00, 0x1C, 0xE3,
  0xBC, 0x7F, 0x1F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x0F, 0xC3, 0xFC, 0xFF, 0x1E,
  0x23, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x63, 0xCF,
  0xF9, 0xFE, 0x3F, 0x80, 0x0E, 0x07, 0x07, 0x87, 0xF7, 0xFF, 0xFC, 0xF0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC9, 0xFC, 0xFE, 0x3F,
  0x00, 0x3C, 0x79, 0xE3, 0xDF, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE3,
  0xDE, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9, 0xE7, 0xCF, 0xFC, 0x7E, 0xE1,
  0xE7, 0x00, 0xE1, 0xFE, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x78, 0xF7,
  0x8F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x00, 0xE3, 0xE3, 0xF8, 0xF8, 0xFE, 0x3E, 0x7B, 0x9F, 0x9E, 0xE7, 0xEF,
  0x39, 0xFB, 0xCE, 0xEE, 0xE3, 0xBB, 0xF8, 0xFC, 0xFE, 0x3F, 0x3F, 0x0F,
  0xDF, 0xC3, 0xE7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0x1F, 0x00, 0x1E,
  0x3E, 0x3C, 0x78, 0x3D, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x81, 0xEF, 0x07, 0xDE, 0x0F,
  0x3C, 0x3C, 0x7C, 0x00, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0xC0, 0x7F, 0xCF, 0xFC, 0xFF, 0xC0, 0x01, 0xE0, 0x7C,
  0x1F, 0x83, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0xC1, 0xF0,
  0x78, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3E,
  0x07, 0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0xF0, 0x3F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x7E, 0x1F, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x0F, 0xC1, 0xF8, 0x3E, 0x00,
  0x78, 0x1F, 0xF3, 0xFF, 0xFC, 0xFF, 0x81, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 10, 7, 12, 3, -19 },
  { 29, 15, 19, 15, 0, -19 },
  { 65, 13, 23, 13, 0, -21 },
  { 103, 20, 20, 21, 1, -20 },
  { 153, 16, 20, 16, 0, -20 },
  { 193, 5, 7, 7, 3, -19 },
  { 198, 9, 24, 8, 1, -20 },
  { 225, 10, 24, 8, -2, -20 },
  { 255, 11, 13, 12, 2, -21 },
  { 273, 12, 13, 14, 1, -16 },
  { 293, 6, 8, 7, -1, -4 },
  { 299, 8, 4, 8, 0, -9 },
  { 303, 5, 4, 7, 0, -4 },
  { 306, 14, 20, 11, -1, -20 },
  { 341, 12, 20, 13, 1, -20 },
  { 371, 10, 19, 13, 2, -19 },
  { 395, 14, 20, 13, -1, -20 },
  { 430, 13, 20, 13, 0, -20 },
  { 463, 13, 19, 13, 0, -19 },
  { 494, 13, 19, 13, 0, -19 },
  { 525, 13, 20, 13, 1, -20 },
  { 558, 13, 19, 13, 1, -19 },
  { 589, 13, 20, 13, 0, -20 },
  { 622, 13, 20, 13, 0, -20 },
  { 655, 7, 15, 7, 0, -15 },
  { 669, 9, 19, 7, -2, -15 },
  { 691, 12, 14, 14, 1, -17 },
  { 712, 12, 9, 14, 1, -14 },
  { 726, 12, 14, 14, 1, -17 },
  { 747, 11, 20, 11, 1, -20 },
  { 775, 19, 21, 20, 1, -19 },
  { 825, 15, 19, 15, -2, -19 },
  { 861, 15, 19, 14, 0, -19 },
  { 897, 14, 20, 14, 1, -20 },
  { 932, 15, 19, 15, 0, -19 },
  { 968, 13, 19, 12, 0, -19 },
  { 999, 13, 19, 12, 0, -19 },
  { 1030, 15, 20, 16, 1, -20 },
  { 1068, 17, 19, 16, 0, -19 },
  { 1109, 13, 19, 10, -1, -19 },
  { 1140, 13, 25, 8, -4, -19 },
  { 1181, 17, 19, 14, 0, -19 },
  { 1222, 10, 19, 12, 0, -19 },
  { 1246, 22, 19, 21, 0, -19 },
  { 1299, 18, 19, 17, 0, -19 },
  { 1342, 15, 20, 16, 1, -20 },
  { 1380, 15, 19, 14, 0, -19 },
  { 1416, 15, 25, 16, 1, -20 },
  { 1463, 14, 19, 14, 0, -19 },
  { 1497, 13, 20, 12, 0, -20 },
  { 1530, 12, 19, 12, 2, -19 },
  { 1559, 15, 19, 16, 1, -19 },
  { 1595, 15, 19, 14, 2, -19 },
  { 1631, 21, 19, 21, 2, -19 },
  { 1681, 18, 19, 14, -2, -19 },
  { 1724, 14, 19, 13, 2, -19 },
  { 1758, 15, 19, 12, -1, -19 },
  { 1794, 11, 24, 8, -1, -20 },
  { 1827, 6, 20, 11, 3, -20 },
  { 1842, 11, 24, 8, -2, -20 },
  { 1875, 13, 12, 13, 0, -19 },
  { 1895, 11, 3, 10, -3, 2 },
  { 1900, 5, 5, 9, 4, -21 },
  { 1904, 13, 15, 14, 1, -15 },
  { 1929, 13, 21, 14, 0, -21 },
  { 1964, 11, 15, 11, 1, -15 },
  { 1985, 14, 21, 14, 1, -21 },
  { 2022, 12, 15, 13, 1, -15 },
  { 2045, 15, 27, 9, -3, -21 },
  { 2096, 14, 21, 14, 0, -15 },
  { 2133, 13, 21, 14, 0, -21 },
  { 2168, 8, 21, 7, 0, -21 },
  { 2189, 11, 27, 7, -3, -21 },
  { 2227, 15, 21, 13, 0, -21 },
  { 2267, 8, 21, 7, 0, -21 },
  { 2288, 20, 15, 21, 0, -15 },
  { 2326, 13, 15, 14, 0, -15 },
  { 2351, 12, 15, 14, 1, -15 },
  { 2374, 14, 21, 14, -1, -15 },
  { 2411, 13, 21, 14, 1, -15 },
  { 2446, 11, 15, 10, 0, -15 },
  { 2467, 11, 15, 11, 0, -15 },
  { 2488, 9, 18, 9, 1, -18 },
  { 2509, 13, 15, 14, 1, -15 },
  { 2534, 12, 15, 12, 2, -15 },
  { 2557, 18, 15, 19, 2, -15 },
  { 2591, 15, 15, 13, -1, -15 },
  { 2620, 16, 21, 12, -2, -15 },
  { 2662, 12, 15, 11, -1, -15 },
  { 2685, 11, 23, 9, 0, -19 },
  { 2717, 3, 27, 12, 4, -21 },
  { 2728, 11, 23, 9, -2, -19 },
  { 2760, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC27PT7B_H_
