#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC37PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x1F,
  0x00, 0x3E, 0x7E, 0x7C, 0xF9, 0xF9, 0xF3, 0xE3, 0xE7, 0xCF, 0x8F, 0x9F,
  0x1E, 0x3E, 0x3C, 0x78, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x07,
  0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x07, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xCE, 0x0F, 0xB1, 0x07,
  0xEC, 0x01, 0xFB, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0D, 0xF0, 0x03, 0x7C,
  0x61, 0x9F, 0x1E, 0x6F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFC, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xF8, 0x0F, 0x81, 0xFE, 0x03, 0xC0, 0xFF, 0xC1, 0xE0,
  0x3D, 0xF0, 0x78, 0x1E, 0x3C, 0x3C, 0x07, 0x8F, 0x1F, 0x03, 0xE7, 0xC7,
  0x80, 0xF1, 0xE3, 0xC0, 0x3C, 0x78, 0xF0, 0x0F, 0x1E, 0x78, 0x03, 0xCF,
  0xBE, 0x7C, 0xF3, 0xCF, 0x3F, 0xBF, 0xF7, 0x9F, 0xF7, 0xFB, 0xEF, 0xFD,
  0xFC, 0xF3, 0xCF, 0x1C, 0x7D, 0xF3, 0xC0, 0x1E, 0x78, 0xF0, 0x0F, 0x1E,
  0x3C, 0x07, 0xC7, 0x8F, 0x01, 0xE1, 0xE7, 0xC0, 0xF0, 0xF9, 0xE0, 0x3C,
  0x3E, 0x78, 0x1E, 0x07, 0xBC, 0x0F, 0x81, 0xFF, 0x03, 0xC0, 0x7F, 0x81,
  0xE0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE3, 0xF1, 0xFF, 0x8F, 0xCF, 0xFF, 0x3E, 0x3E,
  0xFD, 0xF9, 0xF9, 0xFF, 0xC7, 0xC7, 0xFF, 0x3F, 0x0F, 0xF8, 0xFC, 0x3F,
  0xC3, 0xF0, 0x7F, 0x0F, 0xE7, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0x00, 0x7D, 0xFF, 0xFE, 0xFB, 0xEF, 0x3C,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x83, 0x1E, 0x07, 0xBC, 0x1F, 0xFB,
  0xFF, 0xFF, 0xBF, 0xFF, 0x0F, 0xFE, 0x1F, 0x84, 0x7F, 0x83, 0xFF, 0x07,
  0xDF, 0x07, 0x9F, 0x06, 0x3E, 0x04, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x8F, 0x87, 0xC7, 0xE3,
  0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0x7F, 0xEF, 0xF9, 0xFF, 0x3F,
  0xEF, 0xFC, 0x3C, 0xFB, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFC, 0xFC, 0x7E, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F,
  0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xC1, 0xF3, 0xE0, 0xFB, 0xF0, 0x7D,
  0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0x3E, 0x1F, 0x9F, 0x0F, 0xCF, 0x87,
  0xC7, 0xE7, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x1F, 0xF8, 0xFF,
  0xE7, 0xFF, 0xBF, 0x7C, 0x79, 0xF0, 0xCF, 0xC2, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0x9F, 0xC0, 0xC1, 0xF8, 0x10, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xC3, 0xF0, 0x40, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x20, 0x1F, 0x8F, 0xBF, 0xE3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x7B, 0xF0, 0x3C, 0xFC, 0x1F, 0x3E, 0x07,
  0x8F, 0x83, 0xC3, 0xE1, 0xF1, 0xF8, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0xC0, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x83, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xEF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7,
  0xF7, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x8F, 0xC3, 0xF3, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7,
  0xC1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x0F, 0xCF, 0xE7, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x01, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1, 0xFC, 0xFC, 0xFC, 0x7E, 0x7C,
  0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC7, 0xF7, 0xE3, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xBE, 0x07, 0x9F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC3, 0x1F, 0xC1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0x03, 0xE0, 0xFC, 0x7F, 0x1F,
  0x87, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x7C, 0x3F, 0x8F, 0xC3, 0xF0, 0xF8, 0x00, 0x00, 0xC0, 0x3E,
  0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFF,
  0x03, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x7F, 0xC7, 0xFF, 0x9F, 0xFF, 0x3F,
  0xFC, 0xC3, 0xF2, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x01, 0xE0,
  0xF8, 0x00, 0x78, 0x3C, 0x1F, 0x0F, 0x1E, 0x1F, 0xF3, 0xCF, 0x0F, 0xFC,
  0xF3, 0xC7, 0xDF, 0x3D, 0xE3, 0xE7, 0x8F, 0x78, 0xF1, 0xE3, 0xDE, 0x78,
  0x78, 0xF7, 0x1E, 0x1E, 0x3B, 0xC7, 0x8F, 0x1E, 0xF1, 0xC3, 0xC7, 0xBC,
  0xF0, 0xF1, 0xCF, 0x3C, 0x7C, 0xF3, 0xC7, 0xBF, 0x78, 0xF1, 0xFD, 0xFE,
  0x3C, 0x7F, 0x7F, 0x0F, 0x07, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x10, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3F, 0x3E,
  0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x03, 0xF3, 0xF0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x03,
  0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xC7, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0x7E,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0xC3, 0xE0,
  0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xC7, 0x0F, 0xE0, 0x21, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x18, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0x83, 0xF8, 0x7C,
  0x3F, 0x87, 0xE3, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFE, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE, 0x1C, 0x1F, 0xC0, 0x43, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x3F,
  0xEF, 0xC7, 0xFC, 0xFC, 0x7F, 0xCF, 0xC7, 0xFC, 0xFC, 0x7F, 0xCF, 0xC0,
  0xF8, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03,
  0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0xFE, 0x0F, 0xC3, 0xF8, 0x1F, 0x87,
  0xE0, 0x3F, 0x1F, 0x80, 0x7C, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0,
  0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x80, 0x1F, 0x7E, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F,
  0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xFF, 0xF7, 0xFF, 0xDF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFE, 0x1E, 0xF8, 0x3E, 0xF1, 0xF7,
  0xC1, 0xF7, 0xCF, 0x7E, 0x0F, 0xBE, 0xFB, 0xF0, 0x7D, 0xF7, 0xDF, 0x07,
  0xEF, 0xBC, 0xF8, 0x3E, 0x7F, 0xE7, 0xC1, 0xF3, 0xFE, 0x7E, 0x0F, 0x9F,
  0xF3, 0xE0, 0x7C, 0xFF, 0x1F, 0x07, 0xE7, 0xF8, 0xF8, 0x3E, 0x3F, 0x8F,
  0xC1, 0xF1, 0xFC, 0x7E, 0x0F, 0x8F, 0xC3, 0xE0, 0xFC, 0x7E, 0x1F, 0x07,
  0xC3, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0x81, 0xFE,
  0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x7F, 0x83, 0xF0, 0x7F, 0xC1, 0xF0, 0x3F,
  0xF0, 0xF8, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x7E, 0x07, 0xFE, 0x3F, 0x07,
  0xDF, 0x1F, 0x03, 0xE7, 0xCF, 0x81, 0xF3, 0xE7, 0xC0, 0xF9, 0xF7, 0xE0,
  0x7C, 0xFB, 0xE0, 0x7E, 0x7F, 0xF0, 0x3E, 0x1F, 0xF8, 0x1F, 0x0F, 0xFC,
  0x0F, 0x87, 0xFE, 0x07, 0xC3, 0xFE, 0x07, 0xE0, 0xFF, 0x03, 0xE0, 0x7F,
  0x81, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7C, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x7F, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x7E, 0xF8,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xCF, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F,
  0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x7F,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x7E,
  0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7C, 0xFE, 0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE1,
  0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xF8, 0xF8, 0x1F,
  0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0xFC,
  0x1F, 0x9F, 0x83, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFF, 0x83, 0xF9, 0xE1, 0xFC, 0x10, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x80, 0x7E, 0x38, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF8,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x07, 0xE3, 0xF0, 0x3E,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x07, 0xC1, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07,
  0xC3, 0xF0, 0x7C, 0x3F, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0,
  0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x7D, 0xF8, 0x07, 0xDF, 0x00, 0x7D, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFC,
  0x0F, 0x81, 0xFF, 0xE0, 0x7C, 0x0F, 0xBF, 0x07, 0xE0, 0xFD, 0xF8, 0x3F,
  0x07, 0xEF, 0xC3, 0xF8, 0x3E, 0x7C, 0x1F, 0xC3, 0xF3, 0xE1, 0xFE, 0x1F,
  0x1F, 0x0F, 0xF1, 0xF8, 0xF8, 0x7F, 0x8F, 0xC7, 0xC7, 0xFC, 0x7C, 0x3E,
  0x3F, 0xE7, 0xE1, 0xF3, 0xFF, 0x3E, 0x0F, 0x9F, 0xFB, 0xF0, 0x7C, 0xF7,
  0xDF, 0x83, 0xEF, 0xBE, 0xF8, 0x1F, 0x79, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC,
  0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC1,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x7F, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0xFC, 0x01, 0xF1, 0xF8, 0x01, 0xF9,
  0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xCF, 0x80, 0x1F, 0x8F,
  0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xEF, 0x83, 0xF1, 0xF0, 0x7E, 0x3F,
  0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF7, 0xE0, 0x3E,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x08, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x01,
  0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF,
  0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x02, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x03, 0xE7, 0xC1, 0xF0, 0xF0, 0x7C,
  0x3C, 0x3E, 0x0F, 0x8F, 0x03, 0xE7, 0xC0, 0x7B, 0xE0, 0x1F, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x7E, 0x3E, 0x3E, 0x1F, 0x0F, 0x01, 0x80,
  0x01, 0xF9, 0xF0, 0xFF, 0x7C, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xCF, 0xE3,
  0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFD, 0xF0, 0x3E, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x38, 0x0F, 0xBF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F,
  0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7,
  0xE3, 0xF1, 0xFD, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xBF, 0xC3, 0xE7,
  0xC0, 0x00, 0xF0, 0x07, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC7, 0xF1,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x08, 0xFE, 0xF1, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1C,
  0x7C, 0x07, 0xEF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F,
  0x3F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F,
  0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xE7, 0xC0, 0x00, 0x60, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xBF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x7F, 0x7F, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF0, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x18, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x20, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x9F, 0x03,
  0xFD, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0xFE, 0x0F, 0xC7, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x7F,
  0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFD, 0xF0, 0x0F, 0xBF, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0xC0, 0x7E, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x38, 0x0F, 0xBF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F, 0x8F,
  0xC3, 0xE3, 0xE1, 0xF8, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xC7, 0xE1,
  0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xF1, 0xF8,
  0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83,
  0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC1, 0xF9, 0xF8, 0x1F,
  0xBF, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xE7, 0xC0,
  0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x00, 0x8E, 0x03, 0x01, 0xE7, 0xF3,
  0xF8, 0x3D, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F,
  0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7E, 0x3F, 0x1F, 0x0F, 0x87,
  0xE7, 0xE1, 0xF0, 0xFC, 0xFC, 0x7E, 0x1F, 0x1F, 0x0F, 0xC3, 0xE3, 0xE1,
  0xF8, 0xFC, 0xFC, 0x3E, 0x1F, 0x9F, 0x87, 0xC3, 0xE3, 0xF1, 0xF8, 0x7C,
  0x7C, 0x3F, 0x0F, 0x8F, 0x87, 0xC3, 0xF3, 0xF0, 0xF8, 0x7E, 0x7E, 0x1F,
  0x0F, 0x8F, 0x87, 0xE1, 0xF0, 0x00, 0x86, 0x03, 0xCF, 0xE0, 0xF7, 0xF8,
  0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0x87,
  0xE7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F, 0xCF, 0xC3, 0xE3,
  0xF0, 0xF8, 0xFC, 0x3E, 0x00, 0x00, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0xF8, 0xF8, 0x7E, 0xFC, 0x3F, 0x7C, 0x1F,
  0xBE, 0x0F, 0xBF, 0x07, 0xDF, 0x83, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0,
  0xF9, 0xF8, 0xFC, 0xFC, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x3E, 0xFC, 0x03, 0xDF, 0xE0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0x3F, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3E, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xF9, 0xF0, 0xFF, 0x7C,
  0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xCF, 0xE3, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E,
  0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F,
  0x8F, 0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFD, 0xF0, 0x3E, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x06, 0x1F, 0x7C, 0x3F, 0xF8, 0x7B, 0xE1, 0xFF, 0xC3, 0xFF,
  0x87, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0xC7, 0xE1, 0x8F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x40, 0xFC, 0xE3,
  0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F, 0x00, 0x1F,
  0x8F, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0x87,
  0xE3, 0xE1, 0xF9, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xC3, 0xF1,
  0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xF8, 0xFF,
  0xFE, 0x3F, 0xEF, 0x07, 0xFB, 0xC0, 0xF9, 0xF0, 0xFC, 0x1F, 0xFE, 0x1F,
  0xBF, 0x0F, 0xDF, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xE1, 0xF3, 0xF0, 0xF9,
  0xF0, 0x7D, 0xF8, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x0F, 0xFE, 0x1F, 0xC7, 0xEF, 0x87, 0xF1,
  0xF3, 0xE3, 0xFC, 0x7C, 0xF8, 0xFF, 0x3F, 0x3E, 0x3F, 0xCF, 0x8F, 0x9F,
  0xF7, 0xE3, 0xE7, 0xFD, 0xF0, 0xFB, 0xFE, 0x7C, 0x3E, 0xF7, 0xBE, 0x0F,
  0xBD, 0xEF, 0x83, 0xFE, 0x7B, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC,
  0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE3, 0xF8, 0x3F,
  0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xF7, 0xE0, 0x3F, 0x3F, 0x01, 0xF8, 0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C,
  0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x03,
  0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x08, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x70, 0x00, 0x7F, 0x01,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 26, 10, 0, -26 },
  { 37, 15, 9, 16, 3, -26 },
  { 54, 21, 26, 20, 0, -26 },
  { 123, 18, 30, 18, 0, -28 },
  { 191, 26, 27, 29, 2, -27 },
  { 279, 22, 27, 22, 0, -27 },
  { 354, 6, 9, 9, 4, -26 },
  { 361, 13, 33, 11, 1, -27 },
  { 415, 13, 33, 11, -3, -27 },
  { 469, 15, 16, 17, 3, -28 },
  { 499, 16, 18, 19, 2, -22 },
  { 535, 9, 10, 10, -2, -5 },
  { 547, 11, 5, 11, 0, -12 },
  { 554, 7, 6, 10, 0, -6 },
  { 560, 20, 27, 15, -2, -27 },
  { 628, 17, 27, 18, 1, -27 },
  { 686, 14, 26, 18, 3, -26 },
  { 732, 19, 27, 18, -1, -27 },
  { 797, 18, 27, 18, 0, -27 },
  { 858, 18, 26, 18, 0, -26 },
  { 917, 18, 26, 18, 0, -26 },
  { 976, 18, 27, 18, 1, -27 },
  { 1037, 19, 26, 18, 1, -26 },
  { 1099, 18, 27, 18, 0, -27 },
  { 1160, 17, 27, 18, 1, -27 },
  { 1218, 10, 21, 10, 0, -21 },
  { 1245, 12, 26, 10, -2, -21 },
  { 1284, 16, 19, 19, 2, -23 },
  { 1322, 16, 12, 19, 2, -19 },
  { 1346, 16, 19, 19, 2, -23 },
  { 1384, 14, 27, 14, 2, -27 },
  { 1432, 26, 30, 27, 1, -27 },
  { 1530, 20, 26, 20, -2, -26 },
  { 1595, 20, 26, 20, 0, -26 },
  { 1660, 19, 27, 19, 2, -27 },
  { 1725, 21, 26, 21, 0, -26 },
  { 1794, 18, 26, 17, 0, -26 },
  { 1853, 18, 26, 16, 0, -26 },
  { 1912, 20, 27, 22, 2, -27 },
  { 1980, 23, 26, 22, 0, -26 },
  { 2055, 17, 26, 13, -1, -26 },
  { 2111, 18, 34, 11, -6, -26 },
  { 2188, 23, 26, 20, 0, -26 },
  { 2263, 14, 26, 16, 0, -26 },
  { 2309, 29, 26, 28, 0, -26 },
  { 2404, 25, 26, 24, 0, -26 },
  { 2486, 20, 27, 23, 2, -27 },
  { 2554, 20, 26, 19, 0, -26 },
  { 2619, 20, 33, 23, 2, -27 },
  { 2702, 19, 26, 20, 0, -26 },
  { 2764, 18, 27, 17, 0, -27 },
  { 2825, 16, 26, 17, 3, -26 },
  { 2877, 21, 26, 21, 2, -26 },
  { 2946, 20, 26, 19, 3, -26 },
  { 3011, 29, 26, 29, 3, -26 },
  { 3106, 24, 26, 19, -2, -26 },
  { 3184, 19, 26, 18, 3, -26 },
  { 3246, 20, 26, 17, -1, -26 },
  { 3311, 15, 33, 11, -1, -27 },
  { 3373, 8, 27, 15, 4, -27 },
  { 3400, 16, 33, 11, -3, -27 },
  { 3466, 18, 16, 18, 0, -26 },
  { 3502, 15, 3, 14, -4, 3 },
  { 3508, 8, 6, 12, 5, -28 },
  { 3514, 18, 21, 19, 1, -21 },
  { 3562, 18, 28, 19, 0, -28 },
  { 3625, 15, 21, 15, 1, -21 },
  { 3665, 20, 28, 19, 1, -28 },
  { 3735, 16, 21, 18, 1, -21 },
  { 3777, 20, 37, 12, -4, -28 },
  { 3870, 20, 30, 19, -1, -21 },
  { 3945, 18, 28, 19, 0, -28 },
  { 4008, 11, 28, 10, 0, -28 },
  { 4047, 16, 37, 10, -5, -28 },
  { 4121, 20, 28, 18, 0, -28 },
  { 4191, 11, 28, 10, 0, -28 },
  { 4230, 27, 21, 28, 0, -21 },
  { 4301, 18, 21, 19, 0, -21 },
  { 4349, 17, 21, 19, 1, -21 },
  { 4394, 20, 30, 19, -2, -21 },
  { 4469, 18, 30, 19, 1, -21 },
  { 4537, 15, 21, 13, 0, -21 },
  { 4577, 15, 21, 15, 0, -21 },
  { 4617, 12, 25, 13, 2, -25 },
  { 4655, 18, 20, 19, 1, -20 },
  { 4700, 17, 20, 17, 2, -20 },
  { 4743, 26, 20, 26, 2, -20 },
  { 4808, 21, 20, 17, -2, -20 },
  { 4861, 22, 29, 17, -3, -20 },
  { 4941, 17, 20, 15, -1, -20 },
  { 4984, 15, 32, 13, 0, -26 },
  { 5044, 4, 36, 16, 6, -28 },
  { 5062, 15, 32, 13, -2, -26 },
  { 5122, 16, 6, 19, 2, -16 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC37PT7B_H_
