#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC58PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xE3, 0xFE, 0x7F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xE3,
  0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F,
  0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFD, 0xF8, 0x07, 0xF9, 0xC3, 0x80, 0x7F, 0x9C, 0x08, 0x07,
  0xF1, 0xC0, 0x00, 0xFF, 0x38, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xCF, 0xF0, 0x00, 0x1C, 0xFF, 0x04, 0x01,
  0xCF, 0xF0, 0x70, 0x1C, 0xFF, 0x07, 0xC3, 0xDF, 0xF0, 0xFF, 0xBF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x08,
  0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x7E, 0x00,
  0x3F, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x7F, 0x00, 0x1F, 0xC3,
  0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x1F,
  0x80, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC7, 0xE1, 0xFE, 0x3F, 0x8F, 0xE7, 0xF1, 0xFF, 0x9F, 0xCF, 0xE7, 0xF1,
  0xFF, 0xEF, 0xFF, 0xF3, 0xF1, 0xFF, 0xF3, 0xFF, 0xF3, 0xF9, 0xFF, 0xFD,
  0xFF, 0xF1, 0xF8, 0xFE, 0xFE, 0x7F, 0xF1, 0xFC, 0xFE, 0x3F, 0x1F, 0xF1,
  0xFC, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F,
  0x87, 0xE0, 0x00, 0xFE, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x83, 0xF0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0xFC,
  0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xDF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x7F,
  0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xF0, 0xFF,
  0x81, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xE3, 0xFC, 0x1F, 0xFF, 0xFC,
  0xFF, 0x87, 0xFE, 0xFF, 0xDF, 0xE0, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xE1,
  0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xE0, 0x7F, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE7, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xF7,
  0xFD, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8,
  0xFE, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x81, 0xFC, 0x00, 0xE0, 0xFE, 0x00,
  0x7C, 0x7F, 0x00, 0x3F, 0xBF, 0x00, 0xBF, 0xFF, 0x8F, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x03, 0xFD, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3E,
  0x1F, 0xE0, 0x0F, 0x0F, 0xF0, 0x03, 0x03, 0xE0, 0x00, 0x81, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0x8F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC,
  0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF3, 0xFE, 0x07,
  0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC,
  0x07, 0xFD, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF,
  0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x3F, 0xE0, 0x7F,
  0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0x3F, 0xC0,
  0xFF, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F,
  0xC3, 0xFE, 0x0F, 0xF9, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xF7, 0xF8, 0x7F, 0x9F, 0xE0, 0xFC, 0xFF, 0x83, 0xE3,
  0xFE, 0x07, 0x0F, 0xF0, 0x08, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xFC, 0x01,
  0xF0, 0x3F, 0xF0, 0x03, 0x80, 0x7F, 0xC0, 0x0C, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xF0, 0x3F, 0xF0, 0x0C,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x80, 0x01, 0xFF, 0x0C, 0x00,
  0x3F, 0xF0, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xDF,
  0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7E, 0x7F, 0xC0,
  0x07, 0xF3, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF0, 0xFF, 0x00, 0x3F,
  0x0F, 0xF8, 0x03, 0xF8, 0x7F, 0xC0, 0x3F, 0x83, 0xFE, 0x01, 0xF8, 0x1F,
  0xE0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x08, 0x00, 0x7F, 0xE0, 0xC0, 0x0F, 0xFE, 0x0F, 0x81,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x1C, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x3F, 0x80, 0x3F, 0xEF, 0xFC, 0x03, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF1, 0xFF, 0x0F, 0xFE, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F,
  0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x3F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F,
  0xC7, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0xE7, 0xFC,
  0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x7F, 0x81, 0xFF, 0xDF, 0xF0, 0x1F, 0xF3, 0xFC, 0x00, 0xF0, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x02, 0x01, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xE0, 0x3F, 0x80, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x87, 0xF7, 0xFF, 0x0F, 0x03, 0xFE, 0x18, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0x0F,
  0xE0, 0x7F, 0xFE, 0x3F, 0x0F, 0xC0, 0xFF, 0xFE, 0x3F, 0x1F, 0xC1, 0xFF,
  0xFE, 0x3F, 0x1F, 0x83, 0xFF, 0xFC, 0x3F, 0x3F, 0x87, 0xF8, 0xFC, 0x3F,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x7E, 0x1F, 0x81, 0xF8,
  0x3F, 0x7C, 0x3F, 0x83, 0xF8, 0x3E, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0xFC,
  0x3F, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x03, 0xF0, 0x7C, 0xFC, 0x3F, 0x07,
  0xF0, 0xFC, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8,
  0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFC, 0x3F, 0xFD, 0xFF, 0xC0, 0xFC, 0x1F, 0xF9, 0xFF,
  0x80, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xFC, 0x03, 0x80, 0x18, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x80,
  0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x01,
  0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC7, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0xE0, 0x1F, 0xFC, 0x00, 0x80, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x30, 0x07,
  0xFF, 0x87, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x3F, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE,
  0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE1,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x10, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x3C, 0x03,
  0xFF, 0xC0, 0x04, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0x87, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFC, 0x3F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF8, 0x01, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFE, 0x1F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x87, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xFE, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xF7, 0xF8, 0x07, 0xFB, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F,
  0xEF, 0xE0, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0x87, 0xFB, 0xFC, 0x01, 0xFE,
  0xFE, 0x1F, 0xCF, 0xF0, 0x07, 0xFB, 0xF8, 0x7F, 0x7F, 0xC0, 0x3F, 0xEF,
  0xE3, 0xF9, 0xFF, 0x00, 0xFF, 0x3F, 0x8F, 0xE7, 0xF8, 0x03, 0xFC, 0xFE,
  0x7F, 0x1F, 0xE0, 0x0F, 0xF3, 0xF9, 0xFC, 0x7F, 0x80, 0x7F, 0xCF, 0xEF,
  0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xBF, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xFF, 0xC7,
  0xFC, 0x03, 0xFE, 0x3F, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0xF8, 0x7F,
  0x80, 0x3F, 0xC3, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80,
  0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F,
  0xFF, 0xE0, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xFD, 0xFE, 0x0F, 0xF0, 0x07,
  0xF9, 0xFE, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8,
  0xFF, 0x80, 0x3F, 0xCF, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xF3, 0xFC, 0x01,
  0xFE, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0x7F,
  0x9F, 0xE0, 0x0F, 0xF0, 0xFF, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0x00,
  0x7F, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x07,
  0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F,
  0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0x9F, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x01,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x8F,
  0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x00, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0x07,
  0xC0, 0x3F, 0xF0, 0x0E, 0x01, 0xFF, 0x80, 0x10, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x10, 0x00, 0x7F, 0xC0,
  0x60, 0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xBF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF,
  0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC1, 0xFE,
  0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xF9, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE,
  0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF3, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xC7, 0xF8, 0x0F, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F,
  0xE1, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xFC, 0x1F, 0xF0,
  0x7F, 0x83, 0xFF, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0x07, 0xF8, 0x1F,
  0xE1, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F, 0xFF, 0xC3, 0xFE, 0x07, 0xF8,
  0x7F, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xF7, 0xF1, 0xFF, 0x01, 0xFE, 0x3F,
  0xBF, 0x8F, 0xF0, 0x0F, 0xF3, 0xFD, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xCF,
  0xE7, 0xFC, 0x03, 0xFC, 0xFE, 0x7F, 0x3F, 0xC0, 0x1F, 0xEF, 0xE3, 0xFB,
  0xFE, 0x00, 0xFF, 0x7F, 0x1F, 0xDF, 0xE0, 0x07, 0xFF, 0xF8, 0xFE, 0xFF,
  0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x41, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE1,
  0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xFB, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x07, 0xFE, 0x3F, 0xC0,
  0x7F, 0xF9, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83,
  0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0xFF, 0x00, 0x7F, 0xE7, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x3F, 0xEF, 0xFC, 0x03, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF1, 0xFE, 0x03,
  0xFE, 0x1F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xF1,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xC0, 0xFE, 0x3F, 0xF0, 0x0F, 0xE1,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFC, 0x1C, 0x3F, 0xF0, 0x08, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x20, 0xFF, 0xC1, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00,
  0x7F, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF,
  0x87, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFB, 0xFC, 0x00,
  0x7F, 0xE7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0,
  0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xEF, 0xF8,
  0x1F, 0xE7, 0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x30, 0x7F, 0xE0, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0x84, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x04, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0xF3,
  0xFC, 0x01, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xFC,
  0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xBF, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x41, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x08, 0x00, 0x3F, 0xE0, 0x1C, 0x00, 0xFF, 0xC0, 0x3F, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x3F, 0xEF, 0xFC, 0x03, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0xC0,
  0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x04, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F,
  0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F,
  0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x07, 0xF8, 0xFF,
  0x80, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x01, 0xF8, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F,
  0xE7, 0xFF, 0x9F, 0xFF, 0x01, 0xFD, 0xFF, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x83,
  0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF,
  0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F,
  0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xF8, 0x7F, 0x80, 0x3F, 0x8F, 0xFC, 0x03,
  0xF9, 0xFF, 0xE0, 0x3F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x03, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F,
  0x83, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC0, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xE3, 0xFE, 0x3F, 0xF0,
  0x7F, 0x8F, 0xF8, 0x1F, 0xE7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFE, 0x03, 0xFE,
  0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03,
  0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x3F, 0xE3, 0xFC,
  0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xF0,
  0x00, 0xFE, 0x3F, 0xF0, 0x01, 0xFC, 0xFF, 0xF0, 0x03, 0xFB, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFC,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFE, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00,
  0x1F, 0xE0, 0x20, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x03,
  0xFF, 0x3F, 0xC0, 0x7F, 0xF9, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x8F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFC,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F,
  0xC0, 0x7F, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0x01,
  0xFC, 0x7F, 0x80, 0x01, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x03, 0xF9, 0xFE, 0x03, 0xFB, 0xFE, 0x03, 0xFB, 0xFE, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFC, 0xFC, 0x0F, 0xF8, 0x18, 0x1F, 0xF0, 0x08, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x80, 0x1F, 0xF0, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x82, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01,
  0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8,
  0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0x9F, 0xC0, 0x3F, 0xF3, 0xF8, 0x01,
  0xFE, 0x3F, 0x80, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF8,
  0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0x7F, 0x83,
  0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F,
  0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0xF0, 0x7F, 0x9F, 0xE1, 0xFF, 0xE0, 0xFF,
  0x3F, 0xC3, 0xFF, 0xC3, 0xFE, 0x7F, 0x87, 0xFF, 0x87, 0xF8, 0xFF, 0x1F,
  0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0xFC, 0x7F,
  0x87, 0xF1, 0xFF, 0xF1, 0xFE, 0x0F, 0xE3, 0xF7, 0xE3, 0xFC, 0x1F, 0xCF,
  0xEF, 0xCF, 0xF8, 0x3F, 0x9F, 0xDF, 0x9F, 0xE0, 0x7F, 0x3F, 0x3F, 0x3F,
  0xC0, 0xFE, 0xFE, 0x7E, 0xFF, 0x01, 0xFD, 0xF8, 0xFD, 0xFE, 0x03, 0xFB,
  0xF1, 0xFB, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF,
  0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE,
  0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x01,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x47, 0xFC,
  0x00, 0x17, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xB0, 0x00, 0xFF, 0xC8, 0x00, 0x05, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 18, 42, 15, 0, -41 },
  { 96, 23, 15, 25, 5, -41 },
  { 140, 33, 41, 32, 0, -41 },
  { 310, 28, 47, 28, 1, -44 },
  { 475, 41, 43, 46, 3, -42 },
  { 696, 35, 43, 35, 0, -42 },
  { 885, 10, 15, 14, 6, -41 },
  { 904, 21, 51, 17, 1, -42 },
  { 1038, 20, 51, 17, -4, -42 },
  { 1166, 25, 27, 27, 4, -45 },
  { 1251, 25, 29, 30, 3, -35 },
  { 1342, 14, 16, 15, -3, -8 },
  { 1370, 16, 7, 18, 1, -19 },
  { 1384, 10, 10, 15, 0, -9 },
  { 1397, 31, 42, 23, -3, -42 },
  { 1560, 26, 43, 28, 2, -42 },
  { 1700, 22, 41, 28, 5, -41 },
  { 1813, 30, 42, 28, -2, -42 },
  { 1971, 28, 43, 28, 0, -42 },
  { 2122, 29, 41, 28, -1, -41 },
  { 2271, 28, 42, 28, 1, -41 },
  { 2418, 28, 43, 28, 2, -42 },
  { 2569, 29, 41, 28, 2, -41 },
  { 2718, 28, 43, 28, 1, -42 },
  { 2869, 27, 43, 28, 1, -42 },
  { 3015, 15, 33, 15, 0, -32 },
  { 3077, 18, 40, 15, -3, -32 },
  { 3167, 26, 29, 30, 2, -35 },
  { 3262, 26, 19, 30, 2, -30 },
  { 3324, 25, 29, 30, 3, -35 },
  { 3415, 23, 43, 23, 2, -42 },
  { 3539, 40, 47, 43, 2, -42 },
  { 3774, 31, 42, 32, -3, -42 },
  { 3937, 31, 41, 31, 0, -41 },
  { 4096, 30, 43, 29, 2, -42 },
  { 4258, 33, 41, 33, 0, -41 },
  { 4428, 29, 41, 26, 0, -41 },
  { 4577, 29, 41, 26, 0, -41 },
  { 4726, 33, 43, 34, 2, -42 },
  { 4904, 36, 41, 34, 0, -41 },
  { 5089, 27, 41, 21, -2, -41 },
  { 5228, 27, 54, 17, -9, -41 },
  { 5411, 36, 41, 31, 0, -41 },
  { 5596, 22, 41, 25, 0, -41 },
  { 5709, 46, 41, 45, 0, -41 },
  { 5945, 39, 41, 37, 0, -41 },
  { 6145, 33, 43, 35, 2, -42 },
  { 6323, 31, 41, 30, 0, -41 },
  { 6482, 33, 52, 35, 2, -42 },
  { 6697, 31, 41, 31, 0, -41 },
  { 6856, 29, 43, 27, 0, -42 },
  { 7012, 25, 41, 26, 5, -41 },
  { 7141, 32, 42, 34, 3, -41 },
  { 7309, 30, 41, 30, 5, -41 },
  { 7463, 45, 41, 45, 5, -41 },
  { 7694, 37, 41, 30, -3, -41 },
  { 7884, 29, 41, 29, 5, -41 },
  { 8033, 32, 41, 26, -2, -41 },
  { 8197, 24, 51, 18, -2, -42 },
  { 8350, 13, 42, 23, 6, -42 },
  { 8419, 24, 51, 18, -4, -42 },
  { 8572, 27, 26, 28, 0, -41 },
  { 8660, 23, 6, 22, -6, 4 },
  { 8678, 12, 9, 19, 8, -44 },
  { 8692, 29, 33, 30, 1, -32 },
  { 8812, 28, 45, 30, 0, -44 },
  { 8970, 23, 33, 24, 2, -32 },
  { 9065, 31, 45, 30, 1, -44 },
  { 9240, 25, 33, 28, 2, -32 },
  { 9344, 31, 58, 19, -6, -44 },
  { 9569, 31, 46, 30, -1, -32 },
  { 9748, 28, 44, 30, 0, -44 },
  { 9902, 18, 45, 15, 0, -45 },
  { 10004, 25, 59, 15, -7, -45 },
  { 10189, 32, 44, 29, 0, -44 },
  { 10365, 18, 44, 15, 0, -44 },
  { 10464, 43, 32, 44, 0, -32 },
  { 10636, 28, 32, 30, 0, -32 },
  { 10748, 26, 33, 29, 2, -32 },
  { 10856, 31, 46, 30, -3, -32 },
  { 11035, 29, 46, 30, 1, -32 },
  { 11202, 24, 32, 21, 0, -32 },
  { 11298, 24, 33, 24, 0, -32 },
  { 11397, 20, 39, 20, 2, -38 },
  { 11495, 28, 33, 30, 2, -32 },
  { 11611, 27, 32, 26, 3, -32 },
  { 11719, 39, 32, 40, 4, -32 },
  { 11875, 33, 32, 27, -3, -32 },
  { 12007, 34, 46, 27, -4, -32 },
  { 12203, 27, 32, 23, -2, -32 },
  { 12311, 24, 50, 20, 0, -41 },
  { 12461, 7, 57, 25, 9, -44 },
  { 12511, 23, 50, 20, -3, -41 },
  { 12655, 26, 11, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC58PT7B_H_
