#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC51PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7E,
  0x00, 0x30, 0x00, 0x3F, 0x8F, 0xEF, 0xF3, 0xFD, 0xFC, 0x7F, 0xBF, 0x8F,
  0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0xFE, 0x3F,
  0x9F, 0x87, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F,
  0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0x7C, 0x0F, 0xE7, 0x1C, 0x0F, 0xE7, 0x04,
  0x0F, 0xE6, 0x00, 0x0F, 0xEE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3B, 0xF8, 0x00, 0x3B, 0xF8, 0x80, 0x33, 0xF8, 0x40, 0x73, 0xF8,
  0xF0, 0x77, 0xF8, 0xFE, 0x7F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x7F, 0xC0, 0x07, 0xE0,
  0x0F, 0xFE, 0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0x00,
  0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x3F, 0x3F, 0x03, 0xF0, 0x07, 0xE3,
  0xF0, 0x3F, 0x00, 0x7E, 0x3F, 0x07, 0xE0, 0x07, 0xC3, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF1, 0xF8, 0x00, 0xFC, 0x3E, 0x1F,
  0x80, 0x0F, 0xC7, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x7E, 0x00, 0x0F, 0x87,
  0xC7, 0xE3, 0xF8, 0xF8, 0xFC, 0xFC, 0x7F, 0xCF, 0xDF, 0xCF, 0x8F, 0xFE,
  0xFF, 0xF9, 0xF9, 0xFF, 0xEF, 0xFF, 0x3F, 0x3F, 0xFF, 0x7F, 0xF3, 0xF3,
  0xF3, 0xF3, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x07, 0xC7, 0xE3, 0xF0, 0x00,
  0xFC, 0x7C, 0x3F, 0x00, 0x1F, 0x8F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xFC, 0x7E, 0x00, 0x7E, 0x0F,
  0x87, 0xE0, 0x0F, 0xC0, 0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0x8F, 0xC0, 0x1F,
  0x80, 0xFC, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xF8,
  0x07, 0xE0, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x83, 0xFC,
  0x0F, 0xFF, 0x07, 0xF0, 0x3F, 0xFE, 0x1F, 0xE0, 0xFF, 0xFE, 0x3F, 0x83,
  0xFF, 0xFC, 0xFF, 0x0F, 0xF7, 0xFD, 0xFC, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F,
  0x8F, 0xFF, 0xE0, 0xFF, 0x0F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x07, 0xF8,
  0x1F, 0xFE, 0x0F, 0xF0, 0x3F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE1,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xE1,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3,
  0xF9, 0xF8, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x02, 0x07, 0xE0, 0x1C, 0x3E,
  0x01, 0xF9, 0xF0, 0x0F, 0xEF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFE, 0x04, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xC7, 0xE0, 0x3E,
  0x3F, 0x80, 0xE1, 0xF8, 0x02, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07,
  0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x30, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x7F,
  0x03, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0xBF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFD, 0xFC, 0x3F, 0x3F,
  0x87, 0xCF, 0xF0, 0x61, 0xFE, 0x04, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0xFF,
  0x00, 0xF0, 0x3F, 0xC0, 0x18, 0x0F, 0xF0, 0x04, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xC1, 0xFF,
  0x01, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x88, 0x00, 0x7F, 0xC6, 0x00, 0x7F, 0xC3, 0xE0, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0x9F, 0xE0, 0x07,
  0xE7, 0xF8, 0x03, 0xF1, 0xFC, 0x00, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0xC0,
  0x3F, 0x0F, 0xF0, 0x1F, 0x83, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0C, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x80, 0x0F, 0xF0, 0x80, 0x1F, 0xF0, 0xF0, 0x7F,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xCF, 0x80, 0x3F, 0x9F, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x7F,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xEF, 0xF8, 0xFF, 0x87,
  0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFE, 0x07,
  0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xCF, 0xF8, 0x7F, 0x87,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC,
  0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0xCF,
  0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC3, 0xFE, 0x7F, 0x8F, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFE,
  0xFE, 0x03, 0xF9, 0xFC, 0x00, 0x87, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x20, 0x3F, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xFC, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xE0,
  0xFF, 0x18, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x7F, 0xC3, 0xF0, 0xFC, 0x1F, 0xFF, 0x1F, 0x0F, 0x83,
  0xFF, 0xF1, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0x1F, 0x0F, 0xE3, 0xE1, 0xF3,
  0xF0, 0xFC, 0x3E, 0x1F, 0x3E, 0x1F, 0x87, 0xE1, 0xF3, 0xE1, 0xF0, 0x7C,
  0x1F, 0x3E, 0x3F, 0x07, 0xC1, 0xF7, 0xE3, 0xF0, 0x7C, 0x3E, 0x7C, 0x3E,
  0x0F, 0xC3, 0xE7, 0xC3, 0xE0, 0xFC, 0x3E, 0x7C, 0x7E, 0x0F, 0x87, 0xE7,
  0xC7, 0xE1, 0xF8, 0x7C, 0x7C, 0x7E, 0x1F, 0x87, 0xCF, 0xC7, 0xE3, 0xF8,
  0xF8, 0xFC, 0x7E, 0x7F, 0x9F, 0x8F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7C, 0x3F,
  0xFF, 0xFE, 0x07, 0xC1, 0xFE, 0x7F, 0xC0, 0x7C, 0x0F, 0xC3, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x80, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x1F, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFE, 0x00,
  0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x1F, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x38,
  0x0F, 0xFC, 0x02, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x40, 0x1F, 0xFC, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF3, 0xFF, 0xC0, 0x7F, 0x83, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFE, 0x03, 0xFE, 0x0F, 0xF0,
  0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xFF, 0x03,
  0xFC, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x78, 0x07, 0xFC, 0x00, 0xC0,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC3, 0xFF, 0xC3, 0xFC, 0x1F, 0xFE, 0x1F, 0xE0, 0xFF, 0xF0,
  0xFF, 0x07, 0xFF, 0x8F, 0xF8, 0x7F, 0xFC, 0x7F, 0xC3, 0xFF, 0xC3, 0xFC,
  0x1F, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xF9,
  0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x0F, 0xDF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x87, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC3, 0xF7, 0xF0, 0x0F, 0xEF, 0xE3, 0xFB, 0xF8, 0x07,
  0xF7, 0xF1, 0xFB, 0xFC, 0x03, 0xFB, 0xF9, 0xFD, 0xFE, 0x01, 0xFD, 0xFC,
  0xFC, 0xFE, 0x01, 0xFE, 0x7E, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x7E, 0x3F,
  0x80, 0x7F, 0x1F, 0xBF, 0x3F, 0xC0, 0x3F, 0x8F, 0xFF, 0x1F, 0xE0, 0x1F,
  0xC7, 0xFF, 0x8F, 0xE0, 0x1F, 0xE3, 0xFF, 0xC7, 0xF0, 0x0F, 0xE1, 0xFF,
  0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x7F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0x01, 0xFC, 0x03,
  0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0xFE, 0x0F, 0xF0,
  0x1F, 0xFF, 0x83, 0xF8, 0x07, 0xFF, 0xE0, 0xFE, 0x01, 0xFD, 0xFC, 0x3F,
  0x80, 0x7F, 0x7F, 0x0F, 0xE0, 0x1F, 0xDF, 0xC7, 0xF8, 0x0F, 0xE7, 0xF1,
  0xFC, 0x03, 0xF8, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F,
  0xE7, 0xF0, 0x1F, 0xE3, 0xFB, 0xFC, 0x07, 0xF0, 0xFE, 0xFE, 0x01, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0x07, 0xFF, 0xE0, 0x1F, 0xC1, 0xFF, 0xF8, 0x0F,
  0xF0, 0x7F, 0xFC, 0x03, 0xF8, 0x1F, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xF8, 0x0F, 0xFE,
  0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xF8, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x87, 0xFC,
  0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x07,
  0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF3,
  0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07,
  0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1,
  0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x81, 0xFF,
  0xBF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFE, 0x0F, 0xF1,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x3F,
  0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0,
  0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x3F,
  0xC7, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0x87, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFF,
  0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFC, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFC, 0x7C, 0x07, 0xF8, 0x04, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x04, 0x00,
  0xFF, 0x87, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF8,
  0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xEF,
  0xE0, 0x07, 0xFB, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x7F,
  0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0xFF, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F,
  0x83, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0,
  0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7F,
  0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFF, 0x01, 0xFC, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFF, 0x03,
  0xF8, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0xFF,
  0x07, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xFE,
  0x0F, 0xE0, 0xFF, 0x0F, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F,
  0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x7E, 0x3F, 0x80, 0xFE, 0x7F, 0x7E, 0x7F,
  0x80, 0xFE, 0x7E, 0x7E, 0x7F, 0x00, 0xFE, 0xFE, 0x7E, 0xFF, 0x00, 0xFE,
  0xFE, 0x7E, 0xFE, 0x00, 0xFE, 0xFC, 0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x1F,
  0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC3, 0xF8,
  0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xE0, 0x3F,
  0xCF, 0xF0, 0x1F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFD, 0xF8, 0x01, 0xF9, 0xF8,
  0x03, 0xF9, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E,
  0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F,
  0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x7F, 0xCF, 0xE0, 0x7F, 0xF7, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1,
  0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xF8,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F,
  0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFD, 0xFC, 0x07, 0xFC, 0xFE,
  0x01, 0xFC, 0x7E, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0xBF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x87, 0xFC, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07,
  0xF8, 0x7F, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x87, 0xF8, 0x7F,
  0xC7, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xEF, 0xFE, 0x07, 0xF7, 0xFE, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFE, 0x0C, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x41, 0xFE, 0x1E,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x10, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xE1,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x8F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0x3F, 0xC7, 0xF8, 0x3F, 0x8F,
  0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0C, 0x1F, 0xF9, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFC, 0x40, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x8F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x01, 0xFF, 0x3F,
  0x80, 0x7F, 0xF7, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0,
  0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFD, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x18, 0x01, 0xFE, 0x03, 0xC0, 0x7F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x7F, 0x3F, 0x80, 0x7F,
  0xBF, 0xE0, 0x3F, 0xBF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x87, 0xFE, 0x7F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x03,
  0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0,
  0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x00,
  0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x09, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0x07, 0xF8, 0x3F,
  0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x07,
  0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFE, 0x7F,
  0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0x00,
  0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x07, 0xF0,
  0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x20, 0x01, 0x00, 0x1F, 0x8F, 0xE0, 0x7F, 0x01,
  0xFC, 0xFF, 0x8F, 0xFC, 0x0F, 0xEF, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0x9F, 0xFC, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xF8, 0x7F, 0x83, 0xFC, 0x1F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x8F, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x8F, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0x8F,
  0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x01, 0xF8, 0xFE, 0x00,
  0xFC, 0xFF, 0x80, 0xFE, 0xFF, 0xE0, 0x7E, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x1F, 0xF9, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xFC,
  0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x1F,
  0xE1, 0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF8,
  0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0x80, 0xFF, 0x7F, 0x01,
  0xFF, 0xFE, 0x03, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F,
  0x9F, 0xE0, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0xFE,
  0x7F, 0xC0, 0x0F, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x83,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F, 0xF8, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x18, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x7F, 0xEF,
  0xE0, 0x7F, 0xF7, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFE, 0x3F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFD, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x10, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x1F, 0x8F, 0xC1, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFE, 0x60,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xCF, 0x83,
  0xFC, 0x0C, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x40, 0x1F, 0xE3, 0x81, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xDF,
  0xFF, 0xE1, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE1, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8,
  0x00, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xE0, 0xFF, 0xF7, 0xE0, 0x7F, 0xE7, 0xE0,
  0x3F, 0x8F, 0xC0, 0x04, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFB,
  0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F,
  0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC1, 0xF8,
  0x7F, 0x03, 0xF1, 0xFE, 0x07, 0xE3, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xDF,
  0xC0, 0x3F, 0x7F, 0x80, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0x83, 0xFB,
  0xF8, 0x3F, 0xE0, 0x7F, 0x7F, 0x07, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x83,
  0xF9, 0xFC, 0x3F, 0xF0, 0xFF, 0x3F, 0x87, 0xFE, 0x1F, 0xC7, 0xF1, 0xFF,
  0xC3, 0xF8, 0xFE, 0x3F, 0xF8, 0xFE, 0x1F, 0xC7, 0xFF, 0x1F, 0xC3, 0xF9,
  0xFF, 0xE7, 0xF8, 0x7F, 0x3F, 0xFC, 0xFE, 0x0F, 0xEF, 0xDF, 0x9F, 0xC1,
  0xFD, 0xFB, 0xF7, 0xF0, 0x3F, 0xBE, 0x7E, 0xFE, 0x07, 0xFF, 0xCF, 0xDF,
  0x80, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFE, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFD,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0x3F, 0x80, 0x1F, 0xE1, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x04,
  0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xE0, 0x02, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x40, 0x07,
  0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 16, 37, 14, 0, -36 },
  { 75, 19, 13, 22, 5, -36 },
  { 106, 29, 36, 28, 0, -36 },
  { 237, 24, 42, 25, 1, -39 },
  { 363, 36, 37, 40, 3, -37 },
  { 530, 31, 38, 31, 0, -37 },
  { 678, 9, 13, 12, 5, -36 },
  { 693, 18, 45, 15, 1, -37 },
  { 795, 18, 45, 15, -4, -37 },
  { 897, 21, 23, 24, 4, -39 },
  { 958, 23, 24, 26, 2, -30 },
  { 1027, 12, 14, 13, -3, -7 },
  { 1048, 14, 7, 16, 1, -17 },
  { 1061, 9, 9, 13, 0, -8 },
  { 1072, 28, 37, 21, -3, -37 },
  { 1202, 24, 38, 25, 1, -37 },
  { 1316, 19, 36, 25, 5, -36 },
  { 1402, 26, 37, 25, -2, -37 },
  { 1523, 25, 38, 25, 0, -37 },
  { 1642, 26, 36, 25, -1, -36 },
  { 1759, 24, 37, 25, 1, -36 },
  { 1870, 24, 38, 25, 2, -37 },
  { 1984, 26, 36, 25, 1, -36 },
  { 2101, 24, 38, 25, 1, -37 },
  { 2215, 23, 38, 25, 1, -37 },
  { 2325, 13, 29, 14, 0, -28 },
  { 2373, 16, 35, 14, -3, -28 },
  { 2443, 23, 25, 26, 2, -31 },
  { 2515, 23, 16, 26, 2, -26 },
  { 2561, 23, 25, 26, 2, -31 },
  { 2633, 20, 38, 20, 2, -37 },
  { 2728, 36, 41, 37, 1, -37 },
  { 2913, 28, 37, 28, -3, -37 },
  { 3043, 27, 36, 27, 0, -36 },
  { 3165, 27, 38, 26, 2, -37 },
  { 3294, 29, 36, 29, 0, -36 },
  { 3425, 25, 36, 23, 0, -36 },
  { 3538, 25, 36, 22, 0, -36 },
  { 3651, 29, 38, 30, 2, -37 },
  { 3789, 32, 36, 30, 0, -36 },
  { 3933, 24, 36, 18, -2, -36 },
  { 4041, 24, 47, 15, -8, -36 },
  { 4182, 32, 36, 27, 0, -36 },
  { 4326, 19, 36, 22, 0, -36 },
  { 4412, 41, 36, 39, 0, -36 },
  { 4597, 34, 36, 33, 0, -36 },
  { 4750, 29, 38, 31, 2, -37 },
  { 4888, 27, 36, 26, 0, -36 },
  { 5010, 29, 46, 31, 2, -37 },
  { 5177, 27, 36, 27, 0, -36 },
  { 5299, 25, 38, 23, 0, -37 },
  { 5418, 23, 36, 23, 4, -36 },
  { 5522, 29, 37, 30, 2, -36 },
  { 5657, 26, 36, 27, 5, -36 },
  { 5774, 40, 36, 40, 4, -36 },
  { 5954, 33, 36, 26, -3, -36 },
  { 6103, 25, 36, 25, 5, -36 },
  { 6216, 28, 36, 23, -2, -36 },
  { 6342, 21, 45, 15, -2, -37 },
  { 6461, 12, 37, 21, 5, -37 },
  { 6517, 21, 45, 15, -4, -37 },
  { 6636, 24, 23, 24, 0, -36 },
  { 6705, 20, 5, 19, -5, 4 },
  { 6718, 11, 8, 16, 7, -39 },
  { 6729, 25, 30, 26, 1, -29 },
  { 6823, 25, 40, 26, 0, -39 },
  { 6948, 21, 30, 21, 1, -29 },
  { 7027, 28, 40, 26, 1, -39 },
  { 7167, 23, 29, 24, 1, -28 },
  { 7251, 28, 51, 16, -6, -39 },
  { 7430, 27, 41, 26, -1, -29 },
  { 7569, 25, 39, 26, 0, -39 },
  { 7691, 15, 39, 13, 0, -39 },
  { 7765, 21, 51, 13, -6, -39 },
  { 7899, 28, 39, 25, 0, -39 },
  { 8036, 16, 39, 13, 0, -39 },
  { 8114, 37, 29, 39, 0, -29 },
  { 8249, 25, 29, 26, 0, -29 },
  { 8340, 23, 30, 26, 1, -29 },
  { 8427, 28, 41, 26, -3, -29 },
  { 8571, 25, 41, 26, 1, -29 },
  { 8700, 21, 29, 19, 0, -29 },
  { 8777, 21, 30, 21, 0, -29 },
  { 8856, 17, 35, 18, 2, -34 },
  { 8931, 24, 29, 26, 2, -28 },
  { 9018, 23, 28, 23, 3, -28 },
  { 9099, 35, 28, 35, 3, -28 },
  { 9222, 29, 28, 24, -3, -28 },
  { 9324, 29, 40, 23, -3, -28 },
  { 9469, 24, 28, 20, -2, -28 },
  { 9553, 21, 44, 18, 0, -36 },
  { 9669, 6, 51, 22, 8, -39 },
  { 9708, 20, 44, 18, -3, -36 },
  { 9818, 23, 9, 26, 2, -22 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC51PT7B_H_
