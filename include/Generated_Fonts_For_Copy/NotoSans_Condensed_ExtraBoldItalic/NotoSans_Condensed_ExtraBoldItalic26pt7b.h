#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC26PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF0, 0xF0, 0x79, 0xDE, 0xF7, 0xBD,
  0xCF, 0x73, 0x9C, 0xEF, 0x38, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x19,
  0xC0, 0x73, 0x87, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1D, 0xC0,
  0x73, 0x83, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x1C, 0xC0, 0x33,
  0x80, 0xE7, 0x01, 0xCE, 0x00, 0x00, 0xC0, 0x04, 0x00, 0xF8, 0x1F, 0xF1,
  0xFF, 0x0F, 0xF8, 0xF4, 0x47, 0xA0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0x71, 0x1B, 0x8E, 0xFC, 0x7F, 0xE7, 0xFE, 0x0F, 0xC0,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x0E, 0x03, 0x83, 0xE0, 0xE0, 0xFE, 0x38,
  0x39, 0xC7, 0x07, 0x39, 0xC0, 0xE7, 0x38, 0x39, 0xCE, 0x07, 0x3B, 0x80,
  0xE7, 0x77, 0xCF, 0xDD, 0xFD, 0xF3, 0xBB, 0x9C, 0xEE, 0x70, 0x39, 0xCE,
  0x07, 0x39, 0xC1, 0xC7, 0x70, 0x38, 0xCE, 0x0E, 0x1F, 0xC3, 0x83, 0xF0,
  0xF0, 0x3C, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0E,
  0x78, 0x0E, 0x78, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x8F, 0x3F,
  0xDE, 0x7B, 0xDE, 0x7B, 0xFC, 0xF1, 0xF8, 0xF1, 0xF8, 0xF9, 0xF0, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3F, 0x7C, 0x7B, 0xDE, 0xE7, 0x3B, 0xC0, 0x03, 0xC1,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x80, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x0F, 0x07,
  0x07, 0x83, 0x83, 0xC3, 0xC0, 0x07, 0x01, 0xE1, 0x38, 0x3F, 0x0F, 0xFF,
  0xFF, 0xC7, 0xF9, 0xF8, 0x7F, 0x1E, 0xF0, 0xCE, 0x01, 0x00, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x3D, 0xE7, 0x9C, 0xF3, 0x8E, 0x00, 0x7F, 0x7E,
  0x7E, 0xFE, 0x77, 0xFD, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0xFE, 0x1F, 0xE3, 0xFE, 0x3C, 0xE7, 0x8F,
  0x78, 0xF7, 0x8E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x78, 0xFF, 0x8F, 0xF0, 0x7E, 0x00, 0x01, 0xC1, 0xF0, 0xFC,
  0x7E, 0x3F, 0xBF, 0xE7, 0x78, 0x9E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3F, 0x83,
  0xFE, 0x3F, 0xF0, 0xC7, 0x84, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7F, 0xE7,
  0xFF, 0x3F, 0xF8, 0x03, 0xC0, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0x8F, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x0F, 0xC0, 0x7C, 0x07, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x98, 0x7C, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0, 0x00, 0x78,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x1B, 0x81, 0xFC, 0x1D,
  0xE1, 0xCF, 0x0E, 0x78, 0xE3, 0x8F, 0xFF, 0x7F, 0xFB, 0xFF, 0xC0, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x04, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x98, 0x7C, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0,
  0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0xFC,
  0x7F, 0xCF, 0xFE, 0xF9, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0x7C,
  0xFF, 0x87, 0xF8, 0x3E, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0xFF, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x00,
  0x03, 0xC0, 0x7F, 0x87, 0xFE, 0x3D, 0xF1, 0xC7, 0x8E, 0x3C, 0x7B, 0xC3,
  0xFE, 0x0F, 0xC0, 0x7C, 0x0F, 0xF0, 0xFB, 0xC7, 0x9E, 0x78, 0x73, 0xC7,
  0x9E, 0x3C, 0x7F, 0xE3, 0xFE, 0x0F, 0xE0, 0x03, 0xC0, 0xFE, 0x1F, 0xF1,
  0xFF, 0x3C, 0xF3, 0xC7, 0x3C, 0xF7, 0x8F, 0x7C, 0xF3, 0xFF, 0x3F, 0xF3,
  0xEE, 0x0D, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0xFF, 0x8F, 0xF0, 0xFE, 0x00,
  0x1E, 0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xCF, 0x1E,
  0x00, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE0, 0x00, 0x10, 0x07, 0x01, 0xF0,
  0x7F, 0x1F, 0x87, 0xE0, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E,
  0x01, 0xF0, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0x00, 0xC0, 0x00, 0x0F,
  0x0F, 0xE7, 0xFC, 0xFF, 0x23, 0xC0, 0xF0, 0x3C, 0x1E, 0x1F, 0x07, 0x83,
  0xC0, 0xE0, 0x78, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x38, 0x0E, 0x1C, 0x01, 0xCE, 0x3E,
  0x77, 0x1F, 0xDD, 0xCE, 0x67, 0x67, 0x39, 0xF9, 0xCE, 0x7E, 0x63, 0x9B,
  0xB8, 0xC6, 0xCE, 0x73, 0xB3, 0x9D, 0xCC, 0xFF, 0xE3, 0x9E, 0xF0, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x83, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xF7,
  0x01, 0xCE, 0x07, 0x9C, 0x0F, 0x38, 0x3C, 0x70, 0x7F, 0xE1, 0xFF, 0xC3,
  0xFF, 0x8F, 0xFF, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x7F, 0xE0, 0xF8, 0x0F,
  0x80, 0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x1E, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0x3C, 0x78, 0x79, 0xE3, 0xE7,
  0x8F, 0x1E, 0x7C, 0x7F, 0xE3, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xE0, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3E, 0x10, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x30, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE1, 0xE3, 0xC3, 0xC7, 0xC7, 0x8F, 0x8F, 0x1F, 0x3C, 0x3E,
  0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x3E, 0x3F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC,
  0x3F, 0xE1, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF0, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x08, 0x7F, 0x87, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xE0, 0x87, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x79, 0xFD, 0xF3, 0xF3, 0xC7, 0xE7, 0x8F, 0xCF, 0x07, 0x9E, 0x1E, 0x3E,
  0x3C, 0x7E, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3C, 0x3C, 0x7C, 0x3C, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F,
  0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0x70, 0x00, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x3E,
  0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x79, 0xE0,
  0x79, 0xF0, 0x79, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x7F, 0xFF, 0xEF, 0xF8, 0x0F, 0x81, 0xF8, 0x7C,
  0x0F, 0xC3, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8,
  0x7E, 0x3F, 0x83, 0xF1, 0xDC, 0x3F, 0x8F, 0xE1, 0xFC, 0xEF, 0x0F, 0xF7,
  0x78, 0x77, 0xF3, 0x87, 0xBF, 0xBC, 0x3D, 0xFD, 0xE1, 0xEF, 0xCF, 0x0F,
  0x3E, 0x78, 0x71, 0xE3, 0x87, 0x8F, 0x3C, 0x3C, 0x71, 0xE0, 0x0F, 0x03,
  0x87, 0xC3, 0xC3, 0xE1, 0xE3, 0xF0, 0xF1, 0xF8, 0x70, 0xFE, 0x38, 0x7F,
  0x3C, 0x3F, 0x9E, 0x3D, 0xCF, 0x1E, 0xE7, 0x0F, 0x7B, 0x87, 0x3F, 0xC7,
  0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF0, 0xF1, 0xF8, 0x70, 0xFC, 0x78, 0x3E,
  0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE3,
  0xC7, 0x87, 0xDF, 0x0F, 0xBC, 0x1F, 0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0xF7,
  0x81, 0xEF, 0x07, 0xDE, 0x0F, 0x3C, 0x3E, 0x7C, 0xF8, 0x7F, 0xE0, 0xFF,
  0x80, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x3C, 0x78, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8,
  0x7F, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE3, 0xC7, 0x87,
  0xDF, 0x0F, 0xBC, 0x1F, 0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF,
  0x07, 0xDE, 0x0F, 0x3C, 0x3E, 0x7C, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0x7E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F,
  0xC0, 0xFF, 0x87, 0xFE, 0x1E, 0x7C, 0x78, 0xF1, 0xE7, 0xC7, 0x1E, 0x3C,
  0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x79, 0xC1, 0xE7, 0x87, 0x9E, 0x1E,
  0x78, 0x79, 0xF3, 0xC3, 0xCF, 0x0F, 0x00, 0x03, 0xE0, 0x7F, 0xC7, 0xFC,
  0x3F, 0xE3, 0xE1, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF2, 0x0F, 0x1E, 0xF8, 0xFF, 0xC7, 0xFC,
  0x3F, 0x80, 0x7F, 0xF7, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8,
  0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x7D,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x3F, 0xC1, 0xEF, 0x07,
  0xBC, 0x3E, 0xF0, 0xF3, 0xC3, 0xC7, 0x1E, 0x1C, 0x78, 0x73, 0xC1, 0xCF,
  0x07, 0x78, 0x1D, 0xE0, 0x77, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x70, 0x7F, 0x87, 0x87, 0xBC, 0x3C,
  0x3D, 0xE3, 0xE3, 0xCF, 0x1F, 0x1E, 0x78, 0xF8, 0xF3, 0xCF, 0xCF, 0x1E,
  0x7E, 0x78, 0xF7, 0xF7, 0x87, 0xBB, 0xBC, 0x3D, 0xDD, 0xE1, 0xFC, 0xFE,
  0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x00, 0x07, 0x87, 0x83, 0xC7, 0xC1,
  0xE3, 0xC0, 0xF3, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7B,
  0x80, 0x7D, 0xE0, 0x3C, 0xF0, 0x3C, 0x78, 0x3E, 0x3C, 0x3E, 0x1F, 0x00,
  0xF0, 0x7F, 0xC7, 0xDE, 0x3C, 0xF3, 0xC7, 0x9E, 0x3D, 0xE1, 0xEF, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC7, 0xFF, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0xE1, 0xF8, 0x3F,
  0x00, 0xE3, 0x8E, 0x38, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1E, 0x79, 0xE3,
  0x8E, 0x38, 0xE3, 0xC0, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x07, 0xE1, 0xF8, 0x3F, 0x00,
  0x01, 0x80, 0x1C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFE, 0x1E, 0xE1, 0xCE,
  0x3C, 0xE3, 0x8F, 0x70, 0x7F, 0x07, 0xFF, 0xFF, 0xE0, 0xF7, 0x9E, 0x70,
  0x04, 0x01, 0xF7, 0x3F, 0xF7, 0xFF, 0x79, 0xF7, 0x9E, 0xF1, 0xEF, 0x1E,
  0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0x3C, 0xFF, 0xCF, 0xFC, 0x7B, 0x80, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x20, 0x7F, 0xC3, 0xFE,
  0x3F, 0xF9, 0xE3, 0xCF, 0x1E, 0x70, 0xF3, 0x8F, 0x3C, 0x79, 0xE3, 0xCF,
  0x1E, 0x79, 0xE7, 0xFF, 0x3F, 0xF1, 0xCF, 0x00, 0x03, 0x07, 0xF3, 0xFC,
  0xFE, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC4, 0xFF,
  0x3F, 0xC7, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x11, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF1, 0xE7, 0xC7, 0x9E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0xFF, 0x0F, 0xFC,
  0x1E, 0xE0, 0x03, 0x01, 0xF8, 0xFF, 0x9E, 0xF7, 0x8E, 0xE3, 0xFF, 0xF7,
  0xFE, 0xFF, 0x1E, 0x03, 0x80, 0x78, 0x4F, 0xF8, 0xFF, 0x0F, 0xC0, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7A, 0x01, 0xE0, 0x0F, 0x20, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x02, 0x00, 0x7D,
  0xC7, 0xFE, 0x7F, 0xF3, 0xCF, 0x9E, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF3,
  0xC7, 0x9E, 0x78, 0xF7, 0xC7, 0xFE, 0x3F, 0xF0, 0xF7, 0x00, 0x78, 0x03,
  0xC4, 0x3E, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x20, 0x7F, 0xC3, 0xFE, 0x3F, 0xF9, 0xF3,
  0xCF, 0x1E, 0x79, 0xE3, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1C, 0x79, 0xE7,
  0x8F, 0x3C, 0x79, 0xE3, 0xC0, 0x06, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x1E,
  0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0,
  0xF0, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x07, 0xE0, 0xF8, 0x1E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE7, 0xC7, 0x1E, 0x3C, 0xF0, 0xF7, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0x73, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0x00, 0x40, 0x83, 0xBE,
  0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xEF, 0x9E, 0x79, 0xF3, 0xCF, 0x3C,
  0x79, 0xC7, 0x8F, 0x78, 0xF3, 0xCF, 0x1E, 0x79, 0xE7, 0x8F, 0x3C, 0xF1,
  0xEF, 0x1E, 0x39, 0xE3, 0xCF, 0x3C, 0x71, 0xE0, 0x00, 0x40, 0xEF, 0x87,
  0xFC, 0x7F, 0xF3, 0xE7, 0x9E, 0x38, 0xF3, 0xC7, 0x1E, 0x78, 0xF3, 0xC7,
  0x9E, 0x38, 0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x80, 0x02, 0x03, 0xF8,
  0xFF, 0xBF, 0xF7, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xCF,
  0x79, 0xEF, 0xF8, 0xFF, 0x0F, 0x80, 0x00, 0x20, 0x3B, 0xE0, 0xFF, 0x87,
  0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x3C, 0x7F, 0xF1, 0xFF, 0x87, 0xBC, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x04, 0x01, 0xF7, 0x3F, 0xF7,
  0xFF, 0x79, 0xF7, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF,
  0x3C, 0xFF, 0xCF, 0xFC, 0x7B, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0x00, 0x63, 0xB8, 0x7F, 0x1F, 0xE3, 0xFC, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x00,
  0x02, 0x03, 0xFC, 0xFF, 0x1F, 0xE3, 0xC4, 0x78, 0x0F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x1E, 0x43, 0xCF, 0xF9, 0xFE, 0x3F, 0x80, 0x0E, 0x0E, 0x07,
  0x0F, 0xFF, 0xF7, 0xF9, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0xF1, 0xF8, 0x7C, 0x00, 0x3C, 0xF3, 0x8F, 0x78, 0xF7, 0x8F, 0x78,
  0xE7, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0xFC, 0xFF,
  0xC7, 0xB8, 0xF0, 0xF7, 0x1E, 0x71, 0xE7, 0x1C, 0x73, 0xC7, 0x3C, 0x77,
  0x87, 0x78, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xE3,
  0xE7, 0xF1, 0xE3, 0xF9, 0xF3, 0xDC, 0xF9, 0xEE, 0xFC, 0xE7, 0x7E, 0xF3,
  0xBF, 0x79, 0xFB, 0xB8, 0xFD, 0xFC, 0x7C, 0xFC, 0x3E, 0x7E, 0x1F, 0x3E,
  0x0F, 0x1F, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x79, 0xE0, 0xEF, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xDE,
  0x1E, 0x78, 0x79, 0xE3, 0xC7, 0xC0, 0x0E, 0x1E, 0x1C, 0x7C, 0x38, 0xF0,
  0x71, 0xE0, 0xE7, 0x81, 0xEF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x1F,
  0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x07, 0xFC, 0xFF, 0xCF, 0xF8, 0x00, 0x20, 0x7C, 0x1F, 0x03, 0xE0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC1, 0xF0, 0x7C, 0x0F, 0x80, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0xE0, 0x7C, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08,
  0x03, 0xC1, 0xF0, 0x7E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xFC, 0x0F, 0x0F, 0x87, 0xE1, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC1, 0xE0,
  0xF8, 0x3E, 0x0E, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 10, 7, 11, 2, -19 },
  { 29, 15, 19, 14, 0, -19 },
  { 65, 13, 22, 13, 0, -20 },
  { 101, 19, 19, 20, 1, -19 },
  { 147, 16, 19, 16, 0, -19 },
  { 185, 5, 7, 6, 2, -19 },
  { 190, 10, 23, 8, 0, -19 },
  { 219, 9, 23, 8, -2, -19 },
  { 245, 11, 12, 12, 2, -20 },
  { 262, 12, 12, 13, 1, -15 },
  { 280, 6, 7, 7, -1, -3 },
  { 286, 8, 4, 8, 0, -9 },
  { 290, 5, 4, 7, 0, -4 },
  { 293, 14, 19, 10, -1, -19 },
  { 327, 12, 19, 13, 1, -19 },
  { 356, 10, 19, 13, 2, -19 },
  { 380, 13, 19, 13, -1, -19 },
  { 411, 13, 19, 13, 0, -19 },
  { 442, 13, 19, 13, 0, -19 },
  { 473, 13, 19, 13, 0, -19 },
  { 504, 12, 19, 13, 1, -19 },
  { 533, 13, 19, 13, 1, -19 },
  { 564, 13, 19, 13, 0, -19 },
  { 595, 12, 19, 13, 0, -19 },
  { 624, 7, 14, 7, 0, -14 },
  { 637, 8, 18, 7, -1, -14 },
  { 655, 12, 13, 13, 1, -16 },
  { 675, 12, 8, 13, 1, -13 },
  { 687, 12, 13, 13, 1, -16 },
  { 707, 10, 19, 10, 1, -19 },
  { 731, 18, 21, 19, 1, -19 },
  { 779, 15, 19, 14, -2, -19 },
  { 815, 14, 19, 14, 0, -19 },
  { 849, 14, 19, 13, 1, -19 },
  { 883, 15, 19, 15, 0, -19 },
  { 919, 13, 19, 12, 0, -19 },
  { 950, 13, 19, 11, 0, -19 },
  { 981, 15, 19, 15, 1, -19 },
  { 1017, 16, 19, 15, 0, -19 },
  { 1055, 12, 19, 9, -1, -19 },
  { 1084, 12, 25, 7, -4, -19 },
  { 1122, 16, 19, 14, 0, -19 },
  { 1160, 10, 19, 11, 0, -19 },
  { 1184, 21, 19, 20, 0, -19 },
  { 1234, 17, 19, 17, 0, -19 },
  { 1275, 15, 19, 16, 1, -19 },
  { 1311, 14, 19, 13, 0, -19 },
  { 1345, 15, 23, 16, 1, -19 },
  { 1389, 14, 19, 14, 0, -19 },
  { 1423, 13, 19, 12, 0, -19 },
  { 1454, 12, 19, 12, 2, -19 },
  { 1483, 15, 19, 15, 1, -19 },
  { 1519, 14, 19, 14, 2, -19 },
  { 1553, 21, 19, 20, 2, -19 },
  { 1603, 17, 19, 13, -2, -19 },
  { 1644, 13, 19, 13, 2, -19 },
  { 1675, 14, 19, 12, -1, -19 },
  { 1709, 11, 23, 8, -1, -19 },
  { 1741, 6, 19, 10, 3, -19 },
  { 1756, 11, 23, 8, -2, -19 },
  { 1788, 12, 12, 12, 0, -19 },
  { 1806, 10, 2, 10, -2, 2 },
  { 1809, 5, 4, 8, 4, -20 },
  { 1812, 12, 15, 13, 1, -15 },
  { 1835, 13, 20, 13, 0, -20 },
  { 1868, 10, 15, 11, 1, -15 },
  { 1887, 14, 20, 13, 1, -20 },
  { 1922, 11, 15, 12, 1, -15 },
  { 1943, 14, 26, 8, -3, -20 },
  { 1989, 13, 21, 13, 0, -15 },
  { 2024, 13, 20, 13, 0, -20 },
  { 2057, 8, 20, 7, 0, -20 },
  { 2077, 11, 26, 7, -3, -20 },
  { 2113, 14, 20, 13, 0, -20 },
  { 2148, 8, 20, 7, 0, -20 },
  { 2168, 19, 15, 20, 0, -15 },
  { 2204, 13, 15, 13, 0, -15 },
  { 2229, 11, 15, 13, 1, -15 },
  { 2250, 14, 21, 13, -1, -15 },
  { 2287, 12, 21, 13, 1, -15 },
  { 2319, 11, 15, 9, 0, -15 },
  { 2340, 11, 15, 11, 0, -15 },
  { 2361, 9, 17, 9, 1, -17 },
  { 2381, 12, 14, 13, 1, -14 },
  { 2402, 12, 14, 12, 1, -14 },
  { 2423, 17, 14, 18, 2, -14 },
  { 2453, 14, 14, 12, -1, -14 },
  { 2478, 15, 20, 12, -2, -14 },
  { 2516, 12, 14, 10, -1, -14 },
  { 2537, 11, 23, 9, 0, -19 },
  { 2569, 3, 26, 11, 4, -20 },
  { 2579, 10, 23, 9, -1, -19 },
  { 2608, 12, 4, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC26PT7B_H_
