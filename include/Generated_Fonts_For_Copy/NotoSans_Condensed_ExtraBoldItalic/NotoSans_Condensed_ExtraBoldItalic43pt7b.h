#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC43PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x01, 0xF0, 0x02, 0x00, 0x3F, 0x3F, 0xBF, 0x9F, 0x9F, 0x8F, 0xCF,
  0xC7, 0xE7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x01, 0xE1, 0xE0, 0x03,
  0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0xC0, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x0F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E,
  0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFD, 0x8C, 0x1F, 0x98, 0x41, 0xFB, 0x80, 0x1F, 0xB8, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xCF, 0xC8,
  0x0C, 0xFC, 0xC0, 0xCF, 0xCF, 0x9D, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x0F, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0xE0, 0x7C, 0x03,
  0xF7, 0xC0, 0xF8, 0x07, 0xCF, 0x83, 0xE0, 0x1F, 0x1F, 0x07, 0xC0, 0x3E,
  0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0xF8, 0x03, 0xE1,
  0xE3, 0xE0, 0x07, 0xC7, 0xC7, 0x80, 0x0F, 0x8F, 0x9F, 0x1F, 0x1F, 0x1F,
  0x7C, 0x7F, 0x3F, 0x7C, 0xF9, 0xFF, 0x3F, 0xF3, 0xE7, 0xFE, 0x7F, 0xEF,
  0x9F, 0xFE, 0x7F, 0x9F, 0x3E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0x00, 0xF9,
  0xF1, 0xF0, 0x03, 0xE3, 0xE3, 0xE0, 0x0F, 0x8F, 0x87, 0xC0, 0x1F, 0x1F,
  0x1F, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x7C, 0x03, 0xE0, 0xF9,
  0xF0, 0x0F, 0x81, 0xF3, 0xE0, 0x1F, 0x03, 0xFF, 0x80, 0x7C, 0x03, 0xFF,
  0x00, 0xF8, 0x07, 0xFC, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFC, 0x1F, 0xF8,
  0x7E, 0x0F, 0xFF, 0x1F, 0x87, 0xFF, 0xCF, 0xE3, 0xFB, 0xFB, 0xF1, 0xFC,
  0xFF, 0xFC, 0x7E, 0x1F, 0xFE, 0x1F, 0x87, 0xFF, 0x0F, 0xE1, 0xFF, 0xC3,
  0xF8, 0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0x80, 0xFF,
  0x0F, 0xE0, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFC,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x00, 0xF4, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x30, 0xF8,
  0x1F, 0x3C, 0x07, 0xEF, 0x1D, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0,
  0x3F, 0xFC, 0x1F, 0xC1, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0xF7, 0xC0, 0xF9,
  0xF8, 0x1E, 0x3F, 0x03, 0x0F, 0x80, 0x43, 0x80, 0x00, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F,
  0x0F, 0xC3, 0xE0, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xE0, 0x3E,
  0x7E, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1,
  0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF0, 0x7F, 0x3F, 0x07, 0xF7, 0xF0, 0x7E,
  0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0xFC, 0xFE, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF8, 0xFE, 0x3F, 0x0F, 0xE7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xFC, 0xFE, 0xFC, 0x7D, 0xFC, 0x39, 0xFC, 0x21, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3C, 0x1F, 0xC0, 0x60, 0x7F, 0x01, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0C, 0x0F, 0xE0, 0x40, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x80, 0x3F, 0xC7, 0x83, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x7D, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x03, 0xE7, 0xE0, 0x3E, 0x3F,
  0x01, 0xF1, 0xF8, 0x1F, 0x1F, 0xC1, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0xF8,
  0x3F, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0xC0, 0x3F,
  0xC7, 0x87, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0x18, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x7E,
  0x03, 0xF7, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0x9F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC,
  0x7F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x3F, 0x83, 0xFB,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF9, 0xFC, 0x1F, 0x87, 0xE1,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xF7, 0xF0, 0x7E, 0x1F, 0x87, 0xF0, 0xFE,
  0x3F, 0x07, 0xF1, 0xF8, 0x1F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xC3, 0xF0,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFE, 0xFE, 0x1F, 0xC7, 0xE3, 0xF8, 0x7F, 0x3F,
  0x87, 0xF3, 0xF0, 0x7F, 0x3F, 0x07, 0xF3, 0xF0, 0x7F, 0x7F, 0x0F, 0xE7,
  0xF0, 0xFE, 0x7F, 0x9F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xEF, 0xC0, 0xFC, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x08, 0x3F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x7F,
  0x8F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0, 0x30, 0x00, 0x00, 0xF0, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xF3, 0xFC,
  0x40, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFE, 0x03, 0xF0,
  0x0F, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x0F,
  0x81, 0xFC, 0x3C, 0x3C, 0x1F, 0xF8, 0xF1, 0xF0, 0xFF, 0xE3, 0xC7, 0x87,
  0xFF, 0x8F, 0x3E, 0x3E, 0x3E, 0x3C, 0xF1, 0xF0, 0xF0, 0xF7, 0xC7, 0xC3,
  0xC3, 0xDF, 0x1E, 0x1F, 0x0F, 0x78, 0xF8, 0x7C, 0x7D, 0xE3, 0xE1, 0xE1,
  0xE7, 0x8F, 0x07, 0x87, 0xBE, 0x3C, 0x3E, 0x3E, 0xF8, 0xF0, 0xF8, 0xF3,
  0xE3, 0xC7, 0xE7, 0xCF, 0x8F, 0xFF, 0xFE, 0x3E, 0x3F, 0xFF, 0xF0, 0xF8,
  0x7F, 0x7F, 0x83, 0xE0, 0xF8, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x01, 0xFE, 0x7F,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00,
  0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7E, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xFC, 0x3F,
  0x07, 0xF0, 0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0x03, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x01, 0x03, 0xFE, 0x7C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF1, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF8, 0x3F, 0x0F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0x1C,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xFC, 0xFE, 0x1F, 0xFC,
  0xFE, 0x1F, 0xFC, 0xFE, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x11, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x9F, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x07, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC,
  0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xBF, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0xFF,
  0xF1, 0xF7, 0xE0, 0x7E, 0xFC, 0xFD, 0xF8, 0x1F, 0x9F, 0x3E, 0x7E, 0x07,
  0xE7, 0xDF, 0xBF, 0x81, 0xF9, 0xF7, 0xCF, 0xC0, 0x7E, 0x7D, 0xF3, 0xF0,
  0x3F, 0x1F, 0xF8, 0xFC, 0x0F, 0xC7, 0xFE, 0x3F, 0x03, 0xF1, 0xFF, 0x9F,
  0xC0, 0xFC, 0x7F, 0xC7, 0xE0, 0x3F, 0x1F, 0xF1, 0xF8, 0x1F, 0x87, 0xF8,
  0x7E, 0x07, 0xE1, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F,
  0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0xFF, 0x80, 0xFC, 0x07, 0xFC,
  0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0x01, 0xFF, 0x03, 0xF8, 0x1F, 0xF8, 0x1F,
  0x80, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0x3F, 0x03,
  0xFF, 0xC3, 0xF0, 0x1F, 0xBF, 0x1F, 0x80, 0xFD, 0xF8, 0xFC, 0x07, 0xEF,
  0xC7, 0xE0, 0x3F, 0x7E, 0x3F, 0x03, 0xF3, 0xF3, 0xF0, 0x1F, 0x8F, 0xDF,
  0x80, 0xFC, 0x7E, 0xFC, 0x07, 0xE3, 0xF7, 0xE0, 0x3F, 0x1F, 0xBF, 0x03,
  0xF0, 0xFF, 0xF0, 0x1F, 0x83, 0xFF, 0x80, 0xFC, 0x1F, 0xFC, 0x07, 0xE0,
  0xFF, 0xE0, 0x3F, 0x07, 0xFF, 0x03, 0xF0, 0x1F, 0xF0, 0x1F, 0x80, 0xFF,
  0x80, 0xFC, 0x07, 0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0x7F, 0x01, 0xFE, 0x03,
  0xF0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0,
  0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF1, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03,
  0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0xBF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFC, 0x7F, 0x83, 0xF8, 0x7F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xF9,
  0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xC1, 0x81, 0xFC, 0x04, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x10, 0x07, 0xF0, 0xE0, 0x3F,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF0, 0x1F,
  0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x7F, 0x0F,
  0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC7,
  0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x7F, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x01, 0xF9, 0xF8,
  0x1F, 0xC0, 0x7E, 0x7E, 0x07, 0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0x0F, 0xC7,
  0xE0, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0xC1, 0xF8, 0x7E, 0x1F, 0xF0, 0x7E,
  0x1F, 0x87, 0xFC, 0x3F, 0x87, 0xE1, 0xFF, 0x0F, 0xC1, 0xF8, 0xFF, 0xC7,
  0xF0, 0x7E, 0x3F, 0xF1, 0xF8, 0x1F, 0x9F, 0xFC, 0x7E, 0x07, 0xE7, 0xDF,
  0x3F, 0x81, 0xF9, 0xF7, 0xCF, 0xC0, 0x7E, 0xFD, 0xF7, 0xF0, 0x1F, 0xBE,
  0x7D, 0xF8, 0x07, 0xDF, 0x9F, 0x7E, 0x01, 0xF7, 0xC7, 0xFF, 0x80, 0x7D,
  0xF1, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xF8, 0x03,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE,
  0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x7F, 0x3F, 0x03, 0xFB,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x1F, 0x07, 0xC1,
  0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xE0, 0xF8, 0x3E,
  0x1F, 0x83, 0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xF7, 0xE0, 0x1F, 0x7C, 0x01,
  0xFF, 0xC0, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0,
  0xFE, 0x3F, 0x9F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x01, 0xF0, 0xF8, 0x1F,
  0xCF, 0xC1, 0xFF, 0x7E, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1,
  0xF8, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0x8F, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xC1, 0xFF, 0x7C, 0x07, 0xE3, 0xE0, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x3E, 0x01, 0xFB, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xDF, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0,
  0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFF, 0x3F,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xBF, 0xE0, 0xF8,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F,
  0xFF, 0x07, 0xF9, 0xC3, 0xFC, 0x10, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x81, 0x0F, 0xF1, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xE3,
  0xF0, 0x0F, 0xE7, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFB, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xEF, 0x80, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x8F, 0xCF, 0xE1, 0xF9,
  0xF8, 0x3F, 0x7F, 0x0F, 0xEF, 0xC3, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x08, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xEC, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x8F, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x3E, 0x01, 0xFE, 0xFC, 0x07, 0xFD, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE,
  0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x04, 0x01, 0xFC, 0x0E, 0x07, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x3E, 0x01, 0xFB, 0xFC, 0x1F, 0xBF, 0xE0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F,
  0xC3, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F,
  0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0xC0, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x27,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0,
  0xFE, 0x3F, 0x81, 0xF8, 0xFE, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0xDF, 0xC0, 0x3F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xBF,
  0x00, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xFC,
  0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0xF8, 0x07, 0xCF,
  0xF3, 0xFC, 0x0F, 0xDF, 0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3,
  0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x7F, 0x83,
  0xF7, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x8F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x7F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x9F, 0xCF,
  0xE1, 0xF9, 0xFC, 0x3F, 0x7F, 0x07, 0xEF, 0xE0, 0xFD, 0xF8, 0x1F, 0xBF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7E, 0xFE,
  0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xF0,
  0x0F, 0xDF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0x9F, 0xC0,
  0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0,
  0x7F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x9F,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xDF, 0xF0,
  0x1F, 0x9F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x1F,
  0xEF, 0xC1, 0xFF, 0x7E, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE7, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F,
  0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC7, 0xC1, 0xF3, 0xE0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xF1, 0xC1, 0xF8, 0x10,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x20, 0x3F,
  0x8E, 0x0F, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0xF3, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x8F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x08, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7,
  0xF0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0x8F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0x7C, 0x07, 0xF3, 0xE0, 0xFE, 0x07, 0xF7, 0xE0,
  0x7E, 0x7E, 0x0F, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0x7E,
  0x1F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E, 0x07,
  0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x1F, 0xC1, 0xFF,
  0xE1, 0xFE, 0x1F, 0xFF, 0x0F, 0xF0, 0xFD, 0xF8, 0xFF, 0x8F, 0xEF, 0xC7,
  0xFC, 0x7E, 0x7E, 0x3F, 0xE3, 0xF3, 0xF3, 0xFE, 0x3F, 0x1F, 0x9F, 0xF1,
  0xF8, 0xFC, 0xF7, 0x8F, 0xC7, 0xCF, 0xBC, 0xFC, 0x3E, 0x7F, 0xE7, 0xE1,
  0xF7, 0xDF, 0x7E, 0x0F, 0xBE, 0xFB, 0xF0, 0x7D, 0xF7, 0xDF, 0x03, 0xFF,
  0x3F, 0xF8, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x7F,
  0xE0, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80,
  0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF1, 0xFC, 0x03,
  0xF9, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0x1F, 0xCF, 0xC0, 0x3F,
  0x8F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF8,
  0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x08, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x2F,
  0xF8, 0x0F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0,
  0x1F, 0xF4, 0x00, 0x30,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 32, 11, 0, -31 },
  { 53, 17, 11, 18, 4, -31 },
  { 77, 24, 31, 23, 0, -31 },
  { 170, 20, 36, 21, 1, -33 },
  { 260, 31, 31, 34, 2, -31 },
  { 381, 26, 31, 26, 0, -31 },
  { 482, 8, 11, 10, 4, -31 },
  { 493, 15, 38, 13, 1, -31 },
  { 565, 15, 38, 13, -3, -31 },
  { 637, 18, 20, 20, 3, -33 },
  { 682, 19, 21, 22, 2, -26 },
  { 732, 10, 12, 11, -2, -6 },
  { 747, 12, 5, 13, 0, -14 },
  { 755, 8, 8, 11, 0, -7 },
  { 763, 23, 31, 17, -2, -31 },
  { 853, 20, 31, 21, 1, -31 },
  { 931, 16, 31, 21, 4, -31 },
  { 993, 22, 31, 21, -1, -31 },
  { 1079, 21, 31, 21, 0, -31 },
  { 1161, 21, 31, 21, 0, -31 },
  { 1243, 21, 31, 21, 0, -31 },
  { 1325, 21, 31, 21, 1, -31 },
  { 1407, 22, 31, 21, 1, -31 },
  { 1493, 21, 31, 21, 0, -31 },
  { 1575, 20, 31, 21, 1, -31 },
  { 1653, 11, 25, 11, 0, -24 },
  { 1688, 13, 30, 11, -2, -24 },
  { 1737, 19, 21, 22, 2, -26 },
  { 1787, 19, 14, 22, 2, -22 },
  { 1821, 19, 21, 22, 2, -26 },
  { 1871, 17, 31, 17, 2, -31 },
  { 1937, 30, 35, 32, 1, -31 },
  { 2069, 24, 31, 23, -3, -31 },
  { 2162, 23, 31, 23, 0, -31 },
  { 2252, 22, 31, 22, 2, -31 },
  { 2338, 24, 31, 25, 0, -31 },
  { 2431, 21, 31, 19, 0, -31 },
  { 2513, 21, 31, 19, 0, -31 },
  { 2595, 24, 31, 25, 2, -31 },
  { 2688, 27, 31, 26, 0, -31 },
  { 2793, 20, 31, 16, -2, -31 },
  { 2871, 21, 40, 12, -7, -31 },
  { 2976, 27, 31, 23, 0, -31 },
  { 3081, 16, 31, 19, 0, -31 },
  { 3143, 34, 31, 33, 0, -31 },
  { 3275, 29, 31, 27, 0, -31 },
  { 3388, 24, 31, 26, 2, -31 },
  { 3481, 23, 31, 22, 0, -31 },
  { 3571, 24, 38, 26, 2, -31 },
  { 3685, 23, 31, 23, 0, -31 },
  { 3775, 21, 31, 20, 0, -31 },
  { 3857, 20, 31, 19, 3, -31 },
  { 3935, 24, 31, 25, 2, -31 },
  { 4028, 22, 31, 22, 4, -31 },
  { 4114, 34, 31, 33, 3, -31 },
  { 4246, 28, 31, 22, -3, -31 },
  { 4355, 21, 31, 21, 4, -31 },
  { 4437, 24, 31, 19, -2, -31 },
  { 4530, 18, 38, 13, -2, -31 },
  { 4616, 10, 31, 17, 4, -31 },
  { 4655, 18, 38, 13, -3, -31 },
  { 4741, 20, 20, 21, 0, -31 },
  { 4791, 17, 4, 16, -4, 3 },
  { 4800, 9, 7, 14, 6, -33 },
  { 4808, 21, 24, 22, 1, -24 },
  { 4871, 21, 33, 22, 0, -33 },
  { 4958, 18, 24, 18, 1, -24 },
  { 5012, 23, 33, 22, 1, -33 },
  { 5107, 19, 24, 21, 1, -24 },
  { 5164, 24, 43, 14, -5, -33 },
  { 5293, 23, 34, 22, -1, -24 },
  { 5391, 21, 33, 22, 0, -33 },
  { 5478, 13, 33, 11, 0, -33 },
  { 5532, 18, 43, 11, -5, -33 },
  { 5629, 23, 33, 21, 0, -33 },
  { 5724, 13, 33, 11, 0, -33 },
  { 5778, 32, 24, 33, 0, -24 },
  { 5874, 21, 24, 22, 0, -24 },
  { 5937, 19, 24, 22, 1, -24 },
  { 5994, 23, 34, 22, -2, -24 },
  { 6092, 21, 34, 22, 1, -24 },
  { 6182, 18, 24, 16, 0, -24 },
  { 6236, 18, 24, 18, 0, -24 },
  { 6290, 14, 29, 15, 2, -29 },
  { 6341, 21, 24, 22, 1, -24 },
  { 6404, 20, 24, 20, 2, -24 },
  { 6464, 29, 24, 30, 3, -24 },
  { 6551, 24, 24, 20, -2, -24 },
  { 6623, 25, 34, 20, -3, -24 },
  { 6730, 19, 24, 17, -1, -24 },
  { 6787, 18, 38, 15, 0, -31 },
  { 6873, 5, 43, 19, 7, -33 },
  { 6900, 17, 38, 15, -2, -31 },
  { 6981, 19, 8, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC43PT7B_H_
