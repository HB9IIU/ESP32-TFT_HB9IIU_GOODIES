#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC25PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x78, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x7B, 0xDE, 0xF7, 0x39, 0xCE,
  0x73, 0xB9, 0xCE, 0x70, 0x03, 0x9C, 0x0E, 0xE0, 0x33, 0x81, 0xCE, 0x07,
  0x70, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x0C, 0xE0, 0x73, 0x87, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF0, 0xE6, 0x03, 0xB8, 0x0C, 0xE0, 0x73, 0x81, 0xDC, 0x00,
  0x00, 0x80, 0x08, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xD2, 0x3D, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE8, 0x7E, 0x65, 0xE7, 0xFC,
  0xFF, 0x87, 0xF0, 0x08, 0x00, 0x80, 0x1E, 0x07, 0x0F, 0xC3, 0x83, 0xF0,
  0xE1, 0xCC, 0x70, 0x77, 0x18, 0x19, 0xCE, 0x0E, 0x77, 0x03, 0x9D, 0xDE,
  0xFE, 0xEF, 0xDF, 0x77, 0xF7, 0x9D, 0xDC, 0x0E, 0x67, 0x03, 0xB9, 0xC1,
  0xCE, 0x70, 0xE3, 0xB8, 0x38, 0xEE, 0x1C, 0x3F, 0x0E, 0x07, 0x80, 0x03,
  0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x73, 0x81, 0xE7, 0x03, 0xDE, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0x9E, 0x7F, 0x3D, 0xFF, 0xF3, 0xDF, 0xEF, 0x3F, 0x9E,
  0x3E, 0x3C, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x7E, 0xF8, 0x7B, 0xDC, 0xE7,
  0x3B, 0x80, 0x03, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0xC0, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F,
  0x07, 0x07, 0x07, 0x80, 0x0F, 0x03, 0x84, 0xE3, 0xF9, 0xFF, 0xCF, 0xF1,
  0xE5, 0xFC, 0xF7, 0x0D, 0xE2, 0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x3D,
  0xE7, 0x9C, 0xF3, 0x80, 0x7E, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x07, 0x83, 0xF8, 0x7F, 0x9E, 0xF7, 0x9E, 0xF3, 0xDE,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0x71, 0xEE, 0x3D, 0xC7, 0x3D, 0xE7,
  0xF8, 0xFF, 0x0F, 0x80, 0x03, 0xC1, 0xE1, 0xF8, 0xFE, 0x7F, 0xBD, 0xC6,
  0xF1, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x1C, 0xF0, 0xC7, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFC, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xC1, 0xFF,
  0x1F, 0xF1, 0x8F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0xFC, 0x0F, 0x81, 0xFC,
  0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x83, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x6E, 0x0F, 0xE1, 0xDE,
  0x19, 0xC3, 0x9C, 0x73, 0xCF, 0xFF, 0xFF, 0xEF, 0xFE, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0xFC, 0x3F, 0xC3, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0xC3, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0x03, 0xF0, 0xFF, 0x1F, 0xE1, 0xE0,
  0x3C, 0x07, 0x80, 0x7B, 0x07, 0x7C, 0xFF, 0xCF, 0xBC, 0xF1, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF7, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF7, 0xFE, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0x07, 0xE0, 0xFF, 0x1F, 0xF1, 0xC7, 0x1C, 0x71, 0xCF, 0x1F, 0xE1, 0xFE,
  0x0F, 0x81, 0xFC, 0x3F, 0xC7, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0xFC,
  0x7F, 0x83, 0xF0, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xEF, 0x3C, 0xF3, 0xCF,
  0x78, 0xF7, 0x8F, 0x7D, 0xF3, 0xFE, 0x3E, 0xE1, 0xDE, 0x01, 0xC0, 0x3C,
  0x07, 0x8F, 0xF8, 0xFF, 0x0F, 0xC0, 0x1C, 0x7C, 0xF9, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC7, 0x8F, 0x1E, 0x00, 0x0E, 0x1F, 0x1F, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x38, 0x78, 0x78, 0x70, 0xF0, 0xE0,
  0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xE7, 0xF1, 0xF8, 0x3E, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xC0, 0xF8, 0x7E, 0x7F, 0x1F, 0x83, 0xC0, 0x60, 0x00, 0x1F, 0x1F, 0xE7,
  0xFC, 0x8F, 0x03, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0,
  0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xC3, 0xC3, 0x80, 0x73, 0x80, 0x39, 0x8F, 0xCD, 0xCF, 0xE6, 0xCE,
  0x73, 0xE7, 0x31, 0xF7, 0x19, 0xF3, 0x9C, 0xF9, 0xCE, 0x6C, 0xEF, 0x76,
  0x7F, 0xF3, 0x1E, 0xF1, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x38, 0x0F, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF3, 0xC3, 0xCF, 0x0F, 0x78, 0x3F, 0xE0, 0xF0, 0x0F,
  0xE0, 0x7F, 0xC7, 0xFE, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x71, 0xE7, 0xFE,
  0x3F, 0xE1, 0xFF, 0x0E, 0x7C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0xCF,
  0xFC, 0xFF, 0xC7, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0xFC, 0x7E, 0x63,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xE2, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0xC1, 0xFF, 0x87, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0xCF,
  0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0x9E, 0x1E, 0x78, 0xF9, 0xE3, 0xC7,
  0xBF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xFE, 0x3F, 0xC3, 0xFC, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x1F, 0xF1, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC7, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0x87, 0xC6, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF1, 0xFB, 0xC7, 0xEF, 0x3F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC3, 0xCF, 0x8F, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0x0F, 0x0F, 0x0E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0xF0, 0xFE,
  0x1F, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0xFF, 0x0F, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x0F,
  0x1F, 0x0E, 0x3E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1D,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x79,
  0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x71, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0x0F,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x83, 0xF0, 0xF8,
  0x3F, 0x1F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F,
  0x8F, 0xE3, 0xF9, 0xDC, 0x3F, 0x9D, 0xC3, 0xBB, 0xFC, 0x3B, 0xBB, 0xC7,
  0xBB, 0xBC, 0x7B, 0xF3, 0x87, 0xBF, 0x78, 0x73, 0xE7, 0x87, 0x3E, 0x78,
  0xF3, 0xC7, 0x0F, 0x3C, 0xF0, 0x0F, 0x07, 0x87, 0x83, 0x87, 0xE1, 0xC3,
  0xF1, 0xE1, 0xF8, 0xF0, 0xFC, 0x78, 0x7F, 0x38, 0x7F, 0x9C, 0x3D, 0xDE,
  0x1C, 0xEF, 0x0E, 0x77, 0x0F, 0x3F, 0x87, 0x9F, 0xC3, 0xC7, 0xE1, 0xC3,
  0xF0, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0xE1,
  0xFF, 0x8F, 0x9F, 0x3C, 0x3D, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xC3, 0xCF, 0x9F, 0x1F, 0xF8,
  0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x87, 0xFE, 0x3D, 0xF1, 0xE7,
  0x8F, 0x3C, 0x71, 0xE7, 0x8F, 0x3D, 0xF1, 0xFF, 0x8F, 0xF8, 0xFF, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x3F, 0xE1, 0xFF, 0x8F, 0x9F, 0x3C, 0x3D, 0xF0, 0xF7, 0x83, 0xDE, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xC3, 0xCF, 0x9F,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x0F, 0xC0, 0x7F, 0x87, 0xFE, 0x3D, 0xF1, 0xE7, 0x8F, 0x3C, 0x71,
  0xE7, 0x9F, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF7, 0x87, 0xBC, 0x3C, 0xF1,
  0xE7, 0x8E, 0x3C, 0xF1, 0xE7, 0x87, 0x80, 0x07, 0xE0, 0xFF, 0x1F, 0xF3,
  0xE6, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3C, 0x03, 0xC8, 0x3C, 0xE7, 0xCF, 0xF8, 0xFF, 0x8F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x1E,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0xF1, 0xE7, 0x87, 0x9E,
  0x1E, 0x78, 0x71, 0xE3, 0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0x8F,
  0x9E, 0x3F, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x3D,
  0xE1, 0xEF, 0x1E, 0x78, 0xF3, 0xC7, 0x1E, 0x78, 0x73, 0x83, 0xBC, 0x1D,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x1E, 0xF1, 0xF1, 0xEF, 0x1F, 0x1C, 0xF1,
  0xE3, 0xCF, 0x3E, 0x3C, 0xF3, 0xE7, 0x8F, 0x7E, 0x78, 0xF7, 0xE7, 0x0F,
  0xFE, 0xF0, 0xFE, 0xEF, 0x0E, 0xEE, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0x0F, 0x1F,
  0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x07, 0x78, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3D, 0xE0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF,
  0x87, 0x9C, 0x78, 0xF3, 0xC7, 0xBC, 0x3D, 0xC1, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x00,
  0x07, 0xC3, 0xF0, 0xFC, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xF0, 0xFC, 0x3F, 0x00, 0xE7, 0x39, 0xCE, 0x7B, 0xCE, 0x73, 0x9C, 0xE7,
  0xBC, 0xE7, 0x39, 0xC0, 0x07, 0xE0, 0xF8, 0x3F, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x3E, 0x07, 0xC1, 0xF8, 0x00, 0x01,
  0x80, 0x38, 0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1C, 0xE3, 0xCE, 0x38,
  0xE7, 0x0E, 0xF0, 0x70, 0xFF, 0xFF, 0xE0, 0xF7, 0x9C, 0x70, 0x0E, 0x73,
  0xFF, 0x3F, 0xE7, 0x9E, 0x79, 0xEF, 0x1E, 0xF1, 0xEF, 0x1C, 0xF3, 0xCE,
  0x3C, 0xF7, 0xCF, 0xFC, 0xFF, 0x87, 0xB8, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xDE, 0x1F, 0xF3, 0xFF, 0x3E, 0xF3, 0xCF, 0x38, 0xF3,
  0x8F, 0x78, 0xF7, 0x8F, 0x79, 0xE7, 0x9E, 0xFF, 0xCF, 0xFC, 0xEF, 0x80,
  0x0F, 0x87, 0xF3, 0xF9, 0xF2, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x13, 0xFC, 0xFF, 0x1F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0F, 0x0F, 0x78, 0xFF, 0xC7, 0xFC, 0x79, 0xE3, 0xCF, 0x3C, 0x79,
  0xE3, 0xCF, 0x1C, 0x71, 0xE3, 0x8F, 0x1E, 0x78, 0xFF, 0x87, 0xFC, 0x1E,
  0xE0, 0x0F, 0x83, 0xF8, 0xFF, 0x3C, 0xF7, 0x1F, 0xE7, 0xBF, 0xF7, 0xF8,
  0xE0, 0x1C, 0x03, 0xC2, 0x7F, 0xCF, 0xF8, 0xFE, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0xC0, 0xFF, 0x03, 0xFC, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xF0, 0x00, 0x07, 0x38, 0xFF, 0xC7, 0xFC, 0x79, 0xE3,
  0xCF, 0x3C, 0x79, 0xE3, 0xCF, 0x1C, 0x79, 0xE3, 0x8F, 0x1E, 0xF8, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0x0F, 0x00, 0x78, 0x87, 0x87, 0xFC, 0x3F, 0xC1,
  0xF8, 0x00, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xDE, 0x1F,
  0xF3, 0xFF, 0x3E, 0xF3, 0xCF, 0x3C, 0xF3, 0x8F, 0x78, 0xF7, 0x8E, 0x79,
  0xE7, 0x1E, 0xF1, 0xEF, 0x1C, 0xF3, 0xC0, 0x0E, 0x1F, 0x1E, 0x0C, 0x00,
  0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x70, 0xF0,
  0xF0, 0xF0, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0xC0, 0x00, 0x07, 0x80, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x3F, 0x07, 0xC0, 0xF0,
  0x00, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x71, 0xF1,
  0xC7, 0x8F, 0x3C, 0x3D, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xBC, 0x1C, 0xF0, 0xF3, 0xC3, 0xC7, 0x8F, 0x1E, 0x00, 0x0F,
  0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78,
  0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0, 0x1D, 0xE3, 0x87, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFB, 0xEF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0x8F, 0x3D, 0xE3, 0x8F,
  0x79, 0xE3, 0x9E, 0x78, 0xE7, 0x1E, 0x7B, 0xC7, 0x9E, 0xF1, 0xC7, 0xBC,
  0xF1, 0xC0, 0x1D, 0xE1, 0xFF, 0x3F, 0xF3, 0xEF, 0x3C, 0xF3, 0xCF, 0x38,
  0xF7, 0x8E, 0x78, 0xE7, 0x9E, 0x71, 0xEF, 0x1E, 0xF1, 0xCF, 0x3C, 0x0F,
  0x83, 0xF8, 0xFF, 0x3C, 0xF7, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xDC,
  0x7B, 0xCF, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x0E, 0xF0, 0x7F, 0xC7, 0xFE,
  0x3E, 0xF1, 0xE7, 0x8E, 0x3C, 0x71, 0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0x8F,
  0x3C, 0xFF, 0xC7, 0xFE, 0x3D, 0xE1, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x00, 0x0E, 0x73, 0xFF, 0x3F, 0xE7, 0x9E, 0x79, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1C, 0xE1, 0xCE, 0x3C, 0xF3, 0xCF, 0xF8, 0xFF, 0x87,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1D, 0xC7,
  0xF3, 0xFC, 0xFE, 0x3E, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x00, 0x0F, 0x8F, 0xF3, 0xFC, 0xE2, 0x78, 0x0F, 0x03,
  0xF0, 0x7C, 0x0F, 0x81, 0xE8, 0x7B, 0xFC, 0xFF, 0x3F, 0x80, 0x0C, 0x1C,
  0x1C, 0x3F, 0xFF, 0xFF, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0,
  0xFC, 0xFC, 0x7C, 0x38, 0xF3, 0x8F, 0x78, 0xE7, 0x8E, 0x79, 0xE7, 0x1E,
  0xF1, 0xEF, 0x1C, 0xF3, 0xCF, 0x3C, 0xF7, 0xCF, 0xFC, 0xFF, 0x87, 0xB8,
  0xF0, 0xFF, 0x1E, 0x71, 0xE7, 0x3C, 0x73, 0xC7, 0x38, 0x77, 0x87, 0x70,
  0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xE3, 0xC7, 0xF3,
  0xE7, 0xB9, 0xF3, 0xDC, 0xF9, 0xCE, 0xFD, 0xE7, 0x7E, 0xE3, 0xB7, 0xF1,
  0xFB, 0xF8, 0xFD, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1E,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x79, 0xE1, 0xEF, 0x03, 0xBC, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x1E, 0x70,
  0x79, 0xE3, 0xC7, 0x80, 0x1E, 0x1E, 0x1C, 0x78, 0x38, 0xF0, 0x71, 0xC0,
  0xE7, 0x81, 0xCE, 0x03, 0xBC, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0x1C,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x47, 0xF8,
  0xFF, 0x8F, 0xF8, 0x01, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x03, 0xC0, 0xE0,
  0x78, 0x1E, 0x1F, 0x0F, 0x83, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x07, 0xC1, 0xF0, 0x3C, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xF0, 0x78, 0x1E, 0x1F, 0x87, 0x83, 0xC0,
  0xF0, 0x3C, 0x0E, 0x07, 0x83, 0xE0, 0xF0, 0x38, 0x00, 0x78, 0x3F, 0xFF,
  0xFF, 0xC3, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 18, 7, 0, -18 },
  { 19, 10, 7, 11, 2, -18 },
  { 28, 14, 18, 14, 0, -18 },
  { 60, 12, 20, 12, 0, -19 },
  { 90, 18, 18, 20, 1, -18 },
  { 131, 15, 18, 15, 0, -18 },
  { 165, 5, 7, 6, 2, -18 },
  { 170, 9, 22, 7, 0, -18 },
  { 195, 9, 22, 8, -2, -18 },
  { 220, 10, 11, 12, 2, -19 },
  { 234, 11, 12, 13, 1, -15 },
  { 251, 6, 6, 7, -1, -3 },
  { 256, 7, 3, 8, 0, -8 },
  { 259, 4, 4, 7, 0, -4 },
  { 261, 13, 18, 10, -1, -18 },
  { 291, 11, 18, 12, 1, -18 },
  { 316, 10, 18, 12, 2, -18 },
  { 339, 13, 18, 12, -1, -18 },
  { 369, 12, 18, 12, 0, -18 },
  { 396, 12, 18, 12, 0, -18 },
  { 423, 12, 18, 12, 0, -18 },
  { 450, 12, 18, 12, 1, -18 },
  { 477, 12, 18, 12, 1, -18 },
  { 504, 12, 18, 12, 0, -18 },
  { 531, 12, 18, 12, 0, -18 },
  { 558, 7, 14, 7, 0, -14 },
  { 571, 8, 17, 7, -1, -14 },
  { 588, 11, 12, 13, 1, -15 },
  { 605, 11, 8, 13, 1, -13 },
  { 616, 11, 12, 13, 1, -15 },
  { 633, 10, 18, 10, 1, -18 },
  { 656, 17, 20, 18, 1, -18 },
  { 699, 14, 18, 14, -2, -18 },
  { 731, 13, 18, 13, 0, -18 },
  { 761, 13, 18, 13, 1, -18 },
  { 791, 14, 18, 14, 0, -18 },
  { 823, 12, 18, 11, 0, -18 },
  { 850, 12, 18, 11, 0, -18 },
  { 877, 14, 18, 15, 1, -18 },
  { 909, 16, 18, 15, 0, -18 },
  { 945, 12, 18, 9, -1, -18 },
  { 972, 12, 23, 7, -4, -18 },
  { 1007, 16, 18, 13, 0, -18 },
  { 1043, 9, 18, 11, 0, -18 },
  { 1064, 20, 18, 19, 0, -18 },
  { 1109, 17, 18, 16, 0, -18 },
  { 1148, 14, 18, 15, 1, -18 },
  { 1180, 13, 18, 13, 0, -18 },
  { 1210, 14, 22, 15, 1, -18 },
  { 1249, 13, 18, 13, 0, -18 },
  { 1279, 12, 18, 11, 0, -18 },
  { 1306, 11, 18, 11, 2, -18 },
  { 1331, 14, 18, 14, 1, -18 },
  { 1363, 13, 18, 13, 2, -18 },
  { 1393, 20, 18, 19, 2, -18 },
  { 1438, 16, 18, 13, -1, -18 },
  { 1474, 13, 18, 12, 2, -18 },
  { 1504, 14, 18, 11, -1, -18 },
  { 1536, 10, 22, 8, -1, -18 },
  { 1564, 5, 18, 10, 3, -18 },
  { 1576, 11, 22, 8, -2, -18 },
  { 1607, 12, 11, 12, 0, -18 },
  { 1624, 10, 2, 9, -2, 2 },
  { 1627, 5, 4, 8, 4, -19 },
  { 1630, 12, 14, 13, 1, -14 },
  { 1651, 12, 19, 13, 0, -19 },
  { 1680, 10, 14, 10, 1, -14 },
  { 1698, 13, 19, 13, 1, -19 },
  { 1729, 11, 14, 12, 1, -14 },
  { 1749, 14, 25, 8, -3, -19 },
  { 1793, 13, 20, 13, 0, -14 },
  { 1826, 12, 19, 13, 0, -19 },
  { 1855, 8, 19, 7, 0, -19 },
  { 1874, 11, 25, 7, -3, -19 },
  { 1909, 14, 19, 12, 0, -19 },
  { 1943, 8, 19, 6, 0, -19 },
  { 1962, 18, 14, 19, 0, -14 },
  { 1994, 12, 14, 13, 0, -14 },
  { 2015, 11, 14, 13, 1, -14 },
  { 2035, 13, 20, 13, -1, -14 },
  { 2068, 12, 20, 13, 1, -14 },
  { 2098, 10, 14, 9, 0, -14 },
  { 2116, 10, 14, 10, 0, -14 },
  { 2134, 8, 17, 9, 1, -17 },
  { 2151, 12, 14, 13, 1, -14 },
  { 2172, 12, 14, 11, 1, -14 },
  { 2193, 17, 14, 17, 2, -14 },
  { 2223, 14, 14, 12, -1, -14 },
  { 2248, 15, 20, 11, -2, -14 },
  { 2286, 12, 14, 10, -1, -14 },
  { 2307, 10, 22, 9, 0, -18 },
  { 2335, 3, 25, 11, 4, -19 },
  { 2345, 10, 22, 9, -1, -18 },
  { 2373, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC25PT7B_H_
