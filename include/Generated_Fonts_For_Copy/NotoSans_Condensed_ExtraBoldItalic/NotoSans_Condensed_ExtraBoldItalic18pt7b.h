#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC18PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8E, 0x30, 0xC7, 0x1C, 0x60, 0x06, 0x38, 0xE0, 0xEF,
  0xDB, 0x36, 0xED, 0x80, 0x0C, 0xC3, 0x60, 0xD8, 0x66, 0x7F, 0xDF, 0xF1,
  0xB0, 0xC8, 0xFF, 0x8D, 0x86, 0x61, 0xB0, 0x6C, 0x00, 0x02, 0x01, 0x07,
  0xE7, 0xE3, 0x51, 0xA0, 0xF0, 0x3C, 0x0F, 0x07, 0x93, 0xDF, 0xCF, 0xC0,
  0x80, 0x40, 0x38, 0x63, 0xE6, 0x1B, 0x31, 0x9B, 0x0D, 0x98, 0x6D, 0xBB,
  0xFB, 0xEE, 0xDB, 0x0D, 0x98, 0x6D, 0xC6, 0x6C, 0x63, 0xE7, 0x0E, 0x00,
  0x0F, 0x03, 0xF0, 0x6E, 0x1D, 0xC1, 0xF0, 0x3C, 0x0F, 0x3B, 0xF6, 0xEF,
  0xDC, 0xF3, 0x9C, 0x7F, 0xC7, 0xFC, 0xFF, 0x6C, 0x0E, 0x38, 0x61, 0xC3,
  0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x0C, 0x18, 0x30, 0x1C, 0x70,
  0xC3, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x8E, 0x31, 0xC6, 0x30, 0x0C, 0x1C,
  0x78, 0xFF, 0x1F, 0x3C, 0x6C, 0x2E, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x77, 0x6E, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xC0, 0xE0,
  0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0x80,
  0xE0, 0x00, 0x0F, 0x0F, 0x8E, 0xE6, 0x77, 0x3B, 0x9D, 0xCC, 0xCE, 0x67,
  0x73, 0x9B, 0x8F, 0x87, 0x80, 0x0C, 0xF7, 0xFF, 0xD8, 0xE3, 0x8E, 0x38,
  0xC7, 0x1C, 0x70, 0x0F, 0x07, 0xE1, 0xBC, 0x47, 0x01, 0x80, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0x1F, 0xCC, 0xE0,
  0x70, 0x30, 0xF0, 0xF0, 0x7C, 0x07, 0x03, 0xA3, 0x9F, 0xCF, 0xC0, 0x03,
  0x83, 0xC3, 0xC1, 0xE1, 0xF1, 0xB8, 0xD8, 0xCC, 0xFF, 0x7F, 0x83, 0x81,
  0x81, 0xC0, 0x1F, 0x8F, 0xCF, 0xC7, 0x03, 0x01, 0xF1, 0xFC, 0x0E, 0x07,
  0x03, 0xA3, 0x9F, 0xCF, 0xC0, 0x0F, 0x3F, 0x38, 0x70, 0x60, 0xFE, 0xFE,
  0xEE, 0xCE, 0xCE, 0xCE, 0xFC, 0x78, 0x3F, 0xCF, 0xE3, 0xF8, 0x0C, 0x07,
  0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x00, 0x0F,
  0x1F, 0xCE, 0xE6, 0x73, 0xB1, 0xF8, 0xF8, 0xFC, 0x67, 0x73, 0xB9, 0xDF,
  0xC7, 0xC0, 0x1E, 0x1F, 0x8E, 0xEE, 0x77, 0x3B, 0xBD, 0xFC, 0xFE, 0x17,
  0x03, 0x03, 0x9F, 0x8F, 0x80, 0x39, 0xCC, 0x00, 0x00, 0x0C, 0xE7, 0x00,
  0x1C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x71, 0xC6, 0x38, 0x01, 0x07, 0x1E,
  0x78, 0xE0, 0xF8, 0x3E, 0x0F, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0xF8, 0x3E, 0x07, 0x1E, 0xF8, 0xE0, 0x80, 0x3D, 0xFD, 0x38,
  0x71, 0xC7, 0x1C, 0x30, 0x60, 0x03, 0x87, 0x0C, 0x00, 0x07, 0xC1, 0xFE,
  0x30, 0x76, 0x33, 0x6F, 0xBD, 0xDB, 0xD9, 0xBD, 0xB3, 0x9B, 0x69, 0xFE,
  0x9D, 0xCC, 0x00, 0xE1, 0x07, 0xF0, 0x03, 0x81, 0xE0, 0x78, 0x3E, 0x0D,
  0x87, 0x61, 0xD8, 0xE6, 0x3F, 0xCF, 0xF7, 0x1D, 0x87, 0xE1, 0xC0, 0x1F,
  0x07, 0xE3, 0xBC, 0xE7, 0x39, 0x8F, 0xE7, 0xF1, 0xDC, 0x73, 0x9C, 0xE6,
  0x73, 0xFC, 0xFC, 0x00, 0x0F, 0x1F, 0xCE, 0x4E, 0x07, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x9F, 0xC7, 0xE0, 0x1F, 0x07, 0xE3, 0xFC, 0xE7,
  0x39, 0xCC, 0x77, 0x1D, 0xC7, 0x73, 0x9C, 0xE6, 0xF3, 0xF8, 0xFC, 0x00,
  0x1F, 0x8F, 0xCF, 0xC7, 0x03, 0x81, 0xF9, 0xF8, 0xFC, 0x70, 0x38, 0x18,
  0x1F, 0xCF, 0xC0, 0x1F, 0x8F, 0xCF, 0xC7, 0x03, 0x81, 0x81, 0xF8, 0xFC,
  0x70, 0x38, 0x18, 0x1C, 0x0E, 0x00, 0x0F, 0x87, 0xF3, 0xD9, 0xC0, 0x70,
  0x38, 0x0E, 0x7B, 0xBE, 0xE3, 0x39, 0xCE, 0x73, 0xFC, 0x7E, 0x00, 0x1C,
  0xE3, 0x1C, 0xE3, 0x9C, 0x63, 0x9C, 0x7F, 0x9F, 0xF3, 0xFE, 0x71, 0x8E,
  0x71, 0x8E, 0x71, 0xCE, 0x38, 0x1F, 0x8F, 0x83, 0x81, 0xC0, 0xC0, 0xE0,
  0x70, 0x38, 0x18, 0x0C, 0x0E, 0x0F, 0x8F, 0xC0, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE2,
  0xE1, 0xF0, 0xF0, 0x00, 0x1C, 0xE3, 0x38, 0xEF, 0x1D, 0xC3, 0xF0, 0x7C,
  0x1F, 0x83, 0xF0, 0x76, 0x0E, 0xE1, 0x9C, 0x73, 0x8E, 0x78, 0x1C, 0x30,
  0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0xFF, 0xC0, 0x1C, 0x3C,
  0x70, 0xF3, 0xC7, 0xCF, 0x1F, 0x3E, 0x78, 0xFB, 0x67, 0xEF, 0x9F, 0xEE,
  0x7F, 0xB9, 0xBE, 0xC6, 0x73, 0x39, 0xDC, 0xE6, 0x70, 0x1C, 0x71, 0xC7,
  0x3C, 0x63, 0xE6, 0x3E, 0x63, 0x6E, 0x76, 0xE7, 0x6C, 0x77, 0xC6, 0x7C,
  0x63, 0xCE, 0x3C, 0xE3, 0x80, 0x0F, 0x0F, 0xE3, 0xBD, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x8E, 0xE3, 0xB8, 0xEE, 0x73, 0xF8, 0x7C, 0x00, 0x1F, 0x07,
  0xE3, 0xFC, 0xE7, 0x39, 0xCC, 0xE7, 0xF9, 0xFC, 0x7C, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0x00, 0x0F, 0x0F, 0xE3, 0xBD, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F,
  0x8E, 0xE3, 0xB8, 0xEE, 0x73, 0xF8, 0x7C, 0x07, 0x00, 0xE0, 0x3C, 0x1F,
  0x0F, 0xCE, 0xE7, 0x33, 0xB9, 0x9D, 0xFC, 0xFC, 0x7E, 0x3B, 0x99, 0xDC,
  0xEE, 0x78, 0x1F, 0x1F, 0xCE, 0xC6, 0x03, 0x81, 0xE0, 0xF8, 0x3C, 0x0E,
  0x07, 0x33, 0x9F, 0xCF, 0x80, 0x7F, 0x7F, 0xFF, 0x18, 0x38, 0x38, 0x38,
  0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0x39, 0xDC, 0x77, 0x19, 0xCE, 0x73,
  0x98, 0xEE, 0x3B, 0x8C, 0xE7, 0x39, 0xCE, 0xF3, 0xF8, 0x7C, 0x00, 0xC3,
  0xE1, 0xB1, 0xD8, 0xCC, 0xE6, 0x73, 0x71, 0xB8, 0xD8, 0x7C, 0x3C, 0x1E,
  0x0E, 0x00, 0x63, 0x8E, 0xC7, 0x39, 0x9E, 0x73, 0x3C, 0xC6, 0x7B, 0x8D,
  0xF6, 0x1B, 0xFC, 0x3F, 0xF8, 0xFB, 0xE1, 0xF7, 0xC3, 0xCF, 0x07, 0x9E,
  0x0F, 0x3C, 0x00, 0x1C, 0xF1, 0xCE, 0x1D, 0xC0, 0xD8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xB0, 0x33, 0x87, 0x38, 0xE3, 0x80, 0xC7,
  0xF3, 0xBB, 0x9D, 0x8F, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x1C,
  0x0E, 0x00, 0x1F, 0xC7, 0xF0, 0x3C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0x1E, 0x1C, 0x18, 0x18,
  0x18, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x78, 0xF0, 0xCC,
  0xCE, 0xE6, 0x66, 0x66, 0x77, 0x30, 0x1E, 0x3C, 0x38, 0x60, 0xC1, 0x87,
  0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x3C, 0x78, 0x06, 0x07, 0x03, 0x83,
  0xC3, 0xF1, 0x99, 0x8D, 0xC7, 0x7F, 0xFC, 0xFD, 0x80, 0x1D, 0x9F, 0xDC,
  0xEE, 0x77, 0x33, 0x3B, 0x9D, 0xCE, 0x7E, 0x3B, 0x00, 0x1C, 0x0C, 0x0E,
  0x07, 0x03, 0xF1, 0xFC, 0xEE, 0xE7, 0x73, 0xB1, 0x99, 0xDE, 0xEF, 0xE6,
  0xE0, 0x1F, 0x3E, 0x7A, 0x70, 0x70, 0x60, 0xE0, 0x64, 0x7C, 0x7C, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x1D, 0x8F, 0xE7, 0x39, 0xCE, 0x73, 0x18, 0xCE,
  0x73, 0x9C, 0x7E, 0x1D, 0x80, 0x1E, 0x3F, 0x73, 0x73, 0x7F, 0x7C, 0xE0,
  0x62, 0x7E, 0x3E, 0x03, 0x81, 0xF0, 0x78, 0x18, 0x0F, 0x87, 0xC0, 0xE0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0xF0,
  0x3C, 0x00, 0x1D, 0x9F, 0xDC, 0xEE, 0x77, 0x33, 0x3B, 0x9D, 0xCE, 0x7E,
  0x3B, 0x03, 0x91, 0xCF, 0xC7, 0xC0, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0xF1,
  0xFC, 0xEE, 0xE7, 0x73, 0x39, 0x99, 0xDC, 0xEE, 0x77, 0x30, 0x19, 0xC6,
  0x03, 0x98, 0xCE, 0x73, 0x99, 0xCE, 0x70, 0x06, 0x1C, 0x18, 0x00, 0xE1,
  0x83, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0xF1, 0xC0, 0x1C,
  0x06, 0x03, 0x80, 0xE0, 0x39, 0xCC, 0xE3, 0x71, 0xF8, 0x7C, 0x1F, 0x87,
  0xE3, 0xB8, 0xE6, 0x39, 0xC0, 0x1C, 0x63, 0x8E, 0x38, 0xC3, 0x1C, 0x71,
  0xC6, 0x38, 0xE3, 0x80, 0x37, 0x79, 0xFF, 0xCE, 0xEE, 0xE7, 0x77, 0x33,
  0xBB, 0x9D, 0x9C, 0xDC, 0xE6, 0xE6, 0x77, 0x33, 0x80, 0x37, 0x1F, 0xCE,
  0xEE, 0x77, 0x33, 0x99, 0x9D, 0xCE, 0xE7, 0x73, 0x00, 0x1E, 0x1F, 0x9C,
  0xCE, 0x76, 0x33, 0x1B, 0x9C, 0xCE, 0x7E, 0x1E, 0x00, 0x1B, 0x87, 0xF1,
  0xDC, 0xE7, 0x39, 0xCE, 0x63, 0x39, 0xEE, 0x7F, 0x1F, 0x87, 0x01, 0x80,
  0xE0, 0x38, 0x00, 0x1D, 0x9F, 0xDC, 0xEE, 0x77, 0x33, 0x1B, 0x9D, 0xCE,
  0x7E, 0x3B, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x36, 0x7C, 0xFB, 0x87, 0x0E,
  0x18, 0x70, 0xE1, 0xC0, 0x3E, 0xFD, 0xCB, 0x87, 0x87, 0x87, 0x4E, 0xFD,
  0xF0, 0x30, 0xC7, 0xFF, 0x61, 0x8E, 0x38, 0xE3, 0x0F, 0x3C, 0x73, 0x67,
  0xE7, 0xE7, 0xE6, 0xEE, 0xCE, 0xCE, 0xFE, 0xEC, 0xE7, 0xE7, 0xEE, 0xEE,
  0xEC, 0xFC, 0xF8, 0xF8, 0x70, 0x70, 0xE7, 0x3E, 0xF7, 0xEF, 0x6F, 0xBE,
  0xFE, 0xED, 0xEC, 0xF7, 0xCF, 0x78, 0xF7, 0x8E, 0x70, 0x39, 0xC6, 0xE1,
  0xF8, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xFC, 0x77, 0x39, 0xC0, 0x39, 0xCE,
  0x73, 0xB8, 0xEE, 0x3B, 0x0F, 0xC1, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0xF0, 0x38, 0x00, 0x1F, 0x9F, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0,
  0xE0, 0x7E, 0x7F, 0x00, 0x07, 0x0E, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0xF0,
  0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x18, 0x38, 0xF0, 0x61, 0xC3, 0x87, 0x07, 0x1E, 0x70, 0xE1, 0x83,
  0x0E, 0x3C, 0x60, 0xF1, 0xFF, 0x9F,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 13, 5, 0, -13 },
  { 11, 7, 5, 8, 2, -13 },
  { 16, 10, 13, 10, 0, -13 },
  { 33, 9, 15, 9, 0, -14 },
  { 50, 13, 13, 14, 1, -13 },
  { 72, 11, 13, 11, 0, -13 },
  { 90, 3, 5, 4, 2, -13 },
  { 92, 7, 16, 5, 0, -13 },
  { 106, 6, 16, 5, -1, -13 },
  { 118, 8, 8, 8, 1, -14 },
  { 126, 8, 9, 9, 1, -11 },
  { 135, 4, 4, 5, -1, -2 },
  { 137, 5, 2, 6, 0, -6 },
  { 139, 3, 3, 5, 0, -3 },
  { 141, 10, 13, 7, -1, -13 },
  { 158, 9, 13, 9, 0, -13 },
  { 173, 6, 13, 9, 2, -13 },
  { 183, 10, 13, 9, -1, -13 },
  { 200, 9, 13, 9, 0, -13 },
  { 215, 9, 13, 9, 0, -13 },
  { 230, 9, 13, 9, 0, -13 },
  { 245, 8, 13, 9, 1, -13 },
  { 258, 10, 13, 9, 0, -13 },
  { 275, 9, 13, 9, 0, -13 },
  { 290, 9, 13, 9, 0, -13 },
  { 305, 5, 10, 5, 0, -10 },
  { 312, 6, 12, 5, -1, -10 },
  { 321, 8, 9, 9, 1, -11 },
  { 330, 8, 6, 9, 1, -9 },
  { 336, 8, 9, 9, 1, -11 },
  { 345, 7, 13, 7, 1, -13 },
  { 357, 12, 14, 13, 1, -13 },
  { 378, 10, 13, 10, -1, -13 },
  { 395, 10, 13, 10, 0, -13 },
  { 412, 9, 13, 9, 1, -13 },
  { 427, 10, 13, 10, 0, -13 },
  { 444, 9, 13, 8, 0, -13 },
  { 459, 9, 13, 8, 0, -13 },
  { 474, 10, 13, 11, 1, -13 },
  { 491, 11, 13, 11, 0, -13 },
  { 509, 9, 13, 7, -1, -13 },
  { 524, 9, 17, 5, -3, -13 },
  { 544, 11, 13, 10, 0, -13 },
  { 562, 7, 13, 8, 0, -13 },
  { 574, 14, 13, 14, 0, -13 },
  { 597, 12, 13, 12, 0, -13 },
  { 617, 10, 13, 11, 1, -13 },
  { 634, 10, 13, 9, 0, -13 },
  { 651, 10, 16, 11, 1, -13 },
  { 671, 9, 13, 10, 0, -13 },
  { 686, 9, 13, 8, 0, -13 },
  { 701, 8, 13, 8, 1, -13 },
  { 714, 10, 13, 10, 1, -13 },
  { 731, 9, 13, 9, 2, -13 },
  { 746, 15, 13, 14, 1, -13 },
  { 771, 12, 13, 9, -1, -13 },
  { 791, 9, 13, 9, 2, -13 },
  { 806, 10, 13, 8, -1, -13 },
  { 823, 8, 16, 5, -1, -13 },
  { 839, 4, 13, 7, 2, -13 },
  { 846, 7, 16, 5, -1, -13 },
  { 860, 9, 8, 9, 0, -13 },
  { 869, 7, 2, 7, -2, 1 },
  { 871, 3, 3, 6, 3, -14 },
  { 873, 9, 10, 9, 0, -10 },
  { 885, 9, 14, 9, 0, -14 },
  { 901, 8, 10, 7, 0, -10 },
  { 911, 10, 14, 9, 0, -14 },
  { 929, 8, 10, 9, 0, -10 },
  { 939, 10, 18, 6, -2, -14 },
  { 962, 9, 14, 9, 0, -10 },
  { 978, 9, 14, 9, 0, -14 },
  { 994, 5, 14, 5, 0, -14 },
  { 1003, 7, 18, 5, -2, -14 },
  { 1019, 10, 14, 9, 0, -14 },
  { 1037, 6, 14, 5, 0, -14 },
  { 1048, 13, 10, 14, 0, -10 },
  { 1065, 9, 10, 9, 0, -10 },
  { 1077, 9, 10, 9, 0, -10 },
  { 1089, 10, 14, 9, -1, -10 },
  { 1107, 9, 14, 9, 0, -10 },
  { 1123, 7, 10, 7, 0, -10 },
  { 1132, 7, 10, 7, 0, -10 },
  { 1141, 6, 12, 6, 1, -12 },
  { 1150, 8, 10, 9, 1, -10 },
  { 1160, 8, 10, 8, 1, -10 },
  { 1170, 12, 10, 12, 1, -10 },
  { 1185, 10, 10, 8, -1, -10 },
  { 1198, 10, 14, 8, -1, -10 },
  { 1216, 9, 10, 7, -1, -10 },
  { 1228, 8, 16, 6, 0, -13 },
  { 1244, 2, 18, 8, 3, -14 },
  { 1249, 7, 16, 6, -1, -13 },
  { 1263, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC18PT7B_H_
