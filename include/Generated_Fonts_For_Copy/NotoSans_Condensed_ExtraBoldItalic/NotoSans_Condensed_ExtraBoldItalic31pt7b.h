#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC31PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0x00, 0xE7, 0x80, 0x79, 0xC0, 0x1C, 0x70,
  0x07, 0x3C, 0x03, 0xCE, 0x00, 0xE3, 0x83, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x81, 0xC7, 0x00, 0x73, 0xC0, 0x3C, 0xE0, 0x0E, 0x38, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0x1C, 0xF0, 0x0F, 0x38, 0x03, 0x8E, 0x00,
  0xE7, 0x80, 0x79, 0xC0, 0x1E, 0x70, 0x00, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x0F, 0x62, 0x1E, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0xBE, 0x01, 0x7C, 0x86, 0xF1, 0xCD, 0xE3, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x07, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x1F, 0x01, 0xE0, 0xFE,
  0x07, 0x07, 0xF8, 0x3C, 0x1C, 0xF1, 0xE0, 0xF3, 0xC7, 0x03, 0xCE, 0x3C,
  0x0E, 0x38, 0xE0, 0x38, 0xE7, 0x00, 0xE7, 0xBC, 0x63, 0x9C, 0xE7, 0xEF,
  0xF7, 0xBF, 0xBF, 0xBD, 0xFF, 0x7C, 0xE7, 0x3C, 0x07, 0xBC, 0xF0, 0x1C,
  0xF3, 0xC0, 0xF3, 0x8E, 0x07, 0x8E, 0x38, 0x1C, 0x39, 0xE0, 0xF0, 0xE7,
  0x03, 0x83, 0xFC, 0x1E, 0x0F, 0xE0, 0xF0, 0x1F, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x03,
  0xEF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x8F, 0x8F,
  0xF3, 0xE3, 0xFF, 0x7C, 0xFB, 0xFF, 0x1E, 0x3F, 0xE7, 0xC7, 0xF8, 0xF8,
  0x7E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F,
  0x3F, 0x00, 0x7D, 0xE7, 0x9E, 0xF3, 0xCF, 0x3C, 0x03, 0xE0, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0x00, 0x1E, 0x00, 0xE0, 0xC7, 0x07, 0xB8, 0xBF, 0xFF, 0xFF,
  0xE1, 0xFF, 0x0F, 0x89, 0xFE, 0x1F, 0x70, 0x73, 0xC1, 0x9F, 0x08, 0x40,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x7F,
  0xBF, 0xDF, 0xDF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF,
  0x87, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xE1,
  0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0xFB, 0xE3, 0xEF, 0x0F, 0xBC, 0x7C, 0xF1,
  0xF3, 0xEF, 0x8F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x03, 0xE0,
  0xFC, 0x3F, 0x8F, 0xF3, 0xFD, 0xFF, 0xBF, 0xF3, 0xBE, 0x67, 0xC0, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0x07, 0x1F, 0x04, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x07, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xC3, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0x03, 0xF3, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0x78,
  0x1C, 0xF0, 0x7B, 0xE1, 0xE7, 0xC3, 0x8F, 0x8E, 0x1E, 0x3F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF9, 0x83, 0xF3, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE1, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x20, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xE7, 0xF7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C,
  0x7C, 0xF8, 0xF9, 0xF3, 0xE3, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF8, 0x7D, 0xF1, 0xF1, 0xE3, 0xE3, 0xC7, 0xCF, 0x8F, 0x9E,
  0x0F, 0xFC, 0x1F, 0xE0, 0x1F, 0x80, 0xFF, 0x83, 0xFF, 0x8F, 0x9F, 0x1E,
  0x1E, 0x7C, 0x3E, 0xF8, 0x79, 0xF0, 0xF3, 0xF7, 0xE3, 0xFF, 0x87, 0xFE,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7D,
  0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x78, 0x7D, 0xF3, 0xF7, 0xFF, 0x9F, 0xFE,
  0x7F, 0xF8, 0xFB, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x1F, 0x8F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0x03,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x7F,
  0x87, 0xF8, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xE0,
  0x0E, 0x00, 0x20, 0x00, 0x1F, 0xE3, 0xFF, 0x3F, 0xF3, 0xFF, 0x20, 0xF0,
  0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0xF8, 0x07,
  0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0x3F, 0x01, 0xE0, 0x1E,
  0x0F, 0x00, 0x38, 0x78, 0x60, 0xE3, 0xC7, 0xFB, 0x8E, 0x3F, 0xCF, 0x79,
  0xE7, 0x3D, 0xCF, 0x1C, 0xE7, 0x38, 0xF3, 0xBC, 0xE3, 0x8E, 0xE7, 0x8E,
  0x3B, 0x9E, 0x79, 0xCE, 0x79, 0xE7, 0x39, 0xEF, 0xB8, 0xE3, 0xFF, 0xE3,
  0x8F, 0xBF, 0x0E, 0x08, 0x30, 0x3C, 0x00, 0x00, 0x78, 0x02, 0x00, 0xF8,
  0x78, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0xF8, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0x07,
  0xCF, 0x83, 0xEF, 0x81, 0xF7, 0xC0, 0xFF, 0xC0, 0x7C, 0x07, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3C,
  0x3E, 0x3E, 0x1F, 0x7E, 0x0F, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xE7,
  0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0x82, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x10, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0xF9, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C,
  0xF8, 0x7E, 0x7C, 0x7E, 0x3E, 0x7E, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC3, 0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x21, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0x81, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x1F, 0xC7, 0xC7, 0xF1, 0xF3, 0xFC, 0xF8, 0xFF, 0x3E, 0x07, 0x8F, 0x83,
  0xE3, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x5F, 0x80,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC3, 0xE1, 0xF0,
  0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1E, 0x7C, 0x07, 0xDF,
  0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xFC,
  0x00, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7F, 0xF7, 0xFE, 0xFF, 0xEF, 0xFE, 0x07, 0xE0,
  0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE3, 0xFE, 0x0F, 0x71, 0xFF, 0x07, 0xB9, 0xEF, 0x07, 0xDC, 0xF7, 0x83,
  0xEE, 0xF3, 0xC1, 0xE7, 0x7B, 0xE0, 0xF3, 0xB9, 0xF0, 0xF9, 0xFC, 0xF0,
  0x7C, 0xFC, 0x78, 0x3C, 0x7E, 0x7C, 0x1E, 0x3F, 0x3E, 0x0F, 0x1F, 0x1F,
  0x0F, 0x8F, 0x8F, 0x07, 0xC7, 0x8F, 0x80, 0x07, 0xC0, 0xF8, 0x7E, 0x07,
  0x83, 0xF8, 0x3C, 0x1F, 0xC3, 0xE0, 0xFE, 0x1F, 0x07, 0xF0, 0xF0, 0x7F,
  0xC7, 0x83, 0xDE, 0x3C, 0x1E, 0xF3, 0xE0, 0xF7, 0x9F, 0x07, 0xBC, 0xF0,
  0x7D, 0xF7, 0x83, 0xE7, 0xBC, 0x1E, 0x3F, 0xE0, 0xF1, 0xFF, 0x0F, 0x8F,
  0xF0, 0x7C, 0x7F, 0x83, 0xC1, 0xFC, 0x1E, 0x0F, 0xE0, 0xF0, 0x7E, 0x0F,
  0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0x8F, 0x8F, 0xC3, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C,
  0x07, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07,
  0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x1F, 0x1F, 0x87, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E,
  0x1F, 0x1F, 0x0F, 0x9F, 0x87, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0x80, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0x8F, 0xC3, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x7C, 0x07, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x07, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x1F, 0x1F, 0x87, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x3E, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x3C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x78, 0x7C, 0x7C, 0x78, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7E, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xF0,
  0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x80, 0xF9, 0xC3,
  0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x0F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0xC7, 0xC1,
  0xF1, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xE0, 0xF8,
  0xF8, 0x7C, 0x3F, 0x1F, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xF0, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xFB, 0xE0,
  0xFB, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x1E,
  0x0F, 0xBC, 0x1F, 0x07, 0x9E, 0x0F, 0x87, 0xCF, 0x0F, 0xC3, 0xC7, 0x87,
  0xE3, 0xE3, 0xC7, 0xF1, 0xF1, 0xE3, 0xF8, 0xF0, 0xF1, 0xFC, 0xF8, 0x79,
  0xFE, 0x78, 0x3C, 0xFF, 0x7C, 0x1E, 0xF7, 0xBE, 0x0F, 0x7B, 0xDE, 0x07,
  0xBD, 0xFF, 0x03, 0xFC, 0xEF, 0x01, 0xFE, 0x77, 0x80, 0xFE, 0x3F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x3C, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFB, 0xE0, 0x0F,
  0xBE, 0x01, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F,
  0xC1, 0xF0, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7, 0xC7, 0x9F, 0x0F,
  0x3E, 0x1E, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x20, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xF1, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF8,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x3C, 0x78, 0xF1, 0xE3, 0xC0, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xDE, 0x07, 0xBC, 0x1E, 0x38,
  0x3C, 0x78, 0xF0, 0xF3, 0xC1, 0xE7, 0x81, 0xDE, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0xF8, 0xF1, 0xE1, 0xE0, 0x0F, 0x9E, 0x3F, 0xFC,
  0xFF, 0xF1, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F, 0x7C, 0x3C, 0xF8,
  0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0xFE, 0x3F, 0xFC,
  0x3F, 0x78, 0x7C, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F,
  0xF8, 0xF9, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E, 0x1F, 0x7C, 0x3E,
  0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xE7, 0xFF, 0x9F, 0xFE, 0x3D, 0xFC, 0x79,
  0xE0, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xC7, 0xE0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x84, 0x7F, 0xE3,
  0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x0F, 0xBE, 0x1F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF8,
  0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xF9, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7E, 0xF0, 0x7C, 0xE0, 0x07, 0xF0, 0x7F, 0xC7, 0xFE, 0x7C, 0xF7,
  0xC7, 0xBC, 0x3D, 0xE3, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x3C, 0x01, 0xE0,
  0x0F, 0x82, 0x7C, 0x73, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x00, 0x0E, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xF9, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x07,
  0xCF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C,
  0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3E, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x81, 0xF0, 0xE7, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0xBE, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xF9, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x9E, 0x1E, 0x7C, 0x3C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3,
  0xE7, 0x87, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0x03, 0x03, 0xC3, 0xE1,
  0xF0, 0x70, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0,
  0xF8, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xF0, 0x00,
  0x30, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x9F, 0x07,
  0x9F, 0x03, 0xDF, 0x03, 0xEF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0x7C, 0x0F, 0x3E, 0x07, 0x8F, 0x87, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0x1E,
  0x7C, 0x7C, 0x3D, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xF3,
  0xF3, 0xE7, 0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x7C, 0x78, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xE3, 0xE3, 0xC7, 0x87, 0x87,
  0x8F, 0x0F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF0, 0xF0,
  0x1E, 0x7C, 0x3D, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF,
  0x8F, 0x9F, 0x1F, 0x3C, 0x3C, 0x78, 0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7,
  0x8F, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0x07, 0xE0, 0x7F, 0xC3,
  0xFF, 0x8F, 0xFE, 0x7C, 0x7D, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xEF, 0x0F, 0xBC, 0x3E, 0xF9, 0xF3, 0xFF, 0xCF, 0xFE, 0x1F, 0xF0,
  0x3F, 0x80, 0x07, 0x9F, 0x03, 0xDF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3E, 0xF8, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xF1, 0xFF,
  0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F, 0x7C, 0x3C, 0xF8, 0x79, 0xF1, 0xF3,
  0xE3, 0xE7, 0x87, 0x8F, 0x9F, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7D,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x1E, 0x78, 0xF7, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xCF, 0xFC, 0x7C,
  0xE3, 0xE1, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8,
  0x07, 0xC8, 0x3E, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x81, 0xFE, 0xFF, 0x9F, 0xF7, 0xFE, 0x3E, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0xE3, 0xFC,
  0x3F, 0x87, 0xF0, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xF1, 0xE1, 0xE7, 0xC7,
  0xCF, 0x8F, 0x9F, 0x1F, 0x3C, 0x3C, 0x78, 0x79, 0xF1, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x9F, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0x78, 0x7C, 0xE0, 0xF0,
  0x7F, 0xC3, 0xEF, 0x0F, 0xBC, 0x7C, 0xF1, 0xF3, 0xC7, 0x8F, 0x3E, 0x3C,
  0xF0, 0xF7, 0xC3, 0xDE, 0x0F, 0x78, 0x3F, 0xC0, 0x7F, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0xF8, 0xFF, 0x8F, 0xC7, 0xBC, 0x7E,
  0x3D, 0xE7, 0xF3, 0xEF, 0x3F, 0x9E, 0x79, 0xFD, 0xF3, 0xDF, 0xEF, 0x1E,
  0xEF, 0x78, 0xF7, 0x7F, 0x87, 0xFB, 0xFC, 0x3F, 0x9D, 0xE1, 0xFC, 0xFE,
  0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8,
  0x7C, 0x00, 0x0F, 0x8F, 0xC1, 0xE3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0xDF, 0x03, 0xE7, 0xC1,
  0xF1, 0xF0, 0xFC, 0x7E, 0x00, 0x0F, 0x07, 0xC3, 0xC3, 0xE0, 0xF0, 0xF8,
  0x3C, 0x3C, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x3E, 0xF0, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x0F,
  0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0xFE,
  0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xF0, 0x1F, 0x00, 0x78, 0x1F, 0xC0, 0xFC, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3C,
  0x00, 0x18, 0x05, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x03, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 22, 8, 0, -22 },
  { 29, 12, 8, 13, 3, -22 },
  { 41, 18, 22, 17, 0, -22 },
  { 91, 15, 26, 15, 0, -24 },
  { 140, 22, 22, 24, 2, -22 },
  { 201, 19, 22, 19, 0, -22 },
  { 254, 6, 8, 8, 3, -22 },
  { 260, 11, 27, 9, 1, -22 },
  { 298, 11, 28, 9, -2, -23 },
  { 337, 13, 14, 14, 2, -24 },
  { 360, 14, 15, 16, 1, -18 },
  { 387, 8, 8, 8, -2, -4 },
  { 395, 9, 4, 9, 0, -10 },
  { 400, 5, 5, 8, 0, -5 },
  { 404, 17, 22, 12, -2, -22 },
  { 451, 14, 22, 15, 1, -22 },
  { 490, 11, 22, 15, 3, -22 },
  { 521, 16, 22, 15, -1, -22 },
  { 565, 15, 22, 15, 0, -22 },
  { 607, 15, 22, 15, 0, -22 },
  { 649, 15, 22, 15, 0, -22 },
  { 691, 15, 22, 15, 1, -22 },
  { 733, 16, 22, 15, 1, -22 },
  { 777, 15, 22, 15, 0, -22 },
  { 819, 14, 22, 15, 1, -22 },
  { 858, 8, 17, 8, 0, -17 },
  { 875, 10, 21, 8, -2, -17 },
  { 902, 14, 16, 16, 1, -19 },
  { 930, 14, 10, 16, 1, -16 },
  { 948, 14, 16, 16, 1, -19 },
  { 976, 12, 22, 12, 1, -22 },
  { 1009, 22, 25, 23, 1, -22 },
  { 1078, 17, 22, 17, -2, -22 },
  { 1125, 17, 22, 17, 0, -22 },
  { 1172, 16, 22, 16, 1, -22 },
  { 1216, 17, 22, 18, 0, -22 },
  { 1263, 15, 22, 14, 0, -22 },
  { 1305, 15, 22, 14, 0, -22 },
  { 1347, 18, 22, 18, 1, -22 },
  { 1397, 19, 22, 18, 0, -22 },
  { 1450, 14, 22, 11, -1, -22 },
  { 1489, 15, 29, 9, -5, -22 },
  { 1544, 19, 22, 16, 0, -22 },
  { 1597, 12, 22, 13, 0, -22 },
  { 1630, 25, 22, 24, 0, -22 },
  { 1699, 21, 22, 20, 0, -22 },
  { 1757, 18, 22, 19, 1, -22 },
  { 1807, 17, 22, 16, 0, -22 },
  { 1854, 18, 27, 19, 1, -22 },
  { 1915, 16, 22, 16, 0, -22 },
  { 1959, 15, 22, 14, 0, -22 },
  { 2001, 14, 22, 14, 2, -22 },
  { 2040, 18, 22, 18, 1, -22 },
  { 2090, 16, 22, 16, 3, -22 },
  { 2134, 25, 22, 24, 2, -22 },
  { 2203, 20, 22, 16, -2, -22 },
  { 2258, 15, 22, 15, 3, -22 },
  { 2300, 17, 22, 14, -1, -22 },
  { 2347, 13, 27, 9, -1, -22 },
  { 2391, 7, 22, 13, 3, -22 },
  { 2411, 13, 27, 9, -2, -22 },
  { 2455, 15, 14, 15, 0, -22 },
  { 2482, 12, 3, 12, -3, 2 },
  { 2487, 7, 5, 10, 4, -24 },
  { 2492, 15, 17, 16, 1, -17 },
  { 2524, 15, 24, 16, 0, -24 },
  { 2569, 13, 17, 13, 1, -17 },
  { 2597, 16, 24, 16, 1, -24 },
  { 2645, 13, 17, 15, 1, -17 },
  { 2673, 16, 31, 10, -3, -24 },
  { 2735, 16, 24, 16, 0, -17 },
  { 2783, 15, 24, 16, 0, -24 },
  { 2828, 9, 24, 8, 0, -24 },
  { 2855, 13, 31, 8, -4, -24 },
  { 2906, 17, 24, 15, 0, -24 },
  { 2957, 10, 24, 8, 0, -24 },
  { 2987, 23, 17, 24, 0, -17 },
  { 3036, 15, 17, 16, 0, -17 },
  { 3068, 14, 17, 16, 1, -17 },
  { 3098, 17, 24, 16, -2, -17 },
  { 3149, 15, 24, 16, 1, -17 },
  { 3194, 13, 17, 11, 0, -17 },
  { 3222, 13, 17, 13, 0, -17 },
  { 3250, 11, 21, 11, 1, -21 },
  { 3279, 15, 17, 16, 1, -17 },
  { 3311, 14, 17, 14, 2, -17 },
  { 3341, 21, 17, 21, 2, -17 },
  { 3386, 18, 17, 14, -2, -17 },
  { 3425, 18, 24, 14, -2, -17 },
  { 3479, 14, 17, 12, -1, -17 },
  { 3509, 13, 27, 11, 0, -22 },
  { 3553, 4, 31, 13, 5, -24 },
  { 3569, 13, 27, 11, -2, -22 },
  { 3613, 14, 6, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC31PT7B_H_
