#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC62PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00,
  0x3F, 0xE3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFE,
  0x7F, 0xC3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFE,
  0xF7, 0xE0, 0x1F, 0xF3, 0x83, 0x80, 0x7F, 0x8E, 0x04, 0x01, 0xFE, 0x38,
  0x00, 0x07, 0xF9, 0xE0, 0x00, 0x1F, 0xF7, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF7, 0xFC, 0x00, 0x03, 0x9F,
  0xF0, 0x00, 0x0E, 0x7F, 0xC1, 0x00, 0x39, 0xFF, 0x06, 0x00, 0xE7, 0xFC,
  0x1E, 0x07, 0x9F, 0xF0, 0x7F, 0x1D, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0,
  0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xEF,
  0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xC7, 0xF0,
  0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC,
  0x7F, 0x1F, 0xFC, 0xFE, 0x3F, 0xCF, 0xE3, 0xFF, 0xE7, 0xF7, 0xF9, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xFF, 0xF7, 0xFF, 0xF3, 0xF8, 0xFF,
  0xFF, 0x3F, 0xFE, 0x3F, 0x9F, 0xE7, 0xF3, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xF8, 0xFF, 0x3F, 0xC7, 0xF0, 0x7E, 0x0F, 0xE3, 0xF8, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x1F,
  0xE0, 0x03, 0xF8, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x3F, 0xC0,
  0x07, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xE0, 0x7F, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF,
  0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xE7, 0xFE, 0xFF, 0xC3,
  0xFF, 0x3F, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xE7,
  0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0x03, 0xFC, 0x00,
  0xF0, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0xE7, 0xFF, 0xF7,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFB, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0x87, 0xFC, 0x01, 0xC0,
  0xFE, 0x00, 0x30, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x0F, 0x87, 0xF9, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x1F,
  0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03,
  0xFF, 0x3F, 0xE0, 0x3F, 0xF7, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xE7,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x07, 0xFE, 0xFF, 0xC0,
  0x7F, 0xEF, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC,
  0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF,
  0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0xFD, 0xFF, 0x1F, 0xF3, 0xFE, 0x1F, 0xCF, 0xFC, 0x1F, 0x1F,
  0xF0, 0x1C, 0x3F, 0xE0, 0x20, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xCF, 0xFF, 0x00, 0x7F,
  0x07, 0xFF, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x38, 0x03, 0xFF, 0x00, 0x10,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFE, 0x1F, 0xFC, 0x01, 0xC0, 0x3F, 0xF0,
  0x04, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x7F,
  0xF0, 0xE0, 0x03, 0xFF, 0xC3, 0xFC, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0xFE, 0x3F,
  0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x07, 0xF1, 0xFF, 0x00, 0x1F, 0xC3, 0xFE,
  0x00, 0x3F, 0x87, 0xFC, 0x00, 0xFE, 0x1F, 0xF8, 0x03, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFB, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x82, 0x00, 0x07,
  0xFE, 0x08, 0x00, 0x3F, 0xF8, 0x38, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x10, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x7F,
  0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x0F, 0xFE, 0x07, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x03, 0xFF, 0x0F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x80,
  0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x1F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F,
  0xC0, 0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80,
  0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x07, 0xFF,
  0x0F, 0xFC, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xF8, 0x0F, 0xFE,
  0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00, 0x7C, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x78, 0x7F,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0xFE, 0x01,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0x83, 0xFF,
  0x1E, 0x03, 0xFF, 0x08, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x7F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE1, 0xF8,
  0x7F, 0x07, 0xFF, 0xFC, 0x3F, 0x1F, 0xC1, 0xFF, 0xFF, 0x87, 0xE3, 0xF0,
  0x7F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0x9F, 0xC3, 0xF8,
  0x3F, 0x83, 0xF3, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0xFE, 0x1F, 0xC0, 0xFC,
  0x0F, 0xDF, 0xC3, 0xF8, 0x1F, 0x83, 0xFB, 0xF0, 0x7E, 0x07, 0xF0, 0x7E,
  0x7E, 0x1F, 0xC0, 0xFE, 0x0F, 0xDF, 0xC3, 0xF8, 0x1F, 0x81, 0xFB, 0xF8,
  0x7E, 0x07, 0xF0, 0x7F, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xCF, 0xC1, 0xF8,
  0x1F, 0xC1, 0xF9, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x3F, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0xC3, 0xF0, 0xFC, 0x1F, 0xCF, 0xFD, 0xFE,
  0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7E,
  0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xE0, 0x7F, 0xC7, 0xFE, 0x01, 0xFC, 0x07,
  0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x1F, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE,
  0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0x80, 0x70, 0x07, 0xFF, 0x00,
  0x10, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x02, 0x00, 0xFF, 0xF0, 0x1E, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFE, 0x07, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0x80, 0x7F,
  0xF8, 0x00, 0x40, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x04, 0x7F, 0xE0, 0x7F, 0xFE, 0x1F, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xC0,
  0xFF, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x40,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x03, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x00, 0x3F, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFE, 0xFF, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x00,
  0xFF, 0xBF, 0xC3, 0xFD, 0xFF, 0x00, 0x7F, 0xDF, 0xE1, 0xFE, 0xFF, 0x80,
  0x3F, 0xEF, 0xF0, 0xFE, 0x7F, 0xC0, 0x1F, 0xF7, 0xF8, 0xFF, 0x3F, 0xE0,
  0x0F, 0xF3, 0xFC, 0x7F, 0x3F, 0xE0, 0x0F, 0xF9, 0xFE, 0x7F, 0x9F, 0xF0,
  0x07, 0xFC, 0xFF, 0x3F, 0x8F, 0xF8, 0x03, 0xFE, 0x7F, 0xBF, 0xC7, 0xFC,
  0x01, 0xFE, 0x3F, 0xDF, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xFF, 0xE3, 0xFE,
  0x00, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0xF0, 0xFF,
  0x80, 0x3F, 0xE3, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFE, 0x07,
  0xFC, 0x01, 0xFE, 0x07, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x03, 0xFD, 0xFF, 0x07, 0xFC,
  0x01, 0xFE, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x3F, 0xC3, 0xFE, 0x00, 0xFF,
  0x9F, 0xF1, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0xFF, 0x80, 0x3F, 0xE7, 0xFC,
  0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0,
  0x0F, 0xF8, 0x7F, 0xDF, 0xF0, 0x07, 0xFC, 0x3F, 0xEF, 0xF8, 0x03, 0xFE,
  0x1F, 0xF7, 0xFC, 0x01, 0xFE, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0B, 0x40, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE7,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x07,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0x80, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x01, 0x00, 0x07, 0xFE, 0x03, 0x80, 0x1F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F,
  0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80,
  0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xDF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xE7, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF1, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFD, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF1, 0xFE, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x7F,
  0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0x3F, 0x8F, 0xF8, 0x03, 0xFE, 0x7F, 0x9F,
  0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xCF, 0xE7, 0xFC, 0x00, 0xFF, 0xBF, 0xC7,
  0xF3, 0xFE, 0x00, 0x7F, 0xDF, 0xE3, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xE1,
  0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xF8,
  0xFF, 0xFF, 0x80, 0x07, 0xFB, 0xF8, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x87, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07,
  0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x00, 0xFF,
  0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE,
  0x07, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF,
  0xCF, 0xF8, 0x07, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0x80, 0x3F, 0xFE, 0xFF, 0x00, 0x3F, 0xF9,
  0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x7F, 0xBF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x8F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xC0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x1F, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0xFE, 0x03, 0xFC,
  0x7F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFE, 0x1C, 0x0F, 0xFC, 0x02, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x08, 0x3F, 0xF0, 0x18, 0x1F, 0xFC,
  0x7C, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x06, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF3, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07,
  0xFC, 0xFF, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF,
  0x81, 0xFF, 0x9F, 0xF0, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x10, 0x7F, 0xE0,
  0x1E, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x88, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x21, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x07, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xDF, 0xE0, 0x07, 0xFF,
  0xEF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x08, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0xC0, 0x03, 0xFF, 0x00, 0x78, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x1F, 0xF7, 0xFF, 0x00, 0x7F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xDF, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0,
  0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x21, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x3F,
  0xF0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF7,
  0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xC7, 0xFF, 0x0F,
  0xFF, 0x00, 0x7F, 0x3F, 0xFE, 0x7F, 0xFC, 0x03, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0x9F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF0,
  0xFF, 0x80, 0x1F, 0xC7, 0xFF, 0x00, 0x7F, 0x3F, 0xFE, 0x03, 0xFD, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xDF, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0x9F, 0xF8, 0x1F, 0xF3, 0xFE,
  0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x3F, 0xF7,
  0xFC, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xF3, 0xFE, 0x0F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE3, 0xFF, 0x80, 0x07, 0xF3, 0xFF,
  0xC0, 0x07, 0xFB, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0x80, 0x7F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF, 0xC0,
  0x0F, 0xF9, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x0E, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0xC7, 0xF8, 0x07,
  0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x01,
  0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x0E, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F,
  0x9F, 0xF0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x80,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0x0E, 0x07, 0xFC, 0x02, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x40, 0x07, 0xFE,
  0x30, 0x03, 0xFF, 0x1F, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x60, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x70, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC3,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF,
  0x81, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xEF,
  0xE0, 0x1F, 0xFF, 0x3F, 0x80, 0x3F, 0xF8, 0xFE, 0x00, 0x7F, 0xC3, 0xF8,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFE,
  0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xF8,
  0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF9, 0xFF,
  0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x07,
  0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFB, 0xFE, 0x0F, 0xFF, 0x03,
  0xFE, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0x3F, 0xC0, 0xFF, 0xF0, 0x7F, 0xCF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xE3, 0xFC, 0x1F, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFE, 0x3F, 0xC3, 0xFF, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0xF8,
  0x7F, 0xC3, 0xFC, 0x7F, 0x7E, 0x1F, 0xE0, 0xFF, 0x1F, 0xFF, 0x8F, 0xF8,
  0x3F, 0xC7, 0xEF, 0xE3, 0xFC, 0x0F, 0xF3, 0xFB, 0xF9, 0xFF, 0x03, 0xFC,
  0xFE, 0xFE, 0x7F, 0xC0, 0xFF, 0x7F, 0x3F, 0x9F, 0xE0, 0x3F, 0xDF, 0xCF,
  0xEF, 0xF8, 0x0F, 0xF7, 0xF3, 0xFB, 0xFC, 0x03, 0xFF, 0xF8, 0xFE, 0xFF,
  0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xF0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF,
  0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x83, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x2F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xD0, 0x00, 0x7F, 0xF2, 0x00, 0x00, 0xA0, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 19, 45, 16, 0, -44 },
  { 108, 24, 16, 27, 6, -44 },
  { 156, 35, 44, 34, 0, -44 },
  { 349, 30, 51, 30, 1, -47 },
  { 541, 44, 46, 49, 3, -45 },
  { 794, 37, 46, 37, 0, -45 },
  { 1007, 11, 16, 15, 6, -44 },
  { 1029, 22, 55, 19, 1, -45 },
  { 1181, 22, 55, 19, -5, -45 },
  { 1333, 26, 29, 29, 5, -48 },
  { 1428, 27, 30, 32, 3, -37 },
  { 1530, 15, 16, 16, -3, -8 },
  { 1560, 17, 9, 19, 1, -21 },
  { 1580, 11, 11, 16, 0, -10 },
  { 1596, 33, 46, 25, -3, -45 },
  { 1786, 28, 46, 30, 2, -45 },
  { 1947, 23, 44, 30, 6, -44 },
  { 2074, 32, 45, 30, -2, -45 },
  { 2254, 30, 46, 30, 0, -45 },
  { 2427, 31, 44, 30, -1, -44 },
  { 2598, 30, 45, 30, 1, -44 },
  { 2767, 30, 46, 30, 2, -45 },
  { 2940, 31, 44, 30, 2, -44 },
  { 3111, 30, 46, 30, 1, -45 },
  { 3284, 29, 46, 30, 1, -45 },
  { 3451, 16, 36, 16, 0, -35 },
  { 3523, 20, 43, 16, -4, -35 },
  { 3631, 27, 31, 32, 3, -38 },
  { 3736, 27, 20, 32, 3, -32 },
  { 3804, 27, 31, 32, 3, -38 },
  { 3909, 24, 46, 24, 3, -45 },
  { 4047, 43, 50, 46, 2, -45 },
  { 4316, 34, 44, 34, -4, -44 },
  { 4503, 33, 44, 33, 0, -44 },
  { 4685, 32, 46, 31, 3, -45 },
  { 4869, 35, 44, 36, 0, -44 },
  { 5062, 31, 44, 28, 0, -44 },
  { 5233, 31, 44, 27, 0, -44 },
  { 5404, 34, 46, 36, 3, -45 },
  { 5600, 39, 44, 37, 0, -44 },
  { 5815, 29, 44, 22, -2, -44 },
  { 5975, 30, 57, 18, -10, -44 },
  { 6189, 39, 44, 33, 0, -44 },
  { 6404, 23, 44, 27, 0, -44 },
  { 6531, 49, 44, 48, 0, -44 },
  { 6801, 41, 44, 40, 0, -44 },
  { 7027, 34, 46, 38, 3, -45 },
  { 7223, 33, 44, 32, 0, -44 },
  { 7405, 34, 56, 38, 3, -45 },
  { 7643, 33, 44, 33, 0, -44 },
  { 7825, 31, 46, 28, 0, -45 },
  { 8004, 27, 44, 28, 5, -44 },
  { 8153, 35, 45, 36, 3, -44 },
  { 8350, 32, 44, 32, 6, -44 },
  { 8526, 49, 44, 48, 5, -44 },
  { 8796, 41, 44, 32, -4, -44 },
  { 9022, 30, 44, 31, 6, -44 },
  { 9187, 34, 44, 28, -2, -44 },
  { 9374, 25, 55, 19, -2, -45 },
  { 9546, 15, 46, 25, 6, -45 },
  { 9633, 25, 55, 19, -4, -45 },
  { 9805, 29, 28, 30, 0, -44 },
  { 9907, 25, 5, 23, -6, 5 },
  { 9923, 13, 9, 20, 9, -47 },
  { 9938, 31, 36, 32, 1, -35 },
  { 10078, 30, 48, 32, 0, -47 },
  { 10258, 25, 36, 26, 2, -35 },
  { 10371, 34, 48, 32, 1, -47 },
  { 10575, 27, 36, 30, 2, -35 },
  { 10697, 34, 62, 20, -7, -47 },
  { 10961, 33, 50, 32, -1, -35 },
  { 11168, 30, 47, 32, 0, -47 },
  { 11345, 19, 48, 16, 0, -48 },
  { 11459, 27, 63, 16, -8, -48 },
  { 11672, 34, 47, 31, 0, -47 },
  { 11872, 19, 47, 16, 0, -47 },
  { 11984, 46, 35, 47, 0, -35 },
  { 12186, 30, 35, 32, 0, -35 },
  { 12318, 27, 36, 31, 2, -35 },
  { 12440, 33, 50, 32, -3, -35 },
  { 12647, 31, 50, 32, 1, -35 },
  { 12841, 25, 35, 23, 0, -35 },
  { 12951, 25, 36, 25, 0, -35 },
  { 13064, 20, 42, 22, 3, -41 },
  { 13169, 30, 35, 32, 2, -34 },
  { 13301, 28, 34, 28, 4, -34 },
  { 13420, 42, 34, 43, 4, -34 },
  { 13599, 35, 34, 29, -3, -34 },
  { 13748, 36, 49, 28, -4, -34 },
  { 13969, 28, 34, 25, -2, -34 },
  { 14088, 26, 54, 21, 0, -44 },
  { 14264, 8, 61, 27, 9, -47 },
  { 14325, 25, 54, 21, -4, -44 },
  { 14494, 27, 11, 32, 3, -27 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC62PT7B_H_
