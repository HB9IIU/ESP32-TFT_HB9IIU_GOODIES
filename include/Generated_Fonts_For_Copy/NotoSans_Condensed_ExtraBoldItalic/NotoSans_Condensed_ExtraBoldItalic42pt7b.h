#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC42PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3E, 0x00, 0x40, 0x00, 0x7F, 0x3F, 0x7E, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8,
  0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x03,
  0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xDF, 0xC1, 0xFB, 0x8C, 0x1F, 0xB8, 0x01,
  0xFB, 0x00, 0x1F, 0xB0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xDF,
  0x80, 0x0D, 0xF8, 0x80, 0xDF, 0x8C, 0x1D, 0xF8, 0xF1, 0xDF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x3F, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x03, 0xE0,
  0x3E, 0x7C, 0x1F, 0x00, 0xF1, 0xF0, 0xF8, 0x07, 0xC7, 0xC3, 0xE0, 0x1F,
  0x1F, 0x1F, 0x00, 0x78, 0x78, 0x78, 0x03, 0xE3, 0xE3, 0xE0, 0x0F, 0x8F,
  0x9F, 0x00, 0x3E, 0x3E, 0x7C, 0x00, 0xF9, 0xF3, 0xE3, 0xF3, 0xE7, 0xCF,
  0x3F, 0xEF, 0xFE, 0x7C, 0xFF, 0x9F, 0xFB, 0xE7, 0xFF, 0x7F, 0xCF, 0xBE,
  0x7C, 0xFE, 0x7C, 0xF9, 0xF0, 0x01, 0xE3, 0xC7, 0xC0, 0x0F, 0x9F, 0x1F,
  0x00, 0x7C, 0x7C, 0x7C, 0x01, 0xF1, 0xF1, 0xF0, 0x0F, 0x87, 0xC7, 0x80,
  0x7C, 0x1E, 0x3E, 0x01, 0xF0, 0x78, 0xF8, 0x0F, 0x81, 0xE7, 0xC0, 0x3E,
  0x07, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x3F, 0xC0, 0x3E, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x7E, 0x1F, 0xFC, 0x7F, 0x1F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF, 0x8F, 0xCF,
  0xFF, 0x8F, 0xC7, 0xFF, 0xC7, 0xE1, 0xFF, 0xC7, 0xF0, 0xFF, 0xE3, 0xF8,
  0x3F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0xC0, 0xFF, 0x8F, 0xF0,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF8, 0x00,
  0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x87, 0xC0, 0x31, 0xF0, 0x1F, 0x7C, 0x17, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xC0,
  0x1F, 0xF8, 0x0F, 0xDF, 0x07, 0xE7, 0xC0, 0xF9, 0xF8, 0x1C, 0x3E, 0x02,
  0x0E, 0x00, 0x02, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E,
  0x1F, 0x0F, 0x83, 0xE0, 0x3F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xEF,
  0xFE, 0x1C, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xE7, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF7,
  0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xDF,
  0xC1, 0xFB, 0xF8, 0x7F, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F,
  0x0F, 0xC7, 0xE3, 0xF8, 0xFE, 0x7E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xFE, 0xFD,
  0xFB, 0xF1, 0xE7, 0xE1, 0x8F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xF1, 0xFC, 0x0F, 0x0F, 0xE0, 0x20,
  0x3F, 0x01, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x38, 0x7F, 0x02, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC8, 0x03, 0xFC, 0xE0,
  0x7F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xBF, 0x00, 0x7F, 0xF0, 0x07, 0xDF, 0x80, 0x7C, 0xFC,
  0x03, 0xC7, 0xE0, 0x3E, 0x7E, 0x03, 0xE3, 0xF0, 0x3E, 0x1F, 0x81, 0xF0,
  0xFC, 0x1F, 0x0F, 0xE0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x04, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x10, 0x07, 0xF0,
  0xF0, 0x7F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x8E, 0x03, 0xF7, 0xF0, 0x3F, 0xFF,
  0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0,
  0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE,
  0x1F, 0x8F, 0xE3, 0xF8, 0x7E, 0x7F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x7F, 0x1F, 0x81, 0xF9, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xE7, 0xF0, 0xFE, 0x1F, 0x87, 0xE0,
  0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0x9F, 0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x07, 0xE7, 0xE0,
  0xFC, 0xFC, 0x1F, 0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x3F, 0xDF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFD, 0xF8, 0x7F, 0x7E, 0x03, 0x8F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x81, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x00, 0x80, 0x01, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFE, 0x7F, 0xFE,
  0x3F, 0xFF, 0x3F, 0xFF, 0x3C, 0x7F, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x10, 0x1E,
  0x0F, 0x87, 0xFC, 0x78, 0x7C, 0x3F, 0xF9, 0xF1, 0xE1, 0xFF, 0xC7, 0xCF,
  0x8F, 0x8F, 0x1F, 0x3C, 0x7C, 0x3C, 0x7D, 0xF1, 0xF1, 0xF1, 0xE7, 0x8F,
  0x87, 0xC7, 0x9E, 0x3E, 0x1E, 0x1E, 0x78, 0xF0, 0x78, 0x79, 0xE3, 0xC3,
  0xE3, 0xCF, 0x8F, 0x0F, 0x8F, 0x3E, 0x7C, 0x3C, 0x7C, 0xF1, 0xF1, 0xF1,
  0xE3, 0xC3, 0xEF, 0xCF, 0x8F, 0x0F, 0xFF, 0xFC, 0x3E, 0x3F, 0xDF, 0xE0,
  0xF8, 0x7E, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C,
  0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07,
  0xF0, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00,
  0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F,
  0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xF8, 0x7F, 0x1F,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xE3, 0x81, 0xFE, 0x02, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x40, 0xFF, 0x0F,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF1, 0xFE,
  0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0x07, 0xF8,
  0x3F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFF, 0x0F, 0x07, 0xFC, 0x02, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC3, 0xFF, 0x3F, 0x87, 0xFE, 0x7F, 0x0F, 0xFC, 0xFE, 0x1F, 0xF9,
  0xFC, 0x7F, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFF, 0x8F, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x06, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07,
  0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7F, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE,
  0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xE1, 0xF7, 0xE0, 0x7D, 0xF0, 0xFB, 0xF0, 0x7E, 0xF8, 0xFB,
  0xF0, 0x3F, 0x7C, 0x7D, 0xF8, 0x1F, 0xBE, 0x7C, 0xFC, 0x0F, 0xDF, 0x3E,
  0x7E, 0x07, 0xEF, 0xBE, 0x7F, 0x07, 0xE7, 0xDF, 0x3F, 0x03, 0xF3, 0xFF,
  0x9F, 0x81, 0xF9, 0xFF, 0x8F, 0xC0, 0xFC, 0xFF, 0xC7, 0xE0, 0x7C, 0x7F,
  0xC7, 0xE0, 0x7E, 0x1F, 0xE3, 0xF0, 0x3F, 0x0F, 0xE1, 0xF8, 0x1F, 0x87,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE0,
  0xF8, 0x3F, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC,
  0x03, 0xE0, 0x3F, 0xC0, 0x7E, 0x03, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7E,
  0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0xFC, 0x07, 0xFF, 0x0F, 0xC0, 0xFF,
  0xF0, 0xFC, 0x0F, 0xFF, 0x0F, 0xC0, 0xFF, 0xF0, 0xFC, 0x0F, 0xDF, 0x1F,
  0x80, 0xF9, 0xF9, 0xF8, 0x1F, 0x9F, 0x9F, 0x81, 0xF9, 0xF9, 0xF8, 0x1F,
  0x8F, 0x9F, 0x01, 0xF8, 0xFF, 0xF0, 0x1F, 0x8F, 0xFF, 0x03, 0xF0, 0xFF,
  0xF0, 0x3F, 0x0F, 0xFF, 0x03, 0xF0, 0x7F, 0xE0, 0x3F, 0x07, 0xFE, 0x03,
  0xE0, 0x7F, 0xE0, 0x7E, 0x07, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x7E, 0x03,
  0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFE, 0x3F, 0xC7, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F,
  0x9F, 0xC0, 0x7F, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF8, 0xFF, 0x9F, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x3F, 0xC7,
  0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07,
  0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x81, 0xFC,
  0x7F, 0x07, 0xF8, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x1F,
  0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xE7, 0xE0,
  0x3F, 0x9F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xF0, 0x7F,
  0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF8, 0xFE, 0x07,
  0xF3, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFD, 0xF0, 0x3F, 0x81, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC2, 0x00, 0xFE, 0x1C, 0x07, 0xF0, 0xFD, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xFC, 0x1F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x3F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE,
  0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFF,
  0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0,
  0x3F, 0xBF, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE,
  0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F,
  0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0xBF, 0x01, 0xF8, 0x1F,
  0xDF, 0x81, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x07,
  0xF3, 0xF0, 0x7F, 0x83, 0xF1, 0xF8, 0x3F, 0xC1, 0xF8, 0xFC, 0x3F, 0xE1,
  0xF8, 0x7E, 0x1F, 0xF0, 0xFC, 0x3F, 0x1F, 0xF8, 0xFE, 0x1F, 0x8F, 0xFC,
  0x7E, 0x0F, 0x87, 0xFE, 0x3F, 0x07, 0xC7, 0xFF, 0x3F, 0x03, 0xE3, 0xFF,
  0x9F, 0x81, 0xF3, 0xFF, 0x9F, 0xC1, 0xF9, 0xF7, 0xCF, 0xC0, 0xFC, 0xFB,
  0xE7, 0xE0, 0x7E, 0xF9, 0xF7, 0xE0, 0x3F, 0x7C, 0xFB, 0xF0, 0x1F, 0xFE,
  0x7D, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF9,
  0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x00, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE0, 0xFC,
  0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xE3, 0xF0, 0x7E, 0x7E,
  0x07, 0xEF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x20, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFC,
  0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x07, 0xE7, 0xC0,
  0x7C, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7E, 0x1F, 0x03, 0xE3, 0xE0, 0x3E,
  0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x01, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0xFE, 0x3F, 0x1F, 0xC7, 0xE1, 0xF0, 0xFC,
  0x3E, 0x03, 0xF1, 0xF8, 0x3F, 0xCF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0xE7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07,
  0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xF3, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFD, 0xF0, 0x3F, 0xCF, 0x80, 0xFC,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x7E, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0x8F, 0xC3, 0xF8, 0x7F, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8,
  0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC7,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xF7, 0xF8, 0x1F,
  0x1F, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF,
  0xF1, 0xFE, 0x10, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x04, 0x7F, 0x0E, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0xBF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x0F,
  0xC3, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFD, 0xF0, 0x0F, 0xC7, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0xFC, 0x7F, 0x0F, 0xCF, 0xC1, 0xF3,
  0xF8, 0x7E, 0x7E, 0x1F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x43, 0xFE, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x80, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x88, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x08, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x03, 0xFE, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x7F, 0x03, 0xF8, 0xFE, 0x07,
  0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC,
  0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83,
  0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x02, 0x00, 0xFE, 0x07, 0x83, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0xFE, 0x0F, 0xDF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xE3, 0xF1, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F,
  0x83, 0xF1, 0xF8, 0x7F, 0x3F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xC1, 0xF8, 0x01, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x9F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F,
  0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x3F,
  0x00, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0x07, 0xCF, 0xE1, 0xF8, 0x1F, 0xBF, 0xCF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x7F, 0x9F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xF8, 0x7F, 0x1F, 0x83, 0xF0, 0xFC,
  0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x3F,
  0x87, 0xE0, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x87, 0xF1, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x3F, 0x1F, 0x83,
  0xF0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xCF, 0xE0, 0xFD, 0xFE,
  0x0F, 0xBF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x1F, 0xC3,
  0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x87, 0xF3, 0xF8,
  0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x7F,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x1F, 0xCF,
  0xC1, 0xF8, 0xFC, 0x1F, 0x80, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xE3, 0xF9, 0xFC, 0x3F,
  0x7F, 0x07, 0xEF, 0xE0, 0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0xDF, 0x83, 0xF3,
  0xF8, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0x80, 0x01, 0xF3, 0xF0, 0x0F, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xE3, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F,
  0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x7F, 0xC0,
  0xFD, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xF8,
  0x3F, 0xEF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC7,
  0xF0, 0xFE, 0x3F, 0x87, 0xE0, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x7F,
  0x1F, 0x83, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0x80, 0xFC, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xCF, 0x87, 0xEF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xFD, 0xF0,
  0xFC, 0x10, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x80,
  0xFE, 0x60, 0x7F, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x81,
  0xFF, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC2, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x3F, 0x87,
  0xF3, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xEF,
  0x80, 0xFE, 0x7C, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x7E, 0x0F, 0xC7,
  0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x3F, 0x83, 0xFF, 0xC3, 0xF8, 0x7F, 0xF8, 0x7F, 0x87,
  0xEF, 0x87, 0xF8, 0x7E, 0xF8, 0x7F, 0x8F, 0xCF, 0x8F, 0xF8, 0xFC, 0xF8,
  0xFF, 0x8F, 0xCF, 0x9F, 0xF9, 0xF8, 0xF9, 0xFF, 0x9F, 0x8F, 0x9E, 0xFB,
  0xF0, 0xFB, 0xEF, 0xBF, 0x0F, 0xBE, 0xFB, 0xE0, 0xFB, 0xCF, 0xFE, 0x0F,
  0xFC, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x03, 0xF1, 0xFC, 0x03, 0xF3, 0xF8, 0x03,
  0xF3, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0x9F, 0xC0, 0x3F, 0x8F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x09, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x05, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x01, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x2F,
  0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE0,
  0x3F, 0xF4, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 31, 11, 0, -30 },
  { 52, 16, 11, 18, 4, -30 },
  { 74, 24, 30, 23, 0, -30 },
  { 164, 20, 34, 20, 1, -32 },
  { 249, 30, 30, 33, 2, -30 },
  { 362, 25, 30, 25, 0, -30 },
  { 456, 8, 11, 10, 4, -30 },
  { 467, 15, 37, 13, 1, -30 },
  { 537, 15, 38, 13, -3, -31 },
  { 609, 18, 19, 19, 3, -32 },
  { 652, 18, 20, 21, 2, -25 },
  { 697, 10, 12, 11, -2, -6 },
  { 712, 12, 6, 13, 0, -14 },
  { 721, 7, 8, 11, 0, -7 },
  { 728, 22, 30, 17, -2, -30 },
  { 811, 19, 30, 20, 1, -30 },
  { 883, 15, 30, 20, 4, -30 },
  { 940, 21, 30, 20, -1, -30 },
  { 1019, 20, 30, 20, 0, -30 },
  { 1094, 21, 30, 20, 0, -30 },
  { 1173, 21, 30, 20, 0, -30 },
  { 1252, 20, 30, 20, 1, -30 },
  { 1327, 22, 30, 20, 1, -30 },
  { 1410, 21, 30, 20, 0, -30 },
  { 1489, 19, 30, 20, 1, -30 },
  { 1561, 11, 24, 11, 0, -23 },
  { 1594, 13, 29, 11, -2, -23 },
  { 1642, 18, 21, 21, 2, -26 },
  { 1690, 18, 14, 21, 2, -22 },
  { 1722, 18, 21, 21, 2, -26 },
  { 1770, 16, 30, 16, 2, -30 },
  { 1830, 30, 33, 31, 1, -30 },
  { 1954, 23, 30, 23, -3, -30 },
  { 2041, 23, 30, 22, 0, -30 },
  { 2128, 22, 30, 21, 2, -30 },
  { 2211, 24, 30, 24, 0, -30 },
  { 2301, 21, 30, 19, 0, -30 },
  { 2380, 21, 30, 19, 0, -30 },
  { 2459, 23, 30, 25, 2, -30 },
  { 2546, 26, 30, 25, 0, -30 },
  { 2644, 20, 30, 15, -2, -30 },
  { 2719, 20, 39, 12, -7, -30 },
  { 2817, 26, 30, 22, 0, -30 },
  { 2915, 16, 30, 18, 0, -30 },
  { 2975, 33, 30, 32, 0, -30 },
  { 3099, 28, 30, 27, 0, -30 },
  { 3204, 23, 30, 26, 2, -30 },
  { 3291, 23, 30, 22, 0, -30 },
  { 3378, 23, 37, 26, 2, -30 },
  { 3485, 22, 30, 22, 0, -30 },
  { 3568, 21, 30, 19, 0, -30 },
  { 3647, 19, 30, 19, 3, -30 },
  { 3719, 24, 30, 24, 2, -30 },
  { 3809, 22, 30, 22, 4, -30 },
  { 3892, 33, 30, 33, 3, -30 },
  { 4016, 27, 30, 22, -2, -30 },
  { 4118, 20, 30, 21, 4, -30 },
  { 4193, 24, 30, 19, -2, -30 },
  { 4283, 18, 37, 13, -2, -30 },
  { 4367, 10, 30, 17, 4, -30 },
  { 4405, 17, 37, 13, -3, -30 },
  { 4484, 20, 19, 20, 0, -30 },
  { 4532, 17, 4, 16, -4, 3 },
  { 4541, 9, 7, 13, 6, -32 },
  { 4549, 21, 23, 21, 1, -23 },
  { 4610, 21, 32, 21, 0, -32 },
  { 4694, 17, 23, 17, 1, -23 },
  { 4743, 22, 32, 21, 1, -32 },
  { 4831, 19, 23, 20, 1, -23 },
  { 4886, 23, 42, 14, -5, -32 },
  { 5007, 23, 33, 22, -1, -23 },
  { 5102, 20, 32, 22, 0, -32 },
  { 5182, 13, 32, 11, 0, -32 },
  { 5234, 18, 42, 11, -5, -32 },
  { 5329, 23, 32, 21, 0, -32 },
  { 5421, 13, 32, 11, 0, -32 },
  { 5473, 31, 23, 32, 0, -23 },
  { 5563, 20, 23, 22, 0, -23 },
  { 5621, 19, 24, 21, 1, -24 },
  { 5678, 22, 33, 21, -2, -23 },
  { 5769, 21, 33, 21, 1, -23 },
  { 5856, 17, 23, 15, 0, -23 },
  { 5905, 17, 23, 17, 0, -23 },
  { 5954, 14, 28, 15, 2, -28 },
  { 6003, 21, 23, 22, 1, -23 },
  { 6064, 20, 23, 19, 2, -23 },
  { 6122, 28, 23, 29, 3, -23 },
  { 6203, 24, 23, 20, -2, -23 },
  { 6272, 25, 33, 19, -3, -23 },
  { 6376, 19, 23, 17, -1, -23 },
  { 6431, 18, 37, 15, 0, -30 },
  { 6515, 6, 42, 18, 6, -32 },
  { 6547, 16, 37, 15, -2, -30 },
  { 6621, 19, 8, 21, 2, -19 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC42PT7B_H_
