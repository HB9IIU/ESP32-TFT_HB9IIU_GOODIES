#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC17PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x39, 0xCC, 0x03, 0x39, 0xC0, 0xFF, 0x7D, 0xB6,
  0x0D, 0x83, 0x61, 0x91, 0xFF, 0x7F, 0x84, 0x83, 0x63, 0xFE, 0xFF, 0x1B,
  0x06, 0xC1, 0xB0, 0x04, 0x0E, 0x3F, 0x3F, 0x38, 0x38, 0x3C, 0x1E, 0x0E,
  0x96, 0xFE, 0xFC, 0x10, 0x30, 0x78, 0xE7, 0x8C, 0xD9, 0x8D, 0xB0, 0xDB,
  0x0F, 0xEF, 0xF7, 0xB0, 0xDB, 0x19, 0xB1, 0x93, 0x31, 0xE7, 0x1C, 0x1F,
  0x07, 0xC3, 0xB0, 0xEC, 0x1E, 0x07, 0x37, 0xDD, 0xBE, 0xEF, 0xB9, 0xCF,
  0xF1, 0xFE, 0xFB, 0x60, 0x0C, 0x63, 0x8C, 0x71, 0x86, 0x18, 0xE3, 0x8E,
  0x38, 0xE1, 0x86, 0x00, 0x18, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0x63,
  0x0C, 0x61, 0x8C, 0x00, 0x1C, 0xB1, 0xEF, 0xF3, 0xAF, 0x9B, 0x04, 0x38,
  0x70, 0xE7, 0xFF, 0xE7, 0x0E, 0x1C, 0x77, 0x6E, 0x7F, 0xFC, 0x7F, 0x80,
  0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x30, 0x18, 0x18,
  0x1C, 0x00, 0x1E, 0x3F, 0x33, 0x73, 0x73, 0x67, 0x67, 0x67, 0xE6, 0xEE,
  0x7C, 0x78, 0x1C, 0xFF, 0xB6, 0xB8, 0xE3, 0x0C, 0x71, 0xC7, 0x18, 0x0F,
  0x0F, 0xC4, 0xE0, 0x70, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x1F, 0xDF,
  0xC0, 0x3F, 0x3F, 0x23, 0x07, 0x0E, 0x3C, 0x3E, 0x06, 0x06, 0x8E, 0xFE,
  0xF8, 0x07, 0x07, 0x0F, 0x1F, 0x36, 0x36, 0x6E, 0xFF, 0xFF, 0xFE, 0x0C,
  0x1C, 0x1F, 0x3F, 0x38, 0x30, 0x3C, 0x7E, 0x2E, 0x06, 0x06, 0x8E, 0xFC,
  0xF8, 0x1F, 0x3E, 0x70, 0x60, 0xFC, 0xFE, 0xEE, 0xCE, 0xCE, 0xDC, 0xFC,
  0x78, 0x3F, 0x9F, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x38, 0x1C,
  0x1C, 0x1C, 0x00, 0x1F, 0x3F, 0x33, 0x33, 0x3F, 0x1C, 0x7E, 0x66, 0xE6,
  0xE6, 0xFE, 0x7C, 0x1E, 0x3F, 0x73, 0x73, 0x77, 0x77, 0x7F, 0x36, 0x0E,
  0x0C, 0xFC, 0xF8, 0x37, 0x20, 0x00, 0x6E, 0xE0, 0x18, 0xC4, 0x00, 0x00,
  0x0E, 0x63, 0x38, 0x06, 0x3D, 0xF7, 0x8F, 0x07, 0x83, 0x81, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0xC1, 0xE1, 0xF0, 0xF1, 0xEF, 0x38, 0x40, 0xFD,
  0xF4, 0xC3, 0x18, 0xC6, 0x18, 0x01, 0x0E, 0x30, 0x07, 0xE1, 0xC7, 0x38,
  0x33, 0x7D, 0x66, 0x96, 0xD9, 0x49, 0xB5, 0x9B, 0xDB, 0xE4, 0xFC, 0x60,
  0x07, 0x08, 0x3F, 0x80, 0x07, 0x83, 0xC3, 0xE1, 0xB1, 0xD8, 0xCC, 0xE6,
  0x7F, 0x3F, 0xB8, 0xD8, 0x7C, 0x30, 0x1F, 0x1F, 0xCE, 0xE6, 0x73, 0x3B,
  0xF1, 0xFC, 0xE6, 0x63, 0x33, 0xBF, 0x9F, 0x80, 0x1F, 0x9F, 0x9C, 0x4E,
  0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x72, 0x3F, 0x0F, 0x80, 0x1F, 0x0F,
  0xE3, 0xB8, 0xC7, 0x31, 0xDC, 0x67, 0x39, 0xCE, 0x63, 0x99, 0xCF, 0xE3,
  0xF0, 0x1F, 0x3F, 0x38, 0x30, 0x30, 0x7E, 0x7E, 0x70, 0x60, 0x60, 0xFC,
  0xFC, 0x1F, 0x3F, 0x38, 0x38, 0x30, 0x7E, 0x7E, 0x70, 0x60, 0x60, 0xE0,
  0xE0, 0x1F, 0x9F, 0xDC, 0x2E, 0x0E, 0x07, 0x7B, 0xBD, 0x8E, 0xE7, 0x73,
  0xBF, 0x8F, 0xC0, 0x18, 0xE7, 0x18, 0xE7, 0x1C, 0xE3, 0x1C, 0xFF, 0x1F,
  0xE3, 0x9C, 0x63, 0x8C, 0x73, 0x8C, 0x73, 0x80, 0x1F, 0x1E, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x7C, 0xFC, 0x03, 0x07, 0x07, 0x07,
  0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x78, 0xF8, 0xE0,
  0x19, 0xE7, 0x30, 0xEE, 0x1B, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x66,
  0x0C, 0xC3, 0x9C, 0x73, 0x80, 0x18, 0xE3, 0x8C, 0x31, 0xC7, 0x1C, 0x61,
  0x8F, 0xFF, 0x1C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3E, 0x3C, 0xF9, 0xF7,
  0xC7, 0xDB, 0x1B, 0x7C, 0x6F, 0x71, 0xBD, 0x8E, 0xE6, 0x3B, 0xB8, 0x1C,
  0x67, 0x8C, 0xF3, 0x9E, 0x73, 0xEC, 0xFD, 0x9D, 0xB3, 0x3E, 0x67, 0x8C,
  0xF3, 0x8E, 0x71, 0xC0, 0x1F, 0x1F, 0xDC, 0xEC, 0x7E, 0x3F, 0x1F, 0x8F,
  0x87, 0xC7, 0x73, 0xBF, 0x8F, 0x80, 0x1F, 0x1F, 0xCE, 0xE6, 0x73, 0x3B,
  0xBD, 0xFC, 0xF8, 0x60, 0x30, 0x38, 0x1C, 0x00, 0x1F, 0x1F, 0xDC, 0xEC,
  0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0x73, 0xBF, 0x8F, 0x81, 0xC0, 0x60,
  0x38, 0x1F, 0x1F, 0xCE, 0xE6, 0x73, 0x3B, 0xF9, 0xF8, 0xFC, 0x6E, 0x33,
  0x39, 0xDC, 0xE0, 0x1F, 0x3F, 0x31, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x0E,
  0x8E, 0xFC, 0xF8, 0x7F, 0xFF, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70,
  0x70, 0x60, 0xE0, 0x71, 0xB9, 0xDC, 0xEC, 0x76, 0x37, 0x1B, 0x9D, 0xCE,
  0xC7, 0x77, 0x3F, 0x8F, 0x80, 0xC7, 0xC7, 0xC6, 0xCE, 0xCC, 0xDC, 0xD8,
  0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0x63, 0x1F, 0x9C, 0x6E, 0x73, 0xB9, 0xCC,
  0xEF, 0x73, 0xBD, 0x8F, 0xB6, 0x3E, 0xF8, 0xFB, 0xC3, 0xCF, 0x0F, 0x38,
  0x38, 0xE0, 0x1C, 0xE3, 0xB8, 0x76, 0x07, 0xC0, 0xF0, 0x1C, 0x03, 0x80,
  0xF8, 0x3F, 0x06, 0xE1, 0xCC, 0x71, 0xC0, 0xC7, 0xCE, 0xCC, 0xFC, 0xF8,
  0x78, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0x1F, 0xC7, 0xE0, 0x38, 0x1C,
  0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0xF3, 0xF8, 0x1E, 0x3C,
  0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0F, 0x3C, 0x00,
  0xCC, 0xCC, 0xE6, 0x66, 0x66, 0x67, 0x1E, 0x38, 0x30, 0x60, 0xC3, 0x86,
  0x0C, 0x18, 0x70, 0xE1, 0x83, 0x1E, 0x3C, 0x00, 0x0C, 0x0E, 0x1E, 0x3E,
  0x36, 0x67, 0x63, 0xC3, 0x7F, 0xFC, 0xE7, 0x30, 0x08, 0x1F, 0xCF, 0xCE,
  0xE6, 0x73, 0x3B, 0x9D, 0xDC, 0x7E, 0x3B, 0x00, 0x18, 0x38, 0x38, 0x32,
  0x3F, 0x3F, 0x73, 0x73, 0x67, 0x67, 0xE6, 0xFE, 0xDC, 0x04, 0x7C, 0xFB,
  0x86, 0x0C, 0x38, 0x72, 0x7C, 0xF8, 0x01, 0xC0, 0x60, 0x38, 0x2E, 0x3F,
  0x8F, 0xC7, 0x71, 0x9C, 0x67, 0x39, 0x8E, 0x61, 0xF8, 0x76, 0x00, 0x1F,
  0x3F, 0x73, 0x7E, 0x7C, 0xE0, 0xE0, 0x7E, 0x7C, 0x03, 0x83, 0xC1, 0x81,
  0xC1, 0xF0, 0xF8, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0,
  0xC1, 0xE0, 0xE0, 0x00, 0x08, 0x1F, 0xCF, 0xCE, 0xE6, 0x73, 0x3B, 0x9D,
  0xDC, 0x7E, 0x3F, 0x03, 0x91, 0x8F, 0xC7, 0xC0, 0x18, 0x38, 0x38, 0x32,
  0x3F, 0x3F, 0x73, 0x73, 0x67, 0x67, 0xE6, 0xE6, 0xEE, 0x19, 0xC4, 0x03,
  0x19, 0xCE, 0x63, 0x19, 0xCE, 0x00, 0x06, 0x1C, 0x10, 0x10, 0xC1, 0x87,
  0x0E, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x78, 0xE0, 0x18, 0x1C, 0x0E,
  0x06, 0x03, 0x39, 0xB9, 0xF8, 0xF8, 0x7C, 0x3E, 0x3B, 0x9D, 0xCE, 0x60,
  0x19, 0xCE, 0x73, 0x19, 0xCE, 0x63, 0x39, 0xCE, 0x00, 0x02, 0x23, 0xFF,
  0x3F, 0xF7, 0x33, 0x77, 0x36, 0x73, 0x67, 0x7E, 0x67, 0xE6, 0x6E, 0xE6,
  0x02, 0x3F, 0x3F, 0x73, 0x73, 0x67, 0x67, 0x66, 0xE6, 0xEE, 0x04, 0x3E,
  0x3F, 0x73, 0x63, 0x67, 0xE7, 0xE6, 0x7E, 0x7C, 0x01, 0x0F, 0xC7, 0xE7,
  0x33, 0x99, 0x9C, 0xCE, 0xE6, 0x7F, 0x3F, 0x18, 0x0C, 0x0E, 0x07, 0x00,
  0x08, 0x1F, 0xCF, 0xCE, 0xE6, 0x73, 0x3B, 0x99, 0xCC, 0x7E, 0x3F, 0x03,
  0x81, 0x80, 0xC0, 0xE0, 0x02, 0x7C, 0xF3, 0x87, 0x0C, 0x18, 0x70, 0xE1,
  0xC0, 0x08, 0x7D, 0xD3, 0x87, 0x87, 0x87, 0x4E, 0xFD, 0xF0, 0x33, 0xBF,
  0xF6, 0x73, 0x98, 0xC7, 0xBC, 0x67, 0x66, 0xE6, 0xEE, 0xCE, 0xCE, 0xDC,
  0xFC, 0xEC, 0xC7, 0xCE, 0xCC, 0xDC, 0xF8, 0xD8, 0xF0, 0xF0, 0x60, 0xCE,
  0x7C, 0xEE, 0xDE, 0xCD, 0xEC, 0xD7, 0xCF, 0x78, 0xF7, 0x8E, 0x70, 0xE7,
  0x00, 0x3B, 0xC6, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0x61, 0xD8, 0xE7,
  0x00, 0x39, 0xCE, 0xE3, 0xB0, 0xFC, 0x3E, 0x0F, 0x81, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x83, 0xC0, 0xE0, 0x00, 0x3F, 0x3F, 0x0E, 0x0C, 0x1C, 0x38,
  0x70, 0x7E, 0xFC, 0x0E, 0x3C, 0x60, 0xC3, 0x87, 0x3C, 0x70, 0x70, 0xE1,
  0xC3, 0x07, 0x0E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x78,
  0x70, 0xE1, 0xC3, 0x07, 0x87, 0x3C, 0x70, 0xC1, 0x87, 0x1C, 0x30, 0x00,
  0x03, 0xFF, 0xFC, 0x20,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 12, 5, 0, -12 },
  { 9, 6, 4, 7, 2, -12 },
  { 12, 10, 12, 9, 0, -12 },
  { 27, 8, 14, 8, 0, -13 },
  { 41, 12, 12, 13, 1, -12 },
  { 59, 10, 12, 10, 0, -12 },
  { 74, 3, 4, 4, 2, -12 },
  { 76, 6, 15, 5, 0, -12 },
  { 88, 6, 15, 5, -1, -12 },
  { 100, 7, 8, 8, 1, -13 },
  { 107, 7, 8, 9, 1, -10 },
  { 114, 4, 4, 4, -1, -2 },
  { 116, 5, 3, 5, 0, -6 },
  { 118, 3, 3, 4, 0, -3 },
  { 120, 9, 12, 7, -1, -12 },
  { 134, 8, 12, 8, 0, -12 },
  { 146, 6, 12, 8, 2, -12 },
  { 155, 9, 12, 8, -1, -12 },
  { 169, 8, 12, 8, 0, -12 },
  { 181, 8, 12, 8, 0, -12 },
  { 193, 8, 12, 8, 0, -12 },
  { 205, 8, 12, 8, 1, -12 },
  { 217, 9, 12, 8, 0, -12 },
  { 231, 8, 12, 8, 0, -12 },
  { 243, 8, 12, 8, 0, -12 },
  { 255, 4, 9, 5, 0, -9 },
  { 260, 5, 11, 5, -1, -9 },
  { 267, 7, 8, 9, 1, -10 },
  { 274, 7, 6, 9, 1, -9 },
  { 280, 7, 8, 9, 1, -10 },
  { 287, 6, 12, 7, 1, -12 },
  { 296, 12, 13, 13, 0, -12 },
  { 316, 9, 12, 9, -1, -12 },
  { 330, 9, 12, 9, 0, -12 },
  { 344, 9, 12, 9, 1, -12 },
  { 358, 10, 12, 10, 0, -12 },
  { 373, 8, 12, 8, 0, -12 },
  { 385, 8, 12, 8, 0, -12 },
  { 397, 9, 12, 10, 1, -12 },
  { 411, 11, 12, 10, 0, -12 },
  { 428, 8, 12, 6, -1, -12 },
  { 440, 8, 16, 5, -3, -12 },
  { 456, 11, 12, 9, 0, -12 },
  { 473, 6, 12, 7, 0, -12 },
  { 482, 14, 12, 13, 0, -12 },
  { 503, 11, 12, 11, 0, -12 },
  { 520, 9, 12, 10, 1, -12 },
  { 534, 9, 12, 9, 0, -12 },
  { 548, 9, 15, 10, 1, -12 },
  { 565, 9, 12, 9, 0, -12 },
  { 579, 8, 12, 8, 0, -12 },
  { 591, 8, 12, 8, 1, -12 },
  { 603, 9, 12, 10, 1, -12 },
  { 617, 8, 12, 9, 2, -12 },
  { 629, 14, 12, 13, 1, -12 },
  { 650, 11, 12, 9, -1, -12 },
  { 667, 8, 12, 8, 2, -12 },
  { 679, 10, 12, 8, -1, -12 },
  { 694, 7, 15, 5, -1, -12 },
  { 708, 4, 12, 7, 2, -12 },
  { 714, 7, 15, 5, -1, -12 },
  { 728, 8, 8, 8, 0, -12 },
  { 736, 7, 2, 6, -2, 1 },
  { 738, 4, 3, 5, 2, -13 },
  { 740, 9, 10, 9, 0, -10 },
  { 752, 8, 13, 9, 0, -13 },
  { 765, 7, 10, 7, 0, -10 },
  { 774, 10, 13, 9, 0, -13 },
  { 791, 8, 9, 8, 0, -9 },
  { 800, 9, 17, 5, -2, -13 },
  { 820, 9, 14, 9, 0, -10 },
  { 836, 8, 13, 9, 0, -13 },
  { 849, 5, 13, 4, 0, -13 },
  { 858, 7, 17, 4, -2, -13 },
  { 873, 9, 13, 8, 0, -13 },
  { 888, 5, 13, 4, 0, -13 },
  { 897, 12, 10, 13, 0, -10 },
  { 912, 8, 10, 9, 0, -10 },
  { 922, 8, 10, 9, 0, -10 },
  { 932, 9, 14, 9, -1, -10 },
  { 948, 9, 14, 9, 0, -10 },
  { 964, 7, 10, 6, 0, -10 },
  { 973, 7, 10, 7, 0, -10 },
  { 982, 5, 11, 6, 1, -11 },
  { 989, 8, 9, 9, 1, -9 },
  { 998, 8, 9, 8, 1, -9 },
  { 1007, 12, 9, 12, 1, -9 },
  { 1021, 10, 9, 8, -1, -9 },
  { 1033, 10, 13, 8, -1, -9 },
  { 1050, 8, 9, 7, -1, -9 },
  { 1059, 7, 15, 6, 0, -12 },
  { 1073, 2, 17, 7, 3, -13 },
  { 1078, 7, 15, 6, -1, -12 },
  { 1092, 7, 4, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC17PT7B_H_
