#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC39PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x7E, 0x7E, 0xFC, 0xF9, 0xF3,
  0xF3, 0xE7, 0xEF, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF1,
  0xE3, 0xE0, 0x00, 0x3C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0xC0, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x0F, 0x1E, 0x00,
  0x78, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x7C, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xD9, 0xC1, 0xF3, 0x10, 0x3E, 0xC0, 0x07, 0xD8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0C, 0xF8, 0x81, 0x9F, 0x18,
  0x37, 0xE3, 0xE7, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xF0, 0x1E, 0x03, 0xFF, 0x03,
  0xE0, 0x3C, 0xF0, 0x7C, 0x07, 0xCF, 0x87, 0x80, 0x78, 0xF0, 0xF8, 0x07,
  0x8F, 0x0F, 0x00, 0xF8, 0xF1, 0xF0, 0x0F, 0x8F, 0x3E, 0x00, 0xF9, 0xF3,
  0xC0, 0x0F, 0x1E, 0x7C, 0xFC, 0xFB, 0xE7, 0x9F, 0xEF, 0xFC, 0xF3, 0xFE,
  0x7F, 0xDF, 0x7F, 0xF7, 0xF9, 0xE7, 0x9F, 0x3F, 0x3E, 0xF9, 0xF0, 0x03,
  0xCF, 0x9F, 0x00, 0x78, 0xF1, 0xF0, 0x0F, 0x8F, 0x1E, 0x00, 0xF1, 0xF1,
  0xE0, 0x1F, 0x1F, 0x1E, 0x03, 0xE1, 0xF3, 0xE0, 0x3C, 0x1F, 0x3C, 0x07,
  0xC1, 0xFF, 0xC0, 0x78, 0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xC3, 0xFF, 0x1F, 0x8F, 0xFE, 0x3E, 0x3F,
  0x7E, 0xFC, 0xFC, 0xFD, 0xF1, 0xF8, 0xFF, 0xE7, 0xE1, 0xFF, 0x8F, 0xC1,
  0xFF, 0x1F, 0x83, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xEF, 0xC0, 0xFF, 0x1F, 0xC0, 0x7E, 0xFD,
  0xF3, 0xE7, 0xDF, 0x3E, 0x7C, 0xF9, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x01,
  0xF0, 0x01, 0xF0, 0x41, 0xE0, 0x71, 0xE0, 0x7D, 0xE1, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0x07, 0xFF, 0x0F, 0xE1, 0x1F, 0xF0, 0x3F, 0xF0, 0x7E,
  0xF8, 0x3C, 0xF8, 0x1C, 0x7C, 0x08, 0x70, 0x00, 0x40, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0x7C,
  0x7C, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xFF, 0xFC, 0x3C, 0xFF, 0xFF,
  0xFF, 0xDF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0x9F, 0x87,
  0xE7, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFF, 0x7F, 0xFC, 0x7E,
  0xF8, 0x7B, 0xF0, 0xE7, 0xE0, 0x8F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0x7C, 0x7F, 0x03, 0x83, 0xF0, 0x20, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0E,
  0x1F, 0xC1, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF9, 0x00, 0x7E, 0x30, 0x1F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0x7E, 0x03, 0xEF, 0xC0, 0xF9,
  0xF0, 0x1E, 0x3E, 0x07, 0xCF, 0xC1, 0xF1, 0xF8, 0x3C, 0x3F, 0x0F, 0x07,
  0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x41, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF9, 0x00, 0x7E, 0x30, 0x1F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFD, 0xF8, 0x1F, 0x7F,
  0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0xFC, 0xFE, 0x1F,
  0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x1F, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E,
  0xFE, 0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF9,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xF8, 0x3F, 0xBF, 0x07, 0xE3, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xF3, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE7, 0xE3, 0xF0, 0xFC,
  0xFC, 0x3F, 0x3F, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xFD, 0xF8, 0x7E, 0x7E,
  0x3F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xDF, 0x07, 0xEF,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x03,
  0x81, 0xF0, 0xFC, 0x3F, 0x1F, 0xC3, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8,
  0xFC, 0x3F, 0x00, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3E,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00,
  0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC3, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x00, 0x07, 0xF0, 0x7F, 0xF1, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE6,
  0x0F, 0xC8, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x78, 0x3F, 0x0F, 0x1F, 0x1F,
  0xF9, 0xE3, 0xC7, 0xFF, 0x3C, 0xF0, 0xFF, 0xE7, 0x9E, 0x3C, 0x78, 0xF7,
  0x8F, 0x8F, 0x1E, 0xF1, 0xE1, 0xE3, 0xDE, 0x7C, 0x3C, 0x7B, 0xCF, 0x0F,
  0x0F, 0xF1, 0xE1, 0xE3, 0xDE, 0x3C, 0x3C, 0x7B, 0xC7, 0x8F, 0x8F, 0x78,
  0xF1, 0xF3, 0xCF, 0x1F, 0xFF, 0xF1, 0xE3, 0xFF, 0xFC, 0x3C, 0x3F, 0x3F,
  0x07, 0xC1, 0x83, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x01, 0x80, 0x1F, 0xE3, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0,
  0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0xFC, 0x3E, 0x07, 0xE1,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x1F, 0x87,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0x8F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0xFE, 0x1F, 0x07, 0xF1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFE, 0x1C, 0x1F,
  0xC0, 0x43, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x0C, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x9F, 0xE0, 0x7E,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1,
  0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x7F, 0x87, 0xE3, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xF8, 0x30, 0x7F, 0x00, 0x87, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE3, 0xFF, 0x7F,
  0x1F, 0xF3, 0xF0, 0xFF, 0x9F, 0x87, 0xFC, 0xFC, 0x7F, 0xE7, 0xE0, 0x3F,
  0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF8,
  0x3F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0xFE,
  0x07, 0xE1, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xF0,
  0x0F, 0xCF, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0xFF,
  0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0xC7, 0xDF, 0x03, 0xF7,
  0x8F, 0xBE, 0x07, 0xEF, 0x3E, 0xFC, 0x0F, 0x9E, 0x7D, 0xF8, 0x1F, 0x3D,
  0xF3, 0xF0, 0x7E, 0x7B, 0xE7, 0xC0, 0xFC, 0xF7, 0x8F, 0x81, 0xF1, 0xFF,
  0x3F, 0x03, 0xE3, 0xFC, 0x7E, 0x07, 0xC7, 0xF8, 0xFC, 0x1F, 0x8F, 0xF1,
  0xF0, 0x3F, 0x1F, 0xC7, 0xE0, 0x7C, 0x3F, 0x8F, 0xC0, 0xF8, 0x7E, 0x1F,
  0x83, 0xF0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0xE0, 0x3E, 0x07, 0xFC,
  0x0F, 0x81, 0xFF, 0x07, 0xE0, 0x7F, 0xC1, 0xF8, 0x3F, 0xF0, 0x7C, 0x0F,
  0xFE, 0x1F, 0x03, 0xFF, 0x8F, 0xC0, 0xFB, 0xE3, 0xF0, 0x3E, 0xF8, 0xFC,
  0x1F, 0xBE, 0x3E, 0x07, 0xEF, 0xCF, 0x81, 0xF3, 0xF7, 0xE0, 0x7C, 0x7D,
  0xF8, 0x1F, 0x1F, 0x7E, 0x0F, 0xC7, 0xFF, 0x03, 0xF1, 0xFF, 0xC0, 0xF8,
  0x3F, 0xF0, 0x3E, 0x0F, 0xFC, 0x0F, 0x83, 0xFE, 0x07, 0xE0, 0xFF, 0x81,
  0xF8, 0x3F, 0xE0, 0x7C, 0x07, 0xF8, 0x1F, 0x01, 0xFE, 0x0F, 0xC0, 0x7F,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xF1, 0xFC, 0x7F, 0x07, 0xE7, 0xF0,
  0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0xFE, 0x7E,
  0x07, 0xE3, 0xF8, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x1F, 0x87,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F,
  0x87, 0xE1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xF1, 0xFC,
  0x7F, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F,
  0xCF, 0xC0, 0xFE, 0x7E, 0x0F, 0xE3, 0xF8, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF3, 0xF8, 0x1F, 0x8F, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xE1,
  0xF9, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE,
  0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xC7, 0x83, 0xF0, 0x20, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF1, 0x80, 0xFE, 0x3C, 0x3F,
  0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC1, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFC, 0x03, 0xFB, 0xE0, 0x1F, 0x9F,
  0x00, 0xFC, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0x3F,
  0x0F, 0x83, 0xF8, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8,
  0x7E, 0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x80,
  0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x7F,
  0xF8, 0x0F, 0x81, 0xFB, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0x07, 0xEF,
  0xC1, 0xFC, 0x1F, 0x9F, 0x83, 0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0xFC, 0x7E,
  0x1F, 0xE1, 0xF8, 0xFC, 0x3F, 0xC3, 0xF1, 0xF8, 0xFF, 0x8F, 0xC3, 0xF1,
  0xFF, 0x1F, 0x87, 0xE7, 0xFE, 0x7E, 0x0F, 0xCF, 0xFC, 0xFC, 0x1F, 0x9E,
  0xF9, 0xF8, 0x3F, 0x7D, 0xF7, 0xE0, 0x7E, 0xFB, 0xEF, 0xC0, 0xFF, 0xE7,
  0xDF, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xEF, 0x9F, 0xF8, 0x07, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0x7E,
  0x1F, 0x87, 0xE3, 0xF8, 0x3E, 0x3F, 0x03, 0xE7, 0xE0, 0x3F, 0x7E, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x01, 0xF3, 0xC0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0xC1, 0xE3,
  0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFE, 0x00, 0xF0, 0x7F, 0xFF, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E, 0x1F, 0x01,
  0xE0, 0x00, 0xFE, 0x7C, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0x3F, 0x8F, 0xC7, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3, 0xF3, 0xF8,
  0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFB,
  0xE0, 0x7E, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xCF, 0x01, 0xFB, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F,
  0x9F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0xFC, 0xFC,
  0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xF3, 0xF0,
  0xFC, 0x7F, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xBF,
  0xC1, 0xF3, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3F, 0x84, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x18, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xC7, 0xE0,
  0x3F, 0xBF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFB, 0xE0, 0x1F, 0x9F, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF9, 0xF8, 0x7C, 0xFC, 0x3E, 0xFC, 0x3F,
  0x7E, 0x3F, 0xBF, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x04, 0x7F, 0x0E, 0x1F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0xE7, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83,
  0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x06, 0x03, 0xF8, 0x3E, 0x7F, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xCF, 0x01, 0xFB, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xDF, 0xC7, 0xF1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x9F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x00, 0x01,
  0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC3, 0xF1, 0xFC,
  0x1F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7F,
  0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x7C, 0xFE, 0x7F, 0x03, 0xEF, 0xF7, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xF7, 0xFD, 0xFC, 0x7F, 0x1F, 0x87,
  0xE3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3E, 0x1F, 0x07,
  0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87,
  0xE3, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0x01, 0xF3, 0xF8,
  0x3E, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xDF, 0xC7, 0xF1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F,
  0xE7, 0xE3, 0xF0, 0xF9, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xEF, 0xC1,
  0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC,
  0xFC, 0x7F, 0x3F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0x3F, 0x00, 0xFB, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07,
  0xC1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F,
  0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xFE, 0x7C, 0x3F, 0xEF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0x3F, 0x8F, 0xC7, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7,
  0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7E, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x0F, 0x9F, 0x0F, 0xBE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xE2, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x04, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x81, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF1, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC,
  0x00, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC7, 0xE3, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xDF,
  0x03, 0xF3, 0xE0, 0xFC, 0x1F, 0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFC,
  0x7C, 0x3F, 0x1F, 0x1F, 0x87, 0xC7, 0xE1, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F,
  0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x87, 0xFF, 0x87, 0xF0, 0xFB, 0xF1, 0xFE,
  0x3F, 0x7E, 0x3F, 0xC7, 0xCF, 0xC7, 0xF9, 0xF9, 0xF9, 0xFF, 0x3F, 0x3F,
  0x3F, 0xE7, 0xC7, 0xEF, 0xF9, 0xF8, 0xFD, 0xEF, 0x3E, 0x1F, 0xBD, 0xEF,
  0xC3, 0xFF, 0xBD, 0xF0, 0x7D, 0xE7, 0xBE, 0x0F, 0xBC, 0xFF, 0xC1, 0xFF,
  0x9F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0, 0x3E, 0x3F, 0x00, 0xFD,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x9F,
  0x00, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0xC0,
  0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x0F, 0xC0,
  0x3E, 0x1F, 0x80, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF3, 0xF0, 0x03,
  0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFC, 0x07, 0xFA, 0x00, 0x70,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 28, 10, 0, -28 },
  { 43, 15, 10, 17, 4, -28 },
  { 62, 22, 28, 21, 0, -28 },
  { 139, 19, 32, 19, 0, -30 },
  { 215, 28, 28, 31, 2, -28 },
  { 313, 23, 28, 24, 0, -28 },
  { 394, 7, 10, 10, 4, -28 },
  { 403, 14, 34, 12, 1, -28 },
  { 463, 14, 35, 12, -3, -29 },
  { 525, 16, 18, 18, 3, -30 },
  { 561, 17, 19, 20, 2, -23 },
  { 602, 9, 10, 10, -2, -5 },
  { 614, 11, 5, 12, 0, -13 },
  { 621, 7, 6, 10, 0, -6 },
  { 627, 21, 28, 16, -2, -28 },
  { 701, 18, 28, 19, 1, -28 },
  { 764, 15, 28, 19, 3, -28 },
  { 817, 20, 28, 19, -1, -28 },
  { 887, 19, 28, 19, 0, -28 },
  { 954, 19, 28, 19, 0, -28 },
  { 1021, 19, 28, 19, 0, -28 },
  { 1088, 19, 28, 19, 1, -28 },
  { 1155, 20, 28, 19, 1, -28 },
  { 1225, 19, 28, 19, 0, -28 },
  { 1292, 18, 28, 19, 1, -28 },
  { 1355, 10, 22, 10, 0, -22 },
  { 1383, 12, 27, 10, -2, -22 },
  { 1424, 17, 20, 20, 2, -24 },
  { 1467, 17, 13, 20, 2, -20 },
  { 1495, 17, 20, 20, 2, -24 },
  { 1538, 15, 28, 15, 2, -28 },
  { 1591, 27, 31, 29, 1, -28 },
  { 1696, 21, 28, 21, -2, -28 },
  { 1770, 21, 28, 21, 0, -28 },
  { 1844, 20, 28, 20, 2, -28 },
  { 1914, 22, 28, 22, 0, -28 },
  { 1991, 19, 28, 18, 0, -28 },
  { 2058, 19, 28, 17, 0, -28 },
  { 2125, 21, 28, 23, 2, -28 },
  { 2199, 24, 28, 23, 0, -28 },
  { 2283, 18, 28, 14, -1, -28 },
  { 2346, 18, 36, 11, -6, -28 },
  { 2427, 24, 28, 21, 0, -28 },
  { 2511, 15, 28, 17, 0, -28 },
  { 2564, 31, 28, 30, 0, -28 },
  { 2673, 26, 28, 25, 0, -28 },
  { 2764, 21, 28, 24, 2, -28 },
  { 2838, 21, 28, 20, 0, -28 },
  { 2912, 21, 35, 24, 2, -28 },
  { 3004, 21, 28, 21, 0, -28 },
  { 3078, 19, 28, 18, 0, -28 },
  { 3145, 17, 28, 18, 3, -28 },
  { 3205, 22, 28, 23, 2, -28 },
  { 3282, 21, 28, 20, 3, -28 },
  { 3356, 31, 28, 30, 3, -28 },
  { 3465, 25, 28, 20, -2, -28 },
  { 3553, 20, 28, 19, 3, -28 },
  { 3623, 22, 28, 18, -2, -28 },
  { 3700, 16, 34, 12, -1, -28 },
  { 3768, 9, 28, 16, 4, -28 },
  { 3800, 16, 34, 12, -3, -28 },
  { 3868, 18, 18, 19, 0, -28 },
  { 3909, 16, 4, 15, -4, 3 },
  { 3917, 8, 6, 12, 6, -30 },
  { 3923, 19, 22, 20, 1, -22 },
  { 3976, 19, 30, 20, 0, -30 },
  { 4048, 16, 22, 16, 1, -22 },
  { 4092, 21, 30, 20, 1, -30 },
  { 4171, 17, 22, 19, 1, -22 },
  { 4218, 21, 39, 13, -4, -30 },
  { 4321, 21, 31, 20, -1, -22 },
  { 4403, 19, 30, 20, 0, -30 },
  { 4475, 12, 30, 10, 0, -30 },
  { 4520, 17, 39, 10, -5, -30 },
  { 4603, 21, 30, 19, 0, -30 },
  { 4682, 12, 30, 10, 0, -30 },
  { 4727, 29, 22, 30, 0, -22 },
  { 4807, 19, 22, 20, 0, -22 },
  { 4860, 18, 22, 20, 1, -22 },
  { 4910, 21, 31, 20, -2, -22 },
  { 4992, 19, 31, 20, 1, -22 },
  { 5066, 16, 22, 14, 0, -22 },
  { 5110, 16, 22, 16, 0, -22 },
  { 5154, 13, 26, 14, 2, -26 },
  { 5197, 19, 21, 20, 1, -21 },
  { 5247, 18, 21, 18, 2, -21 },
  { 5295, 27, 21, 27, 2, -21 },
  { 5366, 22, 21, 18, -2, -21 },
  { 5424, 23, 30, 18, -3, -21 },
  { 5511, 18, 21, 15, -1, -21 },
  { 5559, 16, 34, 14, 0, -28 },
  { 5627, 5, 39, 17, 6, -30 },
  { 5652, 15, 34, 14, -2, -28 },
  { 5716, 17, 7, 20, 2, -17 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC39PT7B_H_
