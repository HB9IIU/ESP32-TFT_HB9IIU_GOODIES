#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC14PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x36, 0x66, 0x60, 0xCC, 0x6D, 0x6D, 0xB6, 0x1B, 0x1A, 0x16,
  0x7F, 0x34, 0x2C, 0xFE, 0x68, 0x58, 0xD8, 0x08, 0x38, 0xFB, 0x67, 0x07,
  0x07, 0x0E, 0xDD, 0xF0, 0x81, 0x00, 0x71, 0xB4, 0xCD, 0x62, 0xD0, 0xBF,
  0xBA, 0xB1, 0xEC, 0xDA, 0x27, 0x98, 0xC0, 0x1C, 0x36, 0x36, 0x3C, 0x38,
  0x7B, 0xDF, 0xCE, 0xFE, 0x7F, 0x6F, 0x60, 0x19, 0x8C, 0xC6, 0x33, 0x18,
  0xC6, 0x30, 0xC0, 0x18, 0xC6, 0x31, 0x8C, 0x66, 0x31, 0x99, 0x80, 0x12,
  0xCF, 0xDF, 0x73, 0x61, 0x00, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x76, 0x6C,
  0x7F, 0xF0, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xE0,
  0x1C, 0x7D, 0x9B, 0x36, 0x6D, 0xB3, 0x66, 0x78, 0xE0, 0x19, 0xFE, 0xB3,
  0x98, 0xC6, 0x33, 0x00, 0x3C, 0xFC, 0x98, 0x60, 0xC3, 0x0C, 0x30, 0xFD,
  0xF0, 0x3C, 0x7C, 0x18, 0x63, 0x87, 0x83, 0x06, 0xFD, 0xF0, 0x0E, 0x1C,
  0x71, 0xE2, 0xC9, 0xBF, 0x7E, 0x18, 0x30, 0x3E, 0x7C, 0xC3, 0x07, 0xCB,
  0x83, 0x06, 0xF9, 0xF0, 0x1E, 0x7C, 0xC3, 0x47, 0xCD, 0xBB, 0x76, 0x7C,
  0xF0, 0x3F, 0x7E, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0x3C,
  0x7D, 0x99, 0xE3, 0x8F, 0xBB, 0x66, 0xFC, 0xF0, 0x3C, 0x7D, 0x9B, 0x36,
  0xEF, 0x8B, 0x0E, 0xF9, 0xE0, 0x27, 0x20, 0x00, 0xCC, 0x11, 0xC4, 0x00,
  0x01, 0xCC, 0x66, 0x00, 0x04, 0x33, 0xB8, 0xE0, 0xE0, 0xC0, 0xFC, 0x00,
  0x3F, 0x83, 0x0F, 0x0F, 0x3F, 0xCC, 0x00, 0x7F, 0xC6, 0x77, 0x33, 0x00,
  0xC6, 0x00, 0x0F, 0x86, 0x32, 0x45, 0xBD, 0x5B, 0x54, 0x9D, 0x2F, 0x7E,
  0x40, 0x18, 0x83, 0xE0, 0x0E, 0x0E, 0x0A, 0x1B, 0x1B, 0x33, 0x3F, 0x7F,
  0x63, 0xE3, 0x3E, 0x3E, 0x37, 0x76, 0x7C, 0x7C, 0x66, 0x6E, 0xFC, 0xF8,
  0x3E, 0xF9, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xF8, 0xF0, 0x3E, 0x3E, 0x37,
  0x73, 0x63, 0x67, 0x66, 0x6E, 0xFC, 0xF8, 0x3E, 0x7C, 0xC3, 0x87, 0xCF,
  0x98, 0x30, 0xF9, 0xF0, 0x3E, 0x7C, 0xC3, 0x87, 0xCF, 0x98, 0x30, 0xE1,
  0x80, 0x3E, 0xFD, 0x87, 0x0D, 0xFB, 0xF3, 0x66, 0xFC, 0xF8, 0x33, 0x99,
  0x8C, 0xCE, 0x67, 0xF3, 0xF9, 0x98, 0xCC, 0xE6, 0x67, 0x00, 0x3E, 0x38,
  0x60, 0xC1, 0x83, 0x0C, 0x18, 0x31, 0xF0, 0x0C, 0x30, 0xC3, 0x18, 0x61,
  0x86, 0x38, 0xC3, 0x3C, 0xE0, 0x33, 0x9B, 0x8D, 0x8F, 0x87, 0x83, 0xE1,
  0xB0, 0xD8, 0xCC, 0x67, 0x00, 0x31, 0x8C, 0xE6, 0x31, 0x8C, 0xFF, 0xC0,
  0x38, 0xE7, 0x1C, 0xE7, 0xBC, 0xE7, 0xBC, 0xF5, 0x9F, 0xB3, 0xF6, 0xCD,
  0x99, 0xB0, 0x39, 0x9C, 0xCE, 0x6F, 0x36, 0xF3, 0x79, 0xBC, 0xDE, 0xCF,
  0x63, 0x00, 0x3C, 0xFD, 0x9E, 0x3C, 0x78, 0xF1, 0xE6, 0xFC, 0xF0, 0x3E,
  0x3E, 0x37, 0x76, 0x66, 0x7C, 0x70, 0x60, 0xE0, 0xC0, 0x3C, 0xFD, 0x9E,
  0x3C, 0x78, 0xF1, 0xE6, 0xFC, 0xF0, 0x60, 0xE0, 0x3C, 0x7C, 0xDB, 0xB7,
  0xEF, 0x9B, 0x36, 0xED, 0x9C, 0x3E, 0x79, 0x83, 0x83, 0x87, 0x07, 0x4E,
  0xF9, 0xE0, 0xFF, 0xF3, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x00, 0x67, 0x66,
  0x66, 0xE6, 0xCE, 0xCC, 0xCC, 0xCC, 0xF8, 0xF8, 0xC7, 0xC6, 0xCC, 0xCC,
  0xDC, 0xD8, 0xD8, 0x70, 0x70, 0x60, 0xC6, 0x79, 0xDF, 0x3B, 0x6F, 0x6D,
  0xD9, 0xAB, 0x3D, 0x67, 0x38, 0xE7, 0x1C, 0xC0, 0x39, 0x8D, 0x87, 0xC3,
  0xC1, 0xC0, 0xE0, 0xF8, 0x6C, 0x66, 0x73, 0x00, 0xC6, 0xD9, 0xB3, 0xC7,
  0x0E, 0x18, 0x30, 0x60, 0xC0, 0x1F, 0x3F, 0x06, 0x0E, 0x1C, 0x18, 0x30,
  0x70, 0x7E, 0xFC, 0x1C, 0x61, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x3C,
  0xC4, 0x66, 0x66, 0x66, 0x23, 0x3C, 0x21, 0x86, 0x18, 0x61, 0x0C, 0x30,
  0xC3, 0x38, 0x08, 0x30, 0xF1, 0xE6, 0xD8, 0xC0, 0xF8, 0xCD, 0x80, 0x3E,
  0xFD, 0xBB, 0x7E, 0xDD, 0xBF, 0x36, 0x30, 0x60, 0xC1, 0xE7, 0xEC, 0xD9,
  0xB7, 0xED, 0xFB, 0xE0, 0x1C, 0xF6, 0x18, 0xE3, 0x8F, 0x9E, 0x03, 0x07,
  0x06, 0x3E, 0x7E, 0x6E, 0x6E, 0xEC, 0xCC, 0xFC, 0x7C, 0x1C, 0x79, 0x9B,
  0xEF, 0x98, 0x1A, 0x3C, 0x07, 0x0F, 0x0C, 0x0E, 0x1E, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x30, 0xB0, 0xE0, 0x3E, 0x7D, 0xBB, 0x7E, 0xD9, 0xBF,
  0x36, 0x19, 0x33, 0xC0, 0x30, 0x60, 0xC1, 0xE7, 0xEC, 0xD9, 0xB6, 0xED,
  0x9B, 0x30, 0x33, 0x03, 0x66, 0x66, 0x6C, 0xC0, 0x0C, 0x30, 0x03, 0x18,
  0x61, 0x86, 0x18, 0xC3, 0x0C, 0xF3, 0x80, 0x30, 0x30, 0x30, 0x37, 0x6E,
  0x6C, 0x78, 0x78, 0xF8, 0xCC, 0xCC, 0x33, 0x33, 0x66, 0x66, 0xEC, 0xC0,
  0x2C, 0xDF, 0xF6, 0x6D, 0xBB, 0x6C, 0xFB, 0x3C, 0xDB, 0x36, 0x2C, 0xFD,
  0x9B, 0x36, 0xCD, 0xB3, 0x66, 0x1C, 0x79, 0x9B, 0x3E, 0xD9, 0x9F, 0x3C,
  0x16, 0x3F, 0x33, 0x33, 0x37, 0x76, 0x7E, 0x7C, 0x60, 0x60, 0xE0, 0x3E,
  0x7D, 0xBB, 0x7E, 0xD9, 0xBF, 0x36, 0x18, 0x30, 0x60, 0x2D, 0xE7, 0x18,
  0x63, 0x8C, 0x30, 0x39, 0xF6, 0x1C, 0x38, 0x6F, 0xBC, 0x67, 0xFC, 0xCC,
  0xCE, 0xE0, 0x36, 0xCD, 0x9B, 0x76, 0xDD, 0xBF, 0x3E, 0xCF, 0x7D, 0xB6,
  0xF3, 0xCE, 0x38, 0xDD, 0xEE, 0xF7, 0x7F, 0xEE, 0xF7, 0x73, 0xB9, 0x98,
  0x33, 0x36, 0x1E, 0x1C, 0x1C, 0x3C, 0x6C, 0xEE, 0x33, 0x37, 0x36, 0x36,
  0x3C, 0x3C, 0x38, 0x38, 0x30, 0xF0, 0xE0, 0x7D, 0xF1, 0x8C, 0x71, 0x8F,
  0xBE, 0x1C, 0x73, 0x0C, 0x33, 0x8E, 0x18, 0x61, 0x87, 0x1C, 0xFF, 0xFF,
  0xFF, 0xF0, 0x38, 0xE1, 0x86, 0x18, 0x71, 0xCC, 0x30, 0xCE, 0x38, 0xF7,
  0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 6, 4, 6, 1, -10 },
  { 9, 8, 10, 8, 0, -10 },
  { 19, 7, 12, 7, 0, -11 },
  { 30, 10, 10, 11, 1, -10 },
  { 43, 8, 10, 8, 0, -10 },
  { 53, 3, 4, 3, 1, -10 },
  { 55, 5, 12, 4, 0, -10 },
  { 63, 5, 12, 4, -1, -10 },
  { 71, 6, 7, 6, 1, -11 },
  { 77, 6, 6, 7, 1, -8 },
  { 82, 4, 4, 4, -1, -2 },
  { 84, 4, 2, 4, 0, -5 },
  { 85, 2, 2, 4, 0, -2 },
  { 86, 8, 10, 6, -1, -10 },
  { 96, 7, 10, 7, 0, -10 },
  { 105, 5, 10, 7, 1, -10 },
  { 112, 7, 10, 7, 0, -10 },
  { 121, 7, 10, 7, 0, -10 },
  { 130, 7, 10, 7, 0, -10 },
  { 139, 7, 10, 7, 0, -10 },
  { 148, 7, 10, 7, 0, -10 },
  { 157, 8, 10, 7, 0, -10 },
  { 167, 7, 10, 7, 0, -10 },
  { 176, 7, 10, 7, 0, -10 },
  { 185, 4, 8, 4, 0, -8 },
  { 189, 5, 10, 4, -1, -8 },
  { 196, 6, 7, 7, 1, -9 },
  { 202, 6, 4, 7, 1, -7 },
  { 205, 6, 7, 7, 1, -9 },
  { 211, 5, 10, 5, 1, -10 },
  { 218, 10, 11, 10, 0, -10 },
  { 232, 8, 10, 8, -1, -10 },
  { 242, 8, 10, 7, 0, -10 },
  { 252, 7, 10, 7, 1, -10 },
  { 261, 8, 10, 8, 0, -10 },
  { 271, 7, 10, 6, 0, -10 },
  { 280, 7, 10, 6, 0, -10 },
  { 289, 7, 10, 8, 1, -10 },
  { 298, 9, 10, 8, 0, -10 },
  { 310, 7, 10, 5, -1, -10 },
  { 319, 6, 13, 4, -2, -10 },
  { 329, 9, 10, 7, 0, -10 },
  { 341, 5, 10, 6, 0, -10 },
  { 348, 11, 10, 11, 0, -10 },
  { 362, 9, 10, 9, 0, -10 },
  { 374, 7, 10, 9, 1, -10 },
  { 383, 8, 10, 7, 0, -10 },
  { 393, 7, 12, 9, 1, -10 },
  { 404, 7, 10, 7, 0, -10 },
  { 413, 7, 10, 6, 0, -10 },
  { 422, 6, 10, 6, 1, -10 },
  { 430, 8, 10, 8, 1, -10 },
  { 440, 8, 10, 7, 1, -10 },
  { 450, 11, 10, 11, 1, -10 },
  { 464, 9, 10, 7, -1, -10 },
  { 476, 7, 10, 7, 1, -10 },
  { 485, 8, 10, 6, -1, -10 },
  { 495, 6, 12, 4, -1, -10 },
  { 504, 4, 10, 6, 1, -10 },
  { 509, 6, 12, 4, -1, -10 },
  { 518, 7, 6, 7, 0, -10 },
  { 524, 5, 1, 5, -1, 1 },
  { 525, 3, 3, 4, 2, -11 },
  { 527, 7, 8, 7, 0, -8 },
  { 534, 7, 11, 7, 0, -11 },
  { 544, 6, 8, 6, 0, -8 },
  { 550, 8, 11, 7, 0, -11 },
  { 561, 7, 8, 7, 0, -8 },
  { 568, 8, 14, 5, -2, -11 },
  { 582, 7, 11, 7, 0, -8 },
  { 592, 7, 11, 7, 0, -11 },
  { 602, 4, 11, 4, 0, -11 },
  { 608, 6, 14, 4, -2, -11 },
  { 619, 8, 11, 7, 0, -11 },
  { 630, 4, 11, 4, 0, -11 },
  { 636, 10, 8, 11, 0, -8 },
  { 646, 7, 8, 7, 0, -8 },
  { 653, 7, 8, 7, 0, -8 },
  { 660, 8, 11, 7, -1, -8 },
  { 671, 7, 11, 7, 0, -8 },
  { 681, 6, 8, 5, 0, -8 },
  { 687, 6, 8, 6, 0, -8 },
  { 693, 4, 9, 5, 1, -9 },
  { 698, 7, 8, 7, 0, -8 },
  { 705, 6, 8, 6, 1, -8 },
  { 711, 9, 8, 10, 1, -8 },
  { 720, 8, 8, 7, -1, -8 },
  { 728, 8, 11, 6, -1, -8 },
  { 739, 6, 8, 6, 0, -8 },
  { 745, 6, 12, 5, 0, -10 },
  { 754, 2, 14, 6, 2, -11 },
  { 758, 6, 12, 5, -1, -10 },
  { 767, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC14PT7B_H_
