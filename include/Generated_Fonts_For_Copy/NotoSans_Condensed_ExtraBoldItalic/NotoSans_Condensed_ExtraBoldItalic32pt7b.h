#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC32PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xF0, 0xFC, 0x3E, 0x0F, 0x80, 0x7D, 0xF7, 0xDF, 0x79, 0xF7, 0x9E,
  0x79, 0xEF, 0x1E, 0xF1, 0xCF, 0x3C, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x1E,
  0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF3, 0xC1, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x71, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0x1C, 0x03, 0xCF,
  0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x78, 0x07, 0x9C, 0x00, 0x00, 0x30,
  0x00, 0x30, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x6C,
  0x1E, 0x40, 0x1E, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0x3C, 0x43, 0x7C, 0x73, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0F, 0x00, 0xF0, 0xFE, 0x07, 0x83, 0xFC, 0x1C, 0x1E, 0xF0,
  0xF0, 0x73, 0xC7, 0x83, 0xCF, 0x1E, 0x0F, 0x3C, 0xF0, 0x3C, 0xF3, 0x80,
  0xE3, 0x9E, 0x03, 0x9E, 0xF3, 0xEE, 0x7B, 0xDF, 0xFF, 0xDE, 0xFF, 0xFE,
  0x73, 0xDD, 0xF3, 0xDE, 0x70, 0x1E, 0x71, 0xC0, 0x71, 0xC7, 0x03, 0xCF,
  0x3C, 0x0E, 0x3C, 0xF0, 0x78, 0xF3, 0xC3, 0xC3, 0xDE, 0x0E, 0x0F, 0xF8,
  0x78, 0x1F, 0xC3, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x03, 0xEF, 0x80, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x7D,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF1, 0xF1, 0xFF,
  0x3E, 0x7F, 0xEF, 0x9F, 0x7F, 0xF3, 0xC7, 0xFC, 0xF8, 0xFF, 0x1F, 0x0F,
  0xE3, 0xE1, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF3,
  0xE0, 0x7D, 0xF7, 0x9E, 0x7B, 0xEF, 0x3C, 0x03, 0xE0, 0x78, 0x1E, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78,
  0x00, 0x02, 0x00, 0x0F, 0x00, 0x3C, 0x08, 0xF0, 0x73, 0x81, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x7F, 0x03, 0xFC, 0x1F, 0x78, 0x39, 0xF0,
  0x63, 0x80, 0x08, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C,
  0x7C, 0x78, 0xF8, 0x7F, 0xBF, 0xDF, 0xEF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFE,
  0xF8, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF,
  0x1F, 0x7C, 0xF8, 0xF3, 0xE3, 0xDF, 0x0F, 0x7C, 0x3D, 0xF1, 0xF7, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE7,
  0xCF, 0x9F, 0x3F, 0xF8, 0xFF, 0xC1, 0xFF, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x3F, 0x07, 0xE0, 0xFE, 0x3F, 0xE7, 0xFE, 0xFF, 0xC7, 0xBC, 0x67, 0xC2,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x03,
  0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0x1F, 0x06, 0x1F, 0x04, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0E, 0x3F, 0x08, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0xC1, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xBC, 0x07, 0xFC, 0x0F,
  0x7C, 0x0E, 0x78, 0x1C, 0x78, 0x3C, 0xF8, 0x78, 0xF8, 0x70, 0xF8, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x19, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0xC1, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0x80, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7D, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF,
  0xCF, 0xDF, 0x8F, 0xBE, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7,
  0xC7, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0xF8, 0x7C,
  0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFF, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF,
  0x3E, 0x7C, 0xF8, 0xF7, 0xC3, 0xDF, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7, 0xCF,
  0xDF, 0xFF, 0x7F, 0xFC, 0xFD, 0xE1, 0xEF, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x7E, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0x1F,
  0x1F, 0x1F, 0x1F, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xFC, 0xFC, 0xF8, 0xF8, 0x01, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x78,
  0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x03, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xE3, 0xFC, 0x3F, 0xC0, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7E,
  0x03, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x70,
  0x00, 0x0F, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xF3, 0x0F, 0x90, 0x7C, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xF0, 0x1E, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xC3, 0xF9, 0xCF, 0x1F,
  0xE7, 0x38, 0xFF, 0x9D, 0xE7, 0x9E, 0x77, 0x1C, 0x71, 0xDC, 0xF1, 0xC7,
  0xF3, 0x8F, 0x1F, 0x8E, 0x3C, 0xEE, 0x78, 0xE3, 0xB9, 0xE7, 0x9E, 0xE3,
  0xFE, 0xF3, 0x8F, 0xFF, 0x8E, 0x3E, 0x7C, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x04, 0x03, 0xE1, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7, 0x81, 0xF3,
  0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x7C, 0x78, 0x7C, 0x3C, 0x3F, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0x83, 0xE7, 0xC1, 0xF7, 0xC0, 0xFB,
  0xE0, 0x7F, 0xF0, 0x3E, 0x07, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF,
  0xF0, 0xF9, 0xF8, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x8F, 0xFF, 0x87, 0xFF,
  0xC7, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFC, 0x60, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x84, 0x0F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFE, 0x0F, 0xBF, 0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E, 0x7C, 0x3F, 0x1F, 0x0F, 0xC7, 0xCF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFE, 0x0F, 0xC3, 0x87, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC7, 0xF9, 0xF1, 0xFE, 0x7C, 0x7F, 0x3F,
  0x3F, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x1E, 0x3F, 0x0F, 0x87, 0xE3,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x07, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC1, 0x3F, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F,
  0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F,
  0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xC7, 0xFC,
  0x1F, 0xF1, 0xFF, 0x07, 0xBC, 0x7F, 0xC1, 0xEF, 0x3D, 0xE0, 0x7B, 0xCF,
  0xF8, 0x3E, 0xF7, 0xBE, 0x0F, 0xBD, 0xEF, 0x83, 0xCF, 0xF3, 0xC0, 0xF3,
  0xFC, 0xF0, 0x7C, 0xFE, 0x7C, 0x1F, 0x3F, 0x9F, 0x07, 0xCF, 0xC7, 0xC1,
  0xE3, 0xF1, 0xE0, 0x78, 0xFC, 0x78, 0x3E, 0x3E, 0x3E, 0x0F, 0x8F, 0x8F,
  0x80, 0x07, 0xE0, 0x78, 0x3F, 0x07, 0xC3, 0xF8, 0x3E, 0x1F, 0xC1, 0xF0,
  0xFE, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC7, 0xC3, 0xFE, 0x3E, 0x1E, 0xF1,
  0xF0, 0xF7, 0xCF, 0x07, 0xBE, 0x78, 0x3C, 0xF7, 0xC3, 0xE7, 0xBE, 0x1F,
  0x3D, 0xE0, 0xF1, 0xFF, 0x07, 0x8F, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1, 0xFE,
  0x1F, 0x0F, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F,
  0xCF, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x01,
  0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC0, 0xFB,
  0xE0, 0x7E, 0xFC, 0x1F, 0x3F, 0x0F, 0xC7, 0xC7, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0xF9, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x8F, 0xC7, 0xCF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xCF, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xF8,
  0x1F, 0x7E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x03, 0xEF, 0xC0, 0xFB, 0xE0, 0x7E, 0xFC, 0x1F, 0x3F, 0x0F, 0xC7,
  0xC7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9, 0xF8, 0x7C, 0x7C, 0x3C,
  0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0x80, 0xFB, 0xE0, 0x7D, 0xF0, 0x7C, 0xF8, 0x3E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xC1, 0xF3, 0xE0, 0xF8, 0x01,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x9C, 0x1F, 0x04, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x80, 0xF8, 0xE1,
  0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFE, 0xFF,
  0xF9, 0xFF, 0xF3, 0xFF, 0xE8, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3,
  0xF1, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3C, 0x0F, 0xBE, 0x07, 0xDE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x0F, 0xBC, 0x1F, 0x07, 0xDE, 0x0F,
  0x83, 0xCF, 0x0F, 0xC3, 0xE7, 0x87, 0xE1, 0xF3, 0xC3, 0xF1, 0xF1, 0xE3,
  0xF8, 0xF8, 0xF1, 0xFC, 0x78, 0x79, 0xFE, 0x7C, 0x3C, 0xFF, 0x3E, 0x1E,
  0x7F, 0xBE, 0x0F, 0x7B, 0xDF, 0x07, 0xBD, 0xEF, 0x03, 0xFC, 0xFF, 0x81,
  0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC,
  0x00, 0x07, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x07, 0xCF, 0x80, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0,
  0x7E, 0x00, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0x78, 0xF8,
  0x7D, 0xF0, 0x7D, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE0, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0xF0,
  0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x03, 0xF8,
  0x3F, 0xC1, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xBC, 0x0F,
  0x3C, 0x3C, 0x78, 0xF8, 0xF1, 0xE1, 0xE7, 0x81, 0xEF, 0x03, 0xFC, 0x07,
  0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFC, 0xFB, 0xE7, 0x9F, 0x3C, 0x70, 0x07,
  0x9E, 0x1F, 0xBC, 0x7F, 0x79, 0xFF, 0xF3, 0xE7, 0xEF, 0x8F, 0x9F, 0x1F,
  0x7E, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F,
  0x3F, 0x3F, 0xFC, 0x7F, 0xF8, 0x7E, 0xF0, 0xF9, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x38, 0x1F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xBF, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7F, 0xF8, 0xFF, 0xF8, 0xF7, 0xF0, 0xF3, 0xE0, 0x03, 0xE0, 0x7F,
  0xC7, 0xFE, 0x7F, 0xE3, 0xE3, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x23, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC1, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x78, 0x1F, 0xBC, 0x1F, 0xFE, 0x1F, 0xFF,
  0x0F, 0x9F, 0x8F, 0x8F, 0x87, 0xC7, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3F, 0x0F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0xF9, 0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F,
  0xFF, 0x3E, 0x7D, 0xF1, 0xF7, 0xC7, 0xFE, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F,
  0xF8, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x4F, 0xCE, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x02, 0x7C, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xE0, 0x00, 0x03, 0xCF, 0x07, 0xEF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8,
  0x3E, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x81, 0xF0, 0xC3, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x3C, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xBF, 0x1F, 0x1E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C,
  0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0x01, 0x01, 0xF0, 0xFC, 0x3E, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0,
  0xF8, 0x00, 0x00, 0x10, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0xBF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x9F, 0x07, 0x9F, 0x03,
  0xDF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x1F, 0x7C, 0x0F, 0x9F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE1,
  0xF1, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0x0E, 0x38, 0x3C,
  0x3D, 0xFD, 0xFC, 0x7B, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFB, 0xFB, 0xE3,
  0xE7, 0xE3, 0xCF, 0x8F, 0x8F, 0x9F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x78,
  0x7C, 0x7C, 0xF0, 0xF0, 0xF3, 0xE3, 0xE3, 0xE7, 0xC7, 0xC7, 0xCF, 0x8F,
  0x8F, 0x9E, 0x1E, 0x1F, 0x7C, 0x3C, 0x3C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF1,
  0xF0, 0x0E, 0x3C, 0x1E, 0xFE, 0x1E, 0xFE, 0x1F, 0xFE, 0x1F, 0xBF, 0x1F,
  0x1E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C,
  0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF8,
  0xF8, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7D, 0xF1, 0xF7,
  0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0xFB,
  0xE7, 0xEF, 0xFF, 0x1F, 0xF8, 0x7F, 0xE0, 0xFE, 0x00, 0x03, 0x8E, 0x01,
  0xEF, 0xC0, 0x7B, 0xF8, 0x1F, 0xFE, 0x07, 0xCF, 0xC1, 0xF1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1E, 0x0F, 0x8F, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xBE, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x9E, 0x1F, 0xBC,
  0x7F, 0xF9, 0xFF, 0xF3, 0xE7, 0xEF, 0x8F, 0x9F, 0x1F, 0x3C, 0x3E, 0xF8,
  0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3F, 0x3F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF0, 0xFB, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x0E, 0x38, 0xF3,
  0xC7, 0xBE, 0x3F, 0xE1, 0xFF, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0xC7, 0xFE, 0x7F, 0xE3, 0xE3, 0x1F,
  0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xC0, 0x3E,
  0x41, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0xC7, 0xF8, 0x00, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0xF3, 0xFE, 0xFF, 0xDF, 0xF5, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0xE3, 0xFC, 0x3F,
  0x87, 0xF0, 0x1E, 0x1E, 0x7C, 0x3C, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xEF,
  0x87, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7,
  0xCF, 0x8F, 0x9F, 0x3F, 0x3F, 0xFE, 0x7F, 0xF8, 0xFE, 0xF0, 0xF9, 0xE0,
  0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xBE, 0x3E, 0xF8, 0xF3, 0xE7, 0xCF, 0x9E,
  0x3E, 0xF8, 0xFB, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0xF8, 0x7F, 0xC3,
  0xE1, 0xEF, 0x1F, 0x8F, 0xBC, 0x7E, 0x3E, 0xF1, 0xF8, 0xF3, 0xCF, 0xE7,
  0xCF, 0x3B, 0x9E, 0x3D, 0xEE, 0xF8, 0xF7, 0xFB, 0xC3, 0xDD, 0xEF, 0x0F,
  0xF7, 0xFC, 0x3F, 0xDF, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xC7,
  0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87,
  0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x7E, 0x3C,
  0x3F, 0x0F, 0x80, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3E, 0x3E,
  0x0F, 0x8F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x07, 0xBE, 0x01,
  0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x2F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC0,
  0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x3E, 0x03, 0xE0,
  0x1F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x80,
  0xFC, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xD0, 0x04, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 23, 9, 0, -23 },
  { 30, 12, 8, 14, 3, -23 },
  { 42, 18, 23, 17, 0, -23 },
  { 94, 16, 26, 15, 0, -24 },
  { 146, 22, 23, 25, 2, -23 },
  { 210, 19, 23, 19, 0, -23 },
  { 265, 6, 8, 8, 3, -23 },
  { 271, 11, 28, 10, 1, -23 },
  { 310, 11, 28, 10, -2, -23 },
  { 349, 14, 15, 15, 2, -25 },
  { 376, 14, 15, 16, 1, -19 },
  { 403, 8, 8, 8, -2, -4 },
  { 411, 9, 5, 10, 0, -11 },
  { 417, 6, 5, 8, 0, -5 },
  { 421, 18, 23, 13, -2, -23 },
  { 473, 14, 23, 15, 1, -23 },
  { 514, 12, 23, 16, 3, -23 },
  { 549, 16, 23, 15, -1, -23 },
  { 595, 16, 23, 15, 0, -23 },
  { 641, 16, 23, 16, 0, -23 },
  { 687, 16, 23, 15, 0, -23 },
  { 733, 15, 23, 15, 1, -23 },
  { 777, 16, 23, 15, 1, -23 },
  { 823, 16, 23, 15, 0, -23 },
  { 869, 14, 23, 15, 1, -23 },
  { 910, 8, 18, 9, 0, -18 },
  { 928, 10, 22, 9, -2, -18 },
  { 956, 14, 16, 16, 1, -20 },
  { 984, 15, 10, 16, 1, -16 },
  { 1003, 15, 16, 16, 1, -20 },
  { 1033, 13, 23, 12, 1, -23 },
  { 1071, 22, 26, 24, 1, -23 },
  { 1143, 17, 23, 17, -2, -23 },
  { 1192, 17, 23, 17, 0, -23 },
  { 1241, 17, 23, 16, 1, -23 },
  { 1290, 18, 23, 18, 0, -23 },
  { 1342, 16, 23, 14, 0, -23 },
  { 1388, 16, 23, 14, 0, -23 },
  { 1434, 18, 23, 19, 1, -23 },
  { 1486, 20, 23, 19, 0, -23 },
  { 1544, 15, 23, 12, -1, -23 },
  { 1588, 15, 30, 9, -5, -23 },
  { 1645, 20, 23, 17, 0, -23 },
  { 1703, 12, 23, 14, 0, -23 },
  { 1738, 26, 23, 25, 0, -23 },
  { 1813, 21, 23, 20, 0, -23 },
  { 1874, 18, 23, 20, 1, -23 },
  { 1926, 17, 23, 16, 0, -23 },
  { 1975, 18, 28, 20, 1, -23 },
  { 2038, 17, 23, 17, 0, -23 },
  { 2087, 16, 23, 15, 0, -23 },
  { 2133, 15, 23, 14, 2, -23 },
  { 2177, 19, 23, 19, 1, -23 },
  { 2232, 17, 23, 17, 3, -23 },
  { 2281, 25, 23, 25, 3, -23 },
  { 2353, 21, 23, 17, -2, -23 },
  { 2414, 16, 23, 16, 3, -23 },
  { 2460, 17, 23, 14, -1, -23 },
  { 2509, 13, 28, 10, -1, -23 },
  { 2555, 8, 23, 13, 3, -23 },
  { 2578, 13, 28, 10, -2, -23 },
  { 2624, 15, 15, 15, 0, -23 },
  { 2653, 13, 3, 12, -3, 2 },
  { 2658, 6, 6, 10, 5, -25 },
  { 2663, 15, 18, 16, 1, -18 },
  { 2697, 16, 24, 16, 0, -24 },
  { 2745, 13, 18, 13, 1, -18 },
  { 2775, 17, 24, 16, 1, -24 },
  { 2826, 14, 18, 15, 1, -18 },
  { 2858, 18, 32, 10, -4, -24 },
  { 2930, 16, 26, 16, 0, -18 },
  { 2982, 16, 24, 16, 0, -24 },
  { 3030, 10, 25, 8, 0, -25 },
  { 3062, 14, 33, 8, -4, -25 },
  { 3120, 17, 24, 16, 0, -24 },
  { 3171, 10, 24, 8, 0, -24 },
  { 3201, 23, 18, 24, 0, -18 },
  { 3253, 16, 18, 16, 0, -18 },
  { 3289, 14, 18, 16, 1, -18 },
  { 3321, 18, 26, 16, -2, -18 },
  { 3380, 15, 26, 16, 1, -18 },
  { 3429, 13, 18, 12, 0, -18 },
  { 3459, 13, 18, 13, 0, -18 },
  { 3489, 11, 21, 11, 1, -21 },
  { 3518, 15, 18, 16, 1, -18 },
  { 3552, 14, 18, 15, 2, -18 },
  { 3584, 22, 18, 22, 2, -18 },
  { 3634, 18, 18, 15, -2, -18 },
  { 3675, 18, 26, 15, -2, -18 },
  { 3734, 15, 18, 13, -1, -18 },
  { 3768, 13, 28, 11, 0, -23 },
  { 3814, 4, 31, 14, 5, -24 },
  { 3830, 13, 28, 11, -2, -23 },
  { 3876, 15, 6, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC32PT7B_H_
