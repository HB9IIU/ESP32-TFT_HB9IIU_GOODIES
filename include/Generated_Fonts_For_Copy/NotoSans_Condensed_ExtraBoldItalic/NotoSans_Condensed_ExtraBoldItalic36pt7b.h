#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC36PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0xC0, 0x00, 0x78, 0xE0, 0x07, 0x9E,
  0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x38,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xE0, 0x07, 0x9E, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC1, 0xE3, 0xC0, 0x1E, 0x78, 0x01,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3E, 0xCC, 0x1F, 0x30, 0x07, 0xD8, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x09, 0xF1, 0x06, 0x7C, 0x71, 0xBE, 0x1F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x3E, 0x0F, 0xE0, 0x1E,
  0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x1F, 0x07, 0xDE, 0x0F, 0x03, 0xCF, 0x0F,
  0x01, 0xE7, 0x87, 0x81, 0xE3, 0xC7, 0x80, 0xF1, 0xE7, 0xC0, 0x78, 0xF3,
  0xC0, 0x3C, 0xF3, 0xC7, 0x9E, 0x79, 0xE7, 0xEF, 0xFD, 0xE7, 0xFF, 0xFD,
  0xF7, 0xFD, 0xFC, 0xF7, 0xDE, 0x7C, 0xF3, 0xCF, 0x00, 0x79, 0xE7, 0x80,
  0x79, 0xE3, 0xC0, 0x78, 0xF1, 0xE0, 0x3C, 0x78, 0xF0, 0x3C, 0x3C, 0x78,
  0x3E, 0x1E, 0x78, 0x1E, 0x0F, 0xFC, 0x1E, 0x07, 0xFC, 0x0F, 0x01, 0xFC,
  0x0F, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0xFC, 0x3F, 0xE3, 0xE1, 0xFF, 0x9F, 0x8F, 0xFF, 0x7C,
  0x7E, 0xFF, 0xF1, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3F, 0x0F, 0xF0, 0xFC,
  0x3F, 0x83, 0xF9, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xF7,
  0xE0, 0x7F, 0x9F, 0xC0, 0x3E, 0x7D, 0xFB, 0xE7, 0xCF, 0x9E, 0x3C, 0x79,
  0xF0, 0x01, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x02, 0x00, 0x07,
  0xC0, 0x0F, 0x02, 0x1E, 0x06, 0x3C, 0x1F, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFE, 0x1F, 0xFC, 0x7F, 0x01, 0xFF, 0x0F, 0xDE, 0x0F, 0xBE, 0x0E,
  0x3E, 0x08, 0x70, 0x00, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C,
  0x00, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0xFF, 0x80, 0x39, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFF, 0x1F, 0x9F, 0x1F, 0x1F, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7E,
  0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xFC, 0xFD, 0xF8, 0xFF,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x3F,
  0x81, 0xFE, 0x0F, 0xF8, 0x7F, 0xE7, 0xFF, 0x3F, 0xFC, 0x7D, 0xF0, 0xCF,
  0xC2, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xE3, 0xF0, 0x30, 0x7C, 0x08, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x81, 0x83, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x80, 0x7E, 0x3C, 0x7F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xDF, 0x00,
  0xFF, 0xC0, 0x7B, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x07, 0x8F, 0x83, 0xC7,
  0xE1, 0xF1, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE8,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x87, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x80,
  0x7E, 0x3C, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x3C, 0x1F, 0xFF,
  0x0F, 0xBF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xF8, 0xF9, 0xF8, 0x7C, 0xFC,
  0x3E, 0x7E, 0x1F, 0x3F, 0x1F, 0x9F, 0x0F, 0xCF, 0xC7, 0xC7, 0xE7, 0xE1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x88, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xF7, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x03,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFD, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F,
  0xC7, 0xC1, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7E,
  0x1F, 0x7E, 0x1F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFE, 0x3F, 0xBE, 0x1F, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x87, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x07,
  0x87, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x00, 0x01, 0xE0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xF0,
  0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC2, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0x0F, 0xC0, 0x7E, 0x01,
  0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x3C, 0x3F, 0xCF, 0x1E, 0x3F,
  0xE7, 0x9E, 0x3F, 0xF1, 0xCE, 0x3E, 0x78, 0xEF, 0x1E, 0x3C, 0xF7, 0x9E,
  0x1C, 0x7B, 0x8F, 0x1E, 0x3F, 0xC7, 0x0F, 0x1F, 0xE7, 0x87, 0x8E, 0xF3,
  0xC7, 0x8F, 0x79, 0xE3, 0xC7, 0x3C, 0xF3, 0xE7, 0x9E, 0x3F, 0xFF, 0x8F,
  0x1F, 0xBF, 0x87, 0x87, 0x8F, 0x83, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x80, 0x1F, 0xC7, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x07,
  0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0x3E, 0x7E, 0x07, 0xDF, 0x80, 0xFB, 0xF0,
  0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7E,
  0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7E, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0x87, 0xC1,
  0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x40, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC,
  0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x1F,
  0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF3,
  0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3E, 0x0F, 0xC3, 0xE1, 0xFC,
  0x7E, 0x3F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFC, 0x0C, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC7, 0xFC, 0xFC, 0x7F, 0xCF, 0xC7, 0xFC,
  0xFC, 0x7F, 0x8F, 0x8F, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F,
  0x8F, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7E, 0x0F, 0x81,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0,
  0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x3F, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xF0, 0xFC, 0x07, 0xC7,
  0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80,
  0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xF9, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x03, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xDF, 0x07, 0xDE, 0x3F,
  0xF8, 0x3E, 0xF1, 0xFF, 0x81, 0xF7, 0x8F, 0x7C, 0x0F, 0xBC, 0xFB, 0xE0,
  0x7D, 0xE7, 0xBF, 0x07, 0xCF, 0x7D, 0xF0, 0x3E, 0x7B, 0xCF, 0x81, 0xF3,
  0xFE, 0x7C, 0x0F, 0x9F, 0xE3, 0xE0, 0x7C, 0xFF, 0x3F, 0x07, 0xC7, 0xF1,
  0xF0, 0x3E, 0x3F, 0x8F, 0x81, 0xF1, 0xFC, 0x7C, 0x0F, 0x8F, 0xC3, 0xE0,
  0xFC, 0x7E, 0x3F, 0x07, 0xC3, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x07,
  0xF0, 0x1F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3E, 0x07, 0xF8, 0x3E, 0x0F,
  0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x7C, 0x0F, 0xFC, 0x7C, 0x0F,
  0x7C, 0x7C, 0x1F, 0x7C, 0x7C, 0x1F, 0x7C, 0xFC, 0x1F, 0x7C, 0xF8, 0x1F,
  0x3E, 0xF8, 0x1F, 0x3E, 0xF8, 0x3E, 0x3E, 0xF8, 0x3E, 0x3E, 0xF8, 0x3E,
  0x1F, 0xF0, 0x3E, 0x1F, 0xF0, 0x3E, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C,
  0x1F, 0xE0, 0x7C, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F,
  0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xFC, 0x07, 0xE7, 0xE0,
  0x3F, 0x3F, 0x03, 0xF8, 0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F,
  0x8F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x7E,
  0x1F, 0x8F, 0xC7, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xE1, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x3F, 0x03, 0xF8, 0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE1, 0xF0,
  0xFC, 0x7E, 0x3F, 0x0F, 0xCF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0xC0, 0xF9, 0xF8, 0x1F, 0x1F,
  0x07, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0xFC, 0x1F,
  0x9F, 0x83, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x87, 0xF0, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE2, 0x01, 0xF8,
  0xE0, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F,
  0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F,
  0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xFC, 0x7E, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0xFC,
  0x07, 0xFF, 0x80, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xF9, 0xF8,
  0x3F, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1,
  0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xF8, 0x0F, 0x81, 0xFF, 0x81, 0xF8, 0x3F, 0xF8, 0x1F, 0x03, 0xEF,
  0x81, 0xF0, 0x7E, 0xF8, 0x3F, 0x07, 0xEF, 0x83, 0xF0, 0x7C, 0xF8, 0x7F,
  0x0F, 0xCF, 0x87, 0xF0, 0xF8, 0xF8, 0xFF, 0x0F, 0x8F, 0x8F, 0xF1, 0xF8,
  0xF8, 0xFF, 0x1F, 0x0F, 0x9F, 0xF3, 0xF0, 0xF9, 0xEF, 0x3E, 0x0F, 0xBE,
  0xF3, 0xE0, 0xFB, 0xEF, 0x7E, 0x0F, 0xBC, 0xF7, 0xC0, 0xFF, 0xCF, 0x7C,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E,
  0x7E, 0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF1, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xFF, 0x07, 0xE7, 0xC1, 0xF9, 0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F,
  0x87, 0xE7, 0xC1, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xF0, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F,
  0x1F, 0x1F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xDE, 0x07, 0xCF, 0x03,
  0xC7, 0xC3, 0xE3, 0xE3, 0xE0, 0xF1, 0xE0, 0x79, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0xFC, 0x7C, 0x7E,
  0x3E, 0x1E, 0x1F, 0x03, 0xC7, 0xC3, 0xFB, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFF, 0x8F, 0xCF, 0xC7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF3, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xF7, 0xC0, 0xF9, 0xE0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x78, 0x0F, 0xBF, 0x03, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0x7E, 0x1F, 0x8F, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F,
  0x8F, 0xC7, 0xE7, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3E, 0xFE, 0x0F, 0x1F,
  0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFB, 0x87, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3F, 0x04, 0x7E, 0x30, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF,
  0x80, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x1E, 0x7C, 0x0F, 0xEF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xE3, 0xF0, 0xFC, 0x3E,
  0x1F, 0x87, 0xC3, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xF0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3F, 0x3F, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xEF, 0x80, 0xF9, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x3F, 0x7C, 0x3E,
  0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x18, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF9, 0xF0,
  0x3F, 0xBE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0xFC,
  0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0x83, 0xF0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x3F, 0x3F, 0x83, 0xF7,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x0C, 0x0F, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x7C, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFF, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x1F,
  0x8F, 0x87, 0xE3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x0F, 0xC7,
  0xC3, 0xF1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0x87, 0xE0, 0x01,
  0x80, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xC1,
  0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7C, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x3F,
  0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x1F, 0x9F, 0x81, 0xF3, 0xF0, 0x1F, 0x3E,
  0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xC7, 0xC0, 0x7C,
  0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC3, 0xE0, 0xF8, 0x3F, 0x00,
  0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07,
  0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0x00, 0x0F, 0x1F, 0x0F, 0x83, 0xDF, 0xEF, 0xF0, 0xF7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF1, 0xF0, 0xFC,
  0x7C, 0x7C, 0x3E, 0x1F, 0x3F, 0x1F, 0x87, 0xCF, 0x87, 0xE3, 0xF3, 0xE1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x7E, 0x1F, 0x0F, 0x9F, 0x8F, 0xC7, 0xE7,
  0xC3, 0xF1, 0xF9, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x3F, 0x0F, 0x87,
  0xCF, 0xC7, 0xE3, 0xF3, 0xE1, 0xF0, 0xFC, 0x0F, 0x1F, 0x03, 0xDF, 0xE0,
  0xF7, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x3F, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F,
  0x1F, 0x87, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F,
  0xC3, 0xE3, 0xE1, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE,
  0x3F, 0xBF, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7E, 0xFC, 0xFC,
  0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x03, 0xC7, 0x80, 0x3D,
  0xFC, 0x03, 0xDF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x3F, 0x07,
  0xC3, 0xF0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3E, 0xFE, 0x03, 0xE7, 0xC0, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xC3,
  0xFD, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xCF, 0xC7, 0xE1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xC3, 0xF3, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFB, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x0F, 0x1E, 0x1E, 0x78, 0x3D, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFD, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xE3, 0xF1, 0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x20, 0x7E, 0x61, 0xFC, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xFF, 0x9F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF1, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF9, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0x0F,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xC3,
  0xE1, 0xF1, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xF7, 0xC0, 0xF9, 0xE0, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0x78, 0xF8, 0x79,
  0xF0, 0x79, 0xF0, 0x7B, 0xE0, 0x7B, 0xE0, 0x7B, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xF8,
  0x7E, 0x1F, 0xFC, 0x3F, 0x0F, 0xBE, 0x1F, 0x87, 0xDF, 0x1F, 0xC7, 0xCF,
  0x8F, 0xE3, 0xE7, 0xCF, 0xF3, 0xF3, 0xE7, 0xF9, 0xF1, 0xF3, 0xFC, 0xF8,
  0xFB, 0xDE, 0xF8, 0x7D, 0xEF, 0x7C, 0x3E, 0xF7, 0xBC, 0x1F, 0xF3, 0xFE,
  0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87,
  0xF0, 0x00, 0x07, 0xC3, 0xF8, 0x3E, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF,
  0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3F, 0x01, 0xF9,
  0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x3F,
  0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xDF, 0x80, 0x7D, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x80, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x30, 0x00, 0x1E, 0x00, 0xBF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x07, 0xFA, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 26, 10, 0, -26 },
  { 37, 14, 10, 15, 3, -26 },
  { 55, 20, 26, 20, 0, -26 },
  { 120, 18, 29, 17, 0, -27 },
  { 186, 25, 26, 28, 2, -26 },
  { 268, 22, 26, 22, 0, -26 },
  { 340, 7, 10, 9, 3, -26 },
  { 349, 13, 32, 11, 1, -26 },
  { 401, 13, 32, 11, -3, -26 },
  { 453, 15, 17, 17, 3, -28 },
  { 485, 15, 17, 18, 2, -21 },
  { 517, 9, 10, 9, -2, -5 },
  { 529, 10, 5, 11, 0, -12 },
  { 536, 6, 6, 9, 0, -6 },
  { 541, 19, 26, 14, -2, -26 },
  { 603, 16, 26, 17, 1, -26 },
  { 655, 14, 26, 18, 3, -26 },
  { 701, 18, 26, 17, -1, -26 },
  { 760, 18, 26, 17, 0, -26 },
  { 819, 18, 26, 18, 0, -26 },
  { 878, 18, 26, 17, 0, -26 },
  { 937, 17, 26, 17, 1, -26 },
  { 993, 18, 26, 17, 1, -26 },
  { 1052, 18, 26, 17, 0, -26 },
  { 1111, 16, 26, 17, 1, -26 },
  { 1163, 9, 20, 10, 0, -20 },
  { 1186, 11, 25, 10, -2, -20 },
  { 1221, 16, 18, 18, 1, -22 },
  { 1257, 15, 12, 18, 2, -19 },
  { 1280, 16, 18, 18, 2, -22 },
  { 1316, 15, 26, 14, 1, -26 },
  { 1365, 25, 29, 26, 1, -26 },
  { 1456, 19, 26, 20, -2, -26 },
  { 1518, 19, 26, 19, 0, -26 },
  { 1580, 19, 26, 18, 1, -26 },
  { 1642, 20, 26, 21, 0, -26 },
  { 1707, 18, 26, 16, 0, -26 },
  { 1766, 18, 26, 16, 0, -26 },
  { 1825, 20, 26, 21, 2, -26 },
  { 1890, 22, 26, 21, 0, -26 },
  { 1962, 16, 26, 13, -1, -26 },
  { 2014, 17, 34, 10, -6, -26 },
  { 2087, 22, 26, 19, 0, -26 },
  { 2159, 14, 26, 16, 0, -26 },
  { 2205, 29, 26, 28, 0, -26 },
  { 2300, 24, 26, 23, 0, -26 },
  { 2378, 21, 26, 22, 1, -26 },
  { 2447, 19, 26, 19, 0, -26 },
  { 2509, 21, 32, 22, 1, -26 },
  { 2593, 19, 26, 19, 0, -26 },
  { 2655, 18, 26, 16, 0, -26 },
  { 2714, 16, 26, 16, 3, -26 },
  { 2766, 20, 26, 21, 2, -26 },
  { 2831, 19, 26, 19, 3, -26 },
  { 2893, 28, 26, 28, 3, -26 },
  { 2984, 23, 26, 19, -2, -26 },
  { 3059, 18, 26, 18, 3, -26 },
  { 3118, 19, 26, 16, -1, -26 },
  { 3180, 15, 32, 11, -1, -26 },
  { 3240, 8, 26, 15, 4, -26 },
  { 3266, 15, 32, 11, -3, -26 },
  { 3326, 17, 17, 17, 0, -26 },
  { 3363, 14, 3, 13, -3, 3 },
  { 3369, 8, 6, 12, 5, -28 },
  { 3375, 18, 20, 18, 1, -20 },
  { 3420, 18, 27, 18, 0, -27 },
  { 3481, 15, 20, 15, 1, -20 },
  { 3519, 19, 27, 18, 1, -27 },
  { 3584, 16, 20, 17, 1, -20 },
  { 3624, 20, 37, 12, -4, -28 },
  { 3717, 20, 29, 18, -1, -20 },
  { 3790, 18, 27, 19, 0, -27 },
  { 3851, 11, 28, 9, 0, -28 },
  { 3890, 16, 37, 9, -5, -28 },
  { 3964, 20, 27, 18, 0, -27 },
  { 4032, 11, 27, 9, 0, -27 },
  { 4070, 26, 20, 27, 0, -20 },
  { 4135, 18, 20, 19, 0, -20 },
  { 4180, 16, 20, 18, 1, -20 },
  { 4220, 20, 29, 18, -2, -20 },
  { 4293, 18, 29, 18, 1, -20 },
  { 4359, 15, 20, 13, 0, -20 },
  { 4397, 15, 20, 15, 0, -20 },
  { 4435, 13, 24, 13, 1, -24 },
  { 4474, 18, 20, 18, 1, -20 },
  { 4519, 16, 20, 16, 2, -20 },
  { 4559, 25, 20, 25, 2, -20 },
  { 4622, 21, 20, 17, -2, -20 },
  { 4675, 20, 29, 16, -2, -20 },
  { 4748, 16, 20, 14, -1, -20 },
  { 4788, 15, 32, 12, 0, -26 },
  { 4848, 5, 36, 16, 5, -28 },
  { 4871, 14, 32, 12, -2, -26 },
  { 4927, 17, 7, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC36PT7B_H_
