#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC23PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0x00, 0x06,
  0x1E, 0x3C, 0x70, 0x77, 0xBB, 0x9D, 0xDC, 0xEE, 0x77, 0x30, 0x07, 0x30,
  0x3B, 0x81, 0x9C, 0x0C, 0xC3, 0xFF, 0x9F, 0xFC, 0x33, 0x03, 0x98, 0x1D,
  0xC7, 0xFF, 0xBF, 0xF8, 0x77, 0x03, 0x30, 0x19, 0x81, 0xDC, 0x0C, 0xE0,
  0x01, 0x80, 0xF8, 0x3F, 0x8F, 0xF3, 0xF4, 0x74, 0x0F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x02, 0xE4, 0x5C, 0xFF, 0xBF, 0xE3, 0xF8, 0x08, 0x03,
  0x00, 0x0C, 0x02, 0x1F, 0x0E, 0x1F, 0x86, 0x0E, 0xE7, 0x06, 0x73, 0x07,
  0x33, 0x83, 0x9B, 0x81, 0xDD, 0x9E, 0xFD, 0xDF, 0x3E, 0xDD, 0x8C, 0xEC,
  0xE0, 0xEE, 0x60, 0x67, 0x30, 0x73, 0xB8, 0x31, 0xDC, 0x38, 0xFC, 0x38,
  0x3C, 0x00, 0x03, 0x80, 0x1F, 0x80, 0xFE, 0x07, 0xB8, 0x1C, 0xE0, 0x73,
  0x81, 0xFC, 0x03, 0xE0, 0x1F, 0x3C, 0xFC, 0xE7, 0xFF, 0xBC, 0xFC, 0xF3,
  0xF3, 0xC7, 0x8F, 0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0x77, 0x7E, 0xEE, 0x03,
  0x83, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x08, 0x07, 0x23, 0x1D,
  0x9F, 0xFB, 0xFC, 0xF2, 0xFC, 0xF6, 0x13, 0x81, 0x00, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3B,
  0xDC, 0xEE, 0x70, 0x7E, 0xFB, 0xF0, 0x6F, 0xFE, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x07,
  0xE3, 0xFC, 0xFF, 0x79, 0xDC, 0x77, 0x1F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3B,
  0x8E, 0xE7, 0xB9, 0xCF, 0xF3, 0xF8, 0x7C, 0x00, 0x07, 0x8F, 0x8F, 0xCF,
  0xEF, 0xF3, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x01, 0x80, 0x7E, 0x1F, 0xF1, 0xEF, 0x08, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x7F,
  0xC7, 0xFC, 0xFF, 0xC0, 0x07, 0x83, 0xF8, 0x7F, 0x8C, 0xF0, 0x0E, 0x03,
  0xC0, 0x70, 0xFC, 0x1F, 0x03, 0xF0, 0x0F, 0x01, 0xE0, 0x3D, 0x07, 0xBF,
  0xE7, 0xF8, 0xFE, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x83, 0xE0, 0xFC, 0x1B,
  0x86, 0xF1, 0xDE, 0x73, 0x8C, 0x73, 0xFF, 0xFF, 0xEF, 0xFC, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x74, 0x0F, 0xE1,
  0xFE, 0x33, 0xC0, 0x78, 0x0F, 0x01, 0xE8, 0x79, 0xFF, 0x3F, 0xC7, 0xF0,
  0x01, 0xC1, 0xFC, 0x7F, 0x1F, 0x13, 0x80, 0xF0, 0x1D, 0xC7, 0xFC, 0xFF,
  0x9E, 0x73, 0xCE, 0x71, 0xCE, 0x39, 0xCF, 0x3F, 0xC7, 0xF8, 0x7E, 0x00,
  0x3F, 0xEF, 0xFD, 0xFF, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0x03, 0x81,
  0xFC, 0x7F, 0x8E, 0x73, 0xCE, 0x79, 0xC7, 0x70, 0xFE, 0x1F, 0x07, 0xF1,
  0xEF, 0x38, 0xEF, 0x1D, 0xE7, 0xBF, 0xE3, 0xFC, 0x3F, 0x00, 0x03, 0x01,
  0xF8, 0x7F, 0x9E, 0xF3, 0x8E, 0x71, 0xDE, 0x7B, 0xCF, 0x7F, 0xE7, 0xF8,
  0xF7, 0x01, 0xE0, 0x38, 0x0F, 0x3F, 0xC7, 0xF0, 0xFC, 0x00, 0x1C, 0xF3,
  0xCE, 0x00, 0x00, 0x00, 0x01, 0x8F, 0x3C, 0xE0, 0x0E, 0x3C, 0x78, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xC7, 0x0E, 0x38, 0x70, 0x00, 0x40,
  0x70, 0x7C, 0x7E, 0x7E, 0x3C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF0, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x38,
  0x0F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x7C, 0xFC, 0xFC, 0x3C, 0x0C, 0x00,
  0x0E, 0x3F, 0x9F, 0xEC, 0xF0, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C,
  0x00, 0x00, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0xF8,
  0x0F, 0xBC, 0x1C, 0x0E, 0x38, 0x06, 0x73, 0xF7, 0x67, 0xF7, 0x66, 0x77,
  0xEE, 0x67, 0xCC, 0x66, 0xCC, 0xE6, 0xCC, 0xEE, 0xCF, 0xFC, 0xCF, 0x78,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x60, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x3F, 0x03, 0xF0, 0x77, 0x07, 0x70, 0xF7, 0x0E, 0x71, 0xE7, 0x1C, 0x71,
  0xFF, 0x3F, 0xF3, 0xFF, 0x78, 0x77, 0x07, 0xF0, 0x7F, 0x07, 0x1F, 0xE1,
  0xFF, 0x1C, 0xF1, 0xC7, 0x1C, 0x73, 0xCF, 0x3F, 0xE3, 0xF8, 0x3F, 0xE7,
  0x9E, 0x78, 0xE7, 0x9E, 0x71, 0xE7, 0xFC, 0xFF, 0xCF, 0xF0, 0x03, 0x80,
  0xFF, 0x1F, 0xE3, 0xE6, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xFF, 0x87, 0xF8, 0x3F, 0x00,
  0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x38, 0xF1, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7,
  0x0F, 0x38, 0x7B, 0xC7, 0x9E, 0x3C, 0xF3, 0xC7, 0x3E, 0x3F, 0xE3, 0xFE,
  0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x78, 0x0F, 0xF1,
  0xFC, 0x3F, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xFF, 0x3F, 0xC7, 0xF8,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x78, 0x0F, 0x11, 0xFC, 0x3F,
  0x8F, 0xF1, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xC0,
  0x3F, 0xC7, 0xFC, 0x7E, 0xE3, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF3,
  0xF7, 0x9F, 0x3C, 0xF9, 0xE3, 0xCF, 0x1E, 0x78, 0xF1, 0xFF, 0x0F, 0xF8,
  0x3F, 0x80, 0x1E, 0x1C, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xF1,
  0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF1, 0xE1, 0xC7, 0x8F, 0x1E, 0x3C, 0x70,
  0xF1, 0xC3, 0x8F, 0x0E, 0x3C, 0x78, 0x1F, 0xE3, 0xF8, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x78, 0x3F, 0xC7, 0xF0, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0x03, 0xC1, 0xF8, 0x3E, 0x0F, 0x80, 0x1E, 0x3C, 0x79,
  0xE1, 0xCF, 0x07, 0x3C, 0x1D, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC1, 0xC7, 0x0F, 0x1E, 0x3C,
  0x78, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C,
  0x1E, 0x0F, 0x07, 0x03, 0xFF, 0xFD, 0xFE, 0x1F, 0x07, 0xC7, 0xC1, 0xF1,
  0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x8E, 0xC7, 0xE3, 0xB3, 0xB8, 0xEC,
  0xFE, 0x3B, 0x77, 0x1E, 0xDD, 0xC7, 0x36, 0x71, 0xCF, 0xBC, 0x73, 0xCF,
  0x1C, 0xF3, 0x8F, 0x3C, 0xE3, 0x8E, 0x78, 0x1F, 0x0E, 0x3E, 0x1C, 0x7C,
  0x78, 0xF8, 0xE1, 0xF9, 0xC7, 0x73, 0x8E, 0xE7, 0x1D, 0xDE, 0x3B, 0xB8,
  0xF7, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3E, 0x3C, 0x3C, 0x70,
  0x78, 0x03, 0x80, 0x7F, 0x07, 0xFC, 0x7D, 0xE3, 0xC7, 0xBC, 0x3D, 0xE1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xBC, 0x3D, 0xE1, 0xEF, 0x1E, 0x78, 0xF3,
  0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xC7, 0x1C,
  0x73, 0xC7, 0x3C, 0xF3, 0xFE, 0x3F, 0xE7, 0xF8, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0x7F, 0x07, 0xFC, 0x7D, 0xE3,
  0xC7, 0xBC, 0x3D, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xBC, 0x3D, 0xE1,
  0xEF, 0x1E, 0x78, 0xF3, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0x1F, 0xE1, 0xFF, 0x1D, 0xF1, 0xCF, 0x1C, 0xF3,
  0xCF, 0x3D, 0xF3, 0xFE, 0x3F, 0xC7, 0xF8, 0x7B, 0x87, 0xBC, 0x73, 0xC7,
  0x1C, 0xF1, 0xCF, 0x1E, 0x03, 0x81, 0xFC, 0x7F, 0x9F, 0xE3, 0xC4, 0x78,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xC0, 0x39, 0x8F, 0x3F,
  0xE7, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0,
  0x3C, 0x79, 0xE3, 0xCE, 0x1C, 0x70, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCE,
  0x1C, 0x70, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0x8F, 0x3C, 0x7F, 0xE1, 0xFE,
  0x07, 0xE0, 0xF0, 0xFF, 0x0E, 0xF1, 0xEF, 0x1C, 0xF3, 0xCF, 0x38, 0xF7,
  0x8F, 0x70, 0xF7, 0x0F, 0xF0, 0xFE, 0x0E, 0xE0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0xE1, 0xC3, 0xF8, 0x70, 0xEE, 0x3C, 0x7B, 0x8F, 0x1C, 0xE7,
  0xC7, 0x39, 0xF3, 0xCE, 0x6C, 0xE3, 0xBB, 0x78, 0xEF, 0xDC, 0x3F, 0x77,
  0x0F, 0xDF, 0xC3, 0xF7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0x1F, 0x03,
  0xC7, 0xC0, 0x1E, 0x3E, 0x1C, 0x70, 0x3D, 0xE0, 0x7F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xEE,
  0x03, 0xDE, 0x0F, 0x3C, 0x1C, 0x78, 0x78, 0x78, 0xF1, 0xFE, 0x39, 0xCF,
  0x39, 0xC7, 0x70, 0xFE, 0x1F, 0x83, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3F, 0xE3, 0xFF, 0x1F, 0xF8, 0x0F, 0xC3, 0xE0, 0xF8,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0xC3, 0xF0, 0xF8, 0x00, 0xE3,
  0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x1C,
  0x07, 0xC3, 0xF0, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x07, 0xC1,
  0xF0, 0xFC, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC1, 0xDC, 0x3B, 0x8E,
  0x73, 0x8E, 0x70, 0xFC, 0x1C, 0xFF, 0xFF, 0xC0, 0xF3, 0x9E, 0x70, 0x1C,
  0xE7, 0xFD, 0xFF, 0x3D, 0xEF, 0x3D, 0xE7, 0xB8, 0xF7, 0x1C, 0xE3, 0x9C,
  0xF3, 0xFE, 0x7F, 0x87, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xDC,
  0x7F, 0xCF, 0xF9, 0xE7, 0x38, 0xE7, 0x1D, 0xE7, 0xB8, 0xF7, 0x1C, 0xE7,
  0xBF, 0xF7, 0xFC, 0xEF, 0x00, 0x0F, 0x1F, 0xDF, 0xCF, 0x2F, 0x07, 0x83,
  0x81, 0xC0, 0xE0, 0x71, 0x3F, 0x9F, 0xC7, 0xC0, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x1D, 0xE3, 0xFE, 0x7F, 0xC7, 0xBC, 0xF3, 0xCF, 0x3C, 0xE3,
  0xCE, 0x38, 0xE3, 0x8E, 0x78, 0xFF, 0x8F, 0xF0, 0x77, 0x00, 0x0F, 0x0F,
  0xE7, 0xFD, 0xC7, 0xF3, 0xFF, 0xEF, 0xF3, 0xF0, 0xE0, 0x38, 0x0F, 0x33,
  0xFC, 0x7E, 0x00, 0x00, 0x60, 0x07, 0xC0, 0x7C, 0x03, 0xA0, 0x3C, 0x01,
  0xF0, 0x3F, 0x81, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x0B,
  0xC0, 0x7E, 0x03, 0xE0, 0x04, 0x00, 0x0E, 0x71, 0xF7, 0x3F, 0xE3, 0xDE,
  0x79, 0xE7, 0x9E, 0x71, 0xE7, 0x1C, 0x71, 0xC7, 0x3C, 0x7F, 0xC7, 0xF8,
  0x3B, 0x80, 0x38, 0x07, 0x8C, 0xF0, 0xFF, 0x0F, 0xE0, 0x10, 0x00, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xDC, 0x7F, 0xCF, 0xF9, 0xE7, 0x38, 0xE7,
  0x3D, 0xE7, 0xBC, 0xE7, 0x1C, 0xE3, 0xBC, 0xF7, 0x9E, 0xE3, 0x80, 0x0C,
  0x3C, 0x78, 0xE0, 0x03, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x1C,
  0x78, 0xF1, 0xE0, 0x01, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0xBC, 0x3E, 0x0F, 0x81, 0x00, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC7, 0x9E, 0x78, 0xF7, 0x87, 0x78, 0x3B, 0x81,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3B, 0xC3, 0xCE, 0x1E, 0x78, 0xE3,
  0xC0, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE3, 0xC7,
  0x0E, 0x3C, 0x78, 0xF0, 0x19, 0xC7, 0x1D, 0xFF, 0xCF, 0xFF, 0xE7, 0xBE,
  0xF3, 0x8E, 0x79, 0xCF, 0x3D, 0xE7, 0x9C, 0xE3, 0x8E, 0x71, 0xC7, 0x38,
  0xE7, 0xBC, 0xF3, 0x9E, 0x71, 0xCE, 0x38, 0xE0, 0x19, 0xC7, 0x7C, 0xFF,
  0x9E, 0x73, 0x8E, 0x73, 0xDE, 0x7B, 0xCE, 0x71, 0xCE, 0x3B, 0xCF, 0x79,
  0xEE, 0x38, 0x0F, 0x0F, 0xE7, 0xFD, 0xEF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F,
  0xE3, 0xB9, 0xEF, 0xF3, 0xFC, 0x7C, 0x00, 0x0C, 0xE1, 0xDF, 0x1F, 0xF1,
  0xE7, 0x1C, 0x71, 0xC7, 0x3C, 0xF3, 0x8F, 0x38, 0xE3, 0x9E, 0x7F, 0xE7,
  0xFC, 0x77, 0x87, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00,
  0x1C, 0xE7, 0xDD, 0xFF, 0x3D, 0xEF, 0x3D, 0xE7, 0xB8, 0xF7, 0x1C, 0xE3,
  0x9C, 0xF3, 0xFE, 0x7F, 0x87, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x19, 0x9D, 0xCF, 0xE7, 0xF3, 0xC1, 0xC1, 0xE0, 0xF0,
  0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x00, 0x0F, 0x1F, 0xCF, 0xEF, 0x17, 0x81,
  0xE0, 0xF8, 0x3E, 0x0F, 0x43, 0xBF, 0xDF, 0xCF, 0xC0, 0x1C, 0x18, 0x3F,
  0xFE, 0xFE, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xFC, 0xFC, 0x7C,
  0x39, 0xEF, 0x3D, 0xC7, 0x38, 0xE7, 0x1D, 0xE7, 0xBC, 0xF7, 0x1C, 0xE3,
  0x9C, 0xF3, 0xFE, 0x7D, 0x8F, 0x30, 0xF1, 0xFE, 0x3B, 0xCF, 0x39, 0xC7,
  0x78, 0xEE, 0x1D, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xF3, 0xC7, 0xF3, 0xCF, 0xF3, 0xCE, 0xF7, 0xCE, 0xF7, 0xDC, 0xFF, 0xDC,
  0xEF, 0xFC, 0xED, 0xF8, 0xFD, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0,
  0xF1, 0xE0, 0x1C, 0x78, 0xE7, 0x87, 0xB8, 0x3F, 0xC0, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x81, 0xFC, 0x0E, 0xF0, 0xF7, 0x8F, 0x1C, 0x00,
  0x1E, 0x3C, 0x78, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0xF0, 0x3B, 0x80, 0xEE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0A, 0x00, 0x00, 0x1F, 0xE3,
  0xFC, 0x7F, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01,
  0xFE, 0x3F, 0xCF, 0xF0, 0x07, 0xC3, 0xE0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x7C, 0x3C, 0x0F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0F,
  0x83, 0xC7, 0xC3, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x7C, 0x3C, 0x18,
  0x00, 0x78, 0x7F, 0xFF, 0xFE, 0x1E,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 9, 6, 10, 2, -16 },
  { 22, 13, 16, 13, 0, -16 },
  { 48, 11, 18, 11, 0, -17 },
  { 73, 17, 17, 18, 1, -17 },
  { 110, 14, 17, 14, 0, -17 },
  { 140, 4, 6, 6, 2, -16 },
  { 143, 9, 21, 7, 0, -17 },
  { 167, 8, 21, 7, -2, -17 },
  { 188, 9, 11, 11, 2, -18 },
  { 201, 10, 11, 12, 1, -14 },
  { 215, 5, 6, 6, -1, -3 },
  { 219, 7, 3, 7, 0, -8 },
  { 222, 4, 4, 6, 0, -4 },
  { 224, 12, 17, 9, -1, -17 },
  { 250, 10, 17, 11, 1, -17 },
  { 272, 9, 16, 11, 2, -16 },
  { 290, 12, 17, 11, -1, -17 },
  { 316, 11, 17, 11, 0, -17 },
  { 340, 11, 16, 11, 0, -16 },
  { 362, 11, 16, 11, 0, -16 },
  { 384, 11, 17, 11, 1, -17 },
  { 408, 11, 16, 11, 1, -16 },
  { 430, 11, 17, 11, 0, -17 },
  { 454, 11, 17, 11, 0, -17 },
  { 478, 6, 13, 6, 0, -13 },
  { 488, 7, 16, 6, -1, -13 },
  { 502, 10, 11, 12, 1, -14 },
  { 516, 10, 8, 12, 1, -12 },
  { 526, 10, 11, 12, 1, -14 },
  { 540, 9, 17, 9, 1, -17 },
  { 560, 16, 19, 17, 1, -17 },
  { 598, 12, 16, 13, -1, -16 },
  { 622, 12, 16, 12, 0, -16 },
  { 646, 12, 17, 12, 1, -17 },
  { 672, 13, 16, 13, 0, -16 },
  { 698, 11, 16, 10, 0, -16 },
  { 720, 11, 16, 10, 0, -16 },
  { 742, 13, 17, 13, 1, -17 },
  { 770, 14, 16, 14, 0, -16 },
  { 798, 11, 16, 8, -1, -16 },
  { 820, 11, 21, 7, -4, -16 },
  { 849, 14, 16, 12, 0, -16 },
  { 877, 9, 16, 10, 0, -16 },
  { 895, 18, 16, 18, 0, -16 },
  { 931, 15, 16, 15, 0, -16 },
  { 961, 13, 17, 14, 1, -17 },
  { 989, 12, 16, 12, 0, -16 },
  { 1013, 13, 21, 14, 1, -17 },
  { 1048, 12, 16, 12, 0, -16 },
  { 1072, 11, 17, 11, 0, -17 },
  { 1096, 10, 16, 10, 2, -16 },
  { 1116, 13, 16, 13, 1, -16 },
  { 1142, 12, 16, 12, 2, -16 },
  { 1166, 18, 16, 18, 2, -16 },
  { 1202, 15, 16, 12, -1, -16 },
  { 1232, 11, 16, 11, 2, -16 },
  { 1254, 13, 16, 10, -1, -16 },
  { 1280, 10, 21, 7, -1, -17 },
  { 1307, 6, 17, 9, 2, -17 },
  { 1320, 10, 21, 7, -2, -17 },
  { 1347, 11, 10, 11, 0, -16 },
  { 1361, 9, 2, 9, -2, 2 },
  { 1364, 5, 4, 7, 3, -18 },
  { 1367, 11, 13, 12, 1, -13 },
  { 1385, 11, 17, 12, 0, -17 },
  { 1409, 9, 13, 10, 1, -13 },
  { 1424, 12, 17, 12, 1, -17 },
  { 1450, 10, 13, 11, 1, -13 },
  { 1467, 13, 24, 7, -3, -18 },
  { 1506, 12, 19, 12, 0, -13 },
  { 1535, 11, 17, 12, 0, -17 },
  { 1559, 7, 18, 6, 0, -18 },
  { 1575, 10, 24, 6, -3, -18 },
  { 1605, 13, 17, 11, 0, -17 },
  { 1633, 7, 17, 6, 0, -17 },
  { 1648, 17, 13, 18, 0, -13 },
  { 1676, 11, 13, 12, 0, -13 },
  { 1694, 10, 13, 12, 1, -13 },
  { 1711, 12, 19, 12, -1, -13 },
  { 1740, 11, 19, 12, 1, -13 },
  { 1767, 9, 13, 8, 0, -13 },
  { 1782, 9, 13, 9, 0, -13 },
  { 1797, 8, 15, 8, 1, -15 },
  { 1812, 11, 13, 12, 1, -13 },
  { 1830, 11, 13, 10, 1, -13 },
  { 1848, 16, 13, 16, 1, -13 },
  { 1874, 13, 13, 11, -1, -13 },
  { 1896, 14, 19, 11, -2, -13 },
  { 1930, 11, 13, 9, -1, -13 },
  { 1948, 10, 20, 8, 0, -16 },
  { 1973, 3, 23, 10, 3, -18 },
  { 1982, 9, 20, 8, -1, -16 },
  { 2005, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC23PT7B_H_
