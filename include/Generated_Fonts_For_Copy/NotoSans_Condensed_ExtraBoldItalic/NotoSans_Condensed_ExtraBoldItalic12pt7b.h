#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC12PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x64, 0x0C, 0xC0, 0x5E, 0xB5, 0x60, 0x14, 0x28, 0xD3,
  0xF2, 0x9F, 0xBF, 0x28, 0xD0, 0x08, 0xF7, 0x5C, 0x38, 0x6A, 0xBE, 0x60,
  0x80, 0x62, 0xE6, 0xA4, 0xA8, 0xFF, 0xD5, 0x2D, 0x6F, 0x46, 0x18, 0x78,
  0xB1, 0xC3, 0x6F, 0xF7, 0x6E, 0x7E, 0x7F, 0x19, 0x88, 0xC4, 0x23, 0x18,
  0xC6, 0x10, 0x31, 0x11, 0x11, 0x33, 0x26, 0xC0, 0x37, 0x5F, 0xE5, 0x00,
  0x63, 0x3E, 0xC6, 0x30, 0x6D, 0x60, 0xFC, 0xF0, 0x06, 0x08, 0x30, 0xC1,
  0x86, 0x08, 0x30, 0xC0, 0x18, 0xF6, 0xDB, 0x4F, 0x2D, 0xB6, 0x70, 0x19,
  0xBD, 0x63, 0x11, 0x8C, 0x60, 0x19, 0xF4, 0xC2, 0x18, 0xC6, 0x3E, 0xF8,
  0x39, 0xF0, 0xC2, 0x30, 0x61, 0xAE, 0xF0, 0x0C, 0x71, 0x8E, 0x7B, 0x7F,
  0x84, 0x30, 0x3C, 0xF6, 0x1C, 0x78, 0x61, 0xAE, 0xF0, 0x0C, 0xF6, 0x1E,
  0x7B, 0x2D, 0xB6, 0x70, 0x7D, 0xF0, 0xC6, 0x18, 0xC3, 0x18, 0xE0, 0x18,
  0xF6, 0xDA, 0x31, 0xED, 0xB6, 0x70, 0x19, 0xF6, 0xDB, 0x7D, 0xA1, 0xAC,
  0xE0, 0x2C, 0x01, 0xB0, 0x13, 0x00, 0x06, 0x64, 0xC0, 0x0C, 0xEE, 0x1C,
  0x1C, 0x10, 0xF8, 0x3F, 0xF0, 0x87, 0x0E, 0xEC, 0x40, 0x33, 0xC6, 0x33,
  0x30, 0x0C, 0xC0, 0x0E, 0x1D, 0x88, 0x6B, 0xD5, 0x5F, 0xAB, 0xF5, 0xAC,
  0x44, 0x1E, 0x00, 0x0C, 0x1C, 0x78, 0xB3, 0x66, 0xDF, 0xB3, 0xC6, 0x38,
  0xF6, 0x5B, 0x79, 0xB4, 0xFF, 0xF8, 0x1C, 0x7D, 0xC3, 0x06, 0x08, 0x30,
  0x34, 0x78, 0x38, 0x79, 0x9B, 0x36, 0x6D, 0x93, 0x7C, 0xF0, 0x3C, 0xF6,
  0x18, 0x79, 0x84, 0x3C, 0xF0, 0x3C, 0xF6, 0x18, 0x79, 0xE4, 0x30, 0xC0,
  0x0C, 0x7D, 0xC3, 0x06, 0xEB, 0xB3, 0x3E, 0x7C, 0x32, 0x4D, 0x9B, 0x37,
  0xEC, 0x93, 0x66, 0xCC, 0x7B, 0xCC, 0x66, 0x31, 0x8C, 0xF0, 0x0C, 0x31,
  0x86, 0x18, 0x61, 0x8C, 0x30, 0xCE, 0x30, 0x36, 0x4D, 0xB3, 0xC7, 0x8F,
  0x16, 0x6C, 0xCC, 0x31, 0x18, 0xC6, 0x31, 0x1F, 0xF0, 0x31, 0xCC, 0x67,
  0x39, 0xCE, 0x77, 0x95, 0x45, 0xD3, 0x6C, 0xDB, 0x00, 0x33, 0x33, 0x73,
  0x7A, 0x7E, 0x5E, 0x4E, 0xCC, 0xCC, 0x1C, 0x7D, 0x9B, 0x36, 0x68, 0xF3,
  0xBE, 0x78, 0x38, 0xF6, 0x5B, 0x7D, 0xE4, 0x30, 0xC0, 0x1C, 0x7D, 0x9B,
  0x36, 0x68, 0xF3, 0xBE, 0x78, 0x30, 0x70, 0x38, 0xF6, 0xDB, 0x7D, 0xE5,
  0xB6, 0xCC, 0x19, 0xF6, 0x18, 0x70, 0xE1, 0xBE, 0xF0, 0xFF, 0xD8, 0xC6,
  0x31, 0x18, 0xC0, 0x6D, 0x3C, 0xF3, 0xCB, 0x69, 0xBE, 0xF0, 0xCF, 0x3C,
  0xB6, 0xD3, 0xCF, 0x38, 0xE0, 0xCC, 0xE4, 0xF6, 0x7B, 0x6F, 0xB7, 0x53,
  0xB9, 0xDC, 0xCC, 0x00, 0x33, 0x36, 0x1E, 0x1C, 0x18, 0x1C, 0x3C, 0x6C,
  0xEC, 0xCF, 0x6D, 0x9C, 0x71, 0x86, 0x10, 0xC0, 0x7D, 0xF1, 0x86, 0x31,
  0x86, 0x3E, 0xF8, 0x39, 0x98, 0xC6, 0x23, 0x18, 0xC5, 0x30, 0xD9, 0x24,
  0x9B, 0x60, 0x39, 0xC6, 0x21, 0x18, 0xC6, 0x21, 0x38, 0x10, 0x63, 0x9A,
  0x4B, 0x30, 0xF8, 0xD0, 0x35, 0xF6, 0xF3, 0xCB, 0x67, 0x80, 0x30, 0x86,
  0x9F, 0x6D, 0x3C, 0xF6, 0xF0, 0x1B, 0xD9, 0x8C, 0x69, 0xC0, 0x06, 0x08,
  0xF3, 0xE6, 0xD9, 0xB2, 0x6C, 0x78, 0x19, 0xF6, 0xFE, 0xC3, 0x27, 0x80,
  0x1C, 0x63, 0x9E, 0x30, 0xC3, 0x08, 0x61, 0x8E, 0x30, 0x35, 0xF6, 0xF3,
  0xDB, 0x67, 0x86, 0xF3, 0x80, 0x30, 0x86, 0x9F, 0x6D, 0x3C, 0xB6, 0xD8,
  0x32, 0x66, 0x66, 0x4C, 0xC0, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x0C, 0x30,
  0xCE, 0x38, 0x30, 0x41, 0x9B, 0x67, 0x8E, 0x3E, 0x6C, 0xD8, 0x32, 0x66,
  0x66, 0xCC, 0xC0, 0x69, 0x3F, 0xDB, 0x69, 0xB4, 0x96, 0xDB, 0x6C, 0x69,
  0xF6, 0xDB, 0x4B, 0x6D, 0x80, 0x39, 0xF6, 0xF3, 0xCB, 0x67, 0x00, 0x34,
  0x7C, 0xD9, 0x32, 0x6D, 0x9E, 0x30, 0x41, 0x80, 0x35, 0xF6, 0xF3, 0xCB,
  0x67, 0x86, 0x10, 0xC0, 0x6B, 0xD8, 0xC4, 0x63, 0x00, 0x33, 0xD8, 0xE3,
  0x5B, 0xC0, 0x31, 0xDC, 0xC6, 0x23, 0x4C, 0x6D, 0xB6, 0xD3, 0xDB, 0x67,
  0x80, 0x9C, 0xED, 0x6A, 0x73, 0x00, 0x9B, 0xBA, 0xBE, 0xBE, 0xFC, 0xDC,
  0xD8, 0x36, 0x68, 0xF0, 0xC3, 0x8D, 0x3B, 0x00, 0x26, 0x4C, 0xF1, 0xE3,
  0x87, 0x0C, 0x18, 0xE1, 0x80, 0x7B, 0xCC, 0x46, 0x63, 0xC0, 0x09, 0xCC,
  0x66, 0x61, 0x8C, 0x43, 0x18, 0xFF, 0xF0, 0x21, 0x84, 0x23, 0x0C, 0xC4,
  0x67, 0x30, 0xFE, 0x70,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 4, 5, 1, -9 },
  { 9, 7, 9, 7, 0, -9 },
  { 17, 6, 10, 6, 0, -9 },
  { 25, 8, 9, 9, 1, -9 },
  { 34, 7, 9, 7, 0, -9 },
  { 42, 2, 4, 3, 1, -9 },
  { 43, 5, 11, 4, 0, -9 },
  { 50, 4, 11, 4, -1, -9 },
  { 56, 5, 5, 6, 1, -9 },
  { 60, 5, 6, 6, 1, -7 },
  { 64, 3, 4, 3, -1, -2 },
  { 66, 3, 2, 4, 0, -4 },
  { 67, 2, 2, 3, 0, -2 },
  { 68, 7, 9, 5, -1, -9 },
  { 76, 6, 9, 6, 0, -9 },
  { 83, 5, 9, 6, 1, -9 },
  { 89, 6, 9, 6, 0, -9 },
  { 96, 6, 9, 6, 0, -9 },
  { 103, 6, 9, 6, 0, -9 },
  { 110, 6, 9, 6, 0, -9 },
  { 117, 6, 9, 6, 0, -9 },
  { 124, 6, 9, 6, 0, -9 },
  { 131, 6, 9, 6, 0, -9 },
  { 138, 6, 9, 6, 0, -9 },
  { 145, 3, 7, 3, 0, -7 },
  { 148, 4, 9, 3, -1, -7 },
  { 153, 6, 6, 6, 0, -7 },
  { 158, 5, 4, 6, 1, -6 },
  { 161, 5, 6, 6, 1, -7 },
  { 165, 5, 9, 5, 0, -9 },
  { 171, 9, 10, 9, 0, -9 },
  { 183, 7, 9, 7, -1, -9 },
  { 191, 6, 9, 6, 0, -9 },
  { 198, 7, 9, 6, 0, -9 },
  { 206, 7, 9, 7, 0, -9 },
  { 214, 6, 9, 5, 0, -9 },
  { 221, 6, 9, 5, 0, -9 },
  { 228, 7, 9, 7, 0, -9 },
  { 236, 7, 9, 7, 0, -9 },
  { 244, 5, 9, 4, 0, -9 },
  { 250, 6, 12, 3, -2, -9 },
  { 259, 7, 9, 6, 0, -9 },
  { 267, 5, 9, 5, 0, -9 },
  { 273, 10, 9, 9, 0, -9 },
  { 285, 8, 9, 8, 0, -9 },
  { 294, 7, 9, 7, 0, -9 },
  { 302, 6, 9, 6, 0, -9 },
  { 309, 7, 11, 7, 0, -9 },
  { 319, 6, 9, 6, 0, -9 },
  { 326, 6, 9, 5, 0, -9 },
  { 333, 5, 9, 5, 1, -9 },
  { 339, 6, 9, 7, 1, -9 },
  { 346, 6, 9, 6, 1, -9 },
  { 353, 9, 9, 9, 1, -9 },
  { 364, 8, 9, 6, -1, -9 },
  { 373, 6, 9, 6, 1, -9 },
  { 380, 6, 9, 5, 0, -9 },
  { 387, 5, 11, 4, 0, -9 },
  { 394, 3, 9, 5, 1, -9 },
  { 398, 5, 11, 4, -1, -9 },
  { 405, 6, 6, 6, 0, -9 },
  { 410, 5, 1, 4, -1, 1 },
  { 411, 2, 2, 4, 2, -9 },
  { 412, 6, 7, 6, 0, -7 },
  { 418, 6, 9, 6, 0, -9 },
  { 425, 5, 7, 5, 0, -7 },
  { 430, 7, 9, 6, 0, -9 },
  { 438, 6, 7, 6, 0, -7 },
  { 444, 6, 12, 4, -1, -9 },
  { 453, 6, 10, 6, 0, -7 },
  { 461, 6, 9, 6, 0, -9 },
  { 468, 4, 9, 3, 0, -9 },
  { 473, 6, 12, 3, -2, -9 },
  { 482, 7, 9, 6, 0, -9 },
  { 490, 4, 9, 3, 0, -9 },
  { 495, 9, 7, 9, 0, -7 },
  { 503, 6, 7, 6, 0, -7 },
  { 509, 6, 7, 6, 0, -7 },
  { 515, 7, 10, 6, -1, -7 },
  { 524, 6, 10, 6, 0, -7 },
  { 532, 5, 7, 4, 0, -7 },
  { 537, 5, 7, 5, 0, -7 },
  { 542, 5, 8, 4, 0, -8 },
  { 547, 6, 7, 6, 0, -7 },
  { 553, 5, 7, 5, 1, -7 },
  { 558, 8, 7, 8, 1, -7 },
  { 565, 7, 7, 6, -1, -7 },
  { 572, 7, 10, 6, -1, -7 },
  { 581, 5, 7, 5, 0, -7 },
  { 586, 5, 11, 4, 0, -9 },
  { 593, 1, 12, 5, 2, -9 },
  { 595, 5, 11, 4, -1, -9 },
  { 602, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC12PT7B_H_
