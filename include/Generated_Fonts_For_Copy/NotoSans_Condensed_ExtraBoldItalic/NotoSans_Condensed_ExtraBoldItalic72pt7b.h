#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC72PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0x9F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xE3,
  0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xF8, 0x3F, 0xF1, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F,
  0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0xF1, 0xF0, 0x03, 0xFF, 0x1E,
  0x0E, 0x00, 0x7F, 0xE7, 0x80, 0x40, 0x0F, 0xFC, 0xF0, 0x00, 0x01, 0xFF,
  0x9E, 0x00, 0x00, 0x3F, 0xF3, 0xC0, 0x00, 0x07, 0xFF, 0x70, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xEF, 0xFE,
  0x00, 0x00, 0x3C, 0xFF, 0xC0, 0x00, 0x07, 0x9F, 0xF8, 0x00, 0x00, 0xF3,
  0xFF, 0x03, 0x00, 0x1E, 0x7F, 0xE0, 0x70, 0x03, 0x8F, 0xFC, 0x0F, 0x80,
  0xF1, 0xFF, 0x81, 0xFE, 0x1E, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x00,
  0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x07, 0x01, 0xFE, 0x0F, 0xF1, 0xFE,
  0x0F, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFF, 0xC7, 0xF8, 0xFF, 0x8F,
  0xF0, 0xFF, 0xFC, 0xFF, 0x9F, 0xE3, 0xFE, 0x3F, 0xFF, 0xDF, 0xFF, 0xFC,
  0x7F, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0x1F, 0xF1, 0xFE, 0x7F,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0xBF, 0xF8,
  0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xEF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x06, 0x01, 0xFE, 0x00, 0x0F,
  0x03, 0xFC, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0xFF,
  0xDF, 0xC0, 0xF3, 0xFF, 0xFF, 0xBF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0x00, 0x3F, 0xF1, 0xFF,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x3E, 0x07, 0xFC,
  0x00, 0x38, 0x0F, 0xE0, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x03, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8, 0xFF, 0x81,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xF1,
  0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE,
  0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF,
  0xCF, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F,
  0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x07,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0,
  0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFE, 0xFF, 0xC3, 0xFF, 0xBF, 0xF8, 0x3F, 0xE7, 0xFF, 0x03, 0xF0, 0xFF,
  0xC0, 0x3C, 0x1F, 0xF8, 0x07, 0x07, 0xFF, 0x00, 0x40, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xBF, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xFF, 0x00,
  0x1F, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x07, 0xFF, 0x00, 0x08, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xFF, 0x80,
  0x1C, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x00, 0x3F, 0xFC, 0x18, 0x00,
  0x0F, 0xFF, 0x83, 0xE0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xDF, 0xF8, 0x00, 0x07, 0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xF0,
  0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xE7,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0xE0,
  0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x07, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x04, 0x00, 0x03, 0xFF, 0xC0,
  0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x30, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x7C, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xDF, 0xFF,
  0x00, 0x3F, 0xF7, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0,
  0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xF1, 0xFF,
  0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xF9, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00,
  0xFF, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xBF,
  0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x08, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFE, 0x0F, 0xFF, 0x0F, 0x80, 0x7F, 0xF0, 0x60, 0x07, 0xFF, 0x04,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x03,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xFF, 0xF8, 0x7F, 0x07, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFE, 0x07,
  0xFF, 0xFF, 0x87, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x1F, 0xC7, 0xF8,
  0x3F, 0xE0, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xCF,
  0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF7, 0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xFD,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0x9F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x80, 0xFE, 0x07,
  0xFB, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0xFF, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE3, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F,
  0xC3, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0xF9, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFF,
  0xE7, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF,
  0xE1, 0xFF, 0xE0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFF,
  0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x01, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x10, 0x03, 0xFF,
  0xC0, 0x03, 0x00, 0x1F, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x20, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x30, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0xF8,
  0x7F, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xF0, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x40, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xDF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC1, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFB,
  0xFE, 0x07, 0xFD, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0xE0,
  0x07, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xC1, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xE0, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xCF,
  0xF0, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xC7, 0xF8, 0x7F, 0xCF, 0xFC, 0x00,
  0x7F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFE, 0x00, 0x3F, 0xF1, 0xFE, 0x3F, 0xE3,
  0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x3F, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F,
  0x9F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xC0, 0x07,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xF0, 0x01, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xBF, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0xBF, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0,
  0x7F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8,
  0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8,
  0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC,
  0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFD,
  0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0x00, 0x1F, 0xFE, 0x00, 0x10, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x04,
  0x00, 0x07, 0xFF, 0x80, 0x38, 0x00, 0x3F, 0xFC, 0x01, 0xF0, 0x03, 0xFF,
  0xE0, 0x1F, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x07, 0xFF, 0x9F, 0xF8,
  0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xF1, 0xFF, 0x80, 0x03, 0xFF,
  0x87, 0xFE, 0x00, 0x1F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x07,
  0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF,
  0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xF8,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF1, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFF, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xF8, 0x03,
  0xFF, 0x0F, 0xFB, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFD, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0xC3, 0xFC, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xE3, 0xFE,
  0x7F, 0x8F, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x3F, 0xC7, 0xFF, 0x00, 0x1F,
  0xF9, 0xFF, 0x1F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x8F, 0xF3, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0xC7, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC3,
  0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE1, 0xFE, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xBF, 0xF0,
  0x00, 0x3F, 0xEF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF7, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x1F, 0xFE,
  0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x07,
  0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x7F,
  0xF0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x01, 0xFF,
  0xCF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0xF1,
  0xFF, 0x80, 0x7F, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xEF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF8,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xDF,
  0xF8, 0x03, 0xFF, 0xFB, 0xFE, 0x00, 0x7F, 0xFE, 0x7F, 0xC0, 0x07, 0xFF,
  0x8F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x8F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0xF0, 0x0F,
  0xF8, 0xFF, 0xFC, 0x01, 0xFF, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x00, 0xFF, 0xF0, 0x04, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x02, 0x03, 0xFF, 0xC0, 0x18, 0x0F, 0xFF, 0x01,
  0xE0, 0x3F, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x01, 0xFF, 0xF3, 0xFF, 0x80, 0x0F, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xEF, 0xF8, 0x00, 0x3F, 0xFF,
  0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8,
  0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0x00, 0xFF, 0xCF,
  0xFE, 0x03, 0xFF, 0x9F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x30, 0x7F, 0xF8, 0x03, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFC,
  0xFF, 0xC0, 0x07, 0xFF, 0xF3, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xE1,
  0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xBF, 0xF0, 0x00,
  0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x00, 0x38, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x02, 0x00, 0x01, 0xFF,
  0xC0, 0x0C, 0x00, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFB, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x20, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF,
  0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x03, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0x9F,
  0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0x1F,
  0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x3F,
  0xF8, 0x07, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x00, 0x3F, 0xE7,
  0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xFF, 0xC0,
  0x03, 0xFE, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xEF, 0xFF, 0xE0, 0x01,
  0xFF, 0xDF, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x87, 0xFC, 0x01, 0xFF,
  0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xF7, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8,
  0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F,
  0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0xFF, 0xC0, 0x07,
  0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F,
  0xE7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFD, 0xFF, 0xC0, 0x1F, 0xF7,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x08, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0x87, 0xE0, 0x3F, 0xFC, 0x07, 0x00, 0xFF, 0xE0, 0x04, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x82, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x7F,
  0xF8, 0x3F, 0x87, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF1, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xDF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xF9, 0xFE, 0x00,
  0x7F, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x03,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x0F, 0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0x3F, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xBF, 0xC3, 0xFF,
  0x03, 0xFF, 0x1F, 0xEF, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFB, 0xFC, 0x7F,
  0xE0, 0x3F, 0xF3, 0xFC, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0x3F, 0xCF,
  0xFC, 0x03, 0xFF, 0x3F, 0xCF, 0xF3, 0xFF, 0x00, 0xFF, 0xDF, 0xE3, 0xFD,
  0xFF, 0x80, 0x3F, 0xF7, 0xF8, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFE, 0x3F,
  0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE1, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x7F, 0xF1, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x8F,
  0xFE, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xF2, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0x1F, 0xFE, 0x00, 0x01, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0xC0, 0x00, 0x7F, 0xF8, 0x80, 0x00, 0x0F,
  0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 22, 52, 19, 0, -51 },
  { 144, 27, 18, 31, 7, -51 },
  { 205, 41, 51, 39, 0, -51 },
  { 467, 35, 59, 35, 1, -55 },
  { 726, 51, 53, 57, 4, -52 },
  { 1064, 43, 53, 43, 0, -52 },
  { 1349, 13, 18, 18, 7, -51 },
  { 1379, 26, 63, 22, 1, -52 },
  { 1584, 25, 64, 22, -5, -53 },
  { 1784, 31, 32, 33, 5, -55 },
  { 1908, 32, 35, 37, 3, -43 },
  { 2048, 17, 20, 19, -4, -10 },
  { 2091, 20, 10, 22, 1, -24 },
  { 2116, 13, 13, 19, 0, -12 },
  { 2138, 39, 53, 29, -4, -52 },
  { 2397, 33, 53, 35, 2, -52 },
  { 2616, 27, 51, 35, 6, -51 },
  { 2789, 36, 52, 35, -2, -52 },
  { 3023, 35, 53, 35, 0, -52 },
  { 3255, 36, 51, 35, -1, -51 },
  { 3485, 35, 52, 35, 1, -51 },
  { 3713, 35, 53, 35, 2, -52 },
  { 3945, 37, 51, 35, 2, -51 },
  { 4181, 35, 53, 35, 1, -52 },
  { 4413, 34, 53, 35, 1, -52 },
  { 4639, 19, 41, 19, 0, -40 },
  { 4737, 23, 50, 19, -4, -40 },
  { 4881, 32, 36, 37, 3, -44 },
  { 5025, 32, 23, 37, 3, -37 },
  { 5117, 32, 36, 37, 3, -44 },
  { 5261, 28, 53, 28, 3, -52 },
  { 5447, 50, 58, 53, 2, -52 },
  { 5810, 39, 52, 39, -4, -52 },
  { 6064, 39, 51, 38, 0, -51 },
  { 6313, 37, 53, 36, 3, -52 },
  { 6559, 40, 51, 41, 0, -51 },
  { 6814, 36, 51, 32, 0, -51 },
  { 7044, 36, 51, 32, 0, -51 },
  { 7274, 40, 53, 42, 3, -52 },
  { 7539, 45, 51, 43, 0, -51 },
  { 7826, 34, 51, 26, -3, -51 },
  { 8043, 34, 67, 21, -11, -51 },
  { 8328, 45, 51, 38, 0, -51 },
  { 8615, 27, 51, 31, 0, -51 },
  { 8788, 57, 51, 55, 0, -51 },
  { 9152, 48, 51, 46, 0, -51 },
  { 9458, 40, 53, 44, 3, -52 },
  { 9723, 39, 51, 37, 0, -51 },
  { 9972, 40, 64, 44, 3, -52 },
  { 10292, 38, 51, 38, 0, -51 },
  { 10535, 37, 53, 33, -1, -52 },
  { 10781, 32, 51, 32, 6, -51 },
  { 10985, 41, 52, 42, 3, -51 },
  { 11252, 38, 51, 38, 6, -51 },
  { 11495, 57, 51, 56, 6, -51 },
  { 11859, 47, 51, 37, -4, -51 },
  { 12159, 36, 51, 36, 6, -51 },
  { 12389, 40, 51, 32, -3, -51 },
  { 12644, 30, 64, 22, -3, -52 },
  { 12884, 17, 53, 29, 7, -52 },
  { 12997, 30, 64, 22, -5, -52 },
  { 13237, 34, 32, 34, 0, -51 },
  { 13373, 29, 6, 27, -7, 6 },
  { 13395, 15, 11, 23, 10, -55 },
  { 13416, 35, 41, 37, 2, -40 },
  { 13596, 35, 56, 37, 0, -55 },
  { 13841, 30, 41, 30, 2, -40 },
  { 13995, 38, 56, 37, 2, -55 },
  { 14261, 31, 41, 34, 2, -40 },
  { 14420, 39, 72, 23, -8, -55 },
  { 14771, 38, 57, 37, -1, -40 },
  { 15042, 35, 55, 37, 0, -55 },
  { 15283, 22, 55, 19, 0, -55 },
  { 15435, 31, 72, 19, -9, -55 },
  { 15714, 39, 55, 36, 0, -55 },
  { 15983, 22, 55, 19, 0, -55 },
  { 16135, 53, 40, 55, 0, -40 },
  { 16400, 35, 40, 37, 0, -40 },
  { 16575, 32, 41, 36, 2, -40 },
  { 16739, 39, 57, 37, -4, -40 },
  { 17017, 35, 57, 37, 2, -40 },
  { 17267, 30, 40, 26, 0, -40 },
  { 17417, 30, 41, 29, 0, -40 },
  { 17571, 24, 49, 25, 3, -48 },
  { 17718, 35, 41, 37, 2, -40 },
  { 17898, 33, 40, 33, 4, -40 },
  { 18063, 50, 40, 50, 4, -40 },
  { 18313, 41, 40, 34, -4, -40 },
  { 18518, 42, 57, 33, -5, -40 },
  { 18818, 33, 40, 29, -2, -40 },
  { 18983, 30, 62, 25, 0, -51 },
  { 19216, 9, 71, 31, 11, -55 },
  { 19296, 29, 62, 25, -4, -51 },
  { 19521, 32, 13, 37, 3, -32 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC72PT7B_H_
