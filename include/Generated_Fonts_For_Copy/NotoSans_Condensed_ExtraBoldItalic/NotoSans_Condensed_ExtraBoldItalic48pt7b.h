#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC48PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x7F, 0x1F, 0xDF, 0xCF, 0xE7,
  0xF3, 0xF9, 0xF8, 0xFE, 0x7E, 0x3F, 0xBF, 0x8F, 0xCF, 0xE3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xE3, 0xE1, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x7C, 0x3E, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0x3E, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xDC, 0xF0, 0x3F, 0x38,
  0x40, 0x7E, 0x60, 0x00, 0xFC, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3B, 0xF8, 0x00, 0x77, 0xF1, 0x00, 0xCF, 0xE3, 0x81, 0x9F, 0xC7, 0xC7,
  0x7F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x04, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x7F,
  0xF0, 0x07, 0xC0, 0x3F, 0xFE, 0x03, 0xE0, 0x0F, 0xDF, 0x81, 0xF8, 0x07,
  0xE7, 0xE0, 0x7C, 0x01, 0xF0, 0xF8, 0x3F, 0x00, 0x7C, 0x7E, 0x1F, 0x80,
  0x3F, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE3, 0xF0, 0x03, 0xE1, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x3F, 0x00, 0x0F, 0x8F, 0xCF,
  0x87, 0xE3, 0xE3, 0xE7, 0xE7, 0xFC, 0xF9, 0xF9, 0xF3, 0xFF, 0xBF, 0xFC,
  0xFD, 0xFF, 0xEF, 0xFE, 0x7E, 0x7F, 0xF9, 0xFF, 0x9F, 0x3F, 0x3E, 0x3F,
  0x8F, 0xCF, 0x8F, 0xC3, 0x83, 0xE7, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0xFC,
  0x00, 0xFC, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC3,
  0xE0, 0x0F, 0xC3, 0xF1, 0xF8, 0x03, 0xE0, 0xFC, 0x7E, 0x01, 0xF8, 0x3F,
  0x1F, 0x00, 0x7C, 0x0F, 0xCF, 0xC0, 0x3F, 0x03, 0xFF, 0xE0, 0x1F, 0x80,
  0x7F, 0xF8, 0x07, 0xC0, 0x1F, 0xFC, 0x03, 0xF0, 0x03, 0xFE, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x7F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0x7F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC3, 0xF8, 0x1F, 0xFC, 0x3F, 0x81, 0xFF, 0xE1, 0xFC,
  0x1F, 0xFF, 0x8F, 0xE1, 0xFF, 0xFC, 0xFE, 0x1F, 0xEF, 0xFF, 0xF1, 0xFE,
  0x7F, 0xFF, 0x0F, 0xE1, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0x87, 0xF8, 0x3F,
  0xF8, 0x3F, 0xC1, 0xFF, 0xC1, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x7F, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0xFE, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x40, 0xFC, 0x07, 0x0F, 0x80, 0x7C, 0xF8,
  0x0F, 0xFF, 0x8E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0x7E, 0x07, 0xF3, 0xF0, 0x3E, 0x3F, 0x80, 0xC3, 0xF0, 0x04, 0x1C, 0x00,
  0x01, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x1E, 0x3F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC,
  0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x7F, 0x83, 0xFD, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xFB, 0xFC, 0x1F,
  0xEF, 0xF0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0x8F,
  0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0x3F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0xC7,
  0xF7, 0xF0, 0xF1, 0xFC, 0x38, 0xFE, 0x04, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xF0, 0xFF, 0x01, 0xC0, 0xFF, 0x00, 0x80, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xC0, 0xFF, 0x01, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC4, 0x00, 0x7F, 0x8E,
  0x01, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFB,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3E, 0x7F,
  0x00, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x0F, 0xE0,
  0x7E, 0x3F, 0xC1, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x06, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x80, 0x0F, 0xF0, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFA, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xC6,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x60, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFC,
  0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07,
  0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFF,
  0x0F, 0xE3, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF9, 0xFC, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xC7, 0xF0, 0x3F, 0x87, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0x8F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC7, 0xF8, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF3, 0xFC, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xE1,
  0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x1F, 0xFB, 0xF0, 0x3F, 0xDF, 0xC0, 0x7E, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x81, 0xFE, 0x0F,
  0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x1F, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xCF, 0xF8, 0xE0, 0xFF, 0x10, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xFC, 0x7C, 0x3E,
  0x0F, 0xFF, 0x1F, 0x1F, 0x87, 0xFF, 0xC7, 0xC7, 0xC3, 0xFF, 0xF1, 0xF3,
  0xE1, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0x3E, 0x1F, 0x3E, 0x3E, 0x0F, 0x87,
  0xDF, 0x0F, 0x83, 0xE1, 0xF7, 0xC7, 0xE1, 0xF0, 0xF9, 0xF1, 0xF0, 0x7C,
  0x3E, 0x7C, 0x7C, 0x1F, 0x0F, 0x9E, 0x1F, 0x0F, 0xC3, 0xC7, 0x87, 0xC3,
  0xE1, 0xF3, 0xE1, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F,
  0xFF, 0xFF, 0x0F, 0x87, 0xFF, 0xFF, 0xC3, 0xE0, 0xFF, 0x7F, 0xE0, 0x7C,
  0x3F, 0x8F, 0xE0, 0x1F, 0x01, 0x80, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x00, 0x0F, 0xE0, 0x01, 0x80,
  0x01, 0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01,
  0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0x7F, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFE,
  0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3,
  0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xFF, 0xC0, 0x07,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0x83, 0xFC,
  0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0x8F, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0,
  0x7F, 0x83, 0xF8, 0x3F, 0xE0, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xF8, 0x18, 0x0F, 0xF8, 0x04, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x08, 0x07, 0xFC, 0x1C, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xF0, 0x1F, 0xC1, 0xFF, 0x03, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F,
  0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF,
  0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x1F,
  0xF8, 0x1F, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE0, 0x38, 0x0F, 0xF8, 0x01, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xFC, 0x7F, 0x87, 0xFF, 0x8F, 0xE0,
  0xFF, 0xE3, 0xFC, 0x1F, 0xFC, 0x7F, 0x87, 0xFF, 0x8F, 0xF0, 0xFF, 0xF1,
  0xFE, 0x1F, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0xFE, 0x07,
  0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x08, 0x7F, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x3F,
  0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xE0,
  0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x03,
  0xF8, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFD,
  0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xBF, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1,
  0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F,
  0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFB,
  0xE0, 0x7F, 0xFC, 0x07, 0xEF, 0x83, 0xF7, 0xF0, 0x1F, 0xBE, 0x0F, 0xFF,
  0x80, 0xFE, 0xF8, 0x7E, 0xFE, 0x03, 0xFB, 0xF1, 0xFB, 0xF8, 0x0F, 0xEF,
  0xC7, 0xEF, 0xE0, 0x3F, 0x3F, 0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0xFD, 0xFC,
  0x07, 0xF3, 0xF7, 0xE7, 0xF0, 0x1F, 0xCF, 0xDF, 0x9F, 0xC0, 0x7F, 0x3F,
  0xFC, 0x7F, 0x01, 0xF8, 0xFF, 0xF3, 0xF8, 0x0F, 0xE3, 0xFF, 0x8F, 0xE0,
  0x3F, 0x8F, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xF0, 0xFE, 0x03, 0xF8, 0xFF,
  0xC3, 0xF8, 0x0F, 0xC3, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x1F, 0x83, 0xFC,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7E,
  0x01, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x80, 0xFE,
  0x03, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC1, 0xFC,
  0x07, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xC1, 0xFC, 0x07, 0xEF, 0xC1, 0xF8,
  0x07, 0xEF, 0xC3, 0xF8, 0x07, 0xEF, 0xE3, 0xF8, 0x0F, 0xEF, 0xE3, 0xF8,
  0x0F, 0xEF, 0xE3, 0xF8, 0x0F, 0xE7, 0xE3, 0xF0, 0x0F, 0xC7, 0xF7, 0xF0,
  0x1F, 0xC7, 0xF7, 0xF0, 0x1F, 0xC7, 0xF7, 0xF0, 0x1F, 0xC3, 0xF7, 0xF0,
  0x1F, 0xC3, 0xF7, 0xE0, 0x1F, 0x83, 0xFF, 0xE0, 0x3F, 0x83, 0xFF, 0xE0,
  0x3F, 0x83, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xC0,
  0x3F, 0x01, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xC0,
  0x7F, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x80,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xC3, 0xFE,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE,
  0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xCF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03,
  0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F,
  0x81, 0xFF, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0x87, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC,
  0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7,
  0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07,
  0xF8, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07,
  0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x38, 0x0F, 0xF0, 0x08, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x80, 0x0F, 0xE0, 0xE0, 0x1F, 0xE0, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01,
  0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE,
  0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xE7, 0xF8, 0x0F, 0xF1,
  0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F,
  0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF0,
  0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0x7F, 0xBF, 0x80, 0xFF, 0x01, 0xFC, 0xFE,
  0x03, 0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0xF0, 0x7F, 0x0F, 0xE1, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xFF, 0x0F,
  0xE0, 0xFE, 0x1F, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0xF1, 0xFC, 0x0F, 0xE3,
  0xFF, 0xC7, 0xF0, 0x3F, 0x9F, 0xBF, 0x3F, 0x80, 0xFE, 0x7E, 0xFC, 0xFE,
  0x03, 0xFB, 0xFB, 0xF7, 0xF8, 0x0F, 0xEF, 0xCF, 0xDF, 0xC0, 0x3F, 0xBF,
  0x3F, 0x7F, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xF7, 0xE3, 0xEF, 0xE0,
  0x0F, 0xDF, 0x8F, 0xBF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x07,
  0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x3F, 0x8F, 0xE0, 0x3F, 0x9F,
  0xE0, 0x3F, 0x9F, 0xC0, 0x3F, 0xBF, 0xC0, 0x3F, 0xBF, 0x80, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x80,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x03,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC,
  0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x07, 0xE0, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F,
  0x87, 0xE0, 0xFC, 0x3F, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x7F, 0x03, 0xFF,
  0x7E, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF7,
  0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83,
  0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xC0, 0x1F, 0x8F,
  0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF3, 0xC0, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0x0F,
  0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0xFF, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x83, 0xF3, 0xFE, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xF1, 0xC1, 0xFE, 0x04, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x10, 0xFF,
  0x03, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1E,
  0x1F, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x9F, 0xF0, 0x1F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF,
  0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFD, 0xF8, 0x03, 0xFE, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x87, 0xE3, 0xF8, 0x3F, 0x3F,
  0x81, 0xF9, 0xFC, 0x1F, 0xDF, 0xE1, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x08, 0x3F, 0xC1, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x10,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xE7, 0xF0,
  0x0F, 0xFD, 0xF8, 0x07, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0xDF, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8,
  0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC,
  0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFB, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0x00, 0x7F,
  0x80, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF3, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFE, 0xFF, 0x0F, 0xF0,
  0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFC, 0x0F,
  0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0x07, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F,
  0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF1, 0xFE,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x80, 0x00, 0x78, 0x01, 0xF8,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x03, 0xFC, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x7F,
  0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xFB,
  0xFC, 0x00, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x1F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0xFC, 0xFF, 0x07, 0xF0, 0x1F, 0xBF, 0xF3, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE,
  0x7F, 0xE7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x0F,
  0xF1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x07, 0xF1, 0xFC, 0x1F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xC7,
  0xF0, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x1F, 0xE3, 0xF8, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC7,
  0xF0, 0x1F, 0xBF, 0xF0, 0x3F, 0x7F, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE,
  0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F,
  0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0x3F,
  0xC1, 0xFC, 0xFE, 0x07, 0xF7, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x03,
  0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFB,
  0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x3F, 0xC3, 0xFC, 0xFF, 0x1F, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0x3F, 0xC0, 0x0F,
  0xDF, 0xF8, 0x03, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xF3, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xDF,
  0xF8, 0x07, 0xF7, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xFE, 0x7F, 0x03, 0xFF, 0x7E, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xE7, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0x83, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0xFF,
  0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0x9F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x7E, 0x3E, 0x07, 0xE7,
  0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xC1, 0xC1, 0xFC, 0x04, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0xC0, 0x7F, 0x8F, 0xDF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF7,
  0xE0, 0x3F, 0xE7, 0xC0, 0x1F, 0xC7, 0xC0, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xEF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE7,
  0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF,
  0x07, 0xF8, 0x3F, 0xBF, 0x87, 0xFC, 0x1F, 0xDF, 0xC3, 0xFE, 0x1F, 0xCF,
  0xE3, 0xFF, 0x0F, 0xE7, 0xF1, 0xFF, 0x8F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF1,
  0xFC, 0xFF, 0xE3, 0xF0, 0xFE, 0x7F, 0xF3, 0xF8, 0x7E, 0x7F, 0xF9, 0xFC,
  0x3F, 0x3E, 0xFD, 0xFC, 0x1F, 0x9F, 0x7E, 0xFE, 0x0F, 0xDF, 0xBF, 0x7E,
  0x07, 0xEF, 0x9F, 0xFF, 0x03, 0xF7, 0xCF, 0xBF, 0x01, 0xFF, 0xE7, 0xDF,
  0x80, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x1F,
  0xC1, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x8F,
  0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0xBF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x01,
  0xFC,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 35, 13, 0, -34 },
  { 67, 18, 12, 21, 5, -34 },
  { 94, 27, 34, 26, 0, -34 },
  { 209, 23, 39, 23, 1, -36 },
  { 322, 34, 35, 38, 3, -35 },
  { 471, 29, 35, 29, 0, -35 },
  { 598, 8, 12, 12, 5, -34 },
  { 610, 17, 43, 14, 1, -35 },
  { 702, 18, 43, 14, -4, -35 },
  { 799, 20, 22, 22, 4, -37 },
  { 854, 21, 24, 24, 2, -29 },
  { 917, 12, 12, 13, -3, -6 },
  { 935, 13, 6, 15, 1, -16 },
  { 945, 8, 9, 13, 0, -8 },
  { 954, 26, 35, 19, -3, -35 },
  { 1068, 22, 35, 23, 1, -35 },
  { 1165, 18, 34, 23, 4, -34 },
  { 1242, 24, 35, 23, -1, -35 },
  { 1347, 23, 35, 23, 0, -35 },
  { 1448, 23, 34, 23, 0, -34 },
  { 1546, 24, 34, 23, 0, -34 },
  { 1648, 23, 35, 23, 2, -35 },
  { 1749, 25, 34, 23, 1, -34 },
  { 1856, 24, 35, 23, 0, -35 },
  { 1961, 22, 35, 23, 1, -35 },
  { 2058, 13, 28, 13, 0, -27 },
  { 2104, 16, 33, 13, -3, -27 },
  { 2170, 21, 24, 24, 2, -29 },
  { 2233, 21, 16, 24, 2, -25 },
  { 2275, 21, 24, 24, 2, -29 },
  { 2338, 19, 36, 19, 2, -35 },
  { 2424, 34, 39, 35, 1, -35 },
  { 2590, 26, 34, 26, -3, -34 },
  { 2701, 26, 34, 26, 0, -34 },
  { 2812, 25, 35, 24, 2, -35 },
  { 2922, 27, 34, 28, 0, -34 },
  { 3037, 24, 34, 22, 0, -34 },
  { 3139, 24, 34, 21, 0, -34 },
  { 3241, 27, 35, 28, 2, -35 },
  { 3360, 30, 34, 29, 0, -34 },
  { 3488, 23, 34, 17, -2, -34 },
  { 3586, 23, 44, 14, -8, -34 },
  { 3713, 30, 34, 25, 0, -34 },
  { 3841, 18, 34, 21, 0, -34 },
  { 3918, 38, 34, 37, 0, -34 },
  { 4080, 32, 34, 31, 0, -34 },
  { 4216, 27, 35, 29, 2, -35 },
  { 4335, 26, 34, 25, 0, -34 },
  { 4446, 27, 43, 29, 2, -35 },
  { 4592, 25, 34, 25, 0, -34 },
  { 4699, 24, 35, 22, 0, -35 },
  { 4804, 21, 34, 22, 4, -34 },
  { 4894, 27, 34, 28, 2, -34 },
  { 5009, 25, 34, 25, 4, -34 },
  { 5116, 38, 34, 37, 4, -34 },
  { 5278, 31, 34, 25, -3, -34 },
  { 5410, 24, 34, 24, 4, -34 },
  { 5512, 27, 34, 22, -2, -34 },
  { 5627, 20, 43, 15, -2, -35 },
  { 5735, 11, 35, 19, 5, -35 },
  { 5784, 19, 43, 15, -3, -35 },
  { 5887, 23, 21, 23, 0, -34 },
  { 5948, 19, 4, 18, -5, 4 },
  { 5958, 10, 8, 15, 7, -37 },
  { 5968, 24, 27, 25, 1, -27 },
  { 6049, 23, 36, 24, 0, -36 },
  { 6153, 20, 27, 20, 1, -27 },
  { 6221, 26, 36, 25, 1, -36 },
  { 6338, 21, 27, 23, 1, -27 },
  { 6409, 26, 49, 15, -5, -37 },
  { 6569, 26, 39, 25, -1, -27 },
  { 6696, 23, 36, 25, 0, -36 },
  { 6800, 15, 37, 13, 0, -37 },
  { 6870, 21, 49, 13, -6, -37 },
  { 6999, 26, 36, 24, 0, -36 },
  { 7116, 15, 36, 12, 0, -36 },
  { 7184, 35, 27, 37, 0, -27 },
  { 7303, 23, 27, 25, 0, -27 },
  { 7381, 22, 27, 24, 1, -27 },
  { 7456, 26, 38, 24, -3, -27 },
  { 7580, 24, 39, 25, 1, -27 },
  { 7697, 20, 27, 17, 0, -27 },
  { 7765, 20, 27, 20, 0, -27 },
  { 7833, 16, 32, 17, 2, -32 },
  { 7897, 24, 26, 25, 1, -26 },
  { 7975, 22, 26, 22, 3, -26 },
  { 8047, 33, 26, 33, 3, -26 },
  { 8155, 28, 26, 22, -3, -26 },
  { 8246, 28, 38, 22, -3, -26 },
  { 8379, 22, 26, 19, -2, -26 },
  { 8451, 20, 42, 17, 0, -34 },
  { 8556, 6, 48, 21, 7, -37 },
  { 8592, 19, 42, 17, -3, -34 },
  { 8692, 21, 8, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC48PT7B_H_
