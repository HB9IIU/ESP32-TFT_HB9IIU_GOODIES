#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC7PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xF0, 0x7F, 0x6F, 0xE0, 0x69, 0xFC, 0x6D, 0xBA, 0x75,
  0x80, 0x66, 0x5B, 0xF0, 0xC0, 0x6A, 0x49, 0x00, 0x24, 0x95, 0x80, 0xFC,
  0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x25, 0x48, 0x6E, 0xDC, 0x76, 0x80, 0x64,
  0xAE, 0x65, 0x9E, 0x2E, 0xF4, 0x6B, 0x9E, 0x74, 0xEA, 0xE0, 0x72, 0x24,
  0xC0, 0x6D, 0xDE, 0x7F, 0x9C, 0x42, 0x42, 0x80, 0x38, 0x80, 0xE3, 0x80,
  0xC7, 0x00, 0x65, 0x08, 0x3B, 0xF7, 0xF9, 0x30, 0x2D, 0xFA, 0x75, 0x6A,
  0xE0, 0x74, 0xC8, 0x60, 0x75, 0x5B, 0xE0, 0x69, 0xCE, 0x69, 0xC8, 0x74,
  0xF9, 0x60, 0x55, 0x79, 0xA0, 0x69, 0x2C, 0x24, 0xA5, 0xA0, 0x56, 0x6A,
  0xA0, 0x49, 0x4E, 0x4D, 0xE7, 0xAA, 0xB8, 0x4B, 0x9D, 0x6B, 0x00, 0x75,
  0xD9, 0x60, 0x75, 0x68, 0x80, 0x75, 0xD9, 0x62, 0x65, 0x6A, 0xA0, 0x69,
  0x9C, 0xF2, 0x48, 0x55, 0x5B, 0xE0, 0xB7, 0x68, 0xAF, 0xBD, 0x6A, 0x00,
  0x56, 0x66, 0xA0, 0xBB, 0x48, 0x72, 0x4C, 0xE0, 0x6A, 0x49, 0x00, 0xF8,
  0x24, 0x95, 0x80, 0x2E, 0x80, 0xE0, 0x80, 0x5E, 0xAE, 0x4D, 0xDE, 0x72,
  0x60, 0x15, 0xAA, 0xE0, 0x77, 0x70, 0x37, 0x24, 0x44, 0x80, 0x5A, 0xAE,
  0x2C, 0x4D, 0xDA, 0x56, 0x80, 0x24, 0xA4, 0xA0, 0x47, 0x6E, 0xA0, 0x56,
  0x80, 0x7B, 0x6B, 0x50, 0x6E, 0xD0, 0x76, 0xF0, 0x6E, 0xF9, 0x00, 0x5A,
  0xAE, 0x24, 0x6A, 0x40, 0x79, 0x60, 0x5D, 0x4C, 0x5E, 0xAE, 0xBA, 0xC4,
  0xAD, 0x7D, 0xE0, 0xF6, 0x4A, 0xBA, 0x44, 0xC8, 0xE9, 0x60, 0x69, 0x69,
  0x80, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 5, 5, 6, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 2, 1, -5 },
  { 17, 3, 6, 2, 0, -5 },
  { 20, 3, 6, 2, -1, -5 },
  { 23, 2, 3, 3, 1, -5 },
  { 24, 3, 3, 4, 0, -4 },
  { 26, 1, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -2 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 2, 5, 3, 1, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 4, 5, 3, 0, -5 },
  { 46, 4, 5, 3, 0, -5 },
  { 49, 3, 5, 3, 0, -5 },
  { 51, 3, 5, 3, 0, -5 },
  { 53, 2, 4, 2, 0, -4 },
  { 54, 2, 5, 2, 0, -4 },
  { 56, 3, 3, 4, 0, -4 },
  { 58, 3, 3, 4, 0, -4 },
  { 60, 3, 3, 4, 0, -4 },
  { 62, 3, 5, 3, 0, -5 },
  { 64, 5, 6, 5, 0, -5 },
  { 68, 3, 5, 4, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 3, 5, 3, 0, -5 },
  { 81, 3, 5, 3, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 3, 5, 3, 0, -5 },
  { 91, 3, 7, 2, -1, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 3, 5, 3, 0, -5 },
  { 99, 6, 5, 5, 0, -5 },
  { 103, 5, 5, 4, 0, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 4, 6, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 3, 5, 3, 1, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 3, 5, 4, 1, -5 },
  { 128, 5, 5, 5, 1, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 3, 5, 3, 1, -5 },
  { 137, 4, 5, 3, 0, -5 },
  { 140, 3, 6, 2, 0, -5 },
  { 143, 1, 5, 3, 1, -5 },
  { 144, 3, 6, 2, -1, -5 },
  { 147, 3, 3, 3, 0, -5 },
  { 149, 3, 1, 3, -1, 0 },
  { 150, 1, 1, 2, 1, -5 },
  { 151, 4, 4, 4, 0, -4 },
  { 153, 3, 5, 4, 0, -5 },
  { 155, 3, 4, 3, 0, -4 },
  { 157, 4, 5, 4, 0, -5 },
  { 160, 3, 4, 3, 0, -4 },
  { 162, 4, 7, 2, -1, -5 },
  { 166, 4, 6, 4, 0, -4 },
  { 169, 3, 5, 4, 0, -5 },
  { 171, 2, 5, 2, 0, -5 },
  { 173, 3, 7, 2, -1, -5 },
  { 176, 4, 5, 3, 0, -5 },
  { 179, 2, 5, 2, 0, -5 },
  { 181, 5, 4, 5, 0, -4 },
  { 184, 3, 4, 4, 0, -4 },
  { 186, 3, 4, 4, 0, -4 },
  { 188, 3, 6, 4, 0, -4 },
  { 191, 4, 6, 4, 0, -4 },
  { 194, 3, 4, 3, 0, -4 },
  { 196, 3, 4, 3, 0, -4 },
  { 198, 3, 5, 2, 0, -5 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 4, 3, 0, -4 },
  { 204, 5, 4, 5, 0, -4 },
  { 207, 4, 4, 3, 0, -4 },
  { 209, 4, 6, 3, 0, -4 },
  { 212, 3, 4, 3, 0, -4 },
  { 214, 3, 6, 2, 0, -5 },
  { 217, 1, 7, 3, 1, -5 },
  { 218, 2, 6, 2, 0, -5 },
  { 220, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC7PT7B_H_
