#ifndef _ROBOTOMONO_BOLD47PT7B_H_
#define _ROBOTOMONO_BOLD47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold47pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0x7E, 0x3E, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xDF, 0x07, 0xBE, 0x0F, 0x7C,
  0x1E, 0xF8, 0x3D, 0xF0, 0x7B, 0xE0, 0xF7, 0xC1, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87,
  0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0x9F, 0xF1, 0xFC, 0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0,
  0x1F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFF, 0x03, 0xFD, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0xF8, 0x20, 0x3C, 0x3E, 0x0E, 0x0F,
  0x07, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x3E, 0x78,
  0x0F, 0x8F, 0x9E, 0x03, 0xFF, 0xCF, 0x00, 0x7F, 0xF3, 0xC0, 0x0F, 0xF9,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x7E,
  0x00, 0x1E, 0x7F, 0xE0, 0x0F, 0x3F, 0xF8, 0x03, 0xCF, 0xFF, 0x01, 0xE7,
  0xC3, 0xC0, 0x79, 0xF0, 0xF0, 0x3C, 0x7C, 0x3C, 0x1F, 0x1F, 0x0F, 0x01,
  0x87, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xF9, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xDF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0xFC, 0xFF, 0xF8, 0x3E,
  0x7F, 0x7F, 0x0F, 0x9F, 0x9F, 0xE3, 0xEF, 0xE3, 0xF9, 0xFB, 0xF0, 0x7F,
  0x7E, 0xFC, 0x0F, 0xFF, 0x3F, 0x01, 0xFF, 0xCF, 0xC0, 0x7F, 0xE3, 0xF8,
  0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF, 0x81, 0xFF, 0x87, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x03, 0x80, 0x3C, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x78, 0x00, 0xC0, 0x60,
  0x03, 0x80, 0x1E, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0x3C, 0x01, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x18, 0x1E, 0x03,
  0x7C, 0x3C, 0x1E, 0xFE, 0x38, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xF7, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xC0, 0x38, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7C,
  0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x3F, 0xBF, 0xDF, 0xEF, 0xFF, 0xFB, 0xFC, 0xFC,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E,
  0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x7E,
  0xFF, 0xFB, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFD, 0xF8,
  0x07, 0xF7, 0xE0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x83, 0xF8, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0xFC, 0x0F, 0xF8, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xC0, 0xFE, 0x7F, 0x00,
  0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xC0, 0x7F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xF7, 0xF8, 0x1F, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3E, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x1F,
  0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0x83, 0xF8, 0x0F,
  0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7E, 0x07,
  0xF8, 0x30, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x1F, 0x9F, 0xC0, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE3, 0xFC, 0x0F, 0xDF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0x07,
  0xFB, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3, 0xF8, 0x1F, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x87, 0xFC, 0xFF, 0x0F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFC,
  0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7,
  0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0x7F, 0xC3, 0xF8, 0x1F, 0xCF, 0xE0,
  0x1F, 0x9F, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFC, 0x01,
  0xFD, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF8, 0x1F, 0xC7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xF9, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7E,
  0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F, 0x01,
  0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xDF, 0x80, 0xFF, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC7, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x9F, 0x80, 0x1E, 0x0F, 0xE7,
  0xF9, 0xFF, 0x7F, 0xDF, 0xF7, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE1,
  0xF8, 0x7C, 0x1F, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFF, 0x7F, 0xC7, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xC0, 0x1E, 0x03, 0xC0,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0xF8, 0x3F, 0x1E, 0x3C, 0x3F, 0xF3, 0x8F,
  0x1F, 0xF8, 0xE7, 0x87, 0xEE, 0x3D, 0xE3, 0xC3, 0x8F, 0x70, 0xF0, 0xE3,
  0xFC, 0x78, 0x78, 0xFF, 0x1E, 0x1E, 0x3F, 0xC7, 0x87, 0x8F, 0xF1, 0xE1,
  0xE3, 0xFC, 0x70, 0x78, 0xFF, 0x3C, 0x1E, 0x3B, 0xCF, 0x87, 0x8E, 0xF1,
  0xE1, 0xE7, 0xBC, 0x78, 0xF9, 0xCF, 0x1F, 0xFE, 0xF3, 0xC7, 0xFF, 0xF8,
  0x78, 0xFE, 0xFE, 0x1E, 0x1E, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x20, 0x07, 0xF8, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xBF,
  0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x01,
  0xFC, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xE7, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x81, 0xFE,
  0x3F, 0x01, 0xFE, 0x7E, 0x01, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xF3, 0xF0, 0x1F,
  0xE7, 0xE0, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xE7, 0xFE, 0x3F, 0x80,
  0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7F, 0x80, 0x3F, 0x3F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFC,
  0x00, 0x7F, 0xBF, 0x00, 0x3F, 0xCF, 0xC0, 0x1F, 0xE3, 0xF0, 0x07, 0xF8,
  0xFC, 0x03, 0xFC, 0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x3F,
  0x80, 0xFC, 0x1F, 0xE0, 0x3F, 0x0F, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xF1,
  0xFC, 0x00, 0xFC, 0xFF, 0x00, 0x3F, 0x7F, 0x80, 0x0F, 0xDF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE0,
  0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x0F,
  0xC0, 0x3F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFE, 0xFC, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9E, 0xFF, 0xFF, 0xBD, 0xFF, 0xEF, 0xFB, 0xFF, 0xDF, 0xF7, 0xFF,
  0xBF, 0xCF, 0xFF, 0x7F, 0x9F, 0xFE, 0x7F, 0x3F, 0xFC, 0xFC, 0x7F, 0xF9,
  0xF8, 0xFF, 0xF3, 0xF1, 0xFF, 0xE3, 0xC3, 0xFF, 0xC7, 0x87, 0xFF, 0x8F,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF0, 0xFF, 0xF7, 0xC3, 0xFF,
  0xCF, 0x8F, 0xFF, 0x3E, 0x3F, 0xFC, 0xFC, 0xFF, 0xF1, 0xF3, 0xFF, 0xC7,
  0xCF, 0xFF, 0x0F, 0xBF, 0xFC, 0x3E, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x83, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0,
  0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF,
  0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0x80,
  0x1F, 0xC7, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xFC,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x07, 0xF1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F,
  0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF9,
  0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF,
  0x1F, 0xF0, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xE7, 0xF8,
  0x0F, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x1F,
  0xDF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03,
  0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x0F,
  0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07,
  0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x1E, 0x07,
  0xFF, 0x87, 0xE0, 0xFB, 0xF0, 0xFC, 0x3F, 0x7E, 0x1F, 0x87, 0xEF, 0xC3,
  0xF0, 0xFD, 0xF8, 0x7E, 0x1F, 0x9F, 0x0F, 0xC3, 0xF3, 0xE1, 0xFC, 0x7E,
  0x7E, 0x7F, 0x8F, 0x8F, 0xCF, 0xF1, 0xF1, 0xF9, 0xFE, 0x7E, 0x3F, 0x3F,
  0xCF, 0xC7, 0xE7, 0xF9, 0xF8, 0xFC, 0xFF, 0x3F, 0x0F, 0x9F, 0xF7, 0xE1,
  0xF7, 0xFE, 0xF8, 0x3F, 0xFB, 0xDF, 0x07, 0xFE, 0x7B, 0xE0, 0xFF, 0xCF,
  0xFC, 0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x3F, 0xE7, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x83,
  0xFC, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xF3, 0xF8, 0x00,
  0xFE, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x00,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x3F,
  0x80, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xEF, 0xF0, 0x1F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x3F, 0xBF, 0x81, 0xFE, 0xFF, 0xBF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xFF, 0x7F, 0x0F, 0xF8, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF9, 0xFE, 0x07, 0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x7F, 0xC1, 0xFC, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFB, 0xF8,
  0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xDF, 0xE0, 0x7F, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF8, 0xFD, 0xFF, 0xF1, 0xFB, 0xFF, 0xC3, 0xF1, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0xBF, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x9F, 0xC3, 0xFF, 0x7F, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFB, 0xF0, 0x7F, 0x8F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0x7F, 0x00, 0x7E, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x21, 0xFC, 0x00, 0xC3, 0xFC, 0x03, 0xC3, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0xFC, 0x3F, 0xFB,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFE, 0x0F, 0xF7,
  0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xDF,
  0xE0, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xBF, 0x07, 0xFC, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC2, 0x00, 0x7F,
  0x1C, 0x03, 0xF8, 0xFC, 0x3F, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE3, 0xFC, 0x3F, 0x9F, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x20, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x10, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x41, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0xFE,
  0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0x80, 0xFF, 0x1F, 0xC0, 0xFE,
  0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF8, 0xFC, 0xFB, 0xFD,
  0xFE, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x3F,
  0xC3, 0xF3, 0xFF, 0x8F, 0xDF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1,
  0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFC, 0x7F,
  0x81, 0xF9, 0xFF, 0x83, 0xF7, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x9F, 0xE0, 0xFF, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFD,
  0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF8, 0x1F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFE, 0x7F, 0x81, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFC, 0x3F, 0xFB, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xF9, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF7, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xF0, 0x17, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x7F, 0xCF, 0xFD, 0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7F,
  0x83, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xEF, 0xC7, 0xFF, 0x3F, 0x07, 0xF8, 0xFC,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F,
  0xC7, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7F, 0x01,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x1E, 0x0F, 0xFF, 0x0F,
  0x83, 0xFF, 0xC3, 0xE0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0x9F,
  0x0F, 0xC3, 0xE7, 0xC3, 0xF1, 0xF9, 0xF1, 0xFC, 0x7E, 0x7E, 0x7F, 0x9F,
  0x9F, 0x9F, 0xE7, 0xC7, 0xE7, 0xF9, 0xF0, 0xF9, 0xDE, 0x7C, 0x3E, 0xF7,
  0x9F, 0x0F, 0xBC, 0xE7, 0xC3, 0xEF, 0x3F, 0xF0, 0xFB, 0xCF, 0xF8, 0x1F,
  0xE3, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8,
  0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x8F,
  0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFB,
  0xF8, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x83,
  0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x06, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0,
  0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0xE0, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xF8, 0x03, 0x1F, 0xFE, 0x01, 0xEF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF1, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFD, 0xE0, 0x3F, 0xFE, 0xF0,
  0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph RobotoMono_Bold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 33, 28, 10, -33 },
  { 34, 15, 12, 28, 6, -35 },
  { 57, 26, 33, 28, 1, -33 },
  { 165, 23, 44, 28, 3, -39 },
  { 292, 26, 34, 28, 1, -34 },
  { 403, 26, 34, 28, 2, -34 },
  { 514, 5, 12, 28, 10, -35 },
  { 522, 13, 47, 28, 8, -37 },
  { 599, 13, 47, 28, 7, -37 },
  { 676, 23, 23, 28, 4, -33 },
  { 743, 23, 25, 28, 2, -28 },
  { 815, 8, 15, 28, 8, -6 },
  { 830, 20, 5, 28, 6, -17 },
  { 843, 9, 8, 28, 10, -8 },
  { 852, 19, 36, 28, 5, -33 },
  { 938, 22, 34, 28, 3, -34 },
  { 1032, 15, 33, 28, 4, -33 },
  { 1094, 23, 34, 28, 2, -34 },
  { 1192, 23, 34, 28, 2, -34 },
  { 1290, 25, 33, 28, 1, -33 },
  { 1394, 22, 33, 28, 3, -33 },
  { 1485, 23, 34, 28, 2, -34 },
  { 1583, 23, 33, 28, 2, -33 },
  { 1678, 23, 34, 28, 2, -34 },
  { 1776, 23, 34, 28, 2, -34 },
  { 1874, 9, 27, 28, 10, -27 },
  { 1905, 10, 36, 28, 10, -27 },
  { 1950, 20, 22, 28, 4, -25 },
  { 2005, 21, 15, 28, 4, -22 },
  { 2045, 20, 22, 28, 4, -25 },
  { 2100, 21, 34, 28, 4, -34 },
  { 2190, 26, 33, 28, 1, -33 },
  { 2298, 27, 33, 28, 1, -33 },
  { 2410, 24, 33, 28, 3, -33 },
  { 2509, 24, 34, 28, 2, -34 },
  { 2611, 23, 33, 28, 3, -33 },
  { 2706, 23, 33, 28, 3, -33 },
  { 2801, 23, 33, 28, 3, -33 },
  { 2896, 24, 34, 28, 2, -34 },
  { 2998, 22, 33, 28, 3, -33 },
  { 3089, 20, 33, 28, 4, -33 },
  { 3172, 22, 33, 28, 3, -33 },
  { 3263, 26, 33, 28, 3, -33 },
  { 3371, 23, 33, 28, 3, -33 },
  { 3466, 23, 33, 28, 3, -33 },
  { 3561, 22, 33, 28, 3, -33 },
  { 3652, 24, 34, 28, 2, -34 },
  { 3754, 24, 33, 28, 3, -33 },
  { 3853, 26, 40, 28, 2, -34 },
  { 3983, 25, 33, 28, 3, -33 },
  { 4087, 25, 34, 28, 2, -34 },
  { 4194, 27, 33, 28, 1, -33 },
  { 4306, 22, 33, 28, 3, -33 },
  { 4397, 27, 33, 28, 1, -33 },
  { 4509, 27, 33, 28, 1, -33 },
  { 4621, 27, 33, 28, 1, -33 },
  { 4733, 27, 33, 28, 1, -33 },
  { 4845, 24, 33, 28, 2, -33 },
  { 4944, 10, 47, 28, 9, -39 },
  { 5003, 18, 36, 28, 6, -33 },
  { 5084, 10, 47, 28, 9, -39 },
  { 5143, 19, 17, 28, 5, -33 },
  { 5184, 21, 5, 28, 3, 0 },
  { 5198, 12, 6, 28, 9, -34 },
  { 5207, 22, 25, 28, 3, -25 },
  { 5276, 23, 35, 28, 3, -35 },
  { 5377, 22, 25, 28, 3, -25 },
  { 5446, 22, 35, 28, 3, -35 },
  { 5543, 23, 25, 28, 3, -25 },
  { 5615, 23, 36, 28, 3, -36 },
  { 5719, 22, 35, 28, 3, -25 },
  { 5816, 22, 35, 28, 3, -35 },
  { 5913, 20, 35, 28, 5, -35 },
  { 6001, 15, 45, 28, 5, -35 },
  { 6086, 24, 35, 28, 3, -35 },
  { 6191, 21, 35, 28, 5, -35 },
  { 6283, 24, 25, 28, 2, -25 },
  { 6358, 22, 25, 28, 3, -25 },
  { 6427, 24, 25, 28, 2, -25 },
  { 6502, 23, 35, 28, 3, -25 },
  { 6603, 22, 35, 28, 3, -25 },
  { 6700, 19, 25, 28, 7, -25 },
  { 6760, 22, 25, 28, 3, -25 },
  { 6829, 22, 31, 28, 3, -31 },
  { 6915, 22, 25, 28, 3, -25 },
  { 6984, 25, 25, 28, 2, -25 },
  { 7063, 26, 25, 28, 1, -25 },
  { 7145, 25, 25, 28, 2, -25 },
  { 7224, 27, 35, 28, 1, -25 },
  { 7343, 23, 25, 28, 3, -25 },
  { 7415, 15, 45, 28, 7, -37 },
  { 7500, 4, 42, 28, 12, -33 },
  { 7521, 15, 45, 28, 8, -37 },
  { 7606, 25, 10, 28, 1, -19 },
};

const GFXfont RobotoMono_Bold47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold47pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_BOLD47PT7B_H_
