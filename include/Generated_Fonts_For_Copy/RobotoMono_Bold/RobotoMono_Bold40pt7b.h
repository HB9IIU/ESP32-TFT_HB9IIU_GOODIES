#ifndef _ROBOTOMONO_BOLD40PT7B_H_
#define _ROBOTOMONO_BOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x03, 0x3F, 0xFF, 0xFF, 0xDE, 0xF8, 0x7F,
  0xC3, 0xFC, 0x1F, 0xE0, 0xEF, 0x07, 0x78, 0x3B, 0xC1, 0xDE, 0x0E, 0xF0,
  0x77, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x00,
  0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0,
  0xE0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0xE1, 0xE0,
  0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07,
  0x0F, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0x0E,
  0x00, 0x38, 0x78, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00,
  0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF0, 0x7F, 0x3E, 0x03, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE1, 0x83, 0x87, 0x8F, 0x0E, 0x1E, 0x38,
  0x38, 0x79, 0xE0, 0xF1, 0xE7, 0x03, 0xFF, 0x3C, 0x07, 0xFC, 0xE0, 0x0F,
  0xE7, 0x80, 0x04, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x8F, 0x80, 0x1E, 0x7F, 0x80, 0x73, 0xFF,
  0x03, 0xDF, 0x3C, 0x0E, 0x78, 0xF0, 0x79, 0xE1, 0xC3, 0xC7, 0x87, 0x02,
  0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x1E, 0x1F,
  0xF8, 0x3C, 0x7F, 0xF8, 0x79, 0xF9, 0xF9, 0xF3, 0xE1, 0xFB, 0xE7, 0xC3,
  0xFF, 0xDF, 0x83, 0xFF, 0x3F, 0x03, 0xFE, 0x3E, 0x03, 0xF8, 0x7E, 0x0F,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xE0, 0x7F, 0xC7,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x18, 0x0F, 0x03,
  0xF0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0E, 0x00, 0x40, 0x40, 0x0C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x03, 0x80, 0x40,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x06, 0x0F, 0x06, 0x78, 0xF1, 0xEF, 0xF6, 0x7F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7B, 0xC0,
  0x0F, 0x9E, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x0C, 0x07,
  0x00, 0x00, 0x20, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E,
  0x7C, 0xFB, 0xE7, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x38, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0x7F, 0xEF, 0x9F, 0xFF, 0x87,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0xFD, 0xF0, 0x3E, 0x7E, 0x1F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x38, 0x0F, 0xC1, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xEF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xEF, 0xC0,
  0x1F, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0x87,
  0xE0, 0x78, 0x3F, 0x07, 0xC1, 0xF8, 0x7C, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC7, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x87,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF8, 0x7E, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x06, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x7E,
  0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xEF, 0xF7, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xDF, 0x01, 0xFB, 0xF0, 0x3F, 0x3F, 0x0F, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3F, 0x7C,
  0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0x87, 0xE3, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xC1, 0xF9, 0xF0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0x7E, 0x0F, 0xEF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xC0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF,
  0xF8, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xDF, 0x83,
  0xFB, 0xFD, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x01, 0xE3,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x39, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x1C, 0x7E, 0xFF, 0xFF, 0xFF,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0xF0,
  0xF0, 0x20, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x03,
  0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xF7,
  0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xE0, 0x7C, 0x1E, 0x00, 0x70, 0xF0, 0x00, 0xE3, 0x87, 0xE3, 0x9E,
  0x3F, 0xCE, 0x71, 0xFF, 0x1D, 0xC7, 0x9C, 0x7F, 0x3C, 0x71, 0xF8, 0xE1,
  0xC7, 0xE3, 0x87, 0x1F, 0x8E, 0x1C, 0x7E, 0x78, 0x71, 0xF9, 0xE1, 0xC6,
  0xE7, 0x87, 0x3B, 0x9E, 0x1C, 0xEE, 0x3C, 0xF3, 0xB8, 0xFF, 0xFC, 0xF1,
  0xFF, 0xE1, 0xC3, 0x8F, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x03,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07,
  0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0x83, 0xFE, 0xF8, 0x07,
  0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0xFC, 0x3F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0,
  0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x0F, 0xCF, 0xC7, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xE0, 0x1F, 0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xDF, 0x01, 0xFB, 0xF0, 0x7E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFC, 0x03, 0xFE, 0x00, 0xF8, 0x03, 0xFB, 0xE0, 0x1F, 0xCF, 0x80, 0xFE,
  0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0xFE, 0x0F, 0x83, 0xF0, 0x3E,
  0x1F, 0x80, 0xF8, 0xFC, 0x03, 0xE7, 0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xF9, 0xF8, 0x0F, 0xC7, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x83, 0xE0, 0x7F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF8, 0xF8, 0x07,
  0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0xBE, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0x9F, 0xFF, 0xF9, 0xFF,
  0xFB, 0xFD, 0xFF, 0xBF, 0xDF, 0xFB, 0xFD, 0xFF, 0x9F, 0xDF, 0xF9, 0xF9,
  0xFF, 0x9F, 0x9F, 0xF9, 0xF9, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F,
  0x1F, 0xFC, 0x61, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0xFE, 0xF1, 0xFF, 0xDF, 0x3F, 0xF9, 0xE7, 0xFF,
  0x3C, 0xFF, 0xE7, 0xDF, 0xFC, 0x7B, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xE0, 0xFE,
  0x7C, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80,
  0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xF8, 0x1F,
  0x87, 0xE0, 0x3E, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80,
  0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F,
  0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F,
  0x81, 0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E,
  0xF8, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x8F, 0x81,
  0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x7F, 0x07, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE7,
  0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0x7C, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x78, 0x7F, 0xF0, 0xF0, 0xFB, 0xE1,
  0xE1, 0xF7, 0xC7, 0xE3, 0xEF, 0x8F, 0xC7, 0xDF, 0x1F, 0x8F, 0xBE, 0x3F,
  0x1F, 0x3C, 0x7E, 0x3C, 0x7C, 0xFC, 0xF8, 0xF9, 0xF9, 0xF1, 0xF7, 0xFB,
  0xE3, 0xEF, 0xF7, 0xC7, 0xDF, 0xEF, 0x8F, 0xBF, 0xDF, 0x0F, 0x77, 0xBC,
  0x1E, 0xE7, 0x78, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1,
  0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8,
  0x1F, 0x00, 0xFE, 0x00, 0xFE, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xE1, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE7,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F, 0x87,
  0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7B, 0xC0, 0x3D, 0xE0, 0x3C, 0xF8, 0x1E, 0x3C, 0x1E, 0x1E, 0x0F, 0x07,
  0x8F, 0x83, 0xC7, 0x81, 0xF3, 0xC0, 0x7B, 0xE0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8,
  0x3C, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFC, 0x1F, 0x9F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x7F,
  0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xF8, 0x7E, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF3, 0xFF, 0xFE, 0x1F, 0xC7, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x20, 0x1F, 0x3F, 0xC3, 0xEF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3E, 0xFC, 0x0F, 0xDF, 0xC3, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xBF, 0xF1, 0xF3, 0xF8, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x1F, 0xDF, 0x81, 0xFB, 0xE0,
  0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x7E, 0x03, 0xE7, 0xE1,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x83, 0xE0, 0xFE, 0x7C, 0x7F,
  0xEF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xDF, 0x81, 0xFB, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x07, 0xEF, 0xE1,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xBE, 0x0F, 0xE7, 0xC0, 0x00,
  0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xC3, 0xF8, 0x3E, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xE8, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x7C, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x03, 0xEF, 0xE1, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xE7, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x18, 0x07, 0xE3, 0x81, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x30, 0x1F, 0x3F, 0xC3, 0xEF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFC,
  0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x7F, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF3,
  0xFF, 0x9F, 0xF9, 0xFF, 0xCF, 0xF8, 0x18, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFE, 0xF8, 0x1F, 0xCF,
  0x83, 0xF8, 0xF8, 0x7F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F, 0x9F, 0x80,
  0xFB, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xEF, 0xC0, 0xFC, 0x7E, 0x0F, 0x87, 0xF0, 0xF8, 0x3F, 0x0F, 0x81,
  0xF8, 0xF8, 0x1F, 0xCF, 0x80, 0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x87, 0xCF, 0x9F,
  0xBE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x7F, 0xE3,
  0xE3, 0xFF, 0x0F, 0x1F, 0xF8, 0x78, 0xFF, 0xC3, 0xC7, 0xFE, 0x1E, 0x3F,
  0xF0, 0xF1, 0xFF, 0x87, 0x8F, 0xFC, 0x3C, 0x7F, 0xE1, 0xE3, 0xFF, 0x0F,
  0x1F, 0xF8, 0x78, 0xFF, 0xC3, 0xC7, 0xFE, 0x1E, 0x3F, 0xF0, 0xF1, 0xFF,
  0x87, 0x8F, 0xFC, 0x3C, 0x7C, 0x00, 0x10, 0x1F, 0x3F, 0xC3, 0xEF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x00, 0x40,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0,
  0xFE, 0x7E, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7,
  0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x20, 0x1F, 0x3F, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x0F, 0xDF, 0xC3, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xBF, 0xF1, 0xF3, 0xF8, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFE, 0x7C, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xDF, 0x81, 0xFB, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x07, 0xEF, 0xE1, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xBE, 0x0F, 0xE7, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x08, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0x9F, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x07, 0xEF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3E, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x02, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFE, 0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0x1F, 0xE7,
  0xC0, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0x80, 0x7C,
  0x3F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x0F, 0x3C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xF8,
  0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x3E, 0x1E, 0xF8, 0xF8,
  0x79, 0xE3, 0xF3, 0xE7, 0x8F, 0xCF, 0x9E, 0x3F, 0x3E, 0x7D, 0xFC, 0xF9,
  0xF7, 0x73, 0xC7, 0xDD, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xF0, 0xF7,
  0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x01, 0xFB,
  0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0x81, 0xF8, 0xFC, 0x07, 0xEF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xF8, 0xFC,
  0x07, 0xEF, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F,
  0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x04, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x1F, 0x87, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x03, 0xE0,
  0x3F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x83, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x2F, 0x80, 0xF8, 0x07, 0xC0, 0x38, 0x00, 0x1F,
  0x00, 0x01, 0xFE, 0x01, 0xDF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF,
  0xF8, 0x3F, 0xFB, 0x80, 0xFF, 0xC2, 0x03, 0xFC, 0x00, 0x03, 0x00,
};

const GFXglyph RobotoMono_Bold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 28, 24, 9, -28 },
  { 22, 13, 10, 24, 5, -30 },
  { 39, 22, 28, 24, 1, -28 },
  { 116, 20, 37, 24, 2, -33 },
  { 209, 22, 29, 24, 1, -29 },
  { 289, 23, 29, 24, 1, -29 },
  { 373, 4, 11, 24, 9, -30 },
  { 379, 11, 41, 24, 7, -32 },
  { 436, 11, 41, 24, 6, -32 },
  { 493, 20, 20, 24, 3, -28 },
  { 543, 19, 21, 24, 2, -24 },
  { 593, 7, 13, 24, 7, -5 },
  { 605, 16, 5, 24, 6, -15 },
  { 615, 8, 7, 24, 8, -7 },
  { 622, 16, 30, 24, 4, -28 },
  { 682, 18, 29, 24, 3, -29 },
  { 748, 13, 28, 24, 3, -28 },
  { 794, 20, 29, 24, 1, -29 },
  { 867, 19, 29, 24, 2, -29 },
  { 936, 21, 28, 24, 1, -28 },
  { 1010, 19, 28, 24, 2, -28 },
  { 1077, 19, 29, 24, 2, -29 },
  { 1146, 20, 28, 24, 1, -28 },
  { 1216, 19, 29, 24, 2, -29 },
  { 1285, 19, 29, 24, 2, -29 },
  { 1354, 7, 23, 24, 9, -23 },
  { 1375, 8, 31, 24, 9, -23 },
  { 1406, 17, 19, 24, 3, -22 },
  { 1447, 19, 12, 24, 3, -18 },
  { 1476, 18, 19, 24, 3, -22 },
  { 1519, 19, 29, 24, 3, -29 },
  { 1588, 22, 28, 24, 1, -28 },
  { 1665, 23, 28, 24, 1, -28 },
  { 1746, 20, 28, 24, 3, -28 },
  { 1816, 20, 29, 24, 2, -29 },
  { 1889, 20, 28, 24, 2, -28 },
  { 1959, 19, 28, 24, 3, -28 },
  { 2026, 19, 28, 24, 3, -28 },
  { 2093, 20, 29, 24, 2, -29 },
  { 2166, 19, 28, 24, 2, -28 },
  { 2233, 16, 28, 24, 4, -28 },
  { 2289, 19, 28, 24, 2, -28 },
  { 2356, 22, 28, 24, 3, -28 },
  { 2433, 19, 28, 24, 3, -28 },
  { 2500, 20, 28, 24, 2, -28 },
  { 2570, 19, 28, 24, 2, -28 },
  { 2637, 20, 29, 24, 2, -29 },
  { 2710, 20, 28, 24, 3, -28 },
  { 2780, 22, 34, 24, 2, -29 },
  { 2874, 20, 28, 24, 3, -28 },
  { 2944, 21, 29, 24, 2, -29 },
  { 3021, 22, 28, 24, 1, -28 },
  { 3098, 20, 28, 24, 2, -28 },
  { 3168, 22, 28, 24, 1, -28 },
  { 3245, 23, 28, 24, 1, -28 },
  { 3326, 23, 28, 24, 1, -28 },
  { 3407, 23, 28, 24, 1, -28 },
  { 3488, 21, 28, 24, 2, -28 },
  { 3562, 9, 40, 24, 8, -33 },
  { 3607, 15, 30, 24, 5, -28 },
  { 3664, 9, 40, 24, 8, -33 },
  { 3709, 17, 15, 24, 4, -28 },
  { 3741, 18, 4, 24, 3, 0 },
  { 3750, 9, 6, 24, 8, -29 },
  { 3757, 19, 22, 24, 2, -22 },
  { 3810, 19, 30, 24, 3, -30 },
  { 3882, 19, 22, 24, 2, -22 },
  { 3935, 19, 30, 24, 2, -30 },
  { 4007, 20, 22, 24, 2, -22 },
  { 4062, 21, 31, 24, 2, -31 },
  { 4144, 19, 30, 24, 2, -22 },
  { 4216, 19, 30, 24, 3, -30 },
  { 4288, 17, 29, 24, 4, -29 },
  { 4350, 13, 38, 24, 4, -29 },
  { 4412, 20, 30, 24, 3, -30 },
  { 4487, 18, 30, 24, 4, -30 },
  { 4555, 21, 22, 24, 1, -22 },
  { 4613, 19, 22, 24, 3, -22 },
  { 4666, 20, 22, 24, 2, -22 },
  { 4721, 19, 30, 24, 3, -22 },
  { 4793, 19, 30, 24, 2, -22 },
  { 4865, 16, 22, 24, 6, -22 },
  { 4909, 20, 22, 24, 2, -22 },
  { 4964, 20, 26, 24, 2, -26 },
  { 5029, 18, 21, 24, 3, -21 },
  { 5077, 22, 21, 24, 1, -21 },
  { 5135, 22, 21, 24, 1, -21 },
  { 5193, 21, 21, 24, 2, -21 },
  { 5249, 23, 30, 24, 1, -21 },
  { 5336, 20, 21, 24, 2, -21 },
  { 5389, 13, 38, 24, 6, -31 },
  { 5451, 4, 36, 24, 10, -28 },
  { 5469, 13, 38, 24, 6, -31 },
  { 5531, 21, 9, 24, 1, -16 },
};

const GFXfont RobotoMono_Bold40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold40pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_BOLD40PT7B_H_
