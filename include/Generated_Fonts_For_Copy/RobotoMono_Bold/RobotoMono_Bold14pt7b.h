#ifndef _ROBOTOMONO_BOLD14PT7B_H_
#define _ROBOTOMONO_BOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0x99, 0x99, 0x12, 0x16, 0x14, 0x7F, 0x34, 0x24,
  0xFE, 0x2C, 0x28, 0x68, 0x10, 0x21, 0xF7, 0x6C, 0x78, 0x1C, 0x1E, 0x07,
  0x8F, 0xBB, 0xE1, 0x00, 0x70, 0xD6, 0xD4, 0x7C, 0x08, 0x18, 0x17, 0x2D,
  0x2D, 0x07, 0x78, 0xF3, 0x22, 0xC7, 0x1E, 0x77, 0xCF, 0xDD, 0xFC, 0xFE,
  0x13, 0x64, 0x4C, 0xCC, 0xC4, 0x46, 0x31, 0x84, 0x62, 0x33, 0x33, 0x33,
  0x26, 0x48, 0x10, 0x23, 0x5B, 0xE3, 0x8D, 0x91, 0x00, 0x30, 0x63, 0xFF,
  0xF3, 0x06, 0x0C, 0x00, 0x6D, 0xAC, 0xFC, 0xF8, 0x0C, 0x31, 0x86, 0x10,
  0xC3, 0x08, 0x61, 0x8C, 0x00, 0x7B, 0xBC, 0xF3, 0xDF, 0x9C, 0x73, 0xED,
  0xE0, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0x3C, 0xFD, 0x1C, 0x30,
  0x61, 0x86, 0x18, 0x7E, 0xFC, 0x79, 0xFB, 0x30, 0x63, 0x87, 0x83, 0x63,
  0xCC, 0xF0, 0x0E, 0x0E, 0x1E, 0x36, 0x26, 0x66, 0x7F, 0xFF, 0x06, 0x06,
  0x7F, 0xFC, 0x34, 0xFC, 0x30, 0x73, 0xED, 0xE0, 0x38, 0xF3, 0x06, 0xCF,
  0xD9, 0xB1, 0xE2, 0xEC, 0xF0, 0xFF, 0xFC, 0x18, 0x20, 0xC1, 0x86, 0x0C,
  0x30, 0x60, 0x7B, 0xFC, 0xF3, 0x7B, 0xFC, 0xF3, 0xCD, 0xE0, 0x7B, 0xFC,
  0xF3, 0xCF, 0xF7, 0xC3, 0x79, 0xC0, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x12,
  0x5A, 0x00, 0x04, 0x37, 0xF8, 0xF0, 0xF0, 0x40, 0xFE, 0x03, 0xFF, 0xF0,
  0x83, 0x87, 0x83, 0x3F, 0xC8, 0x00, 0x7D, 0xDB, 0x18, 0x61, 0xC3, 0x0C,
  0x00, 0x30, 0x60, 0x1C, 0x22, 0x4D, 0x55, 0xB5, 0xA5, 0xB5, 0x5E, 0x40,
  0x3C, 0x18, 0x1C, 0x1C, 0x34, 0x36, 0x36, 0x7E, 0x7F, 0x63, 0xC3, 0xFD,
  0xFF, 0x1E, 0x3F, 0xDF, 0xB1, 0xE3, 0xFF, 0xF8, 0x79, 0xDB, 0x1E, 0x08,
  0x10, 0x30, 0x63, 0xEC, 0xF0, 0xF1, 0xFB, 0x36, 0x3C, 0x78, 0xF1, 0xE6,
  0xFD, 0xF0, 0xFF, 0xFF, 0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xFF, 0xFC, 0xFF,
  0xFF, 0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xC1, 0x80, 0x79, 0xDB, 0x1E, 0x0C,
  0x1B, 0xF1, 0xE3, 0xEE, 0xF8, 0xC7, 0x1C, 0x71, 0xFF, 0xFC, 0x71, 0xC7,
  0x10, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0xFF, 0xF0, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xE2, 0xCC, 0xF0, 0xC6, 0xCC, 0xDC, 0xD8, 0xF0, 0xF8,
  0xD8, 0xCC, 0xCE, 0xC7, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF,
  0xFC, 0xCF, 0xDF, 0xBF, 0xFF, 0x7E, 0xF5, 0xE3, 0xC7, 0x8C, 0xC7, 0x1E,
  0x79, 0xF7, 0x5D, 0xF7, 0xCF, 0x30, 0x79, 0xFB, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xEC, 0xF0, 0xF9, 0xFB, 0x1E, 0x3C, 0xFF, 0xB0, 0x60, 0xC1, 0x80,
  0x79, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xEC, 0xF8, 0x18, 0x10, 0xF9,
  0xFB, 0x1E, 0x3C, 0xFF, 0xB6, 0x66, 0xCD, 0x8C, 0x7D, 0xDF, 0x1E, 0x07,
  0x87, 0x81, 0xE3, 0xEE, 0xF8, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE2, 0xEC, 0xF0,
  0xC3, 0x63, 0x66, 0x66, 0x26, 0x36, 0x3C, 0x3C, 0x1C, 0x18, 0xDB, 0xDB,
  0x5B, 0x5B, 0x5F, 0x7E, 0x76, 0x76, 0x76, 0x66, 0xE3, 0x66, 0x36, 0x3C,
  0x1C, 0x1C, 0x3C, 0x36, 0x66, 0xE3, 0xE3, 0x63, 0x66, 0x36, 0x3C, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFC, 0x30, 0xC1, 0x86, 0x18, 0x70, 0xFF,
  0xFC, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xC0, 0xC6, 0x30, 0xC6, 0x10, 0xC6,
  0x10, 0xC6, 0xFD, 0xB6, 0xDB, 0x6D, 0xB7, 0xC0, 0x30, 0xE2, 0x9A, 0xCC,
  0xFC, 0xCC, 0x11, 0xFB, 0x30, 0xEF, 0xD9, 0xB3, 0x7F, 0xC1, 0x83, 0x06,
  0x8F, 0xD9, 0xB1, 0xE3, 0xC7, 0xDB, 0xF0, 0x11, 0xFC, 0xF0, 0xC3, 0x1E,
  0xDE, 0x0C, 0x30, 0xCB, 0x7F, 0x3C, 0xF3, 0xCF, 0xB7, 0x40, 0x10, 0xFB,
  0x16, 0x3F, 0xF8, 0x3B, 0xBE, 0x1E, 0x7C, 0xC1, 0x8F, 0xC6, 0x0C, 0x18,
  0x30, 0x60, 0xC0, 0x21, 0xFC, 0xF1, 0xC7, 0x1E, 0xDD, 0x0F, 0xF7, 0x80,
  0xC1, 0x83, 0x06, 0x8F, 0xD9, 0xB1, 0xE3, 0xC7, 0x8F, 0x18, 0x38, 0x20,
  0x07, 0xC1, 0x83, 0x06, 0x0C, 0xFF, 0xFC, 0x33, 0x0F, 0x33, 0x33, 0x33,
  0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x1C, 0xDB, 0x3C, 0x7C, 0xD9, 0x9B, 0x18,
  0xF9, 0xF0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x19, 0xFF, 0xF8, 0x25, 0xFE,
  0xDD, 0xBB, 0x76, 0xED, 0xDB, 0x09, 0xFB, 0x36, 0x3C, 0x78, 0xF1, 0xE3,
  0x10, 0xFB, 0x36, 0x3C, 0x78, 0xFB, 0x3C, 0x11, 0xFB, 0x36, 0x3C, 0x78,
  0xFB, 0x7C, 0xC1, 0x83, 0x00, 0x21, 0xFC, 0xF3, 0xCF, 0x3E, 0xDF, 0x0C,
  0x30, 0xC0, 0x0B, 0xFE, 0x70, 0xC3, 0x0C, 0x30, 0x10, 0xFB, 0x1F, 0x07,
  0xC1, 0xF3, 0x3E, 0x20, 0x43, 0xF1, 0x02, 0x04, 0x08, 0x19, 0x3E, 0xC7,
  0x8F, 0x1E, 0x3C, 0x7D, 0xDD, 0x80, 0xE3, 0x66, 0x26, 0x34, 0x3C, 0x1C,
  0x18, 0xDB, 0x5B, 0x5B, 0x5A, 0x76, 0x66, 0x66, 0xCE, 0xD8, 0xE1, 0xC7,
  0x8D, 0xB1, 0x80, 0xE3, 0x63, 0x36, 0x36, 0x1C, 0x1C, 0x18, 0x18, 0x70,
  0x70, 0xFE, 0x18, 0x61, 0x86, 0x1F, 0xFF, 0x80, 0x19, 0x8C, 0x63, 0x13,
  0x0C, 0x21, 0x8C, 0x61, 0x80, 0xFF, 0xF8, 0xC3, 0x18, 0xC6, 0x10, 0xE6,
  0x63, 0x18, 0xCC, 0x00, 0x20, 0xFB, 0xCE,
};

const GFXglyph RobotoMono_Bold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -11 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 7, 13, 8, 1, -12 },
  { 28, 8, 10, 8, 0, -10 },
  { 38, 7, 10, 8, 1, -10 },
  { 47, 2, 4, 8, 3, -11 },
  { 48, 4, 14, 8, 2, -11 },
  { 55, 4, 14, 8, 2, -11 },
  { 62, 7, 7, 8, 1, -10 },
  { 69, 7, 7, 8, 1, -8 },
  { 76, 3, 5, 8, 2, -2 },
  { 78, 6, 1, 8, 2, -5 },
  { 79, 3, 2, 8, 3, -2 },
  { 80, 6, 11, 8, 1, -10 },
  { 89, 6, 10, 8, 1, -10 },
  { 97, 5, 10, 8, 1, -10 },
  { 104, 7, 10, 8, 0, -10 },
  { 113, 7, 10, 8, 1, -10 },
  { 122, 8, 10, 8, 0, -10 },
  { 132, 6, 10, 8, 1, -10 },
  { 140, 7, 10, 8, 1, -10 },
  { 149, 7, 10, 8, 0, -10 },
  { 158, 6, 10, 8, 1, -10 },
  { 166, 6, 10, 8, 1, -10 },
  { 174, 3, 8, 8, 3, -8 },
  { 177, 3, 11, 8, 3, -8 },
  { 182, 6, 7, 8, 1, -8 },
  { 188, 7, 4, 8, 1, -6 },
  { 192, 6, 7, 8, 1, -8 },
  { 198, 7, 10, 8, 1, -10 },
  { 207, 8, 10, 8, 0, -10 },
  { 217, 8, 10, 8, 0, -10 },
  { 227, 7, 10, 8, 1, -10 },
  { 236, 7, 10, 8, 1, -10 },
  { 245, 7, 10, 8, 1, -10 },
  { 254, 7, 10, 8, 1, -10 },
  { 263, 7, 10, 8, 1, -10 },
  { 272, 7, 10, 8, 1, -10 },
  { 281, 6, 10, 8, 1, -10 },
  { 289, 6, 10, 8, 1, -10 },
  { 297, 7, 10, 8, 1, -10 },
  { 306, 8, 10, 8, 1, -10 },
  { 316, 7, 10, 8, 1, -10 },
  { 325, 7, 10, 8, 1, -10 },
  { 334, 6, 10, 8, 1, -10 },
  { 342, 7, 10, 8, 1, -10 },
  { 351, 7, 10, 8, 1, -10 },
  { 360, 7, 12, 8, 1, -10 },
  { 371, 7, 10, 8, 1, -10 },
  { 380, 7, 10, 8, 1, -10 },
  { 389, 8, 10, 8, 0, -10 },
  { 399, 7, 10, 8, 1, -10 },
  { 408, 8, 10, 8, 0, -10 },
  { 418, 8, 10, 8, 0, -10 },
  { 428, 8, 10, 8, 0, -10 },
  { 438, 8, 10, 8, 0, -10 },
  { 448, 7, 10, 8, 1, -10 },
  { 457, 3, 14, 8, 3, -12 },
  { 463, 5, 11, 8, 2, -10 },
  { 470, 3, 14, 8, 3, -12 },
  { 476, 6, 5, 8, 1, -10 },
  { 480, 6, 1, 8, 1, 0 },
  { 481, 3, 2, 8, 3, -10 },
  { 482, 7, 8, 8, 1, -8 },
  { 489, 7, 11, 8, 1, -11 },
  { 499, 6, 8, 8, 1, -8 },
  { 505, 6, 11, 8, 1, -11 },
  { 514, 7, 8, 8, 1, -8 },
  { 521, 7, 11, 8, 1, -11 },
  { 531, 6, 11, 8, 1, -8 },
  { 540, 7, 11, 8, 1, -11 },
  { 550, 7, 10, 8, 1, -10 },
  { 559, 4, 13, 8, 2, -10 },
  { 566, 7, 11, 8, 1, -11 },
  { 576, 7, 11, 8, 1, -11 },
  { 586, 7, 8, 8, 1, -8 },
  { 593, 7, 8, 8, 1, -8 },
  { 600, 7, 8, 8, 1, -8 },
  { 607, 7, 11, 8, 1, -8 },
  { 617, 6, 11, 8, 1, -8 },
  { 626, 6, 8, 8, 2, -8 },
  { 632, 7, 8, 8, 1, -8 },
  { 639, 7, 9, 8, 1, -9 },
  { 647, 7, 7, 8, 1, -7 },
  { 654, 8, 7, 8, 0, -7 },
  { 661, 8, 7, 8, 0, -7 },
  { 668, 7, 7, 8, 1, -7 },
  { 675, 8, 10, 8, 0, -7 },
  { 685, 7, 7, 8, 1, -7 },
  { 692, 5, 13, 8, 2, -11 },
  { 701, 1, 13, 8, 4, -10 },
  { 703, 5, 13, 8, 2, -11 },
  { 712, 8, 3, 8, 0, -6 },
};

const GFXfont RobotoMono_Bold14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold14pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_BOLD14PT7B_H_
