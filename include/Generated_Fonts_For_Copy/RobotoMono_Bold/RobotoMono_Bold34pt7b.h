#ifndef _ROBOTOMONO_BOLD34PT7B_H_
#define _ROBOTOMONO_BOLD34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold34pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x00, 0x00, 0x0E, 0x7F, 0xF7, 0xDE, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0xE1, 0xC0,
  0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xE1, 0xFF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x71, 0xC0, 0x38, 0x70, 0x0E, 0x1C,
  0x03, 0x8E, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0x0E, 0x01,
  0xC3, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0x87, 0x00, 0xE1,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0xFF, 0x80,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7C, 0x7E, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03,
  0xEF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3E, 0xF8, 0x1F, 0x7F, 0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x08, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0x73, 0xC0, 0x0E, 0x38, 0xE1, 0xC7, 0x1C, 0x38,
  0xE7, 0x07, 0x1C, 0xE0, 0xFF, 0xB8, 0x0F, 0xE7, 0x00, 0xF9, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0xFC, 0x03,
  0xBF, 0xC0, 0xE7, 0xF8, 0x1D, 0xE3, 0x87, 0x38, 0x70, 0xE7, 0x0E, 0x08,
  0xF1, 0xC0, 0x0E, 0x78, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x80, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0,
  0x3E, 0x1C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x1E, 0x3F, 0xE1, 0xE7, 0xDF,
  0x1E, 0x78, 0xFB, 0xEF, 0x8F, 0xFC, 0xF8, 0x7F, 0xCF, 0x83, 0xF8, 0xF8,
  0x1F, 0x87, 0xE7, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xF3, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x01, 0xC1, 0xE1, 0xE1, 0xE0, 0xE0, 0xF0,
  0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0x80, 0x40, 0x40, 0x18, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0,
  0xF0, 0x18, 0x04, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x08, 0x1C, 0x17, 0x8C, 0x3B, 0xF6, 0x7D, 0xFF, 0xFF, 0x1F, 0xFC, 0x01,
  0xE0, 0x01, 0xF8, 0x01, 0xDE, 0x01, 0xE7, 0x81, 0xE3, 0xC1, 0xF0, 0xF0,
  0x30, 0x30, 0x08, 0x10, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0xF3,
  0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xFF, 0xFF,
  0xFD, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x80, 0x0F,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x7E, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0x78,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF, 0xFF,
  0xDF, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x78,
  0x1F, 0x7C, 0x1E, 0x3F, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00,
  0x60, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x80, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xF7, 0xF3, 0xE0, 0xFB, 0xE0, 0x3D, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0x80, 0x01, 0x00, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xFC, 0x7E,
  0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7E,
  0x07, 0xFC, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x7E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1E, 0xF8, 0x07, 0xBE,
  0x03, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x3C, 0x3E, 0x1E, 0x0F, 0x87,
  0x83, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7B, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x38, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7E, 0x7E, 0x7F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x01, 0xF8,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF9, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x7C, 0x1F, 0x7F, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x01, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0x7E, 0x78,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F,
  0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xF8, 0x3E, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFE, 0x7E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF0, 0x01, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7E,
  0x7C, 0xF8, 0x3E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0x7E, 0xFF, 0x7F, 0xFF, 0x3F, 0xFE, 0x0F,
  0xDE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3E, 0xFF, 0xFF, 0xF3, 0xE0, 0x18,
  0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x3C, 0x79, 0xE0, 0x80, 0x00,
  0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFB, 0xFF, 0x0F, 0xE0, 0x3E,
  0x00, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFC, 0x01, 0xF0,
  0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0x80, 0x1F, 0x00, 0xFE, 0x0F, 0xFC, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0,
  0x1F, 0x00, 0x30, 0x00, 0x40, 0x00, 0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xF3,
  0xFF, 0xEF, 0xC7, 0xFF, 0x07, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x78, 0x1E, 0x38, 0x03, 0x8E, 0x3E, 0x77, 0x1F, 0xDD, 0x8F, 0xF3, 0xE7,
  0x9C, 0xF9, 0xC7, 0x3E, 0x71, 0x8F, 0x98, 0x63, 0xCE, 0x18, 0xF3, 0x86,
  0x3C, 0xE1, 0x9F, 0x9C, 0xE6, 0xE7, 0xFF, 0xB9, 0xFF, 0xCE, 0x38, 0xE1,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0xCE, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x7D, 0xF0,
  0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xE0,
  0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x1F, 0xBE, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xFF, 0x3E, 0x0F, 0xEF, 0x80, 0xFB, 0xE0, 0x1E, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3F, 0x1F, 0x9F, 0x83, 0xE7, 0xC0, 0x7D, 0xE0, 0x1F, 0x78,
  0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF7, 0x80, 0x7D,
  0xF0, 0x1F, 0x7E, 0x0F, 0x8F, 0xEF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x87,
  0xE7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDF, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFB, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x40, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0x1F, 0x8F, 0x83,
  0xE7, 0xC0, 0x7D, 0xF0, 0x1F, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x78,
  0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x3E, 0x07, 0xCF, 0xE7,
  0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC,
  0x0F, 0xF0, 0xF8, 0x0F, 0xFF, 0x01, 0xF3, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F,
  0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F,
  0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xBE, 0x07, 0xE7, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C,
  0x0F, 0x8F, 0x81, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xF7, 0xC0, 0x3F, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xEE, 0xFF, 0xF7, 0xFF, 0xFB, 0xF7, 0xFD,
  0xFB, 0xFE, 0x7D, 0xFF, 0x3C, 0xFF, 0x9E, 0x7F, 0xC7, 0x3F, 0xE3, 0x9F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x9F, 0xFB, 0x9F, 0xFB, 0xDF, 0xFB, 0xDF, 0xF9, 0xFF, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0x40, 0x01, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3F, 0x3F, 0x1F, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x1F, 0x78,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x7D,
  0xF0, 0x3E, 0x7E, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0x81,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xE3, 0xFF, 0xE1, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0x83, 0xF3, 0xF0, 0x7C, 0x1F, 0x1F, 0x01, 0xE3, 0xE0, 0x3E,
  0x78, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xCF, 0x00, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0xE0, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xE0,
  0x00, 0x18, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8,
  0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03,
  0xEF, 0x81, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0x00, 0x40, 0x01, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x1F, 0x9F, 0x01, 0xF7, 0xC0, 0x7D,
  0xF0, 0x0F, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x01,
  0xF7, 0x80, 0x3D, 0xF0, 0x0F, 0x7C, 0x07, 0xCF, 0xE7, 0xF3, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7F, 0x7E, 0x3F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x1F, 0x0F, 0x03, 0xE1, 0xF0, 0x7C,
  0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0,
  0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0xF8, 0xF0, 0xF7, 0x8F, 0x0F, 0x78, 0xF1, 0xF7, 0x8F, 0x1F,
  0x78, 0xF9, 0xE7, 0x8F, 0x9E, 0x7C, 0xF9, 0xE7, 0xDF, 0x9E, 0x3D, 0xF9,
  0xE3, 0xDF, 0x9E, 0x3D, 0xFB, 0xE3, 0xDF, 0xFC, 0x3D, 0xDF, 0xC3, 0xDD,
  0xFC, 0x3F, 0x9F, 0xC1, 0xF9, 0xFC, 0x1F, 0x9F, 0xC1, 0xF9, 0xFC, 0x1F,
  0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80,
  0xF0, 0xF8, 0x7C, 0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x07, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0x7D, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x7D, 0xE0, 0x07, 0xDF, 0x00, 0xF8, 0xF8, 0x0F,
  0x8F, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0x3E, 0x7E, 0x03, 0xEF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFD, 0xF0, 0x1F, 0x3E, 0x03, 0xE3,
  0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F, 0x3E, 0x01,
  0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xFC, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x81, 0xDC, 0x1E, 0xF0, 0xF7, 0x87,
  0x1C, 0x78, 0xF3, 0x83, 0xBC, 0x1F, 0xE0, 0xFE, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F,
  0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x7E, 0xF8, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x1F, 0xDF, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFB, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xEF,
  0xCF, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xDF, 0x01, 0xEF, 0x81, 0xF7, 0xE0, 0xFB, 0xFD, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFC, 0x7D, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x7F, 0x7E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x7C, 0x1F, 0x7F,
  0x7E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F,
  0xDF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x7C, 0x1F, 0x7F, 0x7F, 0x3F, 0xFF, 0x3F, 0xEF, 0x0F, 0xCF, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xEF, 0xE7, 0xC1, 0xF7, 0xC0, 0x7B,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x31, 0xFE, 0x7C, 0x7F, 0xFE, 0x1F, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0xCF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0x7F, 0x7C, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0x7C, 0x1F, 0x7F, 0x7F, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xCF, 0x00, 0x1F,
  0x10, 0x1F, 0x30, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF8, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0x7F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xC0, 0xF8, 0x1F, 0x81, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xEF, 0xFD, 0xFF, 0x3F, 0xC7, 0xF0, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x1F, 0xBE, 0x0F, 0xCF, 0x87, 0xE3, 0xE3, 0xF0, 0xF9,
  0xF8, 0x3E, 0xFC, 0x0F, 0xBE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xF3, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F, 0x83, 0xE3,
  0xE0, 0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xF0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xCF, 0x3D, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF1, 0xE3, 0xFC, 0x78,
  0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F,
  0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1,
  0xE3, 0xFC, 0x78, 0xF0, 0xF9, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0x7F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xEF, 0x81, 0xF3, 0xE0, 0xF9, 0xFD, 0xF8,
  0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xCF, 0x3F,
  0xEF, 0x3F, 0xFF, 0x7F, 0x7F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C,
  0x1F, 0x7F, 0x7F, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xDF, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF1,
  0xFF, 0xCF, 0xEF, 0x7F, 0xBF, 0xFE, 0xFF, 0x1B, 0xF0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7C, 0x3F, 0x78, 0x1F, 0x78, 0x0F, 0x7C, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0x7C,
  0x1F, 0x7F, 0xFF, 0x3F, 0xFE, 0x0F, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xE7, 0x07, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F,
  0xEF, 0x1F, 0xCF, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x78, 0xF0, 0x3E,
  0x3C, 0x0F, 0x8F, 0x83, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x1F, 0x1E, 0x03,
  0xCF, 0x80, 0xF3, 0xC0, 0x1E, 0xF0, 0x07, 0xB8, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0xF1, 0xF7, 0x8F,
  0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x9F, 0x9E, 0x39,
  0xF9, 0xC3, 0xDF, 0xBC, 0x3D, 0xFB, 0xC3, 0xD9, 0xBC, 0x3D, 0x9B, 0xC3,
  0xF9, 0xFC, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x7C, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E,
  0x0F, 0x8F, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xE0,
  0x1F, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x3E, 0x07, 0xDF, 0x80, 0xFC,
  0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0x78,
  0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0xF8, 0x0F, 0x1F, 0x01, 0xF3, 0xC0,
  0x3E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x87,
  0xF0, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7F, 0x07,
  0xE0, 0xFC, 0x3F, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xE0, 0x00, 0x06,
  0x00, 0x07, 0xF0, 0x1D, 0xFF, 0x83, 0xBF, 0xF8, 0xF7, 0x9F, 0xFD, 0xE0,
  0xFF, 0x98, 0x0F, 0xE0, 0x00, 0x70,
};

const GFXglyph RobotoMono_Bold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 10, 9, 20, 5, -26 },
  { 31, 18, 24, 20, 1, -24 },
  { 85, 17, 32, 20, 2, -28 },
  { 153, 19, 25, 20, 1, -25 },
  { 213, 20, 25, 20, 1, -25 },
  { 276, 3, 10, 20, 8, -26 },
  { 280, 9, 35, 20, 6, -27 },
  { 320, 10, 35, 20, 5, -27 },
  { 364, 17, 17, 20, 3, -24 },
  { 401, 16, 18, 20, 2, -20 },
  { 437, 6, 11, 20, 6, -4 },
  { 446, 14, 4, 20, 5, -13 },
  { 453, 6, 6, 20, 7, -6 },
  { 458, 13, 26, 20, 4, -24 },
  { 501, 16, 25, 20, 2, -25 },
  { 551, 11, 24, 20, 3, -24 },
  { 584, 17, 25, 20, 1, -25 },
  { 638, 16, 25, 20, 2, -25 },
  { 688, 18, 24, 20, 1, -24 },
  { 742, 16, 24, 20, 2, -24 },
  { 790, 16, 24, 20, 2, -24 },
  { 838, 17, 24, 20, 1, -24 },
  { 889, 16, 25, 20, 2, -25 },
  { 939, 16, 25, 20, 2, -25 },
  { 989, 7, 20, 20, 7, -20 },
  { 1007, 7, 27, 20, 7, -20 },
  { 1031, 14, 16, 20, 3, -18 },
  { 1059, 15, 11, 20, 3, -16 },
  { 1080, 15, 16, 20, 3, -18 },
  { 1110, 15, 25, 20, 3, -25 },
  { 1157, 18, 24, 20, 1, -24 },
  { 1211, 20, 24, 20, 0, -24 },
  { 1271, 18, 24, 20, 2, -24 },
  { 1325, 18, 25, 20, 1, -25 },
  { 1382, 17, 24, 20, 2, -24 },
  { 1433, 17, 24, 20, 2, -24 },
  { 1484, 17, 24, 20, 2, -24 },
  { 1535, 18, 25, 20, 1, -25 },
  { 1592, 16, 24, 20, 2, -24 },
  { 1640, 14, 24, 20, 3, -24 },
  { 1682, 16, 24, 20, 2, -24 },
  { 1730, 19, 24, 20, 2, -24 },
  { 1787, 17, 24, 20, 2, -24 },
  { 1838, 17, 24, 20, 2, -24 },
  { 1889, 16, 24, 20, 2, -24 },
  { 1937, 18, 25, 20, 1, -25 },
  { 1994, 17, 24, 20, 2, -24 },
  { 2045, 19, 29, 20, 1, -25 },
  { 2114, 18, 24, 20, 2, -24 },
  { 2168, 18, 25, 20, 1, -25 },
  { 2225, 20, 24, 20, 0, -24 },
  { 2285, 16, 24, 20, 2, -24 },
  { 2333, 19, 24, 20, 1, -24 },
  { 2390, 20, 24, 20, 0, -24 },
  { 2450, 20, 24, 20, 0, -24 },
  { 2510, 19, 24, 20, 1, -24 },
  { 2567, 18, 24, 20, 1, -24 },
  { 2621, 7, 34, 20, 7, -28 },
  { 2651, 13, 26, 20, 4, -24 },
  { 2694, 7, 34, 20, 7, -28 },
  { 2724, 13, 13, 20, 4, -24 },
  { 2746, 16, 4, 20, 2, 0 },
  { 2754, 8, 5, 20, 7, -25 },
  { 2759, 16, 18, 20, 2, -18 },
  { 2795, 17, 26, 20, 2, -26 },
  { 2851, 16, 18, 20, 2, -18 },
  { 2887, 16, 26, 20, 2, -26 },
  { 2939, 17, 18, 20, 2, -18 },
  { 2978, 17, 26, 20, 2, -26 },
  { 3034, 16, 25, 20, 2, -18 },
  { 3084, 16, 26, 20, 2, -26 },
  { 3136, 14, 25, 20, 4, -25 },
  { 3180, 11, 32, 20, 4, -25 },
  { 3224, 18, 26, 20, 2, -26 },
  { 3283, 16, 26, 20, 3, -26 },
  { 3335, 18, 18, 20, 1, -18 },
  { 3376, 16, 18, 20, 2, -18 },
  { 3412, 17, 18, 20, 2, -18 },
  { 3451, 16, 25, 20, 2, -18 },
  { 3501, 16, 25, 20, 2, -18 },
  { 3551, 14, 18, 20, 5, -18 },
  { 3583, 16, 18, 20, 2, -18 },
  { 3619, 16, 22, 20, 2, -22 },
  { 3663, 16, 18, 20, 2, -18 },
  { 3699, 18, 18, 20, 1, -18 },
  { 3740, 20, 18, 20, 0, -18 },
  { 3785, 19, 18, 20, 1, -18 },
  { 3828, 19, 25, 20, 1, -18 },
  { 3888, 17, 18, 20, 2, -18 },
  { 3927, 11, 33, 20, 5, -27 },
  { 3973, 3, 31, 20, 9, -24 },
  { 3985, 11, 33, 20, 6, -27 },
  { 4031, 19, 8, 20, 0, -14 },
};

const GFXfont RobotoMono_Bold34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold34pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_BOLD34PT7B_H_
