#ifndef _ROBOTOMONO_BOLD28PT7B_H_
#define _ROBOTOMONO_BOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x00, 0x77,
  0xFE, 0xE0, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0xC7, 0xC7, 0x07, 0x38, 0x0C,
  0x70, 0x18, 0xC0, 0x31, 0x80, 0xE3, 0x01, 0xCE, 0x1F, 0xFF, 0xBF, 0xFF,
  0x0C, 0x60, 0x18, 0xC0, 0x71, 0x80, 0xE7, 0x0F, 0xFF, 0xDF, 0xFF, 0x86,
  0x30, 0x1C, 0x60, 0x39, 0xC0, 0x73, 0x80, 0xC7, 0x01, 0x8C, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xE7, 0x87, 0x9C,
  0x1E, 0xF0, 0x3D, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3E, 0x00, 0x7B, 0xC0, 0xFF, 0x03, 0xFE, 0x1E, 0x7F, 0xF8,
  0xFF, 0xC1, 0xFE, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0x67, 0x10, 0xE3, 0x18, 0xE3, 0x38, 0x63, 0x30, 0x7F, 0x70, 0x3E,
  0x60, 0x08, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x3E, 0x07,
  0x7F, 0x06, 0x63, 0x0E, 0x63, 0x0C, 0x63, 0x00, 0x63, 0x00, 0x7F, 0x00,
  0x3E, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3C, 0xF0, 0x38, 0x70, 0x38,
  0xF0, 0x3C, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x3F, 0x0E, 0x7F,
  0x8E, 0x7B, 0xCE, 0xF1, 0xFE, 0xF1, 0xFE, 0xF0, 0xFC, 0xF0, 0x7C, 0x7F,
  0xFC, 0x7F, 0xFE, 0x1F, 0xDF, 0xFF, 0xFF, 0xF8, 0x06, 0x1C, 0x78, 0xE3,
  0x8F, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x87, 0x0E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x30, 0x40, 0xE0, 0x70,
  0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0x07, 0x07,
  0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x70, 0xE0,
  0x40, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x63, 0x0B, 0xED, 0xFF,
  0xFF, 0xC3, 0xF8, 0x07, 0x80, 0x3F, 0x01, 0xCE, 0x0F, 0x3C, 0x38, 0x70,
  0x41, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x7B, 0xDE, 0xF7, 0x3B, 0xDC, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x77, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0,
  0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x1F, 0xF1, 0xFF, 0xBF, 0xFF, 0xDF, 0xF8, 0xFF, 0x87, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0x78, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0x00, 0x83,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x0F, 0xC0, 0xFF,
  0xC7, 0xFF, 0x1E, 0x1E, 0xF0, 0x7B, 0xC0, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xC7,
  0xFF, 0x9E, 0x1E, 0x70, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x07, 0xF8,
  0x1F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFC, 0x0F,
  0x78, 0x7D, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0xF3,
  0xC3, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0xF8, 0xFF, 0xE7, 0xFF, 0x9C, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0xF3, 0xFF, 0x9F,
  0xF8, 0x3F, 0x80, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0xF8, 0x7F, 0xF3, 0xFF, 0xEF, 0x87, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0xDE, 0x0F, 0x78, 0x78, 0xFF, 0xE1, 0xFF,
  0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x9E, 0x1E, 0x78, 0x79, 0xE0, 0xE7,
  0x83, 0x9E, 0x1E, 0x3F, 0xF0, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x39,
  0xC0, 0xFF, 0x03, 0xDE, 0x0F, 0x78, 0x7D, 0xFF, 0xE3, 0xFF, 0x07, 0xF8,
  0x0F, 0xC0, 0xFF, 0x83, 0xFF, 0x1E, 0x1E, 0x78, 0x7B, 0xC0, 0xEF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xF7, 0xEF, 0xCF, 0xFE, 0x1F, 0xB8, 0x08,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xC0, 0x77,
  0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0xEF, 0x31, 0xEF, 0xDF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x9E, 0x79, 0xC7, 0x3C,
  0xE1, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF0, 0xFF, 0x7F, 0xCF, 0xE0, 0xF0,
  0x0F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xC0, 0x07, 0x80, 0x3F, 0x81, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xE0, 0x7F, 0x1F, 0xE7, 0xFC, 0x3F, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x1F,
  0xC1, 0xFF, 0x9F, 0xFD, 0xF0, 0xFF, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0xF8,
  0x0F, 0x3C, 0x1C, 0x0E, 0x38, 0x46, 0x31, 0xF3, 0x73, 0xF3, 0x67, 0x33,
  0x66, 0x33, 0x66, 0x33, 0x66, 0x33, 0x6E, 0x33, 0x6E, 0x76, 0x67, 0x76,
  0x67, 0xFC, 0x73, 0x98, 0x30, 0x00, 0x3C, 0x10, 0x1F, 0xF0, 0x07, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1D, 0xC0, 0x1E, 0xF0, 0x0F, 0x38, 0x07, 0x1C, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xE1, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x38, 0x0F,
  0x3C, 0x07, 0x9E, 0x03, 0xDF, 0x00, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0xBC, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xFF, 0xFB, 0xFF,
  0x8F, 0xFF, 0x3C, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xE1, 0xE7, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x07, 0xBC, 0x1E,
  0x78, 0x3C, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x0F,
  0xFE, 0x3C, 0xFC, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x0E, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0xBC, 0x3E,
  0xF1, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x00, 0x0F, 0xE0, 0x7F, 0xE3, 0xFF, 0x9F, 0x0F, 0x78, 0x3D, 0xE0, 0x7F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC0, 0x77, 0x01, 0xDE, 0x07, 0x7C, 0x3C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFC,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0x81, 0xFE, 0x0F, 0xF0, 0xF7, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0xF0, 0x3F,
  0xE0, 0xFB, 0xC1, 0xE7, 0x87, 0x8F, 0x1F, 0x1E, 0x7C, 0x3C, 0xF0, 0x7B,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xBE, 0x1E, 0x3C,
  0x3C, 0x7C, 0x78, 0x78, 0xF0, 0x79, 0xE0, 0xFB, 0xC0, 0xF7, 0x81, 0xF0,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0xDF, 0xFE, 0xFF, 0xF6, 0xFD, 0xF7, 0xEF, 0xBF,
  0x7D, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x7F, 0xBB, 0xFD, 0xDF,
  0xEE, 0xFF, 0x3F, 0xF9, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE0, 0xF0, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83,
  0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0x3C, 0x1E, 0x78, 0x7C, 0x7F,
  0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xBC, 0x3E,
  0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC7, 0xEF, 0xFF,
  0x3F, 0xF8, 0xFF, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0x7C,
  0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0x78, 0x3C,
  0x7C, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0C, 0x00, 0x04, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xFF, 0xEF, 0xFF, 0x3F,
  0xF0, 0xFF, 0xE3, 0xC7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xEF,
  0x03, 0xFC, 0x0F, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x81,
  0xEF, 0x03, 0xDE, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x03, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x78, 0x3E, 0xFF,
  0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8,
  0xFB, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x7C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xF1, 0xC7,
  0xB8, 0xE3, 0x9C, 0x71, 0xCE, 0x78, 0xE7, 0x3C, 0xF3, 0xDF, 0x79, 0xEF,
  0xBC, 0xF7, 0xDC, 0x3B, 0xEE, 0x1D, 0xB7, 0x0E, 0xDB, 0x87, 0xED, 0xC3,
  0xF7, 0xE1, 0xFB, 0xF0, 0xF9, 0xF0, 0x7C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x80, 0x78, 0x0F, 0xBE, 0x0F, 0x8F, 0x07, 0x87,
  0xC7, 0xC1, 0xE3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7B, 0xC0, 0x3D,
  0xF0, 0x3C, 0x78, 0x3E, 0x3E, 0x1E, 0x0F, 0x1F, 0x07, 0xDF, 0x01, 0xF0,
  0xF8, 0x0F, 0xBC, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC1, 0xE1, 0xE0, 0xF1,
  0xE0, 0x38, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0xFF, 0xF0, 0xF0, 0x0E,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xF0, 0x1E, 0x01, 0xC0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x7C, 0x0F, 0x83,
  0xB8, 0x77, 0x0E, 0x73, 0x8E, 0x71, 0xFC, 0x1F, 0x83, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF1, 0xE3, 0xC7, 0x1F, 0x83, 0xFF, 0x3F, 0xFD, 0xE1,
  0xEF, 0x07, 0x00, 0x38, 0x7F, 0xCF, 0xFE, 0xF8, 0x77, 0x83, 0xB8, 0x1D,
  0xE1, 0xEF, 0xFF, 0x7F, 0xFC, 0xFD, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xDF, 0x1F, 0xFC, 0xFF, 0xF7, 0xC7, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC7,
  0xFF, 0xFD, 0xFF, 0xEE, 0x7C, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xF1,
  0xEF, 0x07, 0xF8, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x1F,
  0xF0, 0xF7, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x7D, 0xE7, 0xFF, 0x7F, 0xFF, 0xC7, 0xFC,
  0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0xC7,
  0xDF, 0xFE, 0xFF, 0xF1, 0xF7, 0x80, 0x0F, 0xC1, 0xFF, 0x1F, 0xFD, 0xF1,
  0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x01,
  0xF0, 0x67, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x00, 0x70, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF,
  0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x1F, 0x79,
  0xFF, 0xDF, 0xFF, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xF7, 0xFF, 0xBF, 0xFC, 0x7D, 0xE0, 0x0F,
  0x20, 0x7B, 0x8F, 0xBF, 0xFC, 0x7F, 0xC0, 0xF0, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xCF, 0x1F, 0xFE, 0xFF, 0xF7,
  0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0x80, 0x06, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x03, 0xC1, 0xE0, 0xF0, 0x00, 0x01, 0xFE,
  0xFF, 0x7F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0xFF, 0x7F, 0x3F, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xFC,
  0x3C, 0xF1, 0xF3, 0xCF, 0x8F, 0x7C, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F,
  0xFC, 0x3E, 0xF0, 0xF1, 0xE3, 0xC7, 0xCF, 0x0F, 0xBC, 0x1E, 0xF0, 0x7C,
  0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x39, 0xDF, 0xFB,
  0xFF, 0xF7, 0xBC, 0xFE, 0x39, 0xFC, 0x73, 0xF8, 0xE7, 0xF1, 0xCF, 0xE3,
  0x9F, 0xC7, 0x3F, 0x8E, 0x7F, 0x1C, 0xFE, 0x39, 0xFC, 0x73, 0xF8, 0xE7,
  0x80, 0xE3, 0xE7, 0xFF, 0xBF, 0xFF, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xE0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3D, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x83, 0xDE, 0x1F, 0x3F,
  0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0xF7, 0xC7, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1,
  0xFF, 0xFF, 0x7F, 0xF3, 0xDF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x7B, 0xFF, 0xDF, 0xFF, 0xF1, 0xFF, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xF7,
  0xFF, 0xBF, 0xFC, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0xF3, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00,
  0x1F, 0xC1, 0xFF, 0x9F, 0xFD, 0xE0, 0xFF, 0x07, 0xFC, 0x01, 0xFC, 0x07,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0xDF, 0xBF, 0xF8, 0x7F,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x81, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE1, 0xF7, 0xFF, 0xBF, 0xFC, 0xFC, 0xE0, 0xF0, 0x1F, 0xE0, 0x79,
  0xE0, 0xF3, 0xC1, 0xE3, 0x83, 0x87, 0x8F, 0x0F, 0x1C, 0x0E, 0x38, 0x1E,
  0xF0, 0x1D, 0xC0, 0x3B, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0xF1, 0xC7, 0x71, 0xC7, 0x71, 0xCF, 0x73, 0xCF, 0x73, 0xCE, 0x7B,
  0xEE, 0x7B, 0xEE, 0x3B, 0x6E, 0x3F, 0x6E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C, 0xF8, 0x1E, 0xF0, 0x78, 0xF1,
  0xE0, 0xF3, 0xC1, 0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0,
  0x1F, 0xC0, 0x7B, 0xC0, 0xF3, 0xC3, 0xC7, 0xCF, 0x07, 0xBE, 0x07, 0x80,
  0xF0, 0x1F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x83, 0xC1,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x8F, 0xC7,
  0x83, 0xE0, 0x38, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E,
  0x07, 0x03, 0xC0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x81, 0xF8, 0x3C, 0x7E, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xF0, 0xF0, 0x70, 0x30, 0x00, 0x3E, 0x04, 0x7F,
  0x87, 0x7F, 0xCE, 0xE1, 0xFE, 0xE0, 0xFC, 0x00, 0x38,
};

const GFXglyph RobotoMono_Bold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 8, 7, 17, 4, -21 },
  { 21, 15, 20, 17, 1, -20 },
  { 59, 14, 26, 17, 2, -23 },
  { 105, 16, 20, 17, 0, -20 },
  { 145, 16, 20, 17, 1, -20 },
  { 185, 3, 7, 17, 6, -21 },
  { 188, 7, 28, 17, 5, -22 },
  { 213, 8, 28, 17, 4, -22 },
  { 241, 14, 14, 17, 2, -20 },
  { 266, 14, 14, 17, 1, -16 },
  { 291, 5, 9, 17, 5, -3 },
  { 297, 11, 3, 17, 4, -10 },
  { 302, 5, 5, 17, 6, -5 },
  { 306, 11, 22, 17, 3, -20 },
  { 337, 13, 20, 17, 2, -20 },
  { 370, 9, 20, 17, 2, -20 },
  { 393, 14, 20, 17, 1, -20 },
  { 428, 14, 20, 17, 1, -20 },
  { 463, 14, 20, 17, 1, -20 },
  { 498, 13, 20, 17, 2, -20 },
  { 531, 14, 20, 17, 1, -20 },
  { 566, 14, 20, 17, 1, -20 },
  { 601, 14, 20, 17, 1, -20 },
  { 636, 14, 20, 17, 1, -20 },
  { 671, 5, 16, 17, 6, -16 },
  { 681, 6, 22, 17, 6, -16 },
  { 698, 12, 13, 17, 2, -15 },
  { 718, 13, 9, 17, 2, -13 },
  { 733, 13, 13, 17, 2, -15 },
  { 755, 13, 20, 17, 2, -20 },
  { 788, 16, 20, 17, 0, -20 },
  { 828, 17, 20, 17, 0, -20 },
  { 871, 14, 20, 17, 2, -20 },
  { 906, 15, 20, 17, 1, -20 },
  { 944, 14, 20, 17, 2, -20 },
  { 979, 13, 20, 17, 2, -20 },
  { 1012, 13, 20, 17, 2, -20 },
  { 1045, 14, 20, 17, 1, -20 },
  { 1080, 13, 20, 17, 2, -20 },
  { 1113, 11, 20, 17, 3, -20 },
  { 1141, 13, 20, 17, 2, -20 },
  { 1174, 15, 20, 17, 2, -20 },
  { 1212, 13, 20, 17, 2, -20 },
  { 1245, 13, 20, 17, 2, -20 },
  { 1278, 13, 20, 17, 2, -20 },
  { 1311, 15, 20, 17, 1, -20 },
  { 1349, 14, 20, 17, 2, -20 },
  { 1384, 16, 24, 17, 1, -20 },
  { 1432, 14, 20, 17, 2, -20 },
  { 1467, 15, 20, 17, 1, -20 },
  { 1505, 16, 20, 17, 0, -20 },
  { 1545, 13, 20, 17, 2, -20 },
  { 1578, 16, 20, 17, 0, -20 },
  { 1618, 17, 20, 17, 0, -20 },
  { 1661, 17, 20, 17, 0, -20 },
  { 1704, 17, 20, 17, 0, -20 },
  { 1747, 15, 20, 17, 1, -20 },
  { 1785, 7, 28, 17, 5, -23 },
  { 1810, 11, 22, 17, 3, -20 },
  { 1841, 7, 28, 17, 5, -23 },
  { 1866, 11, 11, 17, 3, -20 },
  { 1882, 13, 3, 17, 2, 0 },
  { 1887, 6, 4, 17, 6, -20 },
  { 1890, 13, 15, 17, 2, -15 },
  { 1915, 13, 21, 17, 2, -21 },
  { 1950, 13, 15, 17, 2, -15 },
  { 1975, 13, 21, 17, 2, -21 },
  { 2010, 13, 15, 17, 2, -15 },
  { 2035, 14, 22, 17, 2, -22 },
  { 2074, 13, 21, 17, 2, -15 },
  { 2109, 13, 21, 17, 2, -21 },
  { 2144, 12, 21, 17, 3, -21 },
  { 2176, 9, 27, 17, 3, -21 },
  { 2207, 14, 21, 17, 2, -21 },
  { 2244, 12, 21, 17, 3, -21 },
  { 2276, 15, 15, 17, 1, -15 },
  { 2305, 13, 15, 17, 2, -15 },
  { 2330, 14, 15, 17, 1, -15 },
  { 2357, 13, 21, 17, 2, -15 },
  { 2392, 13, 21, 17, 2, -15 },
  { 2427, 11, 15, 17, 4, -15 },
  { 2448, 13, 15, 17, 2, -15 },
  { 2473, 13, 18, 17, 2, -18 },
  { 2503, 13, 15, 17, 2, -15 },
  { 2528, 15, 15, 17, 1, -15 },
  { 2557, 16, 15, 17, 0, -15 },
  { 2587, 15, 15, 17, 1, -15 },
  { 2616, 16, 21, 17, 1, -15 },
  { 2658, 14, 15, 17, 2, -15 },
  { 2685, 9, 27, 17, 4, -22 },
  { 2716, 3, 26, 17, 7, -20 },
  { 2726, 9, 27, 17, 5, -22 },
  { 2757, 16, 6, 17, 0, -11 },
};

const GFXfont RobotoMono_Bold28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold28pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_BOLD28PT7B_H_
