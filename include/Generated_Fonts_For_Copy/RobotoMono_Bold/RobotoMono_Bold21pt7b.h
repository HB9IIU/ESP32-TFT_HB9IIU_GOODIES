#ifndef _ROBOTOMONO_BOLD21PT7B_H_
#define _ROBOTOMONO_BOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0xCF, 0x3C, 0xF3, 0xCF, 0x30,
  0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x09, 0x81, 0x98,
  0x19, 0x8F, 0xFE, 0xFF, 0xE1, 0x10, 0x33, 0x03, 0x30, 0x33, 0x00, 0x06,
  0x00, 0xC0, 0x7C, 0x1F, 0xE7, 0x1C, 0xE1, 0xDC, 0x3B, 0x80, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xEE, 0x0F, 0xC1, 0xDC, 0x73, 0xFE, 0x1F, 0x80, 0x80,
  0x10, 0x00, 0x78, 0x07, 0xC0, 0xCC, 0xCC, 0xC8, 0x6D, 0x87, 0x90, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xDF, 0x0D, 0xB1, 0xB3, 0x1B, 0x30, 0x1B, 0x01,
  0xE0, 0x1E, 0x03, 0xF0, 0x73, 0x07, 0x38, 0x73, 0x03, 0x70, 0x3E, 0x03,
  0xC0, 0x7E, 0x6E, 0xE6, 0xE7, 0xEE, 0x3C, 0xE3, 0xCF, 0xFE, 0x3E, 0xF0,
  0xFF, 0xF0, 0x08, 0xCE, 0xE6, 0x73, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xE3, 0x1C, 0x61, 0x84, 0x83, 0x06, 0x0C, 0x38, 0x61, 0x87, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x18, 0xC2, 0x00, 0x0C, 0x03, 0x00,
  0xC3, 0x33, 0xFF, 0xCF, 0xC1, 0xC0, 0xD8, 0x73, 0x18, 0xE0, 0x20, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x6D, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x27, 0xF7, 0x03, 0x83, 0x81,
  0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03,
  0x81, 0xC1, 0xC0, 0x1F, 0x0F, 0xE7, 0x3D, 0xC7, 0x61, 0xF8, 0x7E, 0x7F,
  0xBF, 0xF9, 0xFC, 0x76, 0x1D, 0xC7, 0x71, 0xCF, 0xE1, 0xF0, 0x04, 0xFF,
  0xFF, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x3F, 0x1F,
  0xEF, 0x3B, 0x87, 0xE1, 0xC0, 0x70, 0x38, 0x1C, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x70, 0x3F, 0xFF, 0xFC, 0x3F, 0x1F, 0xEF, 0x3F, 0x87, 0x01, 0xC0,
  0x71, 0xF8, 0x7C, 0x1F, 0xC0, 0x70, 0x1F, 0x87, 0xF1, 0xDF, 0xE3, 0xF0,
  0x03, 0x80, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x77, 0x0C, 0xE3, 0x9C, 0x63,
  0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x07, 0x00, 0xE0, 0x7F, 0xDF, 0xF7,
  0x01, 0xC0, 0x70, 0x1B, 0x87, 0xF9, 0xCF, 0x01, 0xC0, 0x70, 0x1F, 0x87,
  0x71, 0xDF, 0xE3, 0xF0, 0x07, 0x07, 0xC3, 0xC1, 0xC0, 0x70, 0x3B, 0xCF,
  0xFB, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0xDF, 0xE1, 0xF0, 0xFF,
  0xFF, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x18, 0x0E, 0x07, 0x80, 0x3F, 0x1F, 0xE7, 0x3F, 0x87, 0xE1,
  0xDC, 0x77, 0xF8, 0xFC, 0x7F, 0xB8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xE3,
  0xF0, 0x3E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0x7F,
  0xCF, 0xF0, 0x18, 0x0E, 0x0F, 0x0F, 0x83, 0xC0, 0x27, 0xF7, 0x00, 0x00,
  0x27, 0xF7, 0x23, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0xE7, 0x39, 0x9C,
  0x01, 0x87, 0xCF, 0xFF, 0x8E, 0x07, 0xC1, 0xFC, 0x1F, 0x03, 0x80, 0x40,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0xC0, 0x78, 0x3F, 0x83,
  0xF0, 0x38, 0xFF, 0xF9, 0xF0, 0xC0, 0x40, 0x00, 0x3E, 0x7F, 0xF8, 0xFC,
  0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x70, 0x07, 0x81, 0xFC, 0x30, 0x62, 0x33, 0x67, 0xB6, 0xDB, 0x49, 0xBD,
  0x9B, 0xD9, 0xBD, 0x9B, 0x4F, 0xE6, 0xEC, 0x60, 0x03, 0xF8, 0x1F, 0x80,
  0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x00, 0xD8, 0x0E, 0xE0, 0x77, 0x03,
  0x38, 0x38, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0xC7, 0x07, 0x38, 0x3B, 0x81,
  0xE0, 0xFF, 0x1F, 0xFB, 0x8F, 0x70, 0x7E, 0x0F, 0xC1, 0xBF, 0xF7, 0xFC,
  0xE1, 0xDC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xFF, 0xBF, 0xE0, 0x1F, 0x0F,
  0xF1, 0xC7, 0x70, 0x6E, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x83, 0xF0, 0x77, 0x1C, 0xFF, 0x07, 0xC0, 0xFE, 0x1F, 0xE3, 0x9E, 0x70,
  0xEE, 0x1D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x70, 0xEE,
  0x79, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3F, 0xF7, 0xFE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFB, 0xFE, 0xFF,
  0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F, 0x07, 0xF1, 0xC7,
  0x70, 0x6E, 0x0F, 0xC0, 0x38, 0x07, 0x3F, 0xE7, 0xFC, 0xFF, 0x83, 0xF0,
  0x77, 0x1E, 0xFF, 0x87, 0xE0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C,
  0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x87, 0xF3, 0xDF, 0xE3, 0xF0,
  0xE0, 0xFE, 0x1E, 0xE3, 0xCE, 0x38, 0xE7, 0x0E, 0xF0, 0xEE, 0x0F, 0xE0,
  0xFF, 0x0F, 0x70, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x0E, 0xE0, 0xF0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x07, 0xFF, 0xFE, 0xF1, 0xFC, 0xFF, 0x3F, 0xEF, 0xFB, 0xFF, 0xBE,
  0xEF, 0xBB, 0xEC, 0xFB, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0C, 0xE1,
  0xFC, 0x7F, 0x1F, 0xE7, 0xF9, 0xFE, 0x7E, 0xDF, 0xB7, 0xE7, 0xF9, 0xFE,
  0x7F, 0x8F, 0xE3, 0xF8, 0x7E, 0x1C, 0x1F, 0x0F, 0xF1, 0xCF, 0x70, 0xEE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xE7, 0x3C,
  0xFF, 0x07, 0xC0, 0xFE, 0x3F, 0xEC, 0x7B, 0x07, 0xC1, 0xF0, 0x7C, 0x3F,
  0xFE, 0xFF, 0x3E, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F, 0x0F,
  0xF1, 0xCF, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xE7, 0x1C, 0xFF, 0x07, 0xF0, 0x0F, 0x00, 0xE0, 0x08, 0xFF,
  0x1F, 0xFB, 0x8F, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0xFE, 0xFF, 0x1C,
  0xF3, 0x8E, 0x71, 0xEE, 0x1D, 0xC3, 0xF8, 0x38, 0x1F, 0x0F, 0xF9, 0xC7,
  0x70, 0x7E, 0x00, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xC0, 0x3F, 0x83, 0xF0,
  0x7F, 0x1E, 0xFF, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDF, 0xE3, 0xF0, 0xF0,
  0x77, 0x07, 0x70, 0xF7, 0x0E, 0x38, 0xE3, 0x8E, 0x39, 0xC1, 0x9C, 0x1D,
  0xC1, 0xD8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0xE6, 0x3E,
  0x73, 0x67, 0x76, 0x77, 0x67, 0x77, 0xF7, 0x7F, 0x67, 0xF6, 0x7D, 0xE3,
  0xDE, 0x3D, 0xE3, 0x9E, 0x39, 0xE3, 0x9E, 0x38, 0xC0, 0xF0, 0x73, 0x87,
  0x8E, 0x38, 0x73, 0x81, 0xDC, 0x0F, 0xC0, 0x3E, 0x00, 0xE0, 0x0F, 0x80,
  0xFC, 0x07, 0x70, 0x73, 0xC3, 0x8E, 0x38, 0x7B, 0xC1, 0xE0, 0xF0, 0x7B,
  0x83, 0x8E, 0x38, 0x71, 0xC3, 0x9C, 0x0E, 0xE0, 0x76, 0x01, 0xF0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x80, 0xE0, 0x38, 0x0F, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xF9, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xF0, 0xE0, 0x38, 0x1C,
  0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60,
  0x38, 0x1C, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xFF, 0xF0, 0x1C, 0x0E, 0x0F, 0x86, 0xC3, 0x63, 0x19, 0x8D,
  0xC7, 0xFF, 0xFF, 0xC0, 0xF1, 0x86, 0x3F, 0x1F, 0xEE, 0x1C, 0x07, 0x1F,
  0xDF, 0xFF, 0x1F, 0x87, 0xE3, 0xDF, 0xF3, 0xDC, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3B, 0xEF, 0xFB, 0xC7, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE1,
  0xFC, 0x7F, 0xFB, 0xBC, 0x3F, 0x1F, 0xE7, 0x1F, 0x87, 0xE0, 0x38, 0x0E,
  0x03, 0x87, 0x71, 0xDF, 0xE1, 0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xCF, 0xF7, 0xFD, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC, 0x77,
  0xFC, 0xFF, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0x6F, 0xFF, 0xFF, 0xF8, 0x07,
  0x00, 0x70, 0xC7, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x78, 0x0E, 0x01,
  0xC1, 0xFF, 0xBF, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3E, 0xDF, 0xF7, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0x71, 0xDF, 0xF3, 0xFC, 0x07, 0x21, 0xDF, 0xE3, 0xF0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xEF, 0xFF, 0xC7, 0xE1, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x1C, 0x0E, 0x02, 0x00, 0x0F,
  0xC7, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE,
  0x0E, 0x1C, 0x10, 0x07, 0xEF, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0F, 0xFB, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC3, 0xF8, 0xE7, 0x38, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8E, 0x79, 0xC7,
  0x38, 0x77, 0x0F, 0xFC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3, 0xFF, 0xFF, 0xDD, 0xDF, 0xFF,
  0x3B, 0xE7, 0x7C, 0xEF, 0x9D, 0xF3, 0xBE, 0x77, 0xCE, 0xF9, 0xDF, 0x3B,
  0x80, 0xEF, 0xBF, 0xFF, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1C, 0x3F, 0x0F, 0xF1, 0xC7, 0x70, 0xEE, 0x0D, 0xC1, 0xF8,
  0x37, 0x0E, 0x71, 0xCF, 0xF0, 0x7C, 0x00, 0xEF, 0xBF, 0xEF, 0x1F, 0x87,
  0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xF1, 0xFF, 0xEE, 0xF3, 0x80, 0xE0, 0x38,
  0x0E, 0x00, 0x3F, 0xDF, 0xF7, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0x71, 0xDF, 0xF3, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0xEF, 0xFF, 0xBF,
  0xDC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x3F, 0x9F,
  0xF6, 0x1D, 0x80, 0x7C, 0x0F, 0xE0, 0x7F, 0x87, 0xE1, 0xDF, 0xF3, 0xF8,
  0x1C, 0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xC7, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1F, 0xC3, 0xF0, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xE3, 0xFE, 0xDF, 0x60, 0xE0, 0xFC, 0x39, 0xC7, 0x38,
  0xC7, 0x38, 0x67, 0x0E, 0xC0, 0xD8, 0x1F, 0x03, 0xC0, 0x38, 0x00, 0xE6,
  0x76, 0x67, 0x67, 0x76, 0x76, 0x6F, 0x67, 0xF6, 0x7D, 0x63, 0x9E, 0x39,
  0xE3, 0x9C, 0x38, 0xC0, 0xF0, 0xEE, 0x38, 0xEE, 0x0F, 0xC1, 0xF0, 0x1C,
  0x07, 0xC1, 0xDC, 0x3B, 0x8E, 0x3B, 0x83, 0x80, 0xE0, 0xFE, 0x0E, 0x71,
  0xC7, 0x1C, 0x31, 0xC3, 0xB8, 0x3B, 0x81, 0xB0, 0x1F, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x07, 0xC0, 0x78, 0x00, 0xFF, 0xDF, 0xF8, 0x0F, 0x03,
  0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0x80, 0x0E,
  0x38, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0x79, 0xC3, 0xC1, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x38, 0x38, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x61, 0xE0,
  0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x1C, 0x79, 0xC3, 0x87, 0x0E, 0x1C,
  0x30, 0x63, 0x82, 0x00, 0x7C, 0x37, 0xE7, 0xC7, 0xE4, 0x3C,
};

const GFXglyph RobotoMono_Bold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 6, 6, 13, 3, -16 },
  { 12, 12, 15, 13, 0, -15 },
  { 35, 11, 19, 13, 1, -17 },
  { 62, 12, 15, 13, 0, -15 },
  { 85, 12, 15, 13, 1, -15 },
  { 108, 2, 6, 13, 5, -16 },
  { 110, 5, 22, 13, 4, -17 },
  { 124, 6, 22, 13, 3, -17 },
  { 141, 10, 11, 13, 2, -15 },
  { 155, 10, 11, 13, 1, -12 },
  { 169, 3, 6, 13, 4, -2 },
  { 172, 8, 3, 13, 3, -8 },
  { 175, 4, 4, 13, 4, -4 },
  { 177, 9, 16, 13, 2, -15 },
  { 195, 10, 15, 13, 1, -15 },
  { 214, 6, 15, 13, 2, -15 },
  { 226, 10, 15, 13, 1, -15 },
  { 245, 10, 15, 13, 1, -15 },
  { 264, 11, 15, 13, 1, -15 },
  { 285, 10, 15, 13, 1, -15 },
  { 304, 10, 15, 13, 1, -15 },
  { 323, 10, 15, 13, 1, -15 },
  { 342, 10, 15, 13, 1, -15 },
  { 361, 10, 15, 13, 1, -15 },
  { 380, 4, 12, 13, 4, -12 },
  { 386, 5, 16, 13, 4, -12 },
  { 396, 9, 10, 13, 2, -11 },
  { 408, 9, 7, 13, 2, -10 },
  { 416, 9, 10, 13, 2, -11 },
  { 428, 9, 15, 13, 2, -15 },
  { 445, 12, 15, 13, 0, -15 },
  { 468, 13, 15, 13, 0, -15 },
  { 493, 11, 15, 13, 1, -15 },
  { 514, 11, 15, 13, 1, -15 },
  { 535, 11, 15, 13, 1, -15 },
  { 556, 11, 15, 13, 1, -15 },
  { 577, 10, 15, 13, 2, -15 },
  { 596, 11, 15, 13, 1, -15 },
  { 617, 10, 15, 13, 1, -15 },
  { 636, 9, 15, 13, 2, -15 },
  { 653, 10, 15, 13, 1, -15 },
  { 672, 12, 15, 13, 1, -15 },
  { 695, 9, 15, 13, 2, -15 },
  { 712, 10, 15, 13, 1, -15 },
  { 731, 10, 15, 13, 1, -15 },
  { 750, 11, 15, 13, 1, -15 },
  { 771, 10, 15, 13, 2, -15 },
  { 790, 11, 18, 13, 1, -15 },
  { 815, 11, 15, 13, 1, -15 },
  { 836, 11, 15, 13, 1, -15 },
  { 857, 12, 15, 13, 0, -15 },
  { 880, 10, 15, 13, 1, -15 },
  { 899, 12, 15, 13, 0, -15 },
  { 922, 12, 15, 13, 0, -15 },
  { 945, 13, 15, 13, 0, -15 },
  { 970, 13, 15, 13, 0, -15 },
  { 995, 11, 15, 13, 1, -15 },
  { 1016, 5, 20, 13, 4, -17 },
  { 1029, 9, 16, 13, 2, -15 },
  { 1047, 5, 20, 13, 4, -17 },
  { 1060, 9, 8, 13, 2, -15 },
  { 1069, 9, 2, 13, 2, 0 },
  { 1072, 5, 3, 13, 4, -15 },
  { 1074, 10, 11, 13, 1, -11 },
  { 1088, 10, 16, 13, 1, -16 },
  { 1108, 10, 11, 13, 1, -11 },
  { 1122, 10, 16, 13, 1, -16 },
  { 1142, 11, 11, 13, 1, -11 },
  { 1158, 11, 16, 13, 1, -16 },
  { 1180, 10, 15, 13, 1, -11 },
  { 1199, 10, 16, 13, 1, -16 },
  { 1219, 9, 15, 13, 2, -15 },
  { 1236, 7, 19, 13, 2, -15 },
  { 1253, 11, 16, 13, 1, -16 },
  { 1275, 9, 16, 13, 2, -16 },
  { 1293, 11, 11, 13, 1, -11 },
  { 1309, 10, 11, 13, 1, -11 },
  { 1323, 11, 11, 13, 1, -11 },
  { 1339, 10, 15, 13, 1, -11 },
  { 1358, 10, 15, 13, 1, -11 },
  { 1377, 9, 11, 13, 3, -11 },
  { 1390, 10, 11, 13, 1, -11 },
  { 1404, 10, 14, 13, 1, -14 },
  { 1422, 9, 11, 13, 2, -11 },
  { 1435, 11, 11, 13, 1, -11 },
  { 1451, 12, 11, 13, 0, -11 },
  { 1468, 11, 11, 13, 1, -11 },
  { 1484, 12, 15, 13, 1, -11 },
  { 1507, 11, 11, 13, 1, -11 },
  { 1523, 7, 20, 13, 3, -16 },
  { 1541, 2, 19, 13, 5, -15 },
  { 1546, 7, 20, 13, 3, -16 },
  { 1564, 12, 4, 13, 0, -8 },
};

const GFXfont RobotoMono_Bold21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold21pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_BOLD21PT7B_H_
