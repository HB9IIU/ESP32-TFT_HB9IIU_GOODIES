#ifndef _ROBOTOMONO_BOLD23PT7B_H_
#define _ROBOTOMONO_BOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x0E, 0xFE, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xC0, 0x06, 0x60, 0x33, 0x01, 0x98, 0x18, 0xC7, 0xFF, 0xBF,
  0xFC, 0x33, 0x01, 0x98, 0x0C, 0xC7, 0xFF, 0xBF, 0xFC, 0x33, 0x01, 0x98,
  0x0C, 0xC0, 0xC6, 0x06, 0x70, 0x02, 0x00, 0x20, 0x07, 0x01, 0xFC, 0x3F,
  0xE7, 0x8E, 0x70, 0x77, 0x07, 0x78, 0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x01,
  0xE0, 0x0F, 0xF0, 0x77, 0x07, 0x78, 0xE3, 0xFE, 0x1F, 0xC0, 0x60, 0x06,
  0x00, 0x10, 0x03, 0xE0, 0x1B, 0x91, 0xCC, 0xCE, 0x6C, 0x37, 0x61, 0xF6,
  0x02, 0x30, 0x03, 0x00, 0x18, 0x01, 0xBC, 0x0B, 0xF0, 0xD9, 0x8C, 0xCC,
  0x26, 0x60, 0x3F, 0x00, 0xF0, 0x06, 0x00, 0xF8, 0x0F, 0xE0, 0xF3, 0x07,
  0x18, 0x38, 0xC0, 0xFE, 0x07, 0xE0, 0x1C, 0x03, 0xF1, 0x9F, 0xCD, 0xCF,
  0xEE, 0x3F, 0x70, 0xF3, 0xCF, 0x8F, 0xFE, 0x3F, 0x78, 0xFF, 0x6D, 0x80,
  0x0C, 0x73, 0x8C, 0x71, 0x86, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0x61, 0x87, 0x0C, 0x38, 0x70, 0xC0, 0x83, 0x06, 0x1C, 0x30, 0xE3, 0x86,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x1C, 0x63, 0x08, 0x00,
  0x0E, 0x01, 0xC0, 0x10, 0x62, 0x3F, 0xFE, 0x7F, 0x03, 0x80, 0xD8, 0x3B,
  0x8E, 0x38, 0x86, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x77, 0x77, 0x76,
  0xE4, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0xF0, 0x00, 0x0C, 0x0F, 0xC7, 0xFB, 0x8F, 0xE1, 0xF8, 0x7E,
  0x1F, 0x9F, 0xEF, 0xFE, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFE,
  0x3F, 0x00, 0x06, 0x7F, 0xFF, 0xF8, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x06, 0x07, 0xF1, 0xFF, 0x78, 0xEE, 0x0F, 0xC1,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0E, 0x01,
  0xC0, 0x38, 0x7E, 0x0F, 0x81, 0xF8, 0x07, 0x80, 0x70, 0x0F, 0xC1, 0xFE,
  0x7B, 0xFE, 0x3F, 0x80, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x1D, 0xC1,
  0xDC, 0x39, 0xC3, 0x1C, 0x71, 0xCE, 0x1C, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x3F, 0xEF, 0xFD, 0xC0, 0x38, 0x07, 0x00, 0xEE,
  0x1F, 0xF3, 0xFF, 0x10, 0xE0, 0x1C, 0x03, 0xF0, 0x7F, 0x0E, 0xF3, 0xCF,
  0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0xF0, 0x3C, 0x07, 0x00, 0xEF, 0x3F, 0xF7,
  0xFF, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x0E, 0xF3, 0xCF, 0xF0, 0xFC,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x06, 0x07,
  0xF1, 0xFF, 0x38, 0xF7, 0x0E, 0xE1, 0xDC, 0x7B, 0xFE, 0x1F, 0x8F, 0xF9,
  0xC7, 0xF0, 0x7E, 0x0F, 0xE1, 0xDE, 0x7B, 0xFE, 0x1F, 0x80, 0x06, 0x07,
  0xF1, 0xFF, 0x38, 0xEF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xEF, 0xFC,
  0xFF, 0x8E, 0x70, 0x1C, 0x07, 0x87, 0xE0, 0xF8, 0x1C, 0x00, 0x6F, 0xFF,
  0x00, 0x00, 0x06, 0xFF, 0xF0, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0xE7, 0x39, 0xDC, 0xE2, 0x00, 0x00, 0xC1, 0xF1, 0xFF, 0xF8, 0xF0, 0x3C,
  0x0F, 0xE0, 0x7F, 0x07, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x0F, 0xE0, 0xFE, 0x07, 0xC1, 0xF3,
  0xFB, 0xF8, 0xF0, 0x30, 0x00, 0x0C, 0x1F, 0xEF, 0xFF, 0xC7, 0xE1, 0xC0,
  0x70, 0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE0, 0x30, 0x00, 0x00, 0x01, 0xE0,
  0x78, 0x1C, 0x00, 0x07, 0xC0, 0xFF, 0x8E, 0x0C, 0x67, 0x36, 0x7D, 0xB7,
  0x6D, 0xB3, 0x69, 0x9B, 0xCC, 0xDE, 0x66, 0xD3, 0x74, 0xDF, 0xE6, 0x24,
  0x18, 0x00, 0xFF, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xF0,
  0x0F, 0xC0, 0x3B, 0x01, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xE1, 0xC3, 0xFF,
  0x0F, 0xFC, 0x7F, 0xF9, 0xC0, 0xE7, 0x03, 0xBC, 0x0F, 0xFF, 0xCF, 0xFE,
  0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xF3, 0xEF, 0xFC, 0xFF, 0xEF, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xEF, 0xF8, 0x06, 0x01, 0xFC,
  0x7F, 0xE7, 0x0E, 0xF0, 0xFE, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x7F, 0x0F, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0xFF,
  0x0F, 0xFC, 0xF3, 0xCF, 0x0E, 0xF0, 0xEF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFF, 0x0E, 0xF1, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xF7, 0xFE, 0xFF, 0xDC,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDC, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x06, 0x01, 0xFC, 0x3F, 0xE7,
  0x8E, 0xF0, 0xFE, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x3F, 0xE3, 0xFE,
  0x07, 0xE0, 0x77, 0x07, 0x78, 0xF3, 0xFE, 0x1F, 0xC0, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFF, 0xF1, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x7F, 0x0E, 0xF3, 0xDF, 0xF0,
  0xFC, 0xF0, 0xFF, 0x87, 0xBC, 0x79, 0xE7, 0x8F, 0x38, 0x7B, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3C, 0xF1, 0xE3, 0x8F, 0x1E, 0x78, 0x7B,
  0xC3, 0xDE, 0x0F, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xFF, 0xFE, 0xF7, 0xEF, 0x7E,
  0xF7, 0xE6, 0x7E, 0x67, 0xE6, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xCF, 0xF9, 0xFF, 0xBF, 0xF7,
  0xF6, 0xFE, 0xFF, 0xCF, 0xF9, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0x06,
  0x03, 0xF8, 0x7F, 0xC7, 0x1E, 0xF0, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0E, 0x79, 0xE3, 0xFC, 0x1F,
  0x80, 0xFF, 0x9F, 0xFB, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0xFE,
  0xFF, 0xDF, 0xE3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x06,
  0x01, 0xFC, 0x1F, 0xF0, 0xE3, 0xCF, 0x0E, 0x70, 0x3B, 0x81, 0xDC, 0x0E,
  0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x0F, 0x38, 0x71, 0xE7, 0x87,
  0xF8, 0x1F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x40, 0xFF, 0xCF, 0xFE, 0xF1,
  0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0xF3,
  0xCF, 0x1C, 0xF1, 0xEF, 0x0E, 0xF0, 0xFF, 0x07, 0x06, 0x03, 0xFC, 0x7F,
  0xE7, 0x0F, 0xF0, 0x77, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x01,
  0xE0, 0x07, 0xE0, 0x7F, 0x07, 0x78, 0xF3, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x77, 0x0E, 0xF3, 0xCF, 0xF0, 0xFC, 0xF0, 0x3B,
  0x83, 0xDE, 0x1E, 0x70, 0xE3, 0x87, 0x1C, 0x78, 0xF3, 0x83, 0x9C, 0x1C,
  0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0xE3, 0x1D, 0x9C, 0xE7, 0x73, 0x9D, 0xEE, 0x77, 0xB9, 0xDE, 0xE7, 0x7B,
  0x9D, 0xEC, 0x3F, 0xB0, 0xF7, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC3, 0xCE, 0x0E, 0x38, 0xF8, 0x7C, 0xE1, 0xE3, 0xC7, 0x07, 0x38, 0x1E,
  0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x01, 0xFE, 0x07,
  0x38, 0x3C, 0xF0, 0xE1, 0xC7, 0x87, 0xBC, 0x0F, 0xF0, 0x3D, 0xE1, 0xE3,
  0x87, 0x0E, 0x1C, 0x1C, 0xE0, 0x73, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xFF, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xC0, 0x0E, 0x07, 0x81, 0xE0,
  0xFC, 0x33, 0x0C, 0xE7, 0x1B, 0x87, 0xFF, 0xFF, 0xF0, 0xE3, 0x8C, 0x30,
  0x3F, 0x8F, 0xF9, 0xC7, 0x80, 0x70, 0x0E, 0x7F, 0xDE, 0x3F, 0x87, 0xE0,
  0xFE, 0x3D, 0xFF, 0x9F, 0x70, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xFF, 0x3F, 0xE7, 0x9E, 0xE1, 0xDC, 0x3B, 0x87, 0xF0, 0xFE, 0x1D, 0xC3,
  0xBC, 0xF7, 0xFC, 0xFF, 0x00, 0x1F, 0x87, 0xF9, 0xE7, 0xB8, 0x7F, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0xEF, 0x3C, 0xFF, 0x0F, 0xC0, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x7F, 0xDF, 0xFB, 0xCF, 0x70, 0xFC, 0x1F,
  0x83, 0xF0, 0x7F, 0x0E, 0xE1, 0xDE, 0x79, 0xFF, 0x1E, 0xE0, 0x1F, 0x83,
  0xFC, 0x79, 0xE7, 0x0E, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x47,
  0x8E, 0x3F, 0xE1, 0xFC, 0x01, 0xF0, 0x7F, 0x0F, 0xF0, 0xE0, 0x0E, 0x00,
  0xE0, 0xFF, 0xEF, 0xFE, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x3F, 0xEF, 0xFD, 0xE7, 0xB8,
  0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0x70, 0xEF, 0x3C, 0xFF, 0x8F, 0xF0,
  0x0E, 0x41, 0xDF, 0xF9, 0xFE, 0x0F, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3B, 0xEF, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x06, 0x0F, 0x0F, 0x00, 0x00, 0x7F, 0x7F, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x7E, 0x7E,
  0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0xF8, 0xE7, 0x38,
  0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0x71, 0xCF, 0x38, 0xF7, 0x0E, 0xE1,
  0xE0, 0xFE, 0x1F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xEF, 0xFF, 0xEE, 0x7E, 0xE7, 0xEE, 0x7E, 0xE7, 0xEE, 0x7E,
  0xE7, 0xEE, 0x7E, 0xE7, 0xEE, 0x7E, 0xE7, 0xCF, 0xBF, 0xFF, 0x3F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x1F, 0x83,
  0xFC, 0x79, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0x70, 0xE7,
  0x9E, 0x3F, 0xC1, 0xF8, 0xFF, 0x1F, 0xF3, 0xCF, 0x70, 0xEE, 0x1D, 0xC3,
  0xF8, 0x77, 0x0E, 0xE1, 0xDE, 0x7B, 0xFE, 0x7F, 0x8E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x00, 0x3F, 0xEF, 0xFD, 0xE7, 0xB8, 0x7F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x87, 0x70, 0xEF, 0x3C, 0xFF, 0x8F, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0xE7, 0xFB, 0xEF, 0xFB, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0xCF, 0xFD, 0xC3, 0xB8,
  0x77, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xEE, 0x1D, 0xFF, 0x8F, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x7F, 0xFF, 0xFE, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xE2, 0x1F, 0xC1, 0xF8, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xFF, 0xFD, 0xF7,
  0xE0, 0x7F, 0x0E, 0x70, 0xE7, 0x0E, 0x39, 0xC3, 0x9C, 0x39, 0x81, 0xB8,
  0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0xE3, 0x3B, 0x39, 0xD9, 0xCE, 0xEE,
  0x77, 0x7B, 0x3B, 0xD9, 0xD6, 0xC7, 0xBE, 0x3C, 0xF1, 0xE7, 0x8F, 0x38,
  0x71, 0xC0, 0xF0, 0xF7, 0x8E, 0x39, 0xC1, 0xFC, 0x1F, 0x80, 0xF0, 0x0F,
  0x81, 0xF8, 0x3F, 0xC3, 0x9E, 0x70, 0xEF, 0x07, 0xE0, 0x7F, 0x83, 0x9C,
  0x3C, 0xE1, 0xC3, 0x8E, 0x1C, 0xE0, 0x77, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x01, 0xF0, 0x0F, 0x80, 0x70, 0x00,
  0xFF, 0xEF, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x0F, 0x0E, 0x0C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x38, 0xF0, 0xF0, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x0C, 0x0E, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xC1,
  0xC3, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x70, 0x78, 0xF3, 0xC7, 0x0C, 0x18,
  0x30, 0x61, 0xC3, 0x8E, 0x18, 0x00, 0x3C, 0x13, 0xF9, 0xF9, 0xFF, 0x87,
  0xE0, 0x0E, 0x00,
};

const GFXglyph RobotoMono_Bold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 16, 14, 5, -16 },
  { 9, 7, 6, 14, 3, -17 },
  { 15, 13, 16, 14, 0, -16 },
  { 41, 12, 21, 14, 1, -19 },
  { 73, 13, 17, 14, 0, -17 },
  { 101, 13, 17, 14, 1, -17 },
  { 129, 3, 6, 14, 5, -17 },
  { 132, 6, 23, 14, 4, -18 },
  { 150, 6, 23, 14, 4, -18 },
  { 168, 11, 11, 14, 2, -16 },
  { 184, 11, 12, 14, 1, -14 },
  { 201, 4, 8, 14, 4, -3 },
  { 205, 10, 2, 14, 3, -8 },
  { 208, 4, 4, 14, 5, -4 },
  { 210, 10, 17, 14, 2, -16 },
  { 232, 10, 17, 14, 2, -17 },
  { 254, 7, 16, 14, 2, -16 },
  { 268, 11, 17, 14, 1, -17 },
  { 292, 11, 17, 14, 1, -17 },
  { 316, 12, 16, 14, 1, -16 },
  { 340, 11, 16, 14, 1, -16 },
  { 362, 11, 16, 14, 1, -16 },
  { 384, 11, 16, 14, 1, -16 },
  { 406, 11, 17, 14, 1, -17 },
  { 430, 11, 17, 14, 1, -17 },
  { 454, 4, 13, 14, 5, -13 },
  { 461, 5, 18, 14, 5, -13 },
  { 473, 10, 10, 14, 2, -12 },
  { 486, 10, 8, 14, 2, -11 },
  { 496, 10, 10, 14, 2, -12 },
  { 509, 10, 17, 14, 2, -17 },
  { 531, 13, 16, 14, 0, -16 },
  { 557, 14, 16, 14, 0, -16 },
  { 585, 12, 16, 14, 1, -16 },
  { 609, 12, 17, 14, 1, -17 },
  { 635, 12, 16, 14, 1, -16 },
  { 659, 11, 16, 14, 2, -16 },
  { 681, 11, 16, 14, 2, -16 },
  { 703, 12, 17, 14, 1, -17 },
  { 729, 11, 16, 14, 1, -16 },
  { 751, 10, 16, 14, 2, -16 },
  { 771, 11, 16, 14, 1, -16 },
  { 793, 13, 16, 14, 1, -16 },
  { 819, 11, 16, 14, 2, -16 },
  { 841, 12, 16, 14, 1, -16 },
  { 865, 11, 16, 14, 1, -16 },
  { 887, 12, 17, 14, 1, -17 },
  { 913, 11, 16, 14, 2, -16 },
  { 935, 13, 20, 14, 1, -17 },
  { 968, 12, 16, 14, 1, -16 },
  { 992, 12, 17, 14, 1, -17 },
  { 1018, 13, 16, 14, 0, -16 },
  { 1044, 11, 16, 14, 1, -16 },
  { 1066, 13, 16, 14, 0, -16 },
  { 1092, 14, 16, 14, 0, -16 },
  { 1120, 14, 16, 14, 0, -16 },
  { 1148, 14, 16, 14, 0, -16 },
  { 1176, 12, 16, 14, 1, -16 },
  { 1200, 6, 23, 14, 4, -19 },
  { 1218, 9, 17, 14, 3, -16 },
  { 1238, 6, 23, 14, 4, -19 },
  { 1256, 10, 8, 14, 2, -16 },
  { 1266, 10, 2, 14, 2, 0 },
  { 1269, 5, 4, 14, 5, -17 },
  { 1272, 11, 12, 14, 1, -12 },
  { 1289, 11, 17, 14, 2, -17 },
  { 1313, 11, 12, 14, 1, -12 },
  { 1330, 11, 17, 14, 1, -17 },
  { 1354, 12, 12, 14, 1, -12 },
  { 1372, 12, 18, 14, 1, -18 },
  { 1399, 11, 17, 14, 1, -12 },
  { 1423, 10, 17, 14, 2, -17 },
  { 1445, 10, 17, 14, 2, -17 },
  { 1467, 8, 22, 14, 2, -17 },
  { 1489, 11, 17, 14, 2, -17 },
  { 1513, 11, 17, 14, 2, -17 },
  { 1537, 12, 12, 14, 1, -12 },
  { 1555, 10, 12, 14, 2, -12 },
  { 1570, 12, 12, 14, 1, -12 },
  { 1588, 11, 17, 14, 2, -12 },
  { 1612, 11, 17, 14, 1, -12 },
  { 1636, 10, 12, 14, 3, -12 },
  { 1651, 11, 12, 14, 1, -12 },
  { 1668, 11, 15, 14, 1, -15 },
  { 1689, 10, 12, 14, 2, -12 },
  { 1704, 12, 12, 14, 1, -12 },
  { 1722, 13, 12, 14, 0, -12 },
  { 1742, 12, 12, 14, 1, -12 },
  { 1760, 13, 17, 14, 1, -12 },
  { 1788, 12, 12, 14, 1, -12 },
  { 1806, 8, 22, 14, 3, -18 },
  { 1828, 2, 21, 14, 6, -16 },
  { 1834, 7, 22, 14, 4, -18 },
  { 1854, 13, 5, 14, 0, -9 },
};

const GFXfont RobotoMono_Bold23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold23pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_BOLD23PT7B_H_
