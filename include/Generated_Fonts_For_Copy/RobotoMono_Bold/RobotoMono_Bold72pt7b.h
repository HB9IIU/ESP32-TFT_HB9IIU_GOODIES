#ifndef _ROBOTOMONO_BOLD72PT7B_H_
#define _ROBOTOMONO_BOLD72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold72pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0x03,
  0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE,
  0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03,
  0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xFB,
  0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFF,
  0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x18, 0x00, 0xFE,
  0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x07, 0xE0,
  0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x1F, 0xC3, 0xF0, 0x00, 0xFE,
  0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x8F, 0xF1, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xF0,
  0x7F, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0xFF, 0xFF,
  0x00, 0x01, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x7F, 0xFF, 0xE0, 0x00,
  0xFC, 0x7F, 0x87, 0xF0, 0x00, 0x7E, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x07,
  0x80, 0xFE, 0x07, 0xF0, 0x00, 0xC0, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xFF,
  0xFC, 0x01, 0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x03,
  0xFE, 0x3F, 0xFB, 0xFF, 0x03, 0xFE, 0x7F, 0xF3, 0xFF, 0x83, 0xFE, 0x7F,
  0xE1, 0xFF, 0xC3, 0xFE, 0xFF, 0xC0, 0xFF, 0xE7, 0xFC, 0xFF, 0xC0, 0x7F,
  0xF7, 0xFC, 0xFF, 0xC0, 0x7F, 0xF7, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xDF, 0xFE,
  0x03, 0xFF, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00, 0x00,
  0x40, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0x00, 0x1F, 0x80,
  0x02, 0x3C, 0x00, 0xF8, 0x00, 0xC3, 0xF0, 0x0F, 0x80, 0x7E, 0x3F, 0xC0,
  0xF8, 0x1F, 0xE7, 0xFF, 0x8F, 0x87, 0xFE, 0x7F, 0xFE, 0xF9, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x00, 0x60, 0x00, 0x70, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xF8,
  0x7F, 0x8F, 0xF0, 0xFE, 0x07, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0x70, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFE, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x01,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00,
  0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x01, 0xFE, 0x7F,
  0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xF0,
  0x00, 0x7F, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x03,
  0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFE, 0x00,
  0x3F, 0xF8, 0x02, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xE1, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x0F,
  0xFE, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03,
  0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0,
  0x0F, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xE3,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFF, 0xE3, 0xFF, 0x07,
  0xF8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xFF, 0x1F, 0xFE,
  0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF,
  0x8F, 0xFC, 0x1F, 0xE0, 0x0C, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xBF, 0xF8,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xF8, 0x7E, 0x0F, 0xC0, 0xFF,
  0xFC, 0x3E, 0x1F, 0x81, 0xFF, 0xFC, 0x3E, 0x1F, 0x83, 0xFF, 0xFC, 0x3F,
  0x3F, 0x03, 0xFE, 0x7C, 0x3F, 0x3F, 0x07, 0xF0, 0x7C, 0x1F, 0x3F, 0x07,
  0xE0, 0x7C, 0x1F, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x7E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x7E,
  0x1F, 0x80, 0xFC, 0x1F, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x7C, 0x1F, 0x80,
  0xF8, 0x1F, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0xFC, 0x3F, 0x80, 0xF8, 0x3F,
  0xFC, 0x3F, 0x80, 0xF8, 0x3E, 0xFC, 0x3F, 0x80, 0xF8, 0x3E, 0xFC, 0x3F,
  0x81, 0xF8, 0x3E, 0x7C, 0x1F, 0x81, 0xF8, 0x3E, 0x7E, 0x1F, 0x81, 0xF8,
  0x7C, 0x7E, 0x1F, 0xC1, 0xF8, 0x7C, 0x7E, 0x1F, 0xE7, 0xF8, 0xFC, 0x7E,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7E, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xFF,
  0x7F, 0xF0, 0x3F, 0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0x80,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0x81, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xBF,
  0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00,
  0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xBF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0x80, 0x07, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0xEF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x07, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xCF, 0xF8, 0x00,
  0x1F, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF,
  0xC1, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03,
  0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF,
  0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF,
  0xCF, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF3, 0xFE,
  0x00, 0x01, 0xFF, 0xE7, 0xFC, 0x00, 0x07, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x7F,
  0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0xC0, 0x01,
  0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x7F,
  0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x00,
  0x3F, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x7F, 0xF0,
  0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x0F,
  0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xE0, 0x00,
  0x1F, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xFD,
  0xFF, 0x00, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xBF,
  0xFF, 0xEF, 0xC7, 0xF7, 0xFF, 0xFD, 0xFC, 0xFE, 0xFF, 0xFF, 0xBF, 0xBF,
  0x9F, 0xFF, 0xF7, 0xF7, 0xF3, 0xFF, 0xFE, 0x7E, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0x8F, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xC3, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3E, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF,
  0xFF, 0xF3, 0xFC, 0x3F, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xC3,
  0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F,
  0xCF, 0xFF, 0xFF, 0x0F, 0xF3, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0xF0,
  0x7F, 0xBF, 0xFF, 0xFC, 0x0F, 0xEF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07,
  0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xFD, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFC, 0x00,
  0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xDF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFC, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80,
  0x07, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xF9,
  0xFF, 0x00, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x1F,
  0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xC0,
  0x00, 0xFF, 0xE3, 0xFE, 0x00, 0x0F, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F,
  0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x03, 0xFF, 0x9F, 0xF0,
  0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFC, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F,
  0xF7, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xF0,
  0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x07, 0xFD,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF7, 0xFC, 0x0F,
  0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFC, 0x07, 0xFD, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F,
  0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xFE, 0x0F,
  0xF8, 0xFF, 0x87, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF,
  0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xFE, 0x3F,
  0xE0, 0xFF, 0x9F, 0xBF, 0x1F, 0xE0, 0x7F, 0xCF, 0xDF, 0x8F, 0xF0, 0x3F,
  0xE7, 0xEF, 0xE7, 0xF8, 0x1F, 0xF7, 0xF7, 0xF7, 0xFC, 0x0F, 0xFB, 0xFB,
  0xFB, 0xFE, 0x03, 0xFD, 0xFD, 0xFD, 0xFF, 0x01, 0xFE, 0xFE, 0x7E, 0xFF,
  0x80, 0xFF, 0x7E, 0x3F, 0x7F, 0x80, 0x7F, 0xFF, 0x1F, 0xBF, 0xC0, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x0F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFE,
  0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9,
  0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x80,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0x7F,
  0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07,
  0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF,
  0x80, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x01, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF3, 0xFF,
  0xF8, 0x0F, 0xFD, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xF8, 0x7F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xFC, 0x01, 0xFF,
  0xEF, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F,
  0xFF, 0xE0, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x3F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF,
  0xEF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xFF, 0x3F,
  0xF8, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF,
  0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xF9, 0xFF, 0x01, 0xFF,
  0xFC, 0x7F, 0xC0, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x40, 0x7F, 0xF0, 0x00, 0x06, 0x03, 0xFF, 0x80,
  0x00, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE1, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xBF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0x80,
  0x3F, 0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x0F,
  0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xF9, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF7, 0xFE,
  0x01, 0xFF, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xF0, 0x00, 0x3C, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x08, 0x00,
  0x03, 0xFF, 0x01, 0x80, 0x00, 0xFF, 0xE0, 0x7C, 0x00, 0x3F, 0xF8, 0x1F,
  0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xC3,
  0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x7F, 0xFE, 0xFF, 0xF0, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE7, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xF0,
  0x01, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xF0,
  0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFC,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x87, 0xFE, 0x00,
  0x1F, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0xCF,
  0xFC, 0x00, 0x0F, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x1E, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xCF, 0xFE, 0x7F, 0xF9, 0xFE,
  0xFF, 0xFB, 0xFF, 0xCF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF,
  0x83, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF,
  0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xC1,
  0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xE0, 0x7F, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0x83, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0xFF,
  0xBF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00,
  0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xE1, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0xFE, 0x03, 0xFE, 0x7F, 0xFF,
  0xC0, 0xFF, 0xBF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xFF, 0x3F, 0xFC,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF,
  0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0xF0, 0x7F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0xC7, 0xFC, 0x0F,
  0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x0F, 0xFF,
  0xCF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xF8,
  0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xC0, 0x0D, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xF8, 0x01,
  0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x1F, 0xFB, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x3E,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xE0,
  0x01, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xEF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xC0, 0x7F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xBF, 0xE0, 0x1F, 0xC0,
  0x7F, 0xCF, 0xF0, 0x1F, 0xE0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF0, 0x1F, 0xF3,
  0xFE, 0x07, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0xFF, 0x81,
  0xFF, 0x03, 0xFC, 0x7F, 0xC1, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xF8, 0x7F, 0x83,
  0xFC, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xEF, 0x87, 0xF8, 0x1F, 0xE3, 0xF7, 0xE3,
  0xFC, 0x0F, 0xF1, 0xF3, 0xF3, 0xFC, 0x07, 0xF8, 0xF9, 0xF9, 0xFE, 0x03,
  0xFC, 0xFC, 0xFC, 0xFF, 0x00, 0xFE, 0x7E, 0x3E, 0x7F, 0x80, 0x7F, 0xBF,
  0x1F, 0x3F, 0xC0, 0x3F, 0xDF, 0x0F, 0xDF, 0xE0, 0x1F, 0xEF, 0x87, 0xEF,
  0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x8F,
  0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xF8,
  0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xF8,
  0xFF, 0xFF, 0x80, 0x07, 0xF3, 0xFF, 0xFF, 0x80, 0x0F, 0xE7, 0xFF, 0xFF,
  0xC0, 0x3F, 0xDF, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xFB, 0xF8, 0x01,
  0xFF, 0xFF, 0xE7, 0xF0, 0x01, 0xFF, 0xFF, 0xCF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00,
};

const GFXglyph RobotoMono_Bold72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 11, 52, 43, 16, -51 },
  { 73, 22, 19, 43, 10, -54 },
  { 126, 40, 51, 43, 1, -51 },
  { 381, 36, 66, 43, 4, -59 },
  { 678, 41, 53, 43, 1, -52 },
  { 950, 40, 53, 43, 3, -52 },
  { 1215, 8, 19, 43, 16, -54 },
  { 1234, 20, 73, 43, 12, -57 },
  { 1417, 20, 73, 43, 11, -57 },
  { 1600, 36, 36, 43, 5, -51 },
  { 1762, 36, 37, 43, 3, -42 },
  { 1929, 12, 23, 43, 13, -9 },
  { 1964, 29, 8, 43, 10, -27 },
  { 1993, 13, 13, 43, 15, -12 },
  { 2015, 28, 55, 43, 8, -51 },
  { 2208, 33, 53, 43, 5, -52 },
  { 2427, 23, 51, 43, 6, -51 },
  { 2574, 36, 52, 43, 2, -52 },
  { 2808, 36, 53, 43, 3, -52 },
  { 3047, 37, 51, 43, 2, -51 },
  { 3283, 34, 52, 43, 4, -51 },
  { 3504, 35, 53, 43, 4, -52 },
  { 3736, 36, 51, 43, 2, -51 },
  { 3966, 34, 53, 43, 4, -52 },
  { 4192, 35, 52, 43, 3, -52 },
  { 4420, 14, 42, 43, 15, -41 },
  { 4494, 15, 55, 43, 15, -41 },
  { 4598, 32, 34, 43, 5, -39 },
  { 4734, 33, 23, 43, 6, -33 },
  { 4829, 31, 34, 43, 6, -39 },
  { 4961, 33, 52, 43, 6, -52 },
  { 5176, 40, 51, 43, 1, -51 },
  { 5431, 42, 51, 43, 1, -51 },
  { 5699, 36, 51, 43, 5, -51 },
  { 5929, 37, 53, 43, 3, -52 },
  { 6175, 36, 51, 43, 4, -51 },
  { 6405, 35, 51, 43, 5, -51 },
  { 6629, 35, 51, 43, 5, -51 },
  { 6853, 37, 53, 43, 3, -52 },
  { 7099, 34, 51, 43, 4, -51 },
  { 7316, 29, 51, 43, 7, -51 },
  { 7501, 35, 52, 43, 4, -51 },
  { 7729, 39, 51, 43, 5, -51 },
  { 7978, 34, 51, 43, 5, -51 },
  { 8195, 35, 51, 43, 4, -51 },
  { 8419, 34, 51, 43, 4, -51 },
  { 8636, 37, 53, 43, 3, -52 },
  { 8882, 36, 51, 43, 5, -51 },
  { 9112, 40, 61, 43, 3, -52 },
  { 9417, 37, 51, 43, 5, -51 },
  { 9653, 38, 53, 43, 3, -52 },
  { 9905, 41, 51, 43, 1, -51 },
  { 10167, 35, 52, 43, 4, -51 },
  { 10395, 41, 51, 43, 1, -51 },
  { 10657, 41, 51, 43, 1, -51 },
  { 10919, 42, 51, 43, 1, -51 },
  { 11187, 42, 51, 43, 1, -51 },
  { 11455, 38, 51, 43, 3, -51 },
  { 11698, 16, 71, 43, 14, -59 },
  { 11840, 29, 55, 43, 8, -51 },
  { 12040, 16, 71, 43, 14, -59 },
  { 12182, 30, 27, 43, 7, -51 },
  { 12284, 32, 8, 43, 5, 0 },
  { 12316, 17, 10, 43, 14, -52 },
  { 12338, 35, 40, 43, 4, -39 },
  { 12513, 34, 55, 43, 5, -54 },
  { 12747, 34, 40, 43, 4, -39 },
  { 12917, 34, 55, 43, 4, -54 },
  { 13151, 36, 40, 43, 4, -39 },
  { 13331, 37, 56, 43, 4, -56 },
  { 13590, 35, 54, 43, 4, -39 },
  { 13827, 34, 54, 43, 5, -54 },
  { 14057, 31, 53, 43, 8, -53 },
  { 14263, 23, 68, 43, 8, -53 },
  { 14459, 37, 54, 43, 5, -54 },
  { 14709, 32, 54, 43, 7, -54 },
  { 14925, 37, 39, 43, 3, -39 },
  { 15106, 34, 39, 43, 5, -39 },
  { 15272, 36, 40, 43, 4, -39 },
  { 15452, 34, 54, 43, 5, -39 },
  { 15682, 34, 54, 43, 4, -39 },
  { 15912, 29, 39, 43, 10, -39 },
  { 16054, 35, 40, 43, 4, -39 },
  { 16229, 35, 48, 43, 4, -47 },
  { 16439, 34, 39, 43, 5, -38 },
  { 16605, 38, 38, 43, 3, -38 },
  { 16786, 41, 38, 43, 1, -38 },
  { 16981, 39, 38, 43, 3, -38 },
  { 17167, 41, 53, 43, 2, -38 },
  { 17439, 36, 38, 43, 4, -38 },
  { 17610, 23, 69, 43, 11, -56 },
  { 17809, 6, 65, 43, 19, -51 },
  { 17858, 23, 69, 43, 12, -56 },
  { 18057, 39, 16, 43, 1, -29 },
};

const GFXfont RobotoMono_Bold72pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold72pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _ROBOTOMONO_BOLD72PT7B_H_
