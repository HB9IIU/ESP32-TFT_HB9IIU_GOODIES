#ifndef _ROBOTOMONO_BOLD35PT7B_H_
#define _ROBOTOMONO_BOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0x7F, 0xFF, 0xF8, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE3, 0x83, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x1C, 0x38, 0x03, 0x87, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0,
  0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x3C, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFE, 0x7E, 0x0F,
  0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x7C, 0x0F, 0xBF, 0xFF,
  0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x71,
  0xC3, 0x0E, 0x38, 0x71, 0xC7, 0x1C, 0x38, 0xE7, 0x07, 0x1C, 0xE0, 0xFF,
  0xB8, 0x0F, 0xE7, 0x00, 0x21, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x80, 0x1C, 0xFE, 0x03, 0xBF, 0xE0, 0xE7, 0xBC, 0x1C,
  0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x8E, 0x04, 0x71, 0xC0, 0x0F, 0x78, 0x01,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xE0,
  0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFE, 0x1E, 0x3F, 0xF1, 0xE7, 0xDF, 0x9E, 0x78, 0xF9, 0xEF, 0x87,
  0xFE, 0xF8, 0x3F, 0xCF, 0x83, 0xFC, 0xFC, 0x1F, 0x87, 0xF7, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xF3, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x80, 0xC1, 0xE0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0xE0, 0x10, 0x40, 0x18, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x06, 0x01,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x07,
  0x0E, 0x1B, 0xE7, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xF8, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xF7, 0x00, 0xF3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x18,
  0x18, 0x00, 0x08, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF7, 0xDE, 0x7B, 0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xC7, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0xBE, 0xFF, 0xFE,
  0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0x9E, 0x03, 0xCF,
  0x83, 0xE7, 0xC1, 0xF1, 0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x20, 0x3C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0x1E,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8,
  0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3D, 0xFC, 0x1F, 0xFF, 0x0F,
  0xFF, 0xC7, 0xC7, 0xF0, 0x40, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xEF, 0xC1, 0xF3, 0xFB, 0xF8, 0xFF,
  0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x60, 0x7D, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xE3, 0xF7, 0xC0, 0xFB,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xE7, 0xC1, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC3, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D,
  0xF0, 0x3E, 0x78, 0x1F, 0x3E, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0xF1, 0xF8, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0x7C, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xEF, 0xC1, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xFC,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F,
  0x9F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x38, 0xFD, 0xFF, 0xF7, 0xEF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3F, 0x7F, 0xFD, 0xFB, 0xE0, 0x1C,
  0x3E, 0x7F, 0x7F, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78,
  0xF0, 0x20, 0x00, 0x02, 0x00, 0x1C, 0x01, 0xF8, 0x0F, 0xF0, 0xFF, 0xE7,
  0xFF, 0x3F, 0xF0, 0x7F, 0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03,
  0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x00,
  0x3E, 0x03, 0xFC, 0x3F, 0xFB, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x3E, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFE,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x3F,
  0xFC, 0x0F, 0x83, 0xC1, 0xC0, 0x1C, 0x70, 0x03, 0x9C, 0x3F, 0x33, 0x8F,
  0xE7, 0x63, 0xDC, 0xFC, 0xF3, 0x9F, 0x9C, 0x73, 0xF3, 0x8E, 0x7E, 0x71,
  0xCF, 0xCE, 0x39, 0xF9, 0xC7, 0x3F, 0x38, 0xE6, 0xE7, 0x3D, 0xDC, 0xFF,
  0xF3, 0x8F, 0xFE, 0x38, 0xC3, 0x07, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xDF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x0F,
  0x1F, 0x00, 0x78, 0xF8, 0x07, 0xC3, 0xC0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0xFC, 0x00, 0xF8,
  0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x1F, 0xBE,
  0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x87,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0x80, 0xFB, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x1E, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x7D, 0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xE0, 0xFC, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x87, 0xE7, 0xC1, 0xFB, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0x03, 0xEF, 0x87, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x0F, 0xDF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0,
  0x0F, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x78, 0x03, 0xDF, 0x00, 0xF7,
  0xC0, 0x3D, 0xF0, 0x0F, 0x3E, 0x07, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFE, 0x03, 0xFE, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8,
  0x0F, 0xF0, 0x00, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x81,
  0xF8, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF9,
  0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F,
  0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xEE,
  0xEF, 0xF7, 0x77, 0xFB, 0xFB, 0xFC, 0xFD, 0xFE, 0x7C, 0xFF, 0xBE, 0x7F,
  0xDF, 0x3F, 0xE7, 0x1F, 0xF3, 0x8F, 0xF9, 0xC7, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0x80, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFE,
  0xE3, 0xFF, 0x79, 0xFF, 0xBC, 0xFF, 0xCF, 0x7F, 0xE7, 0xBF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x78, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x03, 0xF7, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF3, 0xFF, 0xE1, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3E, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x0F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x1F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E,
  0xF8, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE,
  0x7C, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x0F, 0xDF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xE7, 0xC1, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x00,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x03, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0xF8, 0x70, 0xFB, 0xC3, 0x87, 0x9E, 0x3E, 0x3C, 0xF1, 0xF1, 0xE7, 0x8F,
  0x8F, 0x3E, 0x7C, 0x79, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x3C, 0xF9, 0xE1,
  0xEF, 0xEF, 0x0F, 0x7F, 0x78, 0x7B, 0xBB, 0xC3, 0xDD, 0xDE, 0x1E, 0xEE,
  0xF0, 0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x7C,
  0x07, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x00,
  0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xBE,
  0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x3E, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xFF,
  0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF9, 0xE0, 0x07, 0xBE,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7F, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x77, 0x83, 0xCE, 0x0F, 0x3C, 0x38, 0xF1, 0xE1, 0xC7, 0x87, 0xBC, 0x1E,
  0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3C,
  0x1E, 0x0F, 0x0F, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xC3, 0xF7, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x0F, 0xFF, 0x1F, 0xFF,
  0x9F, 0xFF, 0xDF, 0x83, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF8,
  0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x87, 0xF3, 0xE0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xE0,
  0xF7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x7E, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xF3, 0xF0,
  0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0,
  0x7B, 0xE0, 0x3D, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x79, 0xF0, 0x7C, 0xFE, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0x8F, 0x1F, 0xEF, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x7C,
  0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xCF, 0x03, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x11, 0xF8, 0x1C, 0xFF, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xF7, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xE1, 0xFB, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xF0, 0x7E, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFB, 0xE0, 0x01, 0xF1, 0x00, 0xF1,
  0x80, 0xF8, 0xFB, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF1, 0xE0, 0xF9, 0xFE, 0x7D, 0xFF, 0xBF, 0xFF, 0xDF, 0xC3,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7F,
  0xBF, 0xBF, 0xF7, 0xFC, 0xFF, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0xBE, 0x0F, 0xCF, 0x87, 0xE3, 0xE3, 0xF0, 0xF9, 0xF8, 0x3E,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x83, 0xF3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0x83, 0xF3, 0xE0, 0x7E,
  0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC7, 0x1E,
  0xFD, 0xF3, 0xDF, 0xFF, 0x7F, 0xFF, 0xEF, 0x9F, 0x3D, 0xF3, 0xE7, 0xFE,
  0x7C, 0xFF, 0xCF, 0x9F, 0xF9, 0xF3, 0xFF, 0x3E, 0x7F, 0xE7, 0xCF, 0xFC,
  0xF9, 0xFF, 0x9F, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF, 0xCF, 0x9F, 0xF9,
  0xF3, 0xFF, 0x3E, 0x7F, 0xE7, 0xCF, 0x80, 0x00, 0xF8, 0x7C, 0xFF, 0x3F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF7, 0xE0,
  0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xF0, 0x7C, 0xFE, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x7D, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xE3, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0,
  0x7D, 0xFE, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3E, 0x7E, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x1F, 0xEF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x7C, 0x1F, 0x7F, 0x7F, 0x3F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xC7, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xC1, 0xFB, 0xC0, 0x7D, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0xF8,
  0x3F, 0x7F, 0xFF, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFC, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x1F, 0x9F, 0xFC, 0x07, 0xEF,
  0x80, 0xF9, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07,
  0x83, 0xC0, 0xF8, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3E, 0xF8, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x70, 0xF7, 0x8F, 0x0F, 0x78, 0xF1, 0xF7,
  0x8F, 0x9E, 0x78, 0xF9, 0xE3, 0xCF, 0x9E, 0x3D, 0xF9, 0xE3, 0xDD, 0x9E,
  0x3D, 0xDD, 0xE3, 0xDD, 0xDC, 0x3D, 0x9F, 0xC1, 0xD9, 0xFC, 0x1F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0,
  0x78, 0xFC, 0x0F, 0xDF, 0x03, 0xE3, 0xE1, 0xF0, 0xFC, 0xF8, 0x1F, 0x7E,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xCF, 0x83, 0xE1, 0xF1, 0xF0,
  0x7E, 0x7C, 0x0F, 0xBE, 0x01, 0xF0, 0xF8, 0x03, 0xF7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xE0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07, 0xBE, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x02, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xE0, 0x1E, 0x03, 0xF0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x3F, 0x0F, 0xE0,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x1E,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0xFC, 0x3E, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x3E, 0x07, 0x80, 0xE0, 0x00,
  0x1F, 0x00, 0x03, 0xFC, 0x0F, 0x7F, 0xE0, 0xE7, 0xFF, 0x9E, 0x70, 0xFF,
  0xEF, 0x07, 0xFC, 0x10, 0x1F, 0x80, 0x00, 0x60,
};

const GFXglyph RobotoMono_Bold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 25, 21, 8, -25 },
  { 17, 10, 9, 21, 5, -26 },
  { 29, 19, 25, 21, 1, -25 },
  { 89, 17, 33, 21, 2, -29 },
  { 160, 19, 25, 21, 1, -25 },
  { 220, 20, 25, 21, 1, -25 },
  { 283, 3, 9, 21, 8, -26 },
  { 287, 9, 36, 21, 6, -28 },
  { 328, 10, 36, 21, 5, -28 },
  { 373, 17, 18, 21, 3, -25 },
  { 412, 17, 19, 21, 2, -21 },
  { 453, 6, 11, 21, 6, -4 },
  { 462, 14, 4, 21, 5, -13 },
  { 469, 7, 6, 21, 7, -6 },
  { 475, 14, 27, 21, 4, -25 },
  { 523, 17, 25, 21, 2, -25 },
  { 577, 11, 25, 21, 3, -25 },
  { 612, 18, 25, 21, 1, -25 },
  { 669, 17, 25, 21, 2, -25 },
  { 723, 18, 25, 21, 1, -25 },
  { 780, 17, 25, 21, 2, -25 },
  { 834, 17, 25, 21, 2, -25 },
  { 888, 18, 25, 21, 1, -25 },
  { 945, 17, 25, 21, 2, -25 },
  { 999, 16, 25, 21, 2, -25 },
  { 1049, 7, 20, 21, 7, -20 },
  { 1067, 8, 27, 21, 7, -20 },
  { 1094, 15, 17, 21, 3, -19 },
  { 1126, 16, 11, 21, 3, -16 },
  { 1148, 15, 17, 21, 3, -19 },
  { 1180, 16, 25, 21, 3, -25 },
  { 1230, 19, 25, 21, 1, -25 },
  { 1290, 21, 25, 21, 0, -25 },
  { 1356, 18, 25, 21, 2, -25 },
  { 1413, 19, 25, 21, 1, -25 },
  { 1473, 17, 25, 21, 2, -25 },
  { 1527, 16, 25, 21, 3, -25 },
  { 1577, 16, 25, 21, 3, -25 },
  { 1627, 18, 25, 21, 1, -25 },
  { 1684, 17, 25, 21, 2, -25 },
  { 1738, 15, 25, 21, 3, -25 },
  { 1785, 17, 25, 21, 2, -25 },
  { 1839, 20, 25, 21, 2, -25 },
  { 1902, 16, 25, 21, 3, -25 },
  { 1952, 17, 25, 21, 2, -25 },
  { 2006, 17, 25, 21, 2, -25 },
  { 2060, 19, 25, 21, 1, -25 },
  { 2120, 17, 25, 21, 3, -25 },
  { 2174, 20, 29, 21, 1, -25 },
  { 2247, 19, 25, 21, 2, -25 },
  { 2307, 18, 25, 21, 2, -25 },
  { 2364, 21, 25, 21, 0, -25 },
  { 2430, 17, 25, 21, 2, -25 },
  { 2484, 19, 25, 21, 1, -25 },
  { 2544, 21, 25, 21, 0, -25 },
  { 2610, 20, 25, 21, 1, -25 },
  { 2673, 20, 25, 21, 1, -25 },
  { 2736, 18, 25, 21, 2, -25 },
  { 2793, 7, 35, 21, 7, -29 },
  { 2824, 14, 27, 21, 4, -25 },
  { 2872, 8, 35, 21, 7, -29 },
  { 2907, 14, 13, 21, 4, -25 },
  { 2930, 15, 4, 21, 3, 0 },
  { 2938, 8, 5, 21, 7, -25 },
  { 2943, 17, 19, 21, 2, -19 },
  { 2984, 16, 26, 21, 3, -26 },
  { 3036, 17, 19, 21, 2, -19 },
  { 3077, 16, 26, 21, 2, -26 },
  { 3129, 17, 19, 21, 2, -19 },
  { 3170, 18, 27, 21, 2, -27 },
  { 3231, 17, 26, 21, 2, -19 },
  { 3287, 17, 26, 21, 2, -26 },
  { 3343, 15, 26, 21, 4, -26 },
  { 3392, 11, 33, 21, 4, -26 },
  { 3438, 18, 26, 21, 2, -26 },
  { 3497, 16, 26, 21, 3, -26 },
  { 3549, 19, 19, 21, 1, -19 },
  { 3595, 17, 19, 21, 2, -19 },
  { 3636, 17, 19, 21, 2, -19 },
  { 3677, 17, 26, 21, 2, -19 },
  { 3733, 16, 26, 21, 2, -19 },
  { 3785, 14, 19, 21, 5, -19 },
  { 3819, 17, 19, 21, 2, -19 },
  { 3860, 17, 23, 21, 2, -23 },
  { 3909, 16, 18, 21, 3, -18 },
  { 3945, 19, 18, 21, 1, -18 },
  { 3988, 20, 18, 21, 0, -18 },
  { 4033, 18, 18, 21, 2, -18 },
  { 4074, 20, 25, 21, 1, -18 },
  { 4137, 17, 18, 21, 2, -18 },
  { 4176, 12, 33, 21, 5, -27 },
  { 4226, 3, 32, 21, 9, -25 },
  { 4238, 11, 33, 21, 6, -27 },
  { 4284, 20, 8, 21, 0, -14 },
};

const GFXfont RobotoMono_Bold35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold35pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_BOLD35PT7B_H_
