#ifndef _ROBOTOMONO_BOLD69PT7B_H_
#define _ROBOTOMONO_BOLD69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold69pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3F, 0x8F, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFE, 0x3F, 0x80, 0x80, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x1F,
  0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x04, 0x00, 0x7F, 0x03, 0xF0,
  0x0C, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7C, 0x03,
  0xF8, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x03, 0xE0, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x7E, 0x00,
  0x3F, 0x87, 0xF1, 0xF8, 0x00, 0x7F, 0xFF, 0xE3, 0xF0, 0x00, 0x7F, 0xFF,
  0x8F, 0xC0, 0x00, 0xFF, 0xFE, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x7E, 0x00,
  0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xF8, 0x00,
  0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x0F, 0x8F, 0xFF, 0xF8, 0x00, 0x3F, 0x1F,
  0xFF, 0xF0, 0x00, 0xFC, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0xFE, 0x0F, 0xE0,
  0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x00, 0x60, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0x0F, 0xFD,
  0xFF, 0x81, 0xFE, 0x3F, 0xF1, 0xFF, 0x83, 0xFC, 0x7F, 0xC3, 0xFF, 0x8F,
  0xF9, 0xFF, 0x83, 0xFF, 0x9F, 0xF3, 0xFE, 0x03, 0xFF, 0xBF, 0xC7, 0xFC,
  0x03, 0xFF, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xFF,
  0xFC, 0x3F, 0xE0, 0x07, 0xFF, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0xFF,
  0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0x60, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x3E, 0x00, 0x10, 0xF0, 0x07, 0xC0,
  0x1E, 0x1F, 0x80, 0xF8, 0x0F, 0xC7, 0xFE, 0x1F, 0x07, 0xF8, 0xFF, 0xF3,
  0xE3, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x08, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF,
  0x07, 0xE0, 0x1C, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0xFF, 0x0F, 0xFC,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xCF,
  0xFC, 0x3F, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x87, 0xFB, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x9F,
  0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x20,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFF,
  0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x78, 0x00,
  0x3F, 0xE1, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0xF8, 0x1F, 0xF7, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0, 0x03,
  0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xFE,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x3F,
  0xF0, 0x07, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xF8, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x1F, 0xF9, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0,
  0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFE, 0x07,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0,
  0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xCF, 0xFF,
  0x87, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xF9, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x06, 0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xEF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x1F, 0xE1, 0xFF, 0x9F, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF9, 0xFF, 0x87, 0xF8, 0x06, 0x00, 0x01, 0x00, 0x3F,
  0x83, 0xFF, 0x8F, 0xFE, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F,
  0xFC, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0x3C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x01, 0xFF, 0x07, 0xC0, 0xFC,
  0x0F, 0xFF, 0x0F, 0x83, 0xF0, 0x3F, 0xFF, 0x1F, 0x87, 0xE0, 0xFF, 0xFE,
  0x1F, 0x1F, 0x83, 0xFF, 0xFC, 0x3E, 0x3F, 0x07, 0xF0, 0xF8, 0x7C, 0x7C,
  0x1F, 0xC3, 0xF0, 0xF9, 0xF8, 0x3F, 0x07, 0xE1, 0xF3, 0xF0, 0xFC, 0x0F,
  0xC3, 0xE7, 0xE1, 0xF8, 0x1F, 0x07, 0xCF, 0x83, 0xF0, 0x3E, 0x0F, 0x9F,
  0x07, 0xC0, 0x7C, 0x1F, 0x3E, 0x1F, 0x80, 0xF8, 0x3E, 0xFC, 0x3F, 0x01,
  0xF0, 0x7D, 0xF8, 0x7E, 0x03, 0xE0, 0xFB, 0xF0, 0xFC, 0x07, 0xC1, 0xF7,
  0xE1, 0xF8, 0x0F, 0x83, 0xEF, 0xC3, 0xF0, 0x1F, 0x07, 0x9F, 0x87, 0xE0,
  0x7E, 0x1F, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x3E, 0x1F, 0xC1, 0xF8, 0x7C,
  0x7C, 0x3F, 0x87, 0xF1, 0xF0, 0xFC, 0x3F, 0xFF, 0xE7, 0xE1, 0xF8, 0x7F,
  0xFF, 0xFF, 0x83, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0xFF, 0xCF, 0xFC,
  0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x0F, 0xC0, 0x30, 0x07, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0x3F, 0xF0, 0x07, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xC0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xC0,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF,
  0xBF, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xDF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF8, 0x00,
  0x3F, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFF,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x0F, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xFC,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0xCF, 0xFE,
  0x00, 0x3F, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x01, 0xFF,
  0xCF, 0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF, 0xBF,
  0x7F, 0x7F, 0xFF, 0xEF, 0xDF, 0xDF, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xF9, 0xFF, 0xFF, 0x9F, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0x1F, 0xFF,
  0xF9, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x1F, 0xE1,
  0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0x07, 0xFF, 0xFE, 0x0F, 0x81, 0xFF, 0xFF, 0x83, 0xE0, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0xFE, 0xFF,
  0x0F, 0xFF, 0xFF, 0x3F, 0x87, 0xFF, 0xFF, 0x9F, 0xE3, 0xFF, 0xFF, 0xC7,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFC, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xF8,
  0x7F, 0xBF, 0xFF, 0xFC, 0x3F, 0xDF, 0xFF, 0xFE, 0x0F, 0xEF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFE,
  0x7F, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xE0,
  0x00, 0xFF, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0xCF, 0xFC,
  0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x0F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x7F,
  0xE3, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xFE, 0x01, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x07,
  0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFE,
  0xFF, 0x80, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0xFF, 0x80,
  0xFF, 0x03, 0xFE, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x7F, 0x81, 0xFF, 0x03,
  0xFE, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x7F,
  0xC1, 0xFF, 0x03, 0xFC, 0x7F, 0xC1, 0xFF, 0x83, 0xFC, 0x7F, 0xC1, 0xFF,
  0x83, 0xFC, 0x3F, 0xC3, 0xFF, 0x87, 0xFC, 0x3F, 0xC3, 0xFF, 0x87, 0xFC,
  0x3F, 0xC3, 0xFF, 0x87, 0xFC, 0x3F, 0xC3, 0xFF, 0x87, 0xFC, 0x3F, 0xE3,
  0xFF, 0x87, 0xF8, 0x3F, 0xE3, 0xFF, 0xC7, 0xF8, 0x3F, 0xE3, 0xFF, 0xC7,
  0xF8, 0x1F, 0xE7, 0xFF, 0xC7, 0xF8, 0x1F, 0xE7, 0xFF, 0xCF, 0xF8, 0x1F,
  0xE7, 0xEF, 0xCF, 0xF8, 0x1F, 0xE7, 0xEF, 0xCF, 0xF8, 0x1F, 0xE7, 0xEF,
  0xEF, 0xF0, 0x1F, 0xE7, 0xEF, 0xEF, 0xF0, 0x1F, 0xF7, 0xEF, 0xEF, 0xF0,
  0x0F, 0xFF, 0xE7, 0xEF, 0xF0, 0x0F, 0xFF, 0xE7, 0xEF, 0xF0, 0x0F, 0xFF,
  0xC7, 0xEF, 0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0xF0, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0xC1, 0xFF, 0x80,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x81,
  0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x3F, 0x80,
  0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xE0, 0x07,
  0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xF0, 0x3F, 0xF3, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFD, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xBF,
  0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xF7,
  0xFF, 0x00, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x7F,
  0xC0, 0xFF, 0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x8F, 0xFF, 0x80, 0x7F,
  0xCF, 0xFF, 0xF0, 0x3F, 0xEF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x9F, 0xFC,
  0x00, 0xFF, 0xCF, 0xFF, 0x81, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xDF, 0xFF, 0xF0, 0x3F, 0xE7, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0xFF,
  0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x07, 0xFB, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0xF1,
  0xFF, 0x03, 0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x07,
  0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF, 0xFC, 0x3F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x81, 0xFF, 0xC0, 0x00, 0x70,
  0x3F, 0xF8, 0x00, 0x3E, 0x0F, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xBF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x07, 0xFF,
  0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF,
  0xE0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x38, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x02, 0x00, 0x03, 0xFF,
  0x03, 0x80, 0x01, 0xFF, 0x83, 0xE0, 0x01, 0xFF, 0xC1, 0xFE, 0x03, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0xE3, 0xFE, 0x00, 0x7F, 0xF8, 0x7F,
  0xC0, 0x0F, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0xE0, 0x03, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xCF,
  0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xFC,
  0x7F, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xE0, 0x03,
  0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0x9F, 0xF0,
  0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x7E, 0x0F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFF, 0x7F, 0xF3, 0xFF, 0x8F,
  0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x87,
  0xFC, 0x3F, 0xEF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1,
  0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1,
  0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1,
  0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF,
  0xF8, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFD, 0xFF, 0xF8,
  0x1F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00,
  0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F,
  0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xBF,
  0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xE7,
  0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xF8,
  0x1F, 0xF3, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xF0, 0x07, 0xFC, 0x03, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFE, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0x7F, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F,
  0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xF0, 0x07, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xF9, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0x00,
  0x07, 0x81, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x1C, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0,
  0x0F, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xF0, 0x1F,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x18, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0xF1, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xC0,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFC, 0x07, 0xFB, 0xFE, 0x03, 0xF8, 0x0F, 0xF3, 0xFC, 0x0F,
  0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE0, 0xFF,
  0x9F, 0xE0, 0x7F, 0xC1, 0xFF, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x7F, 0xC1,
  0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xFE, 0x1F,
  0xE1, 0xFE, 0x1F, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0xF1, 0xFE, 0x07, 0xF1, 0xFB, 0xE3, 0xFC, 0x0F, 0xE3, 0xF7, 0xC7,
  0xF8, 0x1F, 0xE7, 0xEF, 0xCF, 0xF0, 0x3F, 0xCF, 0x9F, 0x9F, 0xE0, 0x7F,
  0x9F, 0x3F, 0x3F, 0x80, 0xFF, 0x3E, 0x3E, 0x7F, 0x00, 0xFE, 0xFC, 0x7C,
  0xFE, 0x01, 0xFD, 0xF8, 0xFF, 0xFC, 0x03, 0xFB, 0xE1, 0xFF, 0xF8, 0x07,
  0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x03, 0xFF,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0xFF,
  0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x0F,
  0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE1,
  0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFD,
  0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x3F,
  0xFF, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0x0F, 0xE7, 0xFF, 0xFF, 0xE0,
  0x7F, 0x9F, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0xF3, 0xF8,
  0x07, 0xFF, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0xFF, 0x3F, 0x00, 0x0F, 0xFF,
  0xF8, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00,
};

const GFXglyph RobotoMono_Bold69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 11, 50, 41, 15, -49 },
  { 70, 21, 18, 41, 9, -52 },
  { 118, 38, 49, 41, 1, -49 },
  { 351, 34, 64, 41, 4, -57 },
  { 623, 39, 51, 41, 1, -50 },
  { 872, 39, 51, 41, 3, -50 },
  { 1121, 8, 19, 41, 15, -52 },
  { 1140, 18, 70, 41, 12, -55 },
  { 1298, 19, 70, 41, 11, -55 },
  { 1465, 35, 35, 41, 5, -49 },
  { 1619, 34, 36, 41, 3, -41 },
  { 1772, 12, 22, 41, 12, -8 },
  { 1805, 29, 7, 41, 9, -25 },
  { 1831, 13, 13, 41, 14, -12 },
  { 1853, 28, 53, 41, 7, -49 },
  { 2039, 32, 51, 41, 5, -50 },
  { 2243, 22, 49, 41, 6, -49 },
  { 2378, 35, 50, 41, 2, -50 },
  { 2597, 34, 51, 41, 3, -50 },
  { 2814, 36, 49, 41, 2, -49 },
  { 3035, 33, 50, 41, 4, -49 },
  { 3242, 33, 50, 41, 4, -49 },
  { 3449, 35, 49, 41, 2, -49 },
  { 3664, 33, 51, 41, 4, -50 },
  { 3875, 33, 50, 41, 3, -50 },
  { 4082, 13, 41, 41, 15, -40 },
  { 4149, 14, 54, 41, 15, -40 },
  { 4244, 30, 32, 41, 5, -37 },
  { 4364, 32, 22, 41, 5, -32 },
  { 4452, 31, 32, 41, 5, -37 },
  { 4576, 32, 50, 41, 5, -50 },
  { 4776, 39, 49, 41, 1, -49 },
  { 5015, 40, 49, 41, 1, -49 },
  { 5260, 36, 49, 41, 4, -49 },
  { 5481, 36, 51, 41, 3, -50 },
  { 5711, 34, 49, 41, 4, -49 },
  { 5920, 33, 49, 41, 5, -49 },
  { 6123, 33, 49, 41, 5, -49 },
  { 6326, 35, 51, 41, 3, -50 },
  { 6550, 33, 49, 41, 4, -49 },
  { 6753, 29, 49, 41, 6, -49 },
  { 6931, 33, 50, 41, 4, -49 },
  { 7138, 38, 49, 41, 4, -49 },
  { 7371, 33, 49, 41, 5, -49 },
  { 7574, 34, 49, 41, 4, -49 },
  { 7783, 33, 49, 41, 4, -49 },
  { 7986, 36, 51, 41, 3, -50 },
  { 8216, 34, 49, 41, 5, -49 },
  { 8425, 38, 59, 41, 3, -50 },
  { 8706, 36, 49, 41, 4, -49 },
  { 8927, 36, 51, 41, 3, -50 },
  { 9157, 39, 49, 41, 1, -49 },
  { 9396, 33, 50, 41, 4, -49 },
  { 9603, 39, 49, 41, 1, -49 },
  { 9842, 40, 49, 41, 1, -49 },
  { 10087, 40, 49, 41, 1, -49 },
  { 10332, 40, 49, 41, 1, -49 },
  { 10577, 36, 49, 41, 3, -49 },
  { 10798, 16, 68, 41, 13, -57 },
  { 10934, 27, 53, 41, 8, -49 },
  { 11113, 16, 68, 41, 13, -57 },
  { 11249, 28, 26, 41, 7, -49 },
  { 11340, 31, 7, 41, 5, 0 },
  { 11368, 16, 10, 41, 14, -50 },
  { 11388, 33, 38, 41, 4, -37 },
  { 11545, 33, 53, 41, 5, -52 },
  { 11764, 33, 38, 41, 4, -37 },
  { 11921, 32, 53, 41, 4, -52 },
  { 12133, 34, 38, 41, 4, -37 },
  { 12295, 35, 53, 41, 4, -53 },
  { 12527, 33, 51, 41, 4, -37 },
  { 12738, 32, 52, 41, 5, -52 },
  { 12946, 30, 51, 41, 7, -51 },
  { 13138, 22, 66, 41, 8, -51 },
  { 13320, 35, 52, 41, 5, -52 },
  { 13548, 31, 52, 41, 7, -52 },
  { 13750, 36, 37, 41, 3, -37 },
  { 13917, 32, 37, 41, 5, -37 },
  { 14065, 35, 38, 41, 3, -37 },
  { 14232, 33, 51, 41, 5, -37 },
  { 14443, 32, 51, 41, 4, -37 },
  { 14647, 28, 37, 41, 10, -37 },
  { 14777, 33, 38, 41, 4, -37 },
  { 14934, 33, 46, 41, 4, -45 },
  { 15124, 32, 37, 41, 5, -36 },
  { 15272, 37, 36, 41, 2, -36 },
  { 15439, 39, 36, 41, 1, -36 },
  { 15615, 37, 36, 41, 3, -36 },
  { 15782, 39, 51, 41, 2, -36 },
  { 16031, 34, 36, 41, 4, -36 },
  { 16184, 23, 66, 41, 10, -54 },
  { 16374, 6, 63, 41, 18, -49 },
  { 16422, 23, 66, 41, 11, -54 },
  { 16612, 38, 15, 41, 1, -28 },
};

const GFXfont RobotoMono_Bold69pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold69pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _ROBOTOMONO_BOLD69PT7B_H_
