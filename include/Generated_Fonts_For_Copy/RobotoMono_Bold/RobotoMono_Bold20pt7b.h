#ifndef _ROBOTOMONO_BOLD20PT7B_H_
#define _ROBOTOMONO_BOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold20pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06, 0xF6, 0xCF, 0x3C, 0xF3, 0xCC,
  0x0C, 0xC1, 0x98, 0x32, 0x06, 0xC7, 0xFE, 0xFF, 0xC6, 0x60, 0xCC, 0xFF,
  0xFF, 0xFC, 0x4C, 0x19, 0x83, 0x30, 0x64, 0x00, 0x04, 0x01, 0x03, 0xF9,
  0xFE, 0x71, 0xDC, 0x77, 0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x3C, 0x07, 0xE1,
  0xDC, 0x77, 0xF8, 0xFC, 0x04, 0x01, 0x00, 0x78, 0x0C, 0xC8, 0xCC, 0xCC,
  0xD8, 0x7D, 0x03, 0xB0, 0x06, 0x00, 0x60, 0x0D, 0xE0, 0xBE, 0x1B, 0x31,
  0x33, 0x03, 0x60, 0x1E, 0x3E, 0x0F, 0xE1, 0xCC, 0x39, 0x87, 0x70, 0x7C,
  0x0E, 0x03, 0xE7, 0xEE, 0xFC, 0xFB, 0x1F, 0x71, 0xCF, 0xFC, 0xFD, 0xC0,
  0xFF, 0x6C, 0x04, 0x71, 0x8C, 0x71, 0x86, 0x18, 0xE3, 0x8E, 0x38, 0x61,
  0x86, 0x18, 0x30, 0xC1, 0x83, 0x83, 0x06, 0x0C, 0x30, 0xE1, 0x86, 0x1C,
  0x71, 0xC7, 0x18, 0x61, 0x8E, 0x31, 0xC6, 0x30, 0x0E, 0x00, 0x81, 0x11,
  0x3A, 0xEF, 0xFE, 0x1C, 0x06, 0xC1, 0xD8, 0x31, 0x82, 0x20, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0xFF, 0xFD, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x70, 0x70, 0x60, 0xE0, 0x3F, 0x1F,
  0xE7, 0x39, 0x86, 0xE1, 0xF8, 0xFE, 0xFF, 0xE7, 0xF1, 0xF8, 0x76, 0x19,
  0xCE, 0x7F, 0x8F, 0xC0, 0x0D, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x70, 0x3F, 0x1F, 0xEE, 0x3B, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xEE,
  0x38, 0x06, 0x01, 0x80, 0xE1, 0xF0, 0x7E, 0x01, 0x80, 0x7E, 0x1F, 0x8E,
  0x7F, 0x8F, 0xC0, 0x07, 0x03, 0xC0, 0xF0, 0x7C, 0x1B, 0x0C, 0xC7, 0x31,
  0x8C, 0xC3, 0x3F, 0xFF, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x7F, 0x9F, 0xE7,
  0x01, 0x80, 0x60, 0x1F, 0xC7, 0xF8, 0x8E, 0x01, 0xC0, 0x7E, 0x1F, 0x8E,
  0x7F, 0x8F, 0xC0, 0x0F, 0x0F, 0xC7, 0x81, 0xC0, 0xE0, 0x3F, 0xCF, 0xFB,
  0x86, 0xE1, 0xF8, 0x7E, 0x1D, 0xCE, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0xF0,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x1C, 0x00, 0x3F, 0x1F, 0xEE, 0x3B, 0x86, 0xE3, 0x9C, 0xE3, 0xF1,
  0xFE, 0xE3, 0xB8, 0x7E, 0x1F, 0x8E, 0x7F, 0x8F, 0xC0, 0x3E, 0x3F, 0xB8,
  0xFC, 0x3E, 0x1F, 0x0F, 0x8E, 0xFF, 0x3F, 0x81, 0xC0, 0xE1, 0xE3, 0xE1,
  0xE0, 0x7F, 0x70, 0x00, 0x00, 0x7F, 0x70, 0x77, 0x70, 0x00, 0x00, 0x07,
  0x77, 0x66, 0xC0, 0x01, 0x07, 0x1F, 0xFC, 0xE0, 0xF0, 0x7E, 0x1F, 0x03,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0xE0, 0xF8, 0x3F,
  0x07, 0x0F, 0x7E, 0xF8, 0xC0, 0x80, 0x7E, 0x7F, 0xB8, 0xF8, 0x70, 0x38,
  0x38, 0x38, 0x38, 0x18, 0x0C, 0x00, 0x03, 0x03, 0xC0, 0xC0, 0x0F, 0x83,
  0xB8, 0xC1, 0xB3, 0xD6, 0xDA, 0x93, 0x76, 0x4E, 0xC9, 0xD9, 0x2B, 0xED,
  0xBF, 0x30, 0x03, 0x90, 0x3F, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x1F, 0x81, 0xD8, 0x19, 0xC3, 0x9C, 0x38, 0xC3, 0xFE, 0x7F, 0xE7, 0x0E,
  0x70, 0x7E, 0x07, 0xFF, 0x1F, 0xFB, 0x87, 0x70, 0xEE, 0x1D, 0xC7, 0xBF,
  0xC7, 0xFE, 0xE1, 0xDC, 0x1F, 0x83, 0x70, 0xEF, 0xFD, 0xFE, 0x00, 0x3F,
  0x1F, 0xEE, 0x1F, 0x87, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x1D, 0xC7, 0x7F, 0x8F, 0xC0, 0xFE, 0x3F, 0xCE, 0x3B, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x9E, 0xFF, 0x3F, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0xFB, 0xFE, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3F,
  0x1F, 0xE7, 0x1F, 0x87, 0xE0, 0x38, 0x0E, 0x03, 0x9F, 0xE7, 0xF8, 0x7E,
  0x1D, 0xC7, 0x7F, 0xCF, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x7E, 0x1F, 0x8E, 0x7F, 0x8F, 0xC0, 0xE1, 0xFC, 0x3B, 0x8E, 0x73,
  0x8E, 0xF1, 0xDC, 0x3F, 0x87, 0xF0, 0xF7, 0x1C, 0xE3, 0x8E, 0x70, 0xEE,
  0x1D, 0xC1, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xF3, 0xFC, 0xFF,
  0x3F, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xB7, 0xED, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x70, 0xE1, 0xFC, 0x7F, 0x1F, 0xE7, 0xF9, 0xFE, 0x7E, 0xDF,
  0xB7, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0x70, 0x3F, 0x1F, 0xEE,
  0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xCE,
  0x7F, 0x8F, 0xC0, 0xFF, 0x3F, 0xEE, 0x1F, 0x83, 0xE0, 0xF8, 0x7E, 0x3F,
  0xFE, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3F, 0x0F, 0xF3,
  0x87, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87,
  0x39, 0xE7, 0xF8, 0x7F, 0x00, 0x78, 0x06, 0x00, 0x40, 0xFF, 0x1F, 0xF3,
  0x87, 0x70, 0xEE, 0x1D, 0xC3, 0xBF, 0xF7, 0xFC, 0xFF, 0x1C, 0x63, 0x8E,
  0x70, 0xCE, 0x1D, 0xC1, 0xC0, 0x3F, 0x9F, 0xFE, 0x1F, 0x83, 0xE0, 0x1E,
  0x03, 0xF0, 0x3E, 0x03, 0xC0, 0x7E, 0x0F, 0x87, 0x7F, 0xCF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xCE, 0x7F,
  0x8F, 0xC0, 0xF0, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x39, 0xC3, 0x9C, 0x39,
  0xC1, 0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xE6,
  0x7E, 0x67, 0x66, 0x66, 0xF6, 0x6F, 0x66, 0xF6, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE3, 0x9C, 0x39, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0xF0, 0xF7, 0x0E, 0x39,
  0xC1, 0x9C, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x39,
  0xC3, 0x9E, 0x70, 0xEF, 0x0F, 0xF0, 0x77, 0x0E, 0x30, 0xE3, 0x9C, 0x19,
  0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xFF, 0xFF, 0xF0, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x38, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xFF, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x38,
  0x18, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0xFF, 0xF3, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x18, 0x3C, 0x3C, 0x36, 0x66,
  0x67, 0xE3, 0xFF, 0xFF, 0xC0, 0xF1, 0xC0, 0x1E, 0x1F, 0xC7, 0x3B, 0x86,
  0x01, 0x9F, 0xEF, 0x1B, 0x86, 0xE3, 0xBF, 0xE7, 0xDC, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xEE, 0x3F, 0xEF, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xF3, 0xBF, 0xEE, 0xF0, 0x1E, 0x0F, 0xC7, 0x3B, 0x87, 0xE0, 0x38, 0x0E,
  0x03, 0x87, 0x71, 0x9F, 0xE3, 0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x1D,
  0xDF, 0xF7, 0x7F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0xDF, 0xF3,
  0xDC, 0x0E, 0x0F, 0xE7, 0xBB, 0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x9F, 0xF1, 0xF0, 0x0F, 0xC3, 0xF1, 0xC0, 0x70, 0xFF, 0xFF, 0xF1, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x1D, 0xDF,
  0xF7, 0xBF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDF, 0xF3, 0xFC,
  0x07, 0x63, 0x9F, 0xE3, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE7, 0x3F,
  0xEF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C,
  0x08, 0x0E, 0x07, 0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x0C, 0x3C, 0x30, 0x07, 0xCF, 0x9F, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1D, 0xFB, 0xE0, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x1D, 0xC7, 0x39, 0xC7, 0x70, 0xFC, 0x1F, 0xC3,
  0xF8, 0x73, 0x8E, 0x39, 0xC7, 0xB8, 0x78, 0xFC, 0x7E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE,
  0xD9, 0xBF, 0xFF, 0xFF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3,
  0x3C, 0xCC, 0xE7, 0x3F, 0xEF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1C, 0x1E, 0x0F, 0xC7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0x73, 0x9F, 0xE3, 0xF0, 0xEE, 0x3F, 0xEF, 0x3B, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xBF, 0xEE, 0xF3, 0x80, 0xE0, 0x38, 0x0E,
  0x00, 0x1D, 0xDF, 0xF7, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73,
  0xDF, 0xF3, 0xDC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0xC7, 0xDF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0x1F, 0xE7, 0x3D, 0x87,
  0x70, 0x0F, 0xC0, 0xF8, 0x07, 0xE1, 0xDF, 0xE3, 0xF0, 0x18, 0x06, 0x0F,
  0xFB, 0xFE, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x7F,
  0x0F, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x87,
  0x71, 0xDF, 0xF3, 0xDC, 0xE1, 0xF8, 0x7E, 0x1D, 0x86, 0x73, 0x8C, 0xC3,
  0x30, 0xFC, 0x1E, 0x07, 0x80, 0xC0, 0xE6, 0x7E, 0x66, 0x66, 0x66, 0xE6,
  0x6F, 0x66, 0xFE, 0x7B, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x39, 0xC0, 0xE1,
  0xCE, 0x39, 0xCE, 0x1F, 0x81, 0xF0, 0x3C, 0x07, 0xC1, 0xF8, 0x3B, 0x8E,
  0x3B, 0x87, 0x80, 0xE0, 0xFC, 0x1F, 0x87, 0x38, 0xE7, 0x38, 0x67, 0x0E,
  0xC0, 0xF8, 0x1E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0xF0, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F,
  0xFF, 0xFC, 0x04, 0x1C, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x31, 0xC3, 0xC1,
  0x83, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x38, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x41, 0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x3C, 0x79, 0xC3,
  0x06, 0x0C, 0x18, 0x30, 0xE3, 0x84, 0x00, 0x38, 0x4F, 0xCF, 0xBF, 0xE1,
  0xE0,
};

const GFXglyph RobotoMono_Bold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 14, 12, 4, -14 },
  { 8, 6, 5, 12, 3, -15 },
  { 12, 11, 14, 12, 0, -14 },
  { 32, 10, 18, 12, 1, -16 },
  { 55, 12, 14, 12, 0, -14 },
  { 76, 11, 14, 12, 1, -14 },
  { 96, 3, 5, 12, 4, -15 },
  { 98, 6, 20, 12, 3, -16 },
  { 113, 6, 20, 12, 3, -16 },
  { 128, 11, 10, 12, 1, -14 },
  { 142, 10, 11, 12, 1, -12 },
  { 156, 3, 6, 12, 4, -2 },
  { 159, 8, 2, 12, 3, -7 },
  { 161, 4, 3, 12, 4, -3 },
  { 163, 8, 15, 12, 2, -14 },
  { 178, 10, 14, 12, 1, -14 },
  { 196, 6, 14, 12, 2, -14 },
  { 207, 10, 14, 12, 1, -14 },
  { 225, 10, 14, 12, 1, -14 },
  { 243, 10, 14, 12, 1, -14 },
  { 261, 10, 14, 12, 1, -14 },
  { 279, 10, 14, 12, 1, -14 },
  { 297, 10, 14, 12, 1, -14 },
  { 315, 10, 14, 12, 1, -14 },
  { 333, 9, 14, 12, 1, -14 },
  { 349, 4, 11, 12, 4, -11 },
  { 355, 4, 15, 12, 4, -11 },
  { 363, 8, 10, 12, 2, -11 },
  { 373, 9, 6, 12, 2, -9 },
  { 380, 8, 10, 12, 2, -11 },
  { 390, 9, 14, 12, 2, -14 },
  { 406, 11, 14, 12, 0, -14 },
  { 426, 12, 14, 12, 0, -14 },
  { 447, 11, 14, 12, 1, -14 },
  { 467, 10, 14, 12, 1, -14 },
  { 485, 10, 14, 12, 1, -14 },
  { 503, 10, 14, 12, 1, -14 },
  { 521, 10, 14, 12, 1, -14 },
  { 539, 10, 14, 12, 1, -14 },
  { 557, 10, 14, 12, 1, -14 },
  { 575, 8, 14, 12, 2, -14 },
  { 589, 10, 14, 12, 1, -14 },
  { 607, 11, 14, 12, 1, -14 },
  { 627, 10, 14, 12, 1, -14 },
  { 645, 10, 14, 12, 1, -14 },
  { 663, 10, 14, 12, 1, -14 },
  { 681, 10, 14, 12, 1, -14 },
  { 699, 10, 14, 12, 1, -14 },
  { 717, 11, 17, 12, 1, -14 },
  { 741, 11, 14, 12, 1, -14 },
  { 761, 10, 14, 12, 1, -14 },
  { 779, 12, 14, 12, 0, -14 },
  { 800, 10, 14, 12, 1, -14 },
  { 818, 12, 14, 12, 0, -14 },
  { 839, 12, 14, 12, 0, -14 },
  { 860, 12, 14, 12, 0, -14 },
  { 881, 12, 14, 12, 0, -14 },
  { 902, 10, 14, 12, 1, -14 },
  { 920, 4, 20, 12, 4, -17 },
  { 930, 8, 15, 12, 2, -14 },
  { 945, 4, 20, 12, 4, -17 },
  { 955, 8, 7, 12, 2, -14 },
  { 962, 9, 2, 12, 1, 0 },
  { 965, 5, 2, 12, 4, -14 },
  { 967, 10, 11, 12, 1, -11 },
  { 981, 10, 15, 12, 1, -15 },
  { 1000, 10, 11, 12, 1, -11 },
  { 1014, 10, 15, 12, 1, -15 },
  { 1033, 10, 11, 12, 1, -11 },
  { 1047, 10, 15, 12, 1, -15 },
  { 1066, 10, 15, 12, 1, -11 },
  { 1085, 10, 15, 12, 1, -15 },
  { 1104, 9, 15, 12, 2, -15 },
  { 1121, 7, 19, 12, 2, -15 },
  { 1138, 11, 15, 12, 1, -15 },
  { 1159, 9, 15, 12, 2, -15 },
  { 1176, 10, 11, 12, 1, -11 },
  { 1190, 10, 11, 12, 1, -11 },
  { 1204, 10, 11, 12, 1, -11 },
  { 1218, 10, 15, 12, 1, -11 },
  { 1237, 10, 15, 12, 1, -11 },
  { 1256, 8, 11, 12, 3, -11 },
  { 1267, 10, 11, 12, 1, -11 },
  { 1281, 10, 13, 12, 1, -13 },
  { 1298, 10, 11, 12, 1, -11 },
  { 1312, 10, 11, 12, 1, -11 },
  { 1326, 12, 11, 12, 0, -11 },
  { 1343, 11, 11, 12, 1, -11 },
  { 1359, 11, 15, 12, 1, -11 },
  { 1380, 10, 11, 12, 1, -11 },
  { 1394, 7, 20, 12, 3, -16 },
  { 1412, 2, 18, 12, 5, -14 },
  { 1417, 7, 20, 12, 3, -16 },
  { 1435, 11, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_Bold20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold20pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_BOLD20PT7B_H_
