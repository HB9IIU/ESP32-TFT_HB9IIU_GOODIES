#ifndef _ROBOTOMONO_BOLD15PT7B_H_
#define _ROBOTOMONO_BOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xA4, 0x90, 0x1F, 0x80, 0xDC, 0xE5, 0x20, 0x1A, 0x12, 0x12,
  0x7F, 0x7F, 0x36, 0x34, 0xFF, 0x24, 0x2C, 0x6C, 0x10, 0x71, 0xFF, 0x3C,
  0x6C, 0x1F, 0x07, 0x07, 0x8F, 0xBB, 0xE1, 0x02, 0x00, 0x70, 0x68, 0x34,
  0x9A, 0x87, 0x40, 0x40, 0x68, 0x2F, 0x35, 0x8A, 0xC1, 0xC0, 0x38, 0x7C,
  0x4C, 0x4C, 0x78, 0x70, 0xFB, 0xDB, 0xCE, 0xFE, 0x7F, 0xFF, 0x23, 0x4C,
  0xC8, 0x88, 0x88, 0xCC, 0x46, 0x30, 0x84, 0x63, 0x33, 0x11, 0x11, 0x33,
  0x26, 0xC0, 0x18, 0x18, 0x9A, 0xF7, 0x18, 0x38, 0x66, 0x24, 0x30, 0x60,
  0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0xFF, 0x80, 0xFF, 0xF0, 0x5F, 0x80, 0x0C,
  0x61, 0x84, 0x30, 0xC6, 0x18, 0x63, 0x0C, 0x30, 0x38, 0xFB, 0x1E, 0x3C,
  0xFB, 0xF9, 0xE3, 0xC6, 0xD9, 0xF0, 0x09, 0xFF, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x39, 0xFB, 0x3E, 0x30, 0xC1, 0x86, 0x18, 0x61, 0xFF, 0xF8, 0x39,
  0xFB, 0x18, 0x30, 0xC7, 0x03, 0x83, 0xC7, 0xDD, 0xF0, 0x06, 0x0E, 0x0E,
  0x1E, 0x36, 0x26, 0x66, 0xFF, 0x7F, 0x06, 0x06, 0x7E, 0xFD, 0x06, 0x0F,
  0xDF, 0xC1, 0x83, 0xC7, 0xDD, 0xF0, 0x18, 0x71, 0x86, 0x0F, 0xDF, 0xF1,
  0xE3, 0xC7, 0xFD, 0xF0, 0xFF, 0xFF, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18,
  0x18, 0x30, 0x30, 0x39, 0xFB, 0x1E, 0x3E, 0xCF, 0x3B, 0x63, 0xC7, 0xDD,
  0xF0, 0x39, 0xFB, 0x3E, 0x3C, 0x79, 0xDF, 0x93, 0x0C, 0xF9, 0xC0, 0x5F,
  0x80, 0x17, 0xE0, 0x5D, 0x80, 0x03, 0x6D, 0x60, 0x06, 0x3F, 0xE6, 0x07,
  0x83, 0xC0, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xC1, 0xE0, 0xF0, 0x33,
  0xDE, 0x20, 0x00, 0x38, 0xFF, 0x18, 0x30, 0xE3, 0x86, 0x08, 0x00, 0x70,
  0xE0, 0x0C, 0x1F, 0x18, 0x4B, 0xE5, 0x5F, 0xAF, 0xD5, 0xAA, 0x5A, 0x30,
  0x0F, 0x00, 0x0C, 0x0E, 0x07, 0x03, 0xC3, 0x61, 0xB0, 0xCC, 0xFE, 0x7F,
  0x31, 0xF8, 0x60, 0xF8, 0xFE, 0xC6, 0xC6, 0xC6, 0xFC, 0xC6, 0xC3, 0xC7,
  0xFE, 0xFC, 0x38, 0xFF, 0x1E, 0x3C, 0x18, 0x30, 0x60, 0xC7, 0xFD, 0xF0,
  0xF1, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFB, 0xE0, 0xFF, 0xFF,
  0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x06, 0x0C,
  0x1F, 0xFF, 0xE0, 0xC1, 0x83, 0x00, 0x38, 0xFF, 0x1E, 0x3C, 0x18, 0x37,
  0xE3, 0xC7, 0xFD, 0xF0, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xF1, 0xE3, 0xC7,
  0x8F, 0x18, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x39, 0xFF, 0xF8,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xC7, 0xFD, 0xF0, 0xC7, 0xC6,
  0xCC, 0xDC, 0xD8, 0xF8, 0xF8, 0xCC, 0xCE, 0xC6, 0xC7, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xE7, 0xDF, 0xBF, 0x7F, 0xFF,
  0xF5, 0xE3, 0xC7, 0x8F, 0x18, 0xC7, 0x8F, 0x9F, 0x3F, 0x7A, 0xF7, 0xEF,
  0xCF, 0x9F, 0x18, 0x38, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFD,
  0xF0, 0xF8, 0xFE, 0xC6, 0xC7, 0xC6, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0,
  0x38, 0x7C, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xFE, 0x7E, 0x07,
  0x02, 0xF8, 0xFE, 0xC6, 0xC6, 0xC6, 0xFE, 0xFC, 0xCC, 0xCE, 0xC6, 0xC7,
  0x38, 0x7E, 0xC6, 0xC1, 0xE0, 0x7C, 0x0E, 0x06, 0xC7, 0xFE, 0x7C, 0xFF,
  0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFD, 0xF0, 0xE3, 0xB1,
  0x98, 0xCC, 0x67, 0x71, 0xB0, 0xD8, 0x6C, 0x1C, 0x0E, 0x07, 0x00, 0xC9,
  0xE4, 0xF7, 0x6B, 0xA7, 0xF3, 0xB9, 0xDC, 0xEE, 0x77, 0x3B, 0x8D, 0x80,
  0xE3, 0xB1, 0x8D, 0xC6, 0xC1, 0xE0, 0xE0, 0x70, 0x6C, 0x37, 0x31, 0xB8,
  0xE0, 0xE1, 0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0xFF, 0xFC, 0x18, 0x61, 0x87, 0x0C, 0x30, 0xE1, 0xFF, 0xF8,
  0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xC0, 0xC3, 0x04, 0x18, 0x60, 0x83, 0x0C,
  0x10, 0x61, 0x83, 0xED, 0xB6, 0xDB, 0x6D, 0xB7, 0xC0, 0x21, 0xC7, 0x16,
  0xDA, 0x30, 0xFF, 0xFC, 0xC7, 0x7D, 0xD8, 0x1B, 0xFE, 0x78, 0xFB, 0xBF,
  0xC1, 0x83, 0x07, 0xEF, 0xF8, 0xF1, 0xE3, 0xC7, 0xFF, 0xF0, 0x7D, 0xFF,
  0x1E, 0x0C, 0x18, 0xFB, 0xBE, 0x06, 0x0C, 0x1B, 0xFF, 0xF8, 0xF1, 0xE3,
  0xC7, 0xFD, 0xF8, 0x3C, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0x9E, 0x06, 0x3C,
  0xC1, 0x8F, 0xFF, 0xCC, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x7F, 0xFF, 0x1E,
  0x3C, 0x78, 0xFF, 0xBF, 0x07, 0xDD, 0xF0, 0xC1, 0x83, 0x06, 0xEF, 0xF8,
  0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0x30, 0xC0, 0x3C, 0xF0, 0xC3, 0x0C, 0x33,
  0xFF, 0xC0, 0x33, 0x0F, 0xF3, 0x33, 0x33, 0x33, 0xFE, 0xC0, 0xC0, 0xC0,
  0xC6, 0xCC, 0xD8, 0xF0, 0xF8, 0xCC, 0xCE, 0xC7, 0xF8, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x19, 0xFF, 0xF8, 0xBF, 0xFE, 0x4C, 0x99, 0x32, 0x64,
  0xC9, 0xDD, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x7D, 0xFF, 0x1E, 0x3C,
  0x78, 0xFB, 0xBE, 0xFD, 0xFF, 0x1E, 0x3C, 0x78, 0xFB, 0xFE, 0xC1, 0x83,
  0x00, 0x7F, 0xFF, 0x1E, 0x3C, 0x78, 0xFB, 0xBF, 0x06, 0x0C, 0x18, 0xDF,
  0xFE, 0x30, 0xC3, 0x0C, 0x30, 0x7D, 0xDF, 0x03, 0xC3, 0xF8, 0xF9, 0xBE,
  0x30, 0x63, 0xFF, 0xF3, 0x06, 0x0C, 0x18, 0x3E, 0x3C, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xFF, 0xBF, 0xC7, 0x8F, 0x1B, 0x66, 0xC5, 0x0E, 0x1C, 0xC9,
  0xEC, 0x97, 0xCA, 0xE7, 0x73, 0xB9, 0xDC, 0x6C, 0xC7, 0x6E, 0x7C, 0x38,
  0x38, 0x7C, 0x6E, 0xC7, 0xE1, 0xB1, 0x9C, 0xC6, 0xC3, 0x60, 0xF0, 0x70,
  0x18, 0x18, 0x1C, 0x1C, 0x00, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x3F, 0xFF,
  0x08, 0xCC, 0x63, 0x19, 0x98, 0x71, 0x8C, 0x63, 0x0C, 0x20, 0xFF, 0xFC,
  0x47, 0x08, 0x42, 0x18, 0xC3, 0x31, 0x88, 0x46, 0x71, 0x00, 0x71, 0xFF,
  0xCF,
};

const GFXglyph RobotoMono_Bold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 4, 9, 2, -11 },
  { 9, 8, 11, 9, 0, -11 },
  { 20, 7, 14, 9, 1, -12 },
  { 33, 9, 11, 9, 0, -11 },
  { 46, 8, 11, 9, 1, -11 },
  { 57, 2, 4, 9, 3, -11 },
  { 58, 4, 15, 9, 3, -12 },
  { 66, 4, 15, 9, 2, -12 },
  { 74, 8, 8, 9, 1, -11 },
  { 82, 7, 8, 9, 1, -9 },
  { 89, 2, 5, 9, 3, -2 },
  { 91, 6, 2, 9, 2, -6 },
  { 93, 3, 3, 9, 3, -3 },
  { 95, 6, 12, 9, 2, -11 },
  { 104, 7, 11, 9, 1, -11 },
  { 114, 5, 11, 9, 1, -11 },
  { 121, 7, 11, 9, 1, -11 },
  { 131, 7, 11, 9, 1, -11 },
  { 141, 8, 11, 9, 0, -11 },
  { 152, 7, 11, 9, 1, -11 },
  { 162, 7, 11, 9, 1, -11 },
  { 172, 8, 11, 9, 0, -11 },
  { 183, 7, 11, 9, 1, -11 },
  { 193, 7, 11, 9, 1, -11 },
  { 203, 3, 9, 9, 3, -9 },
  { 207, 3, 12, 9, 3, -9 },
  { 212, 7, 7, 9, 1, -8 },
  { 219, 7, 5, 9, 1, -7 },
  { 224, 7, 7, 9, 1, -8 },
  { 231, 7, 11, 9, 1, -11 },
  { 241, 9, 11, 9, 0, -11 },
  { 254, 9, 11, 9, 0, -11 },
  { 267, 8, 11, 9, 1, -11 },
  { 278, 7, 11, 9, 1, -11 },
  { 288, 7, 11, 9, 1, -11 },
  { 298, 7, 11, 9, 1, -11 },
  { 308, 7, 11, 9, 1, -11 },
  { 318, 7, 11, 9, 1, -11 },
  { 328, 7, 11, 9, 1, -11 },
  { 338, 7, 11, 9, 1, -11 },
  { 348, 7, 11, 9, 1, -11 },
  { 358, 8, 11, 9, 1, -11 },
  { 369, 7, 11, 9, 1, -11 },
  { 379, 7, 11, 9, 1, -11 },
  { 389, 7, 11, 9, 1, -11 },
  { 399, 7, 11, 9, 1, -11 },
  { 409, 8, 11, 9, 1, -11 },
  { 420, 8, 13, 9, 1, -11 },
  { 433, 8, 11, 9, 1, -11 },
  { 444, 8, 11, 9, 1, -11 },
  { 455, 9, 11, 9, 0, -11 },
  { 468, 7, 11, 9, 1, -11 },
  { 478, 9, 11, 9, 0, -11 },
  { 491, 9, 11, 9, 0, -11 },
  { 504, 9, 11, 9, 0, -11 },
  { 517, 9, 11, 9, 0, -11 },
  { 530, 7, 11, 9, 1, -11 },
  { 540, 3, 14, 9, 3, -12 },
  { 546, 6, 12, 9, 2, -11 },
  { 555, 3, 14, 9, 3, -12 },
  { 561, 6, 6, 9, 2, -11 },
  { 566, 7, 2, 9, 1, 0 },
  { 568, 4, 2, 9, 3, -11 },
  { 569, 7, 8, 9, 1, -8 },
  { 576, 7, 11, 9, 1, -11 },
  { 586, 7, 8, 9, 1, -8 },
  { 593, 7, 11, 9, 1, -11 },
  { 603, 7, 8, 9, 1, -8 },
  { 610, 7, 12, 9, 1, -12 },
  { 621, 7, 11, 9, 1, -8 },
  { 631, 7, 11, 9, 1, -11 },
  { 641, 6, 11, 9, 2, -11 },
  { 650, 4, 14, 9, 2, -11 },
  { 657, 8, 11, 9, 1, -11 },
  { 668, 7, 11, 9, 1, -11 },
  { 678, 7, 8, 9, 1, -8 },
  { 685, 7, 8, 9, 1, -8 },
  { 692, 7, 8, 9, 1, -8 },
  { 699, 7, 11, 9, 1, -8 },
  { 709, 7, 11, 9, 1, -8 },
  { 719, 6, 8, 9, 2, -8 },
  { 725, 7, 8, 9, 1, -8 },
  { 732, 7, 10, 9, 1, -10 },
  { 741, 7, 8, 9, 1, -8 },
  { 748, 7, 8, 9, 1, -8 },
  { 755, 9, 8, 9, 0, -8 },
  { 764, 8, 8, 9, 1, -8 },
  { 772, 9, 11, 9, 0, -8 },
  { 785, 7, 8, 9, 1, -8 },
  { 792, 5, 15, 9, 2, -12 },
  { 802, 1, 14, 9, 4, -11 },
  { 804, 5, 15, 9, 2, -12 },
  { 814, 8, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_Bold15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold15pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_BOLD15PT7B_H_
