#ifndef _ROBOTOMONO_BOLD46PT7B_H_
#define _ROBOTOMONO_BOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xC0, 0x00, 0x00, 0x00,
  0x43, 0xEF, 0xFF, 0xFF, 0xFF, 0x7C, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x0F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x78, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0xFE, 0x0F, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F,
  0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xF0, 0xF0, 0x20, 0x3C, 0x3E, 0x1E, 0x0F, 0x0F,
  0x87, 0x03, 0xC3, 0xE3, 0xC0, 0xF0, 0xF9, 0xE0, 0x3C, 0x3C, 0x78, 0x0F,
  0xFF, 0x3C, 0x01, 0xFF, 0xCF, 0x00, 0x3F, 0xE7, 0x80, 0x07, 0xE1, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x79, 0xFF, 0x00,
  0x3C, 0xFF, 0xE0, 0x0F, 0x3F, 0xF8, 0x07, 0x9F, 0x1F, 0x01, 0xE7, 0x87,
  0xC0, 0xF1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x0E, 0x1E, 0x0F, 0x00, 0x87,
  0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x7C, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0x03, 0xE3, 0xFF, 0xC1, 0xF9, 0xFF, 0xF8, 0x7E, 0x7E, 0x7F, 0x1F, 0xBF,
  0x8F, 0xE7, 0xCF, 0xC1, 0xFF, 0xF3, 0xF0, 0x7F, 0xFC, 0xFC, 0x0F, 0xFE,
  0x3F, 0x01, 0xFF, 0x8F, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x02, 0x60, 0x03, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0x00, 0x30, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x08, 0x0F, 0x01, 0x1C, 0x1E, 0x06, 0x7E,
  0x3C, 0x7E, 0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xE7,
  0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xE0, 0x3C, 0x00, 0x80, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3E, 0x7E, 0x7C, 0x7C, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x1F, 0x9F, 0xEF, 0xFF, 0xFB,
  0xFD, 0xFE, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x1F, 0xC3, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0xFD, 0xFF, 0xEF, 0xCF, 0xFF,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFE,
  0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F, 0xC1, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0x80, 0xFE, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xF0, 0x03,
  0xF3, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0x1F,
  0xF0, 0x70, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFB, 0xF0,
  0x07, 0xEF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x07, 0xE7, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xC7, 0xFD, 0xFE, 0x03,
  0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFE, 0x0F, 0xE7,
  0xF0, 0x1F, 0x9F, 0xC0, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xF0,
  0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0x7F, 0x1F, 0xC1, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0xE0, 0xFE, 0x7F, 0x01, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0xFF,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E,
  0xFE, 0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7F, 0x03,
  0xFC, 0xFF, 0xBF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFE, 0xFC,
  0x1F, 0xF7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x1E, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8,
  0x7C, 0x7C, 0x3E, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0xFC, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x78, 0x08, 0x1C,
  0x78, 0x3F, 0x8F, 0x3C, 0x7F, 0xE7, 0xBC, 0x3F, 0xF1, 0xDE, 0x3E, 0x78,
  0xEE, 0x1E, 0x3C, 0x7F, 0x1E, 0x1E, 0x3F, 0x8F, 0x0F, 0x1F, 0xC7, 0x87,
  0x8F, 0xE3, 0x83, 0x87, 0xF3, 0xC1, 0xC3, 0xF9, 0xE0, 0xE1, 0xFC, 0xF0,
  0x71, 0xFE, 0x78, 0x38, 0xEF, 0x1E, 0x3C, 0x77, 0x8F, 0xBE, 0x7B, 0xC7,
  0xFF, 0xF8, 0xF1, 0xFF, 0xF8, 0x78, 0x78, 0xF8, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xE0, 0x08, 0x01, 0xFC, 0x3C, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0x83, 0xFF, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF,
  0x80, 0x7F, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xC1, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0x8F, 0xFE, 0x3F, 0x03, 0xFC, 0x7E, 0x01, 0xFC, 0xFC,
  0x03, 0xF9, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xF9,
  0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC7, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0xBF, 0x80, 0x3F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF3, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0x7E,
  0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF8, 0x1F, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xBF, 0x00, 0x3F, 0x9F, 0x80,
  0x3F, 0x8F, 0xC0, 0x3F, 0xC7, 0xE0, 0x3F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8,
  0x1F, 0xC0, 0xFC, 0x1F, 0xE0, 0x7E, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x8F, 0xE0, 0x0F, 0xCF, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xF7, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFB, 0xF8, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xFC, 0x3F, 0x00,
  0xFE, 0x1F, 0x80, 0x7F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xF3, 0xF0,
  0x03, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0x7F, 0xEF, 0x3D, 0xFF, 0xBD, 0xF7, 0xFE, 0xFF,
  0xDF, 0xFB, 0xFE, 0x7F, 0xE7, 0xF9, 0xFF, 0x9F, 0xE7, 0xFF, 0x7F, 0x3F,
  0xFC, 0xFC, 0xFF, 0xF3, 0xF3, 0xFF, 0xCF, 0x8F, 0xFF, 0x3E, 0x3F, 0xFC,
  0x78, 0xFF, 0xF1, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xF7,
  0xC7, 0xFF, 0xDF, 0x1F, 0xFF, 0x3E, 0x7F, 0xFC, 0xF9, 0xFF, 0xF1, 0xF7,
  0xFF, 0xC7, 0xDF, 0xFF, 0x1F, 0x7F, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC,
  0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE,
  0x7F, 0x01, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F,
  0xC1, 0xFF, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xFE, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0x7E,
  0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x7F, 0x83,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFC, 0x1F, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x80,
  0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x9F, 0xC1, 0xFE, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0,
  0x3F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF8,
  0x3E, 0x0F, 0xFF, 0x0F, 0x83, 0xFF, 0xC3, 0xE0, 0xFF, 0xF0, 0xF8, 0x3F,
  0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xEF, 0xC3, 0xF0, 0xF9, 0xF1, 0xFC,
  0x7E, 0x7C, 0x7F, 0x1F, 0x9F, 0x1F, 0xC7, 0xE7, 0xE7, 0xF9, 0xF9, 0xF9,
  0xFE, 0x7E, 0x7E, 0x7F, 0x9F, 0x1F, 0x9F, 0xE7, 0xC3, 0xEF, 0xF9, 0xF0,
  0xFB, 0xDE, 0xFC, 0x3E, 0xF7, 0xBF, 0x0F, 0xBD, 0xFF, 0xC3, 0xFF, 0x3F,
  0xF0, 0xFF, 0xCF, 0xF8, 0x3F, 0xF3, 0xFE, 0x0F, 0xFC, 0xFF, 0x81, 0xFE,
  0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFE, 0x07, 0xF8, 0x7F, 0x81,
  0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F,
  0xC3, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F,
  0x3F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xBF, 0x80,
  0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x01, 0xFE,
  0xFF, 0xBF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0x7E, 0x0F,
  0xF1, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE3, 0xC0, 0x3F, 0xBF, 0xE0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xF3, 0xFE, 0xFF, 0x03,
  0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFB, 0xFC, 0x0F,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0x0F,
  0xC7, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xC7, 0xF9, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x78, 0x7E, 0x1F, 0xF3, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xBF, 0x81, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xEF, 0xC1, 0xFE, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0x3F, 0xE7, 0xF0, 0x1F,
  0xBF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0x1F, 0xE0, 0x3C,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xF3, 0xF1, 0xFF, 0xEF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD,
  0xFF, 0x3F, 0xF7, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x84, 0x00, 0xFE, 0x1C, 0x03, 0xF8, 0xFC, 0x7F, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x3F, 0x1F, 0xF0, 0xFC, 0xFF, 0xE3, 0xF7,
  0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xE3, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0xA1, 0xFF, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x02, 0xFC, 0x03, 0xFC,
  0xFC, 0x07, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0xFF, 0x00, 0xFD, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0x80, 0xFF, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x70, 0xF9, 0xF9, 0xFC, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0xFE, 0x7F, 0xF8,
  0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8,
  0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8,
  0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8,
  0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8,
  0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0x00, 0x0F, 0x03, 0xF1,
  0xFF, 0x0F, 0xCF, 0xFF, 0x3F, 0x7F, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0x3F,
  0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xE0,
  0x7F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF1,
  0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x03, 0xF3, 0xFE, 0x0F, 0xDF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0xEF, 0xE0, 0x3F,
  0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFE,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFE,
  0xFF, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xE7, 0xC7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xC7, 0xFD, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xBF, 0x07, 0xF9, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xDF,
  0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFC,
  0x0F, 0xE7, 0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x7F, 0x7F, 0x03, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0xDF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFB, 0xF1, 0xFF, 0xCF, 0xC1, 0xFE, 0x3F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F,
  0xC7, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03,
  0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x3E, 0x0F, 0xFF, 0x0F, 0x83, 0xEF, 0xC3, 0xE1, 0xFB, 0xF0, 0xF8, 0x7E,
  0xFC, 0x3F, 0x1F, 0x9F, 0x1F, 0xC7, 0xE7, 0xC7, 0xF1, 0xF1, 0xF1, 0xFC,
  0x7C, 0x7C, 0x7F, 0x1F, 0x1F, 0x9D, 0xC7, 0xC3, 0xE7, 0x7B, 0xF0, 0xFB,
  0xDE, 0xF8, 0x3E, 0xF7, 0xBE, 0x0F, 0xBC, 0xEF, 0x83, 0xEE, 0x3B, 0xE0,
  0xFB, 0x8F, 0xF8, 0x1F, 0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x1F,
  0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xE0, 0xFF, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x0F,
  0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0x80,
  0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xF3,
  0xF8, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC,
  0x07, 0xF1, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xEF,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1C, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x00, 0xF8, 0x01,
  0xF8, 0x07, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0xFF,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFC, 0x03, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xE1, 0xF7, 0xFF,
  0xFF, 0xFB, 0xE0, 0xFF, 0xFD, 0xE0, 0x3F, 0xFC, 0xF0, 0x0F, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x18, 0x00,
};

const GFXglyph RobotoMono_Bold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 7, 33, 28, 10, -33 },
  { 30, 14, 12, 28, 6, -35 },
  { 51, 25, 33, 28, 1, -33 },
  { 155, 23, 43, 28, 3, -38 },
  { 279, 26, 33, 28, 1, -33 },
  { 387, 26, 33, 28, 2, -33 },
  { 495, 5, 13, 28, 10, -35 },
  { 504, 12, 46, 28, 8, -36 },
  { 573, 13, 46, 28, 7, -36 },
  { 648, 23, 23, 28, 3, -33 },
  { 715, 23, 24, 28, 2, -27 },
  { 784, 8, 14, 28, 8, -5 },
  { 798, 19, 5, 28, 6, -17 },
  { 810, 9, 8, 28, 9, -8 },
  { 819, 18, 36, 28, 5, -33 },
  { 900, 21, 33, 28, 3, -33 },
  { 987, 14, 33, 28, 4, -33 },
  { 1045, 23, 33, 28, 2, -33 },
  { 1140, 23, 33, 28, 2, -33 },
  { 1235, 24, 33, 28, 1, -33 },
  { 1334, 22, 33, 28, 3, -33 },
  { 1425, 23, 33, 28, 2, -33 },
  { 1520, 23, 33, 28, 2, -33 },
  { 1615, 22, 33, 28, 2, -33 },
  { 1706, 22, 33, 28, 2, -33 },
  { 1797, 8, 27, 28, 10, -27 },
  { 1824, 9, 36, 28, 10, -27 },
  { 1865, 20, 22, 28, 3, -25 },
  { 1920, 21, 15, 28, 4, -21 },
  { 1960, 20, 22, 28, 4, -25 },
  { 2015, 21, 33, 28, 4, -33 },
  { 2102, 25, 32, 28, 1, -32 },
  { 2202, 27, 33, 28, 1, -33 },
  { 2314, 23, 33, 28, 3, -33 },
  { 2409, 24, 33, 28, 2, -33 },
  { 2508, 23, 33, 28, 3, -33 },
  { 2603, 22, 33, 28, 3, -33 },
  { 2694, 22, 33, 28, 3, -33 },
  { 2785, 23, 33, 28, 2, -33 },
  { 2880, 22, 33, 28, 3, -33 },
  { 2971, 19, 33, 28, 4, -33 },
  { 3050, 23, 33, 28, 2, -33 },
  { 3145, 25, 33, 28, 3, -33 },
  { 3249, 22, 33, 28, 3, -33 },
  { 3340, 22, 33, 28, 3, -33 },
  { 3431, 22, 33, 28, 3, -33 },
  { 3522, 24, 33, 28, 2, -33 },
  { 3621, 23, 33, 28, 3, -33 },
  { 3716, 25, 39, 28, 2, -33 },
  { 3838, 24, 33, 28, 3, -33 },
  { 3937, 24, 33, 28, 2, -33 },
  { 4036, 26, 33, 28, 1, -33 },
  { 4144, 22, 33, 28, 3, -33 },
  { 4235, 26, 33, 28, 1, -33 },
  { 4343, 26, 33, 28, 1, -33 },
  { 4451, 26, 33, 28, 1, -33 },
  { 4559, 27, 33, 28, 1, -33 },
  { 4671, 24, 33, 28, 2, -33 },
  { 4770, 10, 46, 28, 9, -38 },
  { 4828, 18, 36, 28, 5, -33 },
  { 4909, 10, 46, 28, 9, -38 },
  { 4967, 19, 18, 28, 5, -33 },
  { 5010, 21, 5, 28, 3, 0 },
  { 5024, 11, 6, 28, 9, -33 },
  { 5033, 22, 25, 28, 3, -25 },
  { 5102, 22, 35, 28, 3, -35 },
  { 5199, 21, 25, 28, 3, -25 },
  { 5265, 21, 35, 28, 3, -35 },
  { 5357, 22, 25, 28, 3, -25 },
  { 5426, 23, 36, 28, 3, -36 },
  { 5530, 22, 35, 28, 3, -25 },
  { 5627, 22, 35, 28, 3, -35 },
  { 5724, 20, 34, 28, 5, -34 },
  { 5809, 15, 44, 28, 5, -34 },
  { 5892, 24, 35, 28, 3, -35 },
  { 5997, 21, 35, 28, 4, -35 },
  { 6089, 24, 25, 28, 2, -25 },
  { 6164, 22, 25, 28, 3, -25 },
  { 6233, 23, 25, 28, 2, -25 },
  { 6305, 22, 34, 28, 3, -25 },
  { 6399, 21, 34, 28, 3, -25 },
  { 6489, 19, 25, 28, 6, -25 },
  { 6549, 22, 25, 28, 3, -25 },
  { 6618, 22, 30, 28, 3, -30 },
  { 6701, 22, 24, 28, 3, -24 },
  { 6767, 24, 24, 28, 2, -24 },
  { 6839, 26, 24, 28, 1, -24 },
  { 6917, 25, 24, 28, 2, -24 },
  { 6992, 27, 34, 28, 1, -24 },
  { 7107, 23, 24, 28, 3, -24 },
  { 7176, 15, 44, 28, 7, -36 },
  { 7259, 4, 42, 28, 12, -33 },
  { 7280, 15, 44, 28, 7, -36 },
  { 7363, 25, 11, 28, 1, -19 },
};

const GFXfont RobotoMono_Bold46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold46pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_BOLD46PT7B_H_
