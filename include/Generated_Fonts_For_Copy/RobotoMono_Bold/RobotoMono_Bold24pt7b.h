#ifndef _ROBOTOMONO_BOLD24PT7B_H_
#define _ROBOTOMONO_BOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold24pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0x7F, 0x70, 0xE7, 0xE7,
  0xE6, 0xE6, 0xC6, 0xC6, 0x06, 0x30, 0x18, 0xC0, 0x66, 0x01, 0x98, 0x06,
  0x61, 0xFF, 0xF7, 0xFF, 0xC3, 0x38, 0x0C, 0xC0, 0x33, 0x0F, 0xFF, 0xBF,
  0xFE, 0x18, 0xC0, 0x66, 0x01, 0x98, 0x06, 0x60, 0x31, 0x80, 0x03, 0x00,
  0x30, 0x03, 0x01, 0xFC, 0x3F, 0xE3, 0xCF, 0x78, 0x77, 0x07, 0x78, 0x03,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x7F, 0x07, 0x70, 0x77,
  0xDF, 0x3F, 0xE1, 0xFC, 0x03, 0x00, 0x30, 0x03, 0x00, 0x7C, 0x01, 0xF8,
  0x0E, 0x66, 0x39, 0x98, 0xE6, 0xC1, 0xFB, 0x03, 0xD8, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x6F, 0x81, 0xBF, 0x0D, 0xCC, 0x77, 0x30, 0x9C, 0xC0,
  0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xFC, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x1D,
  0xC0, 0xFE, 0x03, 0xC0, 0x3E, 0x03, 0xF9, 0xFD, 0xCF, 0xC7, 0x7E, 0x3F,
  0x70, 0xFB, 0xCF, 0xCF, 0xFE, 0x3F, 0x78, 0xFF, 0xFF, 0xC0, 0x04, 0x1C,
  0x71, 0xC3, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x82, 0x83, 0x0E, 0x1C, 0x38, 0xE1,
  0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x8E, 0x71, 0xCE,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x62, 0xF6, 0xEF, 0xFF, 0x0F, 0x00,
  0xF0, 0x1B, 0x83, 0x98, 0x71, 0xC1, 0x08, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x77, 0x77, 0x77, 0xE4, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x03,
  0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x03, 0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x00, 0x3F, 0x0F, 0xF3, 0xCF,
  0x70, 0xEE, 0x1F, 0xC3, 0xF8, 0xFF, 0x3F, 0xEF, 0xFF, 0x3F, 0xC7, 0xF0,
  0xFE, 0x1F, 0xC3, 0xBE, 0xF3, 0xFC, 0x3F, 0x00, 0x03, 0x1F, 0xFF, 0xFF,
  0xEF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x1F, 0x87, 0xFC, 0x7B, 0xEF, 0x0E, 0xE0, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xFE, 0x79, 0xEF, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0xF0, 0x07, 0xE0, 0x7F, 0x0F,
  0x79, 0xE7, 0xFE, 0x1F, 0x80, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F,
  0xC1, 0xDC, 0x1D, 0xC3, 0x9C, 0x71, 0xC7, 0x1C, 0xE1, 0xCF, 0xFF, 0xFF,
  0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7,
  0x00, 0x70, 0x07, 0x00, 0x7F, 0x87, 0xFE, 0x79, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0xF0, 0xF7, 0x0F, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0x07, 0x81, 0xF8,
  0x3F, 0x83, 0xC0, 0x78, 0x07, 0x00, 0xFF, 0xCF, 0xFE, 0xF9, 0xEF, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x0F, 0x7D, 0xE3, 0xFC, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x00, 0x1F, 0x83, 0xFC, 0x79, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x79, 0xE3,
  0xFC, 0x3F, 0xC7, 0xFE, 0x70, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0x79, 0xE7,
  0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xFC, 0x7B, 0xEF, 0x0E, 0xF0, 0xEE, 0x0E,
  0xE0, 0xFF, 0x0F, 0x79, 0xF7, 0xFE, 0x3F, 0xE0, 0x0E, 0x01, 0xE0, 0x3C,
  0x1F, 0x81, 0xF0, 0x1E, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1D,
  0xFF, 0xB8, 0x73, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x39, 0xCE,
  0x77, 0x10, 0x00, 0x40, 0x70, 0xFC, 0xFE, 0xFE, 0x3C, 0x0F, 0x81, 0xFC,
  0x1F, 0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0x70, 0x7C,
  0xFE, 0xFE, 0x3C, 0x0C, 0x00, 0x3F, 0x8F, 0xFB, 0xEF, 0xF0, 0xF0, 0x0E,
  0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0x83, 0x8C, 0x06,
  0x33, 0xC9, 0x9D, 0x36, 0xEC, 0xDB, 0x33, 0x4C, 0xCF, 0x33, 0x2C, 0xCC,
  0x9B, 0xF6, 0x67, 0x71, 0x80, 0x03, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x03,
  0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3B, 0x80, 0xEE, 0x07,
  0xB8, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x0F, 0xFE, 0x3F, 0xF9, 0xE0, 0xE7,
  0x83, 0xDC, 0x0F, 0xF0, 0x1C, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0xCE, 0x3E, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x1F, 0xC3, 0xFE, 0x79, 0xF7,
  0x07, 0xF0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x77, 0x07, 0x7D, 0xF3, 0xFE, 0x1F, 0x80, 0xFF, 0x0F, 0xFC,
  0xFF, 0xEF, 0x1E, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDF,
  0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDF,
  0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F,
  0xC3, 0xFE, 0x7D, 0xF7, 0x07, 0xF0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x07, 0xF0, 0x77, 0x07, 0x7D, 0xF3, 0xFF, 0x1F,
  0xC0, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x70, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xF0, 0x7F, 0x0F, 0x7F, 0xE7,
  0xFC, 0x1F, 0x80, 0xE0, 0xFF, 0x0F, 0x38, 0x79, 0xC7, 0x8E, 0x78, 0x77,
  0x83, 0xBC, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3D, 0xE1, 0xC7, 0x0E, 0x3C,
  0x70, 0xF3, 0x87, 0x9C, 0x1E, 0xE0, 0x78, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF,
  0x9F, 0xFD, 0xFE, 0xFF, 0xEF, 0x7E, 0xF7, 0xE7, 0x7E, 0x77, 0xE6, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70, 0xF0, 0xFF, 0x0F,
  0xF8, 0xFF, 0x8F, 0xFC, 0xFF, 0xCF, 0xFE, 0xFF, 0xEF, 0xF6, 0xFF, 0x7F,
  0xF3, 0xFF, 0x3F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF0, 0x1F,
  0x83, 0xFC, 0x7D, 0xE7, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x0F, 0x7F, 0xE3, 0xFC, 0x1F,
  0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1E, 0xFF, 0xEF, 0xFC, 0xFE, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0x78, 0xE1, 0xEF, 0x07, 0x70,
  0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xEF, 0x07,
  0x38, 0x79, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x20,
  0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E,
  0xFF, 0xCF, 0xF8, 0xFF, 0x8E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0E,
  0xE0, 0xF0, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x01,
  0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x3C, 0x00, 0xFE, 0x07, 0xF8,
  0x3D, 0xF7, 0xC7, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0xF7, 0x0F, 0x7D, 0xE3, 0xFE,
  0x1F, 0x80, 0xF0, 0x3D, 0xC0, 0xF7, 0x83, 0x9E, 0x1E, 0x38, 0x78, 0xE1,
  0xC3, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x73, 0x80, 0xEE, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0xE3, 0x1D, 0xCE, 0x77,
  0x39, 0xDD, 0xE7, 0x77, 0x9D, 0xDE, 0xE7, 0x7B, 0x9D, 0xEE, 0x77, 0xF8,
  0xDB, 0xE3, 0xEF, 0x8F, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x1C,
  0x1C, 0x70, 0xF8, 0x3D, 0xE0, 0xE3, 0xC7, 0x8F, 0x1C, 0x1E, 0xF0, 0x3B,
  0x80, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0xFE, 0x03, 0xB8, 0x1E,
  0xF0, 0xF1, 0xC3, 0xC7, 0x9E, 0x0E, 0xF8, 0x3C, 0xF0, 0x3D, 0xE0, 0xF3,
  0x83, 0x8F, 0x1E, 0x1C, 0x70, 0x73, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xC0,
  0x1F, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xFF, 0xE0, 0x70, 0x1C,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0,
  0x78, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xFF, 0x0E, 0x03, 0x81,
  0xF0, 0x6C, 0x3B, 0x0C, 0xE3, 0x19, 0xC7, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF1, 0xCE, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0x00, 0xE0, 0xFE,
  0x3F, 0xE7, 0x8E, 0xF0, 0xEF, 0x0E, 0xF1, 0xE7, 0xFE, 0x3E, 0xF0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDE, 0x3F, 0xF7, 0xFE, 0xE1, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0xDE, 0xFF, 0xDD, 0xF0,
  0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0x7F, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x0F, 0x7D, 0xE3, 0xFE, 0x1F, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF1, 0xEF, 0x3F, 0xF7, 0xFF, 0x70, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x70, 0xF7, 0xFF, 0x3F, 0xF1, 0xF7, 0x0F,
  0x83, 0xFC, 0x3F, 0xE7, 0x8F, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x02, 0x7C, 0xF3, 0xFE, 0x0F, 0xC0, 0x00, 0x48, 0x1F, 0x81, 0xFC,
  0x1E, 0x00, 0xE0, 0x07, 0x03, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x73, 0xFF, 0x7F, 0xF7, 0x8F, 0x70, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x77, 0x0F, 0x7D, 0xF3, 0xFF, 0x1F, 0x70, 0x0F, 0x20,
  0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xCF, 0x3F, 0xF7, 0xFF, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0x08, 0x07, 0x81, 0xE0, 0x30, 0x00,
  0x3F, 0x0F, 0xC3, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x1C, 0x38, 0x20, 0x0F, 0xDF, 0xBF,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF,
  0xBE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x1E, 0xE3,
  0xCE, 0x78, 0xE7, 0x0E, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0x78, 0xE3,
  0x8E, 0x3C, 0xE1, 0xEE, 0x0F, 0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0xEE, 0xEF, 0xFF, 0xFF, 0xFE, 0x77,
  0xE7, 0x7E, 0x77, 0xE7, 0x7E, 0x77, 0xE7, 0x7E, 0x77, 0xE7, 0x7E, 0x77,
  0xE7, 0x70, 0xE7, 0x9F, 0xFB, 0xFF, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x77, 0x0F, 0x7D,
  0xE3, 0xFE, 0x1F, 0x80, 0xEF, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x1F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xCF, 0x7F, 0xEE, 0xF9, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x73, 0xFF, 0x7F, 0xF7, 0x0F, 0x70,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x7D, 0xF3, 0xFF, 0x1F,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xE3, 0xFB, 0xFF, 0xFF,
  0xF1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x83, 0xFE, 0x7D, 0xF7, 0x07, 0x70, 0x07, 0xE0, 0x3F, 0xC0,
  0xFE, 0x00, 0xFF, 0x07, 0x78, 0xF7, 0xFE, 0x1F, 0xC0, 0x1E, 0x01, 0xE0,
  0x1E, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF3, 0x0F, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xCF,
  0xBF, 0xF3, 0xEE, 0xE0, 0x7F, 0x83, 0x9C, 0x3C, 0xE1, 0xC7, 0x8E, 0x1C,
  0x70, 0xE7, 0x03, 0xB8, 0x1D, 0x80, 0xFC, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x00, 0xE3, 0x1D, 0x8C, 0x77, 0x39, 0x9D, 0xEE, 0x77, 0xB9, 0xDE, 0xE7,
  0x7B, 0x8D, 0xAE, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0x70,
  0xF0, 0x7B, 0xC7, 0x8E, 0x38, 0x7B, 0xC1, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0xC1, 0xEF, 0x0E, 0x38, 0xF1, 0xEF, 0x07, 0x80, 0xE0, 0x3F,
  0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x8F, 0x1C, 0x70, 0xF7, 0x83, 0xB8, 0x1D,
  0xC0, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x0F, 0xC0,
  0x7C, 0x03, 0xC0, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x02, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x73, 0xE7, 0x0F, 0x07,
  0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0xC1, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x1E, 0x0F, 0x1F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70,
  0xF0, 0xE0, 0x18, 0x03, 0xF0, 0xDF, 0xCF, 0xC7, 0xFC, 0x1F, 0x00, 0x30,
};

const GFXglyph RobotoMono_Bold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 8, 6, 14, 3, -18 },
  { 16, 14, 17, 14, 0, -17 },
  { 46, 12, 23, 14, 1, -20 },
  { 81, 14, 17, 14, 0, -17 },
  { 111, 13, 17, 14, 1, -17 },
  { 139, 3, 6, 14, 5, -18 },
  { 142, 7, 24, 14, 4, -19 },
  { 163, 6, 24, 14, 4, -19 },
  { 181, 12, 12, 14, 2, -17 },
  { 199, 12, 12, 14, 1, -14 },
  { 217, 4, 8, 14, 4, -3 },
  { 221, 10, 3, 14, 3, -9 },
  { 225, 4, 4, 14, 5, -4 },
  { 227, 9, 18, 14, 3, -17 },
  { 248, 11, 17, 14, 2, -17 },
  { 272, 8, 17, 14, 2, -17 },
  { 289, 12, 17, 14, 1, -17 },
  { 315, 12, 17, 14, 1, -17 },
  { 341, 12, 17, 14, 1, -17 },
  { 367, 12, 17, 14, 1, -17 },
  { 393, 12, 17, 14, 1, -17 },
  { 419, 12, 17, 14, 1, -17 },
  { 445, 12, 17, 14, 1, -17 },
  { 471, 12, 17, 14, 1, -17 },
  { 497, 5, 14, 14, 5, -14 },
  { 506, 5, 19, 14, 5, -14 },
  { 518, 10, 11, 14, 2, -13 },
  { 532, 11, 8, 14, 2, -11 },
  { 543, 10, 11, 14, 2, -13 },
  { 557, 11, 17, 14, 2, -17 },
  { 581, 14, 17, 14, 0, -17 },
  { 611, 14, 17, 14, 0, -17 },
  { 641, 12, 17, 14, 2, -17 },
  { 667, 12, 17, 14, 1, -17 },
  { 693, 12, 17, 14, 1, -17 },
  { 719, 11, 17, 14, 2, -17 },
  { 743, 11, 17, 14, 2, -17 },
  { 767, 12, 17, 14, 1, -17 },
  { 793, 12, 17, 14, 1, -17 },
  { 819, 10, 17, 14, 2, -17 },
  { 841, 12, 17, 14, 1, -17 },
  { 867, 13, 17, 14, 2, -17 },
  { 895, 11, 17, 14, 2, -17 },
  { 919, 12, 17, 14, 1, -17 },
  { 945, 12, 17, 14, 1, -17 },
  { 971, 12, 17, 14, 1, -17 },
  { 997, 12, 17, 14, 2, -17 },
  { 1023, 13, 20, 14, 1, -17 },
  { 1056, 12, 17, 14, 2, -17 },
  { 1082, 13, 17, 14, 1, -17 },
  { 1110, 14, 17, 14, 0, -17 },
  { 1140, 12, 17, 14, 1, -17 },
  { 1166, 14, 17, 14, 0, -17 },
  { 1196, 14, 17, 14, 0, -17 },
  { 1226, 14, 17, 14, 0, -17 },
  { 1256, 14, 17, 14, 0, -17 },
  { 1286, 13, 17, 14, 1, -17 },
  { 1314, 5, 24, 14, 5, -20 },
  { 1329, 9, 18, 14, 3, -17 },
  { 1350, 5, 24, 14, 5, -20 },
  { 1365, 10, 9, 14, 2, -17 },
  { 1377, 10, 3, 14, 2, 0 },
  { 1381, 5, 3, 14, 5, -17 },
  { 1383, 12, 13, 14, 1, -13 },
  { 1403, 11, 18, 14, 2, -18 },
  { 1428, 12, 13, 14, 1, -13 },
  { 1448, 12, 18, 14, 1, -18 },
  { 1475, 12, 13, 14, 1, -13 },
  { 1495, 13, 19, 14, 1, -19 },
  { 1526, 12, 18, 14, 1, -13 },
  { 1553, 11, 18, 14, 2, -18 },
  { 1578, 10, 18, 14, 3, -18 },
  { 1601, 7, 23, 14, 3, -18 },
  { 1622, 12, 18, 14, 2, -18 },
  { 1649, 11, 18, 14, 2, -18 },
  { 1674, 12, 13, 14, 1, -13 },
  { 1694, 11, 13, 14, 2, -13 },
  { 1712, 12, 13, 14, 1, -13 },
  { 1732, 11, 18, 14, 2, -13 },
  { 1757, 12, 18, 14, 1, -13 },
  { 1784, 10, 13, 14, 3, -13 },
  { 1801, 12, 13, 14, 1, -13 },
  { 1821, 12, 16, 14, 1, -16 },
  { 1845, 11, 13, 14, 2, -13 },
  { 1863, 13, 13, 14, 1, -13 },
  { 1885, 14, 13, 14, 0, -13 },
  { 1908, 13, 13, 14, 1, -13 },
  { 1930, 13, 18, 14, 1, -13 },
  { 1960, 12, 13, 14, 1, -13 },
  { 1980, 7, 23, 14, 4, -19 },
  { 2001, 2, 22, 14, 6, -17 },
  { 2007, 8, 23, 14, 4, -19 },
  { 2030, 13, 6, 14, 0, -10 },
};

const GFXfont RobotoMono_Bold24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold24pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_BOLD24PT7B_H_
