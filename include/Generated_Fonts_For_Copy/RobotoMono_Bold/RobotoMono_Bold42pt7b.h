#ifndef _ROBOTOMONO_BOLD42PT7B_H_
#define _ROBOTOMONO_BOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x38, 0xFB,
  0xFF, 0xF7, 0xEF, 0x80, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xF0, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x3C, 0x3C, 0x00, 0x78,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF9,
  0xFE, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x1F, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x0C, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x70, 0x78, 0x71,
  0xE0, 0xF1, 0xE3, 0x81, 0xFF, 0xCE, 0x01, 0xFF, 0x3C, 0x01, 0xFE, 0x70,
  0x01, 0xE1, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0xC0, 0x03, 0xCF, 0xE0, 0x07, 0x3F, 0xE0,
  0x1C, 0xFF, 0xE0, 0x79, 0xE3, 0xC0, 0xE3, 0xC3, 0x83, 0xC7, 0x87, 0x07,
  0x0F, 0x0E, 0x02, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xF9, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3,
  0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF8, 0x1F, 0x3F, 0xF8, 0x3E, 0xFF, 0xF8, 0x79, 0xFB, 0xF1, 0xF7,
  0xE3, 0xF3, 0xEF, 0x83, 0xF7, 0xDF, 0x07, 0xFF, 0xBE, 0x07, 0xFE, 0x7C,
  0x07, 0xFC, 0xFC, 0x07, 0xF1, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC3, 0xFF, 0xEF, 0xC1, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF7, 0xBD, 0xE0, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xF0, 0x7C, 0x1F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x0C, 0x60, 0x07, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0x70, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0xCF,
  0x8E, 0x1E, 0x7F, 0x73, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x03, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF1, 0xE0, 0x0F,
  0x8F, 0x80, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x1C, 0x07, 0x00, 0x40, 0x30,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0xFE, 0xFE,
  0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF9, 0xFC, 0xFC, 0x1F,
  0x9F, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x3E, 0xFF, 0xEF, 0x9F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xCF, 0xE3, 0xF8,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x08,
  0x03, 0xC0, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE1,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0x9F, 0xE7, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7, 0xF0, 0xFF, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF,
  0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x3E, 0x1F, 0x80,
  0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x87, 0xC0,
  0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x18, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xE0, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xF8,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x1F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0xF9, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xE0, 0xFE, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0x7D, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0xC0, 0x7E, 0x7E, 0x07, 0xF1, 0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0x9F, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFE, 0x7E, 0x03,
  0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0x9F, 0xC7, 0xE0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0x3E,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x3E, 0x3F, 0x9F, 0xEF, 0xF7,
  0xFB, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF9, 0xFF,
  0xF0, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0x9F, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x07,
  0x1E, 0x1F, 0x8E, 0x78, 0x7F, 0x9E, 0xF1, 0xFF, 0x1D, 0xC7, 0x8E, 0x3F,
  0x8E, 0x1C, 0x7F, 0x3C, 0x38, 0xFE, 0x78, 0x71, 0xF8, 0xE0, 0xE3, 0xF1,
  0xC3, 0xC7, 0xE3, 0x87, 0x8F, 0xC7, 0x0F, 0x3B, 0x8E, 0x1C, 0x77, 0x1E,
  0x38, 0xEF, 0x3F, 0xFB, 0x9E, 0x3F, 0xFF, 0x1C, 0x7E, 0xFC, 0x3C, 0x30,
  0x60, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x0C, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x81,
  0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7E, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7C, 0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x81, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xC0, 0x1F,
  0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFD, 0xFF, 0x3F, 0x81, 0xF9,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x03, 0xF9, 0xFC, 0x7F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0x83, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x7E, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xEF, 0x80, 0xFE, 0xF8, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFC,
  0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xEF, 0xC0, 0x3F, 0x7F, 0x01, 0xF9, 0xFE, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xDF,
  0x80, 0x7E, 0x7E, 0x07, 0xF3, 0xFC, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xF8, 0x01, 0xFD, 0xF0, 0x07, 0xF3,
  0xE0, 0x0F, 0xE7, 0xC0, 0x3F, 0x8F, 0x80, 0xFE, 0x1F, 0x01, 0xF8, 0x3E,
  0x07, 0xF0, 0x7C, 0x1F, 0xC0, 0xF8, 0x7F, 0x01, 0xF0, 0xFC, 0x03, 0xE3,
  0xF8, 0x07, 0xCF, 0xE0, 0x0F, 0xBF, 0x80, 0x1F, 0x7F, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xFC,
  0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0x03, 0xF8, 0x3E, 0x07, 0xF0,
  0x7C, 0x07, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xE3, 0xE0, 0x0F, 0xE7,
  0xC0, 0x1F, 0xCF, 0x80, 0x1F, 0xDF, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xFB,
  0xDF, 0xFF, 0xBD, 0xFF, 0xBF, 0xDF, 0xFB, 0xF9, 0xFF, 0xBF, 0x9F, 0xF9,
  0xF9, 0xFF, 0x9F, 0x1F, 0xF9, 0xF1, 0xFF, 0x9F, 0x1F, 0xF8, 0xF1, 0xFF,
  0x8E, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFD, 0xE1, 0xFF, 0xBE, 0x3F, 0xF3, 0xC7,
  0xFE, 0x7C, 0xFF, 0xCF, 0x9F, 0xF8, 0xF3, 0xFF, 0x1F, 0x7F, 0xE1, 0xEF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x01,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0xFC, 0x7E, 0x07, 0xF0,
  0xFE, 0x3F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xE0, 0x7E, 0x1F, 0x80, 0xFE, 0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x01, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x7F, 0x03, 0xF0, 0x7F, 0x1F, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xE0, 0x1F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFC,
  0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8,
  0x03, 0xF3, 0xE0, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83,
  0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xE0,
  0x1F, 0x8F, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xE0, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xCF, 0xF9, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C,
  0x00, 0xFD, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x01, 0xFD, 0xFE, 0x0F,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0xFE, 0x07, 0xE7, 0xF1, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0,
  0x0F, 0x83, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xC7, 0xE0,
  0x07, 0xE7, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xEF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3E,
  0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xFC, 0x7E, 0x3E,
  0x7C, 0xFE, 0x3E, 0x7C, 0xFE, 0x7E, 0x7C, 0xFE, 0x7C, 0x7C, 0xFE, 0x7C,
  0x7C, 0xFE, 0x7C, 0x7C, 0xFE, 0x7C, 0x7C, 0xEF, 0x7C, 0x7F, 0xEF, 0x7C,
  0x3F, 0xEF, 0x7C, 0x3F, 0xEF, 0xF8, 0x3F, 0xEF, 0xF8, 0x3F, 0xE7, 0xF8,
  0x3F, 0xC7, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF8,
  0x1F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0,
  0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0xFE, 0x00, 0x7F,
  0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xF8,
  0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE7, 0xE0,
  0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xE0,
  0x0F, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC7, 0xE0,
  0x07, 0xE7, 0xE0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F,
  0x81, 0xE1, 0xE0, 0xF8, 0x7C, 0x3C, 0x0F, 0x1F, 0x03, 0xE7, 0xC0, 0xFB,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x03, 0xF1, 0xF8,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x9F, 0x83, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xC7, 0xE0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0x80, 0xFD, 0xFE, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xF1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFB,
  0xFF, 0x8F, 0x9F, 0xE0, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF8, 0x7F, 0x7E, 0x03, 0xF7, 0xE0, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x7E, 0x01, 0xF7, 0xF0,
  0x3F, 0x3F, 0x87, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x0C, 0x3F, 0x07, 0xFB, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0x87, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF3, 0xF8, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFD, 0xF0, 0x7F, 0x9F, 0x00, 0x70,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xC3, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x43, 0xF8, 0x03, 0x0F, 0xF0, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xC1,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x7F, 0x9F, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3,
  0xF8, 0x7F, 0x7F, 0x03, 0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xF0, 0x3F, 0x3F, 0x8F, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xDF, 0x07, 0xF9, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x80, 0x3F, 0x1C, 0x07, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC1, 0x80, 0xFC, 0xFF, 0x0F, 0xDF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xF0,
  0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0xFF,
  0xF7, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xF3, 0xFE, 0x1F, 0xC0, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7F, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE,
  0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0x80, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xDF, 0x80, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x87, 0x9F, 0x9F, 0xBF,
  0xFD, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3,
  0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF1,
  0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F,
  0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F,
  0x8F, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xE0, 0x00, 0x18, 0x0F, 0x8F, 0xF0,
  0xF9, 0xFF, 0xCF, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC3, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xE3, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x0F, 0x9F, 0xE0, 0xFB,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xE0, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFF, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFD, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x9F, 0x1F, 0xFD, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xF8, 0x7F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x3F, 0x3F,
  0x8F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFB, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0E,
  0x7C, 0x3F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFE,
  0x05, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xD0, 0x00, 0x7F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x80,
  0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x86,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xF1, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFB, 0xF0, 0xFE, 0x3F, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x1F,
  0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x78, 0x3F,
  0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC7, 0xCF,
  0x1F, 0x8F, 0x9F, 0x3F, 0x9F, 0x3E, 0x7F, 0x3E, 0x7C, 0xFE, 0x7C, 0xF9,
  0xDC, 0xF9, 0xF3, 0xB9, 0xE1, 0xEF, 0x73, 0xC3, 0xDC, 0xFF, 0x87, 0xB9,
  0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C,
  0x00, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x07, 0xE1, 0xFC,
  0x1F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFB, 0xF0, 0x0F, 0xCF, 0xE0,
  0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x7E, 0x01, 0xFB, 0xF0,
  0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07,
  0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x01,
  0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xFE, 0x07, 0xF0, 0x1F,
  0x81, 0xFC, 0x1F, 0xE1, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00,
  0x77, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF,
  0x03, 0xFF, 0xB8, 0x07, 0xFC, 0x00, 0x07, 0xE0,
};

const GFXglyph RobotoMono_Bold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 30, 25, 9, -30 },
  { 28, 12, 11, 25, 6, -32 },
  { 45, 23, 30, 25, 1, -30 },
  { 132, 20, 39, 25, 3, -35 },
  { 230, 23, 30, 25, 1, -30 },
  { 317, 23, 30, 25, 2, -30 },
  { 404, 5, 12, 25, 9, -32 },
  { 412, 11, 42, 25, 7, -33 },
  { 470, 12, 42, 25, 6, -33 },
  { 533, 21, 21, 25, 3, -30 },
  { 589, 21, 22, 25, 2, -25 },
  { 647, 8, 13, 25, 7, -5 },
  { 660, 17, 4, 25, 6, -15 },
  { 669, 8, 7, 25, 9, -7 },
  { 676, 16, 33, 25, 5, -30 },
  { 742, 19, 30, 25, 3, -30 },
  { 814, 13, 30, 25, 4, -30 },
  { 863, 21, 30, 25, 1, -30 },
  { 942, 20, 30, 25, 2, -30 },
  { 1017, 22, 30, 25, 1, -30 },
  { 1100, 20, 30, 25, 2, -30 },
  { 1175, 21, 30, 25, 2, -30 },
  { 1254, 21, 30, 25, 1, -30 },
  { 1333, 20, 30, 25, 2, -30 },
  { 1408, 20, 30, 25, 2, -30 },
  { 1483, 8, 24, 25, 9, -24 },
  { 1507, 9, 32, 25, 9, -24 },
  { 1543, 18, 20, 25, 3, -23 },
  { 1588, 20, 13, 25, 3, -19 },
  { 1621, 19, 20, 25, 3, -23 },
  { 1669, 20, 30, 25, 3, -30 },
  { 1744, 23, 30, 25, 1, -30 },
  { 1831, 24, 30, 25, 1, -30 },
  { 1921, 21, 30, 25, 3, -30 },
  { 2000, 21, 30, 25, 2, -30 },
  { 2079, 20, 30, 25, 3, -30 },
  { 2154, 20, 30, 25, 3, -30 },
  { 2229, 20, 30, 25, 3, -30 },
  { 2304, 21, 30, 25, 2, -30 },
  { 2383, 19, 30, 25, 3, -30 },
  { 2455, 17, 30, 25, 4, -30 },
  { 2519, 21, 30, 25, 2, -30 },
  { 2598, 23, 30, 25, 3, -30 },
  { 2685, 20, 30, 25, 3, -30 },
  { 2760, 20, 30, 25, 3, -30 },
  { 2835, 19, 30, 25, 3, -30 },
  { 2907, 22, 30, 25, 2, -30 },
  { 2990, 21, 30, 25, 3, -30 },
  { 3069, 23, 35, 25, 2, -30 },
  { 3170, 22, 30, 25, 3, -30 },
  { 3253, 22, 30, 25, 2, -30 },
  { 3336, 24, 30, 25, 1, -30 },
  { 3426, 20, 30, 25, 3, -30 },
  { 3501, 24, 30, 25, 1, -30 },
  { 3591, 24, 30, 25, 1, -30 },
  { 3681, 24, 30, 25, 1, -30 },
  { 3771, 24, 30, 25, 1, -30 },
  { 3861, 22, 30, 25, 2, -30 },
  { 3944, 9, 42, 25, 8, -35 },
  { 3992, 16, 33, 25, 5, -30 },
  { 4058, 9, 42, 25, 8, -35 },
  { 4106, 18, 16, 25, 4, -30 },
  { 4142, 19, 4, 25, 3, 0 },
  { 4152, 10, 5, 25, 8, -30 },
  { 4159, 21, 23, 25, 2, -23 },
  { 4220, 20, 32, 25, 3, -32 },
  { 4300, 20, 23, 25, 2, -23 },
  { 4358, 20, 32, 25, 2, -32 },
  { 4438, 21, 23, 25, 2, -23 },
  { 4499, 21, 32, 25, 3, -32 },
  { 4583, 20, 32, 25, 2, -23 },
  { 4663, 20, 32, 25, 3, -32 },
  { 4743, 19, 31, 25, 4, -31 },
  { 4817, 13, 40, 25, 5, -31 },
  { 4882, 22, 32, 25, 3, -32 },
  { 4970, 19, 32, 25, 4, -32 },
  { 5046, 21, 23, 25, 2, -23 },
  { 5107, 20, 23, 25, 3, -23 },
  { 5165, 21, 23, 25, 2, -23 },
  { 5226, 20, 32, 25, 3, -23 },
  { 5306, 20, 32, 25, 2, -23 },
  { 5386, 17, 23, 25, 6, -23 },
  { 5435, 21, 23, 25, 2, -23 },
  { 5496, 20, 28, 25, 3, -28 },
  { 5566, 20, 22, 25, 3, -22 },
  { 5621, 23, 22, 25, 1, -22 },
  { 5685, 23, 22, 25, 1, -22 },
  { 5749, 22, 22, 25, 2, -22 },
  { 5810, 24, 31, 25, 1, -22 },
  { 5903, 21, 22, 25, 2, -22 },
  { 5961, 14, 40, 25, 6, -33 },
  { 6031, 4, 38, 25, 11, -30 },
  { 6050, 13, 40, 25, 7, -33 },
  { 6115, 22, 9, 25, 1, -17 },
};

const GFXfont RobotoMono_Bold42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold42pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_BOLD42PT7B_H_
