#ifndef _ROBOTOMONO_BOLD19PT7B_H_
#define _ROBOTOMONO_BOLD19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x60, 0x3F, 0xC0, 0xDC, 0xE7, 0x39, 0x80, 0x0C,
  0x81, 0x90, 0x36, 0x04, 0xC7, 0xFE, 0xFF, 0xC6, 0x40, 0xD8, 0x13, 0x1F,
  0xF8, 0xCC, 0x19, 0x03, 0x20, 0x6C, 0x00, 0x0C, 0x03, 0x00, 0xE0, 0xFC,
  0x73, 0x98, 0x66, 0x1D, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x06, 0xE1, 0xF8,
  0x67, 0xF8, 0xFC, 0x0C, 0x03, 0x00, 0x30, 0x0F, 0x03, 0x32, 0x66, 0xCC,
  0xB0, 0xF4, 0x01, 0x80, 0x20, 0x0D, 0xC1, 0x7C, 0x6D, 0x89, 0xB0, 0x36,
  0x03, 0x80, 0x1C, 0x0F, 0x87, 0x71, 0x9C, 0x66, 0x1F, 0x83, 0xC1, 0xE3,
  0xFC, 0xF3, 0xBC, 0x7F, 0x8E, 0xFF, 0x9F, 0x70, 0xFF, 0xC0, 0x08, 0xCC,
  0x66, 0x31, 0x9C, 0xC6, 0x31, 0xCE, 0x31, 0x8E, 0x30, 0xC2, 0x86, 0x18,
  0x63, 0x1C, 0x63, 0x18, 0xC6, 0x31, 0x9C, 0xC6, 0x67, 0x30, 0x0C, 0x03,
  0x00, 0xC1, 0x32, 0xFF, 0xC7, 0xC1, 0xE0, 0x6C, 0x73, 0x88, 0x40, 0x1C,
  0x0E, 0x07, 0x1F, 0xFF, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x77,
  0x76, 0xE4, 0xFF, 0xFC, 0xEF, 0xE0, 0x07, 0x06, 0x0E, 0x0C, 0x0C, 0x1C,
  0x18, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0x1C, 0x1F, 0x9D,
  0xCC, 0x7E, 0x3F, 0x1F, 0x9F, 0xFF, 0xF3, 0xF1, 0xF8, 0xEC, 0x77, 0xF1,
  0xF0, 0x04, 0x7F, 0xFF, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70,
  0x1C, 0x3F, 0xBD, 0xD8, 0x7C, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E,
  0x0E, 0x0F, 0xFF, 0xFC, 0x1C, 0x3F, 0xBD, 0xFC, 0x70, 0x38, 0x1C, 0x7C,
  0x3E, 0x03, 0x80, 0xF0, 0x7C, 0x77, 0xF1, 0xF0, 0x07, 0x03, 0x83, 0xC3,
  0xE1, 0xF1, 0xB9, 0xDC, 0xCE, 0xC7, 0x7F, 0xFF, 0xE0, 0xE0, 0x70, 0x38,
  0x7F, 0xBF, 0xDF, 0xEC, 0x06, 0x03, 0xF1, 0xFD, 0xC7, 0x03, 0x80, 0xF8,
  0xFC, 0x77, 0xF1, 0xF0, 0x06, 0x0F, 0x0F, 0x8E, 0x06, 0x07, 0x73, 0xFD,
  0xC7, 0xE3, 0xF0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x60, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x83, 0x80,
  0x1C, 0x3F, 0x9D, 0xDC, 0x7E, 0x3B, 0x19, 0xFC, 0xFE, 0xE3, 0xF1, 0xF8,
  0xFC, 0x77, 0xF1, 0xF0, 0x1C, 0x3F, 0x1D, 0xDC, 0x7E, 0x3E, 0x1F, 0x8F,
  0xEF, 0x7F, 0x8D, 0xC0, 0xC1, 0xE3, 0xE1, 0xC0, 0xEF, 0xE0, 0x00, 0x00,
  0xEF, 0xE0, 0x7F, 0x70, 0x00, 0x00, 0x06, 0x66, 0x6C, 0x40, 0x01, 0x87,
  0xCF, 0xDF, 0x0F, 0x03, 0xF0, 0x7E, 0x07, 0x00, 0x80, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x7C, 0x1F, 0x81, 0xF0, 0x78, 0xFB, 0xF1,
  0xC0, 0x80, 0x00, 0x1E, 0x3F, 0x9C, 0xFC, 0x30, 0x18, 0x1C, 0x1C, 0x1C,
  0x0C, 0x06, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x1F, 0x86, 0x18, 0x89, 0x37,
  0xB4, 0x97, 0xB2, 0xF6, 0x5E, 0xDB, 0xDB, 0x49, 0xB9, 0x80, 0x18, 0x81,
  0xF0, 0x06, 0x01, 0xC0, 0x3C, 0x07, 0x81, 0xF0, 0x37, 0x06, 0x61, 0xCC,
  0x39, 0xC7, 0xF9, 0xFF, 0x38, 0x76, 0x0F, 0xC0, 0xC0, 0xF8, 0x3F, 0xCF,
  0xFB, 0x87, 0xE1, 0xF8, 0x6F, 0xFB, 0xFE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xFF, 0xBF, 0xC0, 0x1C, 0x0F, 0xC7, 0x7B, 0x86, 0xE1, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0E, 0x1F, 0x8E, 0x7F, 0x8F, 0x80, 0xF0, 0x3F, 0x8F,
  0xF3, 0x8E, 0xE1, 0xB8, 0x6E, 0x1F, 0x87, 0xE1, 0xF8, 0x6E, 0x3B, 0x9E,
  0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xFF, 0xFF,
  0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x1C, 0x0F, 0xC7, 0x3B, 0x86, 0xE1, 0xF0, 0x0C, 0x03, 0x1F, 0xC7,
  0xF8, 0x7E, 0x1F, 0x87, 0x7F, 0x8F, 0xC0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C, 0xFF,
  0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xFF,
  0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xF8, 0x7C, 0x77, 0xF1, 0xF0, 0xE1, 0xFC, 0x3B, 0x8E, 0x73, 0x8E, 0xE1,
  0xDC, 0x3F, 0x07, 0xF0, 0xFE, 0x1C, 0xE3, 0x9C, 0x71, 0xCE, 0x1D, 0xC3,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0F, 0xFF, 0xFC, 0xE3, 0xF9, 0xFC, 0xFE, 0xFD, 0x7E, 0xFF,
  0xF7, 0xFB, 0xED, 0xF4, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C, 0xE3, 0xF1, 0xFC,
  0xFE, 0x7F, 0x3F, 0xDF, 0xEF, 0xDF, 0xEF, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F,
  0x1C, 0x1C, 0x1F, 0xC7, 0x7B, 0x8E, 0xE1, 0xB0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7E, 0x1B, 0x8E, 0x7F, 0x0F, 0x80, 0xF8, 0x3F, 0xCF, 0xFB, 0x87,
  0xE1, 0xF8, 0x7E, 0x3B, 0xFE, 0xFF, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x1C, 0x0F, 0xC7, 0x7B, 0x8E, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7E, 0x1B, 0x8E, 0x7F, 0x0F, 0xE0, 0x1C, 0x03, 0xF8, 0x3F, 0xCF,
  0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xFC, 0xFE, 0x39, 0xCE, 0x33, 0x8E,
  0xE1, 0xB8, 0x70, 0x1E, 0x1F, 0xC7, 0x3B, 0x87, 0xE0, 0x1C, 0x07, 0xE0,
  0x7C, 0x07, 0x80, 0x7C, 0x1F, 0x87, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0xE0, 0xEC, 0x1D,
  0xC3, 0x38, 0xE7, 0x1C, 0x63, 0x8E, 0x61, 0xDC, 0x1B, 0x83, 0xE0, 0x7C,
  0x07, 0x80, 0xE0, 0x1C, 0x00, 0xE6, 0x7C, 0xCD, 0xB9, 0xB7, 0x76, 0xEE,
  0xDD, 0xDB, 0xF3, 0x5E, 0x7B, 0xCF, 0x78, 0xEF, 0x1C, 0xE3, 0x9C, 0x73,
  0x00, 0xE0, 0xEE, 0x1C, 0xC7, 0x1C, 0xE1, 0xB8, 0x3E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xF0, 0xE6, 0x1C, 0xE7, 0x0D, 0xE1, 0xC0, 0xE0, 0xEE, 0x1D,
  0xC3, 0x18, 0xE3, 0x98, 0x37, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE0, 0x60, 0x60,
  0x70, 0x30, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x07,
  0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x7F, 0xF0, 0x18, 0x18,
  0x3C, 0x3C, 0x6C, 0x66, 0xC6, 0xC3, 0xFF, 0xFF, 0xC0, 0xE6, 0x30, 0x3E,
  0x3F, 0xB8, 0xE0, 0x73, 0xFB, 0x9F, 0x8F, 0xC7, 0xFF, 0xBF, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0F, 0xF7, 0xFF, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x7F, 0xFF, 0xF8, 0x3E, 0x3F, 0x98, 0xFC, 0x3E, 0x07, 0x03, 0x80, 0xC7,
  0x7F, 0x1F, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x73, 0xFB, 0xFF, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x77, 0xF9, 0xEC, 0x3F, 0x3F, 0xD8, 0xFC, 0x3F,
  0xFF, 0xFF, 0x80, 0xE2, 0x7F, 0x9F, 0x80, 0x03, 0x83, 0xF1, 0xE4, 0x70,
  0x18, 0x3F, 0xEF, 0xF8, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x3D, 0xBF, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0x7F,
  0x9E, 0xC0, 0xEC, 0x77, 0xF1, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xF7,
  0xFF, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C, 0x18, 0x1C,
  0x18, 0x00, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x0C, 0x70, 0xC0, 0x7D, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0xFB, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xF9, 0xCE, 0xE3, 0xF0,
  0xFC, 0x3F, 0x8E, 0x73, 0x9C, 0xE3, 0xB8, 0x70, 0xF8, 0xF8, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFB, 0xBF,
  0xED, 0xDF, 0x37, 0xCD, 0xF3, 0x7C, 0xDF, 0x37, 0xCD, 0xF3, 0x70, 0xEF,
  0x7F, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xC0, 0x3E,
  0x3F, 0xB8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0x7F, 0x1F, 0x00, 0xFF,
  0x7F, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xFF, 0x7F, 0xB8, 0x1C,
  0x0E, 0x07, 0x00, 0x3D, 0xBF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0x7F, 0x9F, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0xDF, 0xFF, 0xCE, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x80, 0x3F, 0x3F, 0xF8, 0x6C, 0x07, 0xE0, 0xFC, 0x0F,
  0xC3, 0x7F, 0x9F, 0x80, 0x38, 0x1C, 0x0E, 0x1F, 0xFF, 0xF9, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x06, 0x03, 0xF0, 0xF8, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x86, 0xC7, 0x7F, 0x9E, 0xC0, 0xE1, 0xF8, 0x66, 0x39, 0x8C,
  0x73, 0x0D, 0xC3, 0x60, 0x78, 0x1C, 0x07, 0x00, 0xE6, 0x6D, 0xDD, 0xBB,
  0xB7, 0x66, 0xAC, 0xD5, 0x9A, 0xF1, 0xDE, 0x39, 0x86, 0x30, 0xE1, 0xDC,
  0xE3, 0x70, 0xF8, 0x1E, 0x07, 0x83, 0xF0, 0xDC, 0x73, 0xB8, 0x70, 0xF0,
  0xEE, 0x1C, 0xC3, 0x1C, 0xE3, 0x98, 0x37, 0x07, 0xE0, 0x78, 0x0F, 0x00,
  0xC0, 0x38, 0x06, 0x03, 0xC0, 0x70, 0x00, 0xFF, 0xBF, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xF0, 0x0C, 0x71, 0x8E, 0x38,
  0xE3, 0x8C, 0xF3, 0x87, 0x0C, 0x38, 0xE3, 0x8E, 0x18, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC3, 0x87, 0x0C, 0x30, 0xC3, 0x0C, 0x1C, 0x73, 0x8C,
  0x30, 0xC3, 0x1C, 0x63, 0x80, 0x30, 0x0F, 0x8F, 0xFF, 0x63, 0xE0, 0x10,
};

const GFXglyph RobotoMono_Bold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 5, 5, 11, 3, -14 },
  { 11, 11, 14, 11, 0, -14 },
  { 31, 10, 18, 11, 1, -16 },
  { 54, 11, 14, 11, 0, -14 },
  { 74, 10, 14, 11, 1, -14 },
  { 92, 2, 5, 11, 4, -14 },
  { 94, 5, 19, 11, 3, -15 },
  { 106, 5, 19, 11, 3, -15 },
  { 118, 10, 10, 11, 1, -14 },
  { 131, 9, 10, 11, 1, -11 },
  { 143, 4, 6, 11, 3, -2 },
  { 146, 7, 2, 11, 3, -7 },
  { 148, 4, 3, 11, 4, -3 },
  { 150, 8, 15, 11, 2, -14 },
  { 165, 9, 14, 11, 1, -14 },
  { 181, 6, 14, 11, 2, -14 },
  { 192, 9, 14, 11, 1, -14 },
  { 208, 9, 14, 11, 1, -14 },
  { 224, 9, 14, 11, 1, -14 },
  { 240, 9, 14, 11, 1, -14 },
  { 256, 9, 14, 11, 1, -14 },
  { 272, 9, 14, 11, 1, -14 },
  { 288, 9, 14, 11, 1, -14 },
  { 304, 9, 14, 11, 1, -14 },
  { 320, 4, 11, 11, 4, -11 },
  { 326, 4, 15, 11, 4, -11 },
  { 334, 9, 9, 11, 1, -10 },
  { 345, 9, 6, 11, 1, -9 },
  { 352, 9, 9, 11, 1, -10 },
  { 363, 9, 14, 11, 1, -14 },
  { 379, 11, 13, 11, 0, -13 },
  { 397, 11, 14, 11, 0, -14 },
  { 417, 10, 14, 11, 1, -14 },
  { 435, 10, 14, 11, 1, -14 },
  { 453, 10, 14, 11, 1, -14 },
  { 471, 9, 14, 11, 1, -14 },
  { 487, 10, 14, 11, 1, -14 },
  { 505, 10, 14, 11, 1, -14 },
  { 523, 9, 14, 11, 1, -14 },
  { 539, 8, 14, 11, 2, -14 },
  { 553, 9, 14, 11, 1, -14 },
  { 569, 11, 14, 11, 1, -14 },
  { 589, 9, 14, 11, 1, -14 },
  { 605, 9, 14, 11, 1, -14 },
  { 621, 9, 14, 11, 1, -14 },
  { 637, 10, 14, 11, 1, -14 },
  { 655, 10, 14, 11, 1, -14 },
  { 673, 10, 16, 11, 1, -14 },
  { 693, 10, 14, 11, 1, -14 },
  { 711, 10, 14, 11, 1, -14 },
  { 729, 11, 14, 11, 0, -14 },
  { 749, 9, 14, 11, 1, -14 },
  { 765, 11, 14, 11, 0, -14 },
  { 785, 11, 14, 11, 0, -14 },
  { 805, 11, 14, 11, 0, -14 },
  { 825, 11, 14, 11, 0, -14 },
  { 845, 10, 14, 11, 1, -14 },
  { 863, 4, 19, 11, 4, -16 },
  { 873, 8, 15, 11, 2, -14 },
  { 888, 4, 19, 11, 4, -16 },
  { 898, 8, 8, 11, 2, -14 },
  { 906, 9, 2, 11, 1, 0 },
  { 909, 4, 3, 11, 4, -14 },
  { 911, 9, 10, 11, 1, -10 },
  { 923, 9, 14, 11, 1, -14 },
  { 939, 9, 10, 11, 1, -10 },
  { 951, 9, 14, 11, 1, -14 },
  { 967, 9, 10, 11, 1, -10 },
  { 979, 10, 15, 11, 1, -15 },
  { 998, 9, 14, 11, 1, -10 },
  { 1014, 9, 14, 11, 1, -14 },
  { 1030, 8, 14, 11, 2, -14 },
  { 1044, 6, 18, 11, 2, -14 },
  { 1058, 10, 14, 11, 1, -14 },
  { 1076, 8, 14, 11, 2, -14 },
  { 1090, 10, 10, 11, 1, -10 },
  { 1103, 9, 10, 11, 1, -10 },
  { 1115, 9, 10, 11, 1, -10 },
  { 1127, 9, 14, 11, 1, -10 },
  { 1143, 9, 14, 11, 1, -10 },
  { 1159, 7, 10, 11, 3, -10 },
  { 1168, 9, 10, 11, 1, -10 },
  { 1180, 9, 13, 11, 1, -13 },
  { 1195, 9, 10, 11, 1, -10 },
  { 1207, 10, 10, 11, 1, -10 },
  { 1220, 11, 10, 11, 0, -10 },
  { 1234, 10, 10, 11, 1, -10 },
  { 1247, 11, 14, 11, 0, -10 },
  { 1267, 10, 10, 11, 1, -10 },
  { 1280, 6, 18, 11, 3, -15 },
  { 1294, 2, 18, 11, 5, -14 },
  { 1299, 6, 18, 11, 3, -15 },
  { 1313, 11, 5, 11, 0, -8 },
};

const GFXfont RobotoMono_Bold19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold19pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_BOLD19PT7B_H_
