#ifndef _ROBOTOMONO_BOLD36PT7B_H_
#define _ROBOTOMONO_BOLD36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0xBF, 0xF9, 0xE0, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x77, 0x0E, 0xE1, 0xC0, 0x01, 0xC3,
  0x80, 0x38, 0xF0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x83, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x00, 0x70, 0xE0,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0x1C, 0x01, 0xE3, 0x80,
  0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x07, 0x8E, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x1F, 0x9F, 0x03, 0xF7, 0xC0,
  0x7D, 0xF0, 0x1F, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x03, 0xF7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x0E, 0x38, 0x40, 0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0xCE, 0x0E, 0x3D,
  0xE0, 0xFF, 0x9C, 0x07, 0xFB, 0x80, 0x3E, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x78, 0x01, 0xDF, 0xE0,
  0x39, 0xFE, 0x07, 0x3C, 0xF0, 0x73, 0x87, 0x0E, 0x38, 0x70, 0xE3, 0x87,
  0x02, 0x38, 0x70, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xF1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xC3, 0xC7, 0xFF, 0x1E, 0x7C, 0xF9, 0xF3, 0xE3, 0xEF, 0xBE, 0x1F, 0xF9,
  0xF0, 0x7F, 0xCF, 0x81, 0xFC, 0x3E, 0x07, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE,
  0x01, 0x80, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x38, 0x02, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x38,
  0x18, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x10, 0x70, 0x2F, 0x1C, 0x3B, 0xF7, 0x7E, 0xFF, 0xFF, 0xC7, 0xFF,
  0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0x70, 0x03, 0xDE, 0x01, 0xE3, 0xC0,
  0xF0, 0x78, 0x3C, 0x1E, 0x02, 0x03, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x3E, 0x79, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9,
  0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFF, 0x8F, 0xFF, 0xDF, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xBC,
  0x07, 0xDE, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xF0, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x20, 0x1C, 0x1F, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xF0, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xFF, 0xEF, 0xC3, 0xF7, 0xC0, 0x7F, 0xE0, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xDF, 0x00,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x07, 0xC3, 0xC0, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xF1, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xE1, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFB, 0xE0, 0xFD, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0xFC, 0x3E, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0xFC, 0xFF,
  0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xF9, 0xE0, 0x3F, 0xF0, 0x1F,
  0x78, 0x0F, 0x3E, 0x0F, 0x9F, 0x8F, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xF8, 0xF8, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE,
  0x07, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xE3, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xF1, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0x1F, 0xEF, 0x03, 0xC7, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0x78, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C,
  0x79, 0xE3, 0xC3, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF1,
  0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xFE, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFE, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0x8F, 0x81, 0xE0, 0x1C, 0x3C, 0x01, 0xC3, 0x87,
  0x8E, 0x71, 0xFE, 0xE7, 0x3F, 0xE6, 0xE3, 0x8E, 0x6E, 0x38, 0xC7, 0xE7,
  0x0C, 0x7E, 0x70, 0xC7, 0xE7, 0x1C, 0x6E, 0x71, 0xC6, 0xE7, 0x1C, 0xEE,
  0x71, 0xCE, 0xE7, 0x9C, 0xCE, 0x7F, 0xFC, 0xE3, 0xEF, 0x87, 0x08, 0x60,
  0x78, 0x00, 0x03, 0xC0, 0x40, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xC7,
  0x80, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xF0, 0x03,
  0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x87,
  0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xF0, 0xFC, 0x7C, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x0F,
  0xBE, 0x01, 0xF7, 0xC0, 0x7E, 0x7C, 0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0xF8, 0xFF, 0x3E, 0x0F, 0xCF, 0x81, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x1F, 0xBE, 0x0F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x81, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0xFD, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00,
  0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F,
  0x8F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x9F,
  0x80, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x7C, 0x0F, 0xC7, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7E,
  0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0xBF, 0x7F, 0xEF, 0xDF, 0xFB, 0xF7, 0xFE, 0xF9, 0xFF, 0x9E, 0x7F, 0xE7,
  0x9F, 0xF9, 0xC7, 0xFE, 0x31, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFE, 0xF3, 0xFF,
  0x79, 0xFF, 0xBC, 0xFF, 0xCF, 0x7F, 0xE7, 0xBF, 0xF1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF1, 0xFC, 0xFC, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0x7C, 0x1F,
  0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x7F, 0x3E, 0x07, 0xEF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x7E, 0xF8, 0x7F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xC0,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x1F, 0xC3, 0xE0, 0x7C,
  0x7C, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3E, 0xFC, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E,
  0x07, 0xC3, 0xE0, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0x83, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7E, 0x0F, 0xDF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0xFD,
  0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E,
  0x7E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0xF9,
  0xE0, 0x0F, 0xBE, 0x00, 0x7B, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0xF8, 0x78, 0x7B, 0xC3, 0xC3, 0xDE, 0x1E, 0x3E, 0xF0, 0xF1,
  0xF7, 0x8F, 0x8F, 0xBE, 0x7C, 0x7D, 0xF3, 0xE3, 0xCF, 0x9F, 0x9E, 0x3C,
  0xFC, 0xF1, 0xE7, 0xE7, 0x8F, 0x3F, 0x7C, 0x7B, 0xFB, 0xE3, 0xDF, 0xDF,
  0x1F, 0xEE, 0xF0, 0xFF, 0x7F, 0x83, 0xFB, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x00, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0xFC,
  0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xE7,
  0xC0, 0x3F, 0x3F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xE0, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xE0,
  0xFC, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0xF8, 0x03, 0xE7,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x7F, 0x81, 0xEE, 0x0F, 0x3C, 0x3C, 0xF0, 0xE1, 0xE7, 0x87,
  0x9E, 0x0E, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x0F, 0xF8, 0x1F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xC7, 0xE7, 0xC1, 0xF7, 0xC0, 0x7C, 0x00, 0x3E, 0x01,
  0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xDF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xFD, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xF3,
  0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF3, 0xF8, 0x7B, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xC0, 0x7D, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0xC0, 0xFB,
  0xE0, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7B, 0xFE, 0x3C, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE7, 0xC1, 0xFB, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0xEF, 0x8F,
  0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x7D, 0xF0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xF9, 0xE0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E,
  0x0F, 0x9F, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x87, 0xE0, 0x30,
  0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0x80,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x41, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xE7, 0x8F, 0xFB, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7D, 0xF8, 0x3E, 0xFF, 0xFF, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFB, 0xE0, 0x01, 0xF1, 0x00, 0xF8, 0x80, 0xFC, 0xF9,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0xFC, 0x3E, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC,
  0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFD,
  0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3F, 0x1F, 0xFF, 0xF7, 0xFC, 0xFF, 0x0F, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x1F, 0xBC, 0x0F, 0xCF, 0x07, 0xE3, 0xC3, 0xF0,
  0xF1, 0xF8, 0x3C, 0xFC, 0x0F, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0xF8, 0xF8, 0x3C, 0x3F, 0x0F, 0x07,
  0xE3, 0xC0, 0xF8, 0xF0, 0x3F, 0x3C, 0x07, 0xEF, 0x00, 0xFC, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFB, 0xEF, 0xDF, 0xFD,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C,
  0x7F, 0xC7, 0x8F, 0xF8, 0xF1, 0xFF, 0x1E, 0x3F, 0xE3, 0xC7, 0xFC, 0x78,
  0xFF, 0x8F, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C, 0x7F, 0xC7, 0x8F, 0xF8, 0xF1,
  0xFF, 0x1E, 0x3F, 0xE3, 0xC7, 0x80, 0xF8, 0xFE, 0x7D, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xE0, 0x07,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x7C, 0x1F, 0xBF, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xBF, 0x03, 0xE7, 0xC1, 0xF9, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xF3, 0xF8, 0x7B, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0x83, 0xF7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x01, 0xF7, 0x80, 0xFB,
  0xE0, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7B, 0xFE, 0x3C, 0xFE, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xE7, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xC1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7D, 0xF0, 0x7E, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFB, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0xFF,
  0xF7, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xC0, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0x7E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x79, 0xF8, 0x7E, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFF, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0x8F, 0xFC, 0x03,
  0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x07, 0x83, 0xE0, 0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3E, 0x78,
  0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x70, 0xFB, 0xC3,
  0xC7, 0xDE, 0x1E, 0x3C, 0xF1, 0xF1, 0xE7, 0xCF, 0x8F, 0x3E, 0x7C, 0x78,
  0xF3, 0xE7, 0xC7, 0x9B, 0xBC, 0x3D, 0xDD, 0xE1, 0xEE, 0xEF, 0x0F, 0x77,
  0x78, 0x3B, 0x9B, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x87, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0xF8, 0x07,
  0xEF, 0x81, 0xF8, 0xF8, 0x3E, 0x1F, 0x8F, 0x81, 0xF3, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x7C, 0x07, 0xCF, 0xC1, 0xF0, 0xF8,
  0x7E, 0x0F, 0x8F, 0x80, 0xFB, 0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xFB, 0xE0,
  0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x01, 0xE7,
  0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0x3C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x0F, 0xF0, 0xFC, 0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0xF8,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0x1F, 0x80, 0x43,
  0xFE, 0x07, 0x7F, 0xF0, 0xF7, 0xFF, 0xFF, 0x70, 0x7F, 0xEF, 0x03, 0xFE,
  0x00, 0x1F, 0xC0,
};

const GFXglyph RobotoMono_Bold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 11, 9, 22, 5, -27 },
  { 34, 19, 26, 22, 1, -26 },
  { 96, 18, 34, 22, 2, -30 },
  { 173, 20, 26, 22, 1, -26 },
  { 238, 21, 26, 22, 1, -26 },
  { 307, 4, 10, 22, 8, -27 },
  { 312, 10, 36, 22, 6, -28 },
  { 357, 9, 36, 22, 6, -28 },
  { 398, 18, 18, 22, 3, -26 },
  { 439, 17, 18, 22, 2, -21 },
  { 478, 7, 11, 22, 6, -4 },
  { 488, 15, 4, 22, 5, -13 },
  { 496, 7, 6, 22, 7, -6 },
  { 502, 14, 28, 22, 4, -26 },
  { 551, 17, 26, 22, 2, -26 },
  { 607, 11, 26, 22, 3, -26 },
  { 643, 18, 26, 22, 1, -26 },
  { 702, 17, 26, 22, 2, -26 },
  { 758, 19, 26, 22, 1, -26 },
  { 820, 17, 26, 22, 2, -26 },
  { 876, 17, 26, 22, 2, -26 },
  { 932, 18, 26, 22, 1, -26 },
  { 991, 17, 26, 22, 2, -26 },
  { 1047, 17, 26, 22, 2, -26 },
  { 1103, 6, 21, 22, 8, -21 },
  { 1119, 7, 28, 22, 8, -21 },
  { 1144, 15, 16, 22, 3, -19 },
  { 1174, 16, 12, 22, 3, -17 },
  { 1198, 16, 16, 22, 3, -19 },
  { 1230, 16, 26, 22, 3, -26 },
  { 1282, 20, 25, 22, 1, -25 },
  { 1345, 22, 26, 22, 0, -26 },
  { 1417, 19, 26, 22, 2, -26 },
  { 1479, 19, 26, 22, 1, -26 },
  { 1541, 18, 26, 22, 2, -26 },
  { 1600, 17, 26, 22, 3, -26 },
  { 1656, 17, 26, 22, 3, -26 },
  { 1712, 18, 26, 22, 2, -26 },
  { 1771, 17, 26, 22, 2, -26 },
  { 1827, 15, 26, 22, 3, -26 },
  { 1876, 17, 26, 22, 2, -26 },
  { 1932, 20, 26, 22, 2, -26 },
  { 1997, 17, 26, 22, 3, -26 },
  { 2053, 18, 26, 22, 2, -26 },
  { 2112, 17, 26, 22, 2, -26 },
  { 2168, 19, 26, 22, 1, -26 },
  { 2230, 18, 26, 22, 3, -26 },
  { 2289, 20, 31, 22, 1, -26 },
  { 2367, 19, 26, 22, 2, -26 },
  { 2429, 18, 26, 22, 2, -26 },
  { 2488, 21, 26, 22, 0, -26 },
  { 2557, 17, 26, 22, 2, -26 },
  { 2613, 20, 26, 22, 1, -26 },
  { 2678, 21, 26, 22, 0, -26 },
  { 2747, 21, 26, 22, 1, -26 },
  { 2816, 21, 26, 22, 1, -26 },
  { 2885, 18, 26, 22, 2, -26 },
  { 2944, 8, 36, 22, 7, -30 },
  { 2980, 14, 28, 22, 4, -26 },
  { 3029, 8, 36, 22, 7, -30 },
  { 3065, 14, 14, 22, 4, -26 },
  { 3090, 16, 4, 22, 3, 0 },
  { 3098, 9, 5, 22, 7, -26 },
  { 3104, 17, 19, 22, 2, -19 },
  { 3145, 17, 27, 22, 3, -27 },
  { 3203, 17, 19, 22, 2, -19 },
  { 3244, 17, 27, 22, 2, -27 },
  { 3302, 18, 19, 22, 2, -19 },
  { 3345, 18, 28, 22, 2, -28 },
  { 3408, 17, 26, 22, 2, -19 },
  { 3464, 18, 27, 22, 2, -27 },
  { 3525, 15, 26, 22, 4, -26 },
  { 3574, 11, 34, 22, 4, -26 },
  { 3621, 18, 27, 22, 3, -27 },
  { 3682, 17, 27, 22, 3, -27 },
  { 3740, 19, 19, 22, 1, -19 },
  { 3786, 17, 19, 22, 2, -19 },
  { 3827, 18, 19, 22, 2, -19 },
  { 3870, 17, 26, 22, 3, -19 },
  { 3926, 17, 26, 22, 2, -19 },
  { 3982, 15, 19, 22, 5, -19 },
  { 4018, 18, 19, 22, 2, -19 },
  { 4061, 17, 24, 22, 2, -24 },
  { 4112, 16, 19, 22, 3, -19 },
  { 4150, 19, 19, 22, 1, -19 },
  { 4196, 21, 19, 22, 0, -19 },
  { 4246, 19, 19, 22, 2, -19 },
  { 4292, 21, 27, 22, 1, -19 },
  { 4363, 18, 19, 22, 2, -19 },
  { 4406, 12, 34, 22, 5, -28 },
  { 4457, 3, 33, 22, 9, -26 },
  { 4470, 12, 34, 22, 6, -28 },
  { 4521, 20, 7, 22, 0, -14 },
};

const GFXfont RobotoMono_Bold36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold36pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_BOLD36PT7B_H_
