#ifndef _ROBOTOMONO_BOLD7PT7B_H_
#define _ROBOTOMONO_BOLD7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xF0, 0x5F, 0x6F, 0x60, 0x27, 0x56, 0x97, 0x20, 0xCE, 0x27,
  0x30, 0x66, 0x4B, 0xF0, 0xC0, 0x5A, 0xA5, 0xA5, 0x5A, 0x5F, 0x70, 0x2F,
  0x22, 0xC0, 0xE0, 0xC0, 0x69, 0x48, 0x69, 0xF9, 0x60, 0xF5, 0x40, 0x69,
  0x24, 0xF0, 0x69, 0x69, 0x60, 0x26, 0x6F, 0x20, 0x74, 0x79, 0x60, 0x64,
  0xF9, 0x60, 0xF2, 0x24, 0x40, 0x69, 0x69, 0x60, 0x69, 0xF1, 0x60, 0xC3,
  0x41, 0xC0, 0x3B, 0x10, 0xFC, 0x8F, 0x40, 0xE5, 0x04, 0x6B, 0xFF, 0x60,
  0x26, 0x67, 0x90, 0xF9, 0xE9, 0xF0, 0x69, 0x89, 0x70, 0xE9, 0x99, 0xE0,
  0xF8, 0xF8, 0xF0, 0xF3, 0xC8, 0x69, 0xB9, 0x70, 0x99, 0xF9, 0x90, 0xE9,
  0x2E, 0x11, 0x19, 0x60, 0x9A, 0xEA, 0x90, 0x92, 0x4E, 0xFF, 0xB9, 0x90,
  0xDD, 0xBB, 0x90, 0x69, 0x99, 0x60, 0xF7, 0xC8, 0x69, 0x99, 0x61, 0xF9,
  0xFA, 0x90, 0x78, 0x69, 0x70, 0xF2, 0x22, 0x20, 0x99, 0x99, 0x60, 0x95,
  0x66, 0x60, 0xBB, 0xF7, 0x70, 0xD6, 0x26, 0x90, 0x96, 0x62, 0x20, 0xF2,
  0x24, 0xF0, 0xEA, 0xAC, 0x91, 0x26, 0xD5, 0x5C, 0x5A, 0x80, 0xF0, 0xC0,
  0x69, 0xF7, 0x8E, 0x99, 0xE0, 0x69, 0x87, 0x17, 0x99, 0x70, 0x69, 0xE7,
  0x3F, 0x44, 0x40, 0x79, 0x97, 0x70, 0x8E, 0x99, 0x90, 0x59, 0x2E, 0x75,
  0x58, 0x89, 0xAE, 0x90, 0xC9, 0x2E, 0xDB, 0xBB, 0xE9, 0x99, 0x69, 0x96,
  0xE9, 0x9E, 0x80, 0x79, 0x97, 0x10, 0xF2, 0x40, 0x65, 0x3F, 0x4F, 0x44,
  0x70, 0xB6, 0xF0, 0x95, 0x66, 0xBB, 0xF6, 0xD6, 0x6D, 0x95, 0x62, 0x44,
  0xF2, 0x4F, 0x5D, 0x50, 0xFC, 0xD5, 0x60, 0xDA,
};

const GFXglyph RobotoMono_Bold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 1, -5 },
  { 17, 2, 8, 4, 1, -6 },
  { 19, 2, 8, 4, 1, -6 },
  { 21, 3, 4, 4, 1, -5 },
  { 23, 4, 4, 4, 0, -4 },
  { 25, 1, 2, 4, 1, -1 },
  { 26, 3, 1, 4, 1, -3 },
  { 27, 2, 1, 4, 1, -1 },
  { 28, 3, 5, 4, 1, -5 },
  { 30, 4, 5, 4, 0, -5 },
  { 33, 2, 5, 4, 1, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 2, 5, 4, 1, -4 },
  { 62, 3, 4, 4, 1, -4 },
  { 64, 3, 2, 4, 1, -3 },
  { 65, 3, 4, 4, 1, -4 },
  { 67, 3, 5, 4, 1, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 3, 5, 4, 1, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 3, 5, 4, 1, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 3, 5, 4, 1, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 3, 5, 4, 1, -5 },
  { 116, 4, 6, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 4, 5, 4, 0, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 4, 5, 4, 0, -5 },
  { 143, 4, 5, 4, 0, -5 },
  { 146, 2, 7, 4, 1, -6 },
  { 148, 3, 5, 4, 1, -5 },
  { 150, 2, 7, 4, 1, -6 },
  { 152, 3, 3, 4, 1, -5 },
  { 154, 4, 1, 4, 0, 0 },
  { 155, 2, 1, 4, 1, -5 },
  { 156, 4, 4, 4, 0, -4 },
  { 158, 4, 5, 4, 0, -5 },
  { 161, 4, 4, 4, 0, -4 },
  { 163, 4, 5, 4, 0, -5 },
  { 166, 4, 4, 4, 0, -4 },
  { 168, 4, 5, 4, 0, -5 },
  { 171, 4, 5, 4, 0, -4 },
  { 174, 4, 5, 4, 0, -5 },
  { 177, 3, 5, 4, 1, -5 },
  { 179, 2, 7, 4, 1, -5 },
  { 181, 4, 5, 4, 0, -5 },
  { 184, 3, 5, 4, 1, -5 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 4, 4, 4, 0, -4 },
  { 192, 4, 5, 4, 0, -4 },
  { 195, 4, 5, 4, 0, -4 },
  { 198, 3, 4, 4, 1, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 5, 4, 0, -5 },
  { 205, 3, 4, 4, 1, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 4, 4, 0, -4 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 4, 4, 4, 0, -4 },
  { 218, 2, 6, 4, 1, -5 },
  { 220, 1, 6, 4, 2, -5 },
  { 221, 2, 6, 4, 1, -5 },
  { 223, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoMono_Bold7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold7pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_BOLD7PT7B_H_
