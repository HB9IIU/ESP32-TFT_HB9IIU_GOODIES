#ifndef _ROBOTOMONO_BOLD6PT7B_H_
#define _ROBOTOMONO_BOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xF0, 0x7F, 0xD0, 0x4D, 0x1E, 0x80, 0xEA, 0x63, 0x64, 0xDF,
  0xC0, 0x6A, 0xB0, 0xA5, 0x60, 0x5D, 0x80, 0x5D, 0x20, 0xC0, 0xC0, 0x80,
  0x5A, 0xF7, 0xB0, 0xD5, 0xE5, 0x70, 0xEC, 0xF0, 0x6F, 0x90, 0xFC, 0xF0,
  0x7E, 0xB0, 0xE5, 0x20, 0xEE, 0xB0, 0xF5, 0xB0, 0xA0, 0xCA, 0x78, 0x80,
  0xFC, 0xCE, 0x00, 0xE5, 0x20, 0xFF, 0xF0, 0x46, 0x69, 0xFE, 0xF0, 0xF2,
  0x30, 0xF6, 0xF0, 0xFE, 0x70, 0xFE, 0x40, 0xF2, 0xB0, 0xBE, 0xD0, 0xEB,
  0x24, 0xF0, 0xBC, 0xAB, 0x92, 0x70, 0xFF, 0xD0, 0xFE, 0xD0, 0xF6, 0xB0,
  0xF7, 0x40, 0xEA, 0xA6, 0x10, 0xEA, 0xEB, 0xE8, 0xF0, 0xF4, 0x44, 0xB6,
  0xB0, 0xB6, 0x64, 0xDE, 0xE6, 0xB6, 0x6B, 0xB6, 0x44, 0xE5, 0x70, 0xFC,
  0xA5, 0xFC, 0xB0, 0xE0, 0xC0, 0xEF, 0x80, 0x93, 0xDE, 0x71, 0x80, 0x27,
  0xD6, 0x7D, 0x80, 0x2B, 0xA4, 0x75, 0xF0, 0x93, 0xDA, 0xAB, 0x75, 0x80,
  0x88, 0xAC, 0xB0, 0xAA, 0xC0, 0xFF, 0x80, 0xF6, 0x80, 0x75, 0x80, 0xF7,
  0xC0, 0xF5, 0x90, 0xE8, 0xEF, 0x80, 0x5D, 0x30, 0xB5, 0x80, 0xAD, 0x00,
  0xFE, 0x80, 0xEB, 0x80, 0xB6, 0x44, 0xEB, 0x80, 0x5A, 0x50, 0xF8, 0xA9,
  0xA0, 0xE0,
};

const GFXglyph RobotoMono_Bold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 2, 4, 1, -5 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 2, 6, 4, 1, -5 },
  { 17, 3, 3, 4, 0, -4 },
  { 19, 3, 4, 4, 0, -4 },
  { 21, 1, 2, 4, 1, -1 },
  { 22, 2, 1, 4, 1, -2 },
  { 23, 1, 1, 4, 1, -1 },
  { 24, 2, 4, 4, 1, -4 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 2, 4, 4, 0, -4 },
  { 28, 3, 4, 4, 0, -4 },
  { 30, 3, 4, 4, 0, -4 },
  { 32, 3, 4, 4, 0, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 3, 4, 4, 0, -4 },
  { 38, 3, 4, 4, 0, -4 },
  { 40, 3, 4, 4, 0, -4 },
  { 42, 3, 4, 4, 0, -4 },
  { 44, 1, 3, 4, 1, -3 },
  { 45, 2, 4, 4, 1, -3 },
  { 46, 3, 3, 4, 0, -3 },
  { 48, 3, 2, 4, 0, -3 },
  { 49, 3, 3, 4, 0, -3 },
  { 51, 3, 4, 4, 0, -4 },
  { 53, 3, 4, 4, 0, -4 },
  { 55, 4, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 3, 4, 4, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 3, 4, 4, 0, -4 },
  { 71, 2, 4, 4, 1, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 4, 5, 4, 0, -4 },
  { 89, 4, 4, 4, 0, -4 },
  { 91, 3, 4, 4, 0, -4 },
  { 93, 4, 4, 4, 0, -4 },
  { 95, 3, 4, 4, 0, -4 },
  { 97, 4, 4, 4, 0, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 4, 4, 4, 0, -4 },
  { 103, 4, 4, 4, 0, -4 },
  { 105, 3, 4, 4, 0, -4 },
  { 107, 1, 6, 4, 1, -5 },
  { 108, 2, 4, 4, 1, -4 },
  { 109, 1, 6, 4, 1, -5 },
  { 110, 2, 2, 4, 1, -4 },
  { 111, 3, 1, 4, 0, 0 },
  { 112, 2, 1, 4, 1, -4 },
  { 113, 3, 3, 4, 0, -3 },
  { 115, 3, 5, 4, 0, -5 },
  { 117, 3, 3, 4, 0, -3 },
  { 119, 3, 5, 4, 0, -5 },
  { 121, 3, 3, 4, 0, -3 },
  { 123, 3, 5, 4, 0, -5 },
  { 125, 3, 4, 4, 0, -3 },
  { 127, 3, 5, 4, 0, -5 },
  { 129, 2, 4, 4, 1, -4 },
  { 130, 2, 5, 4, 1, -4 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 2, 5, 4, 1, -5 },
  { 137, 3, 3, 4, 0, -3 },
  { 139, 3, 3, 4, 0, -3 },
  { 141, 3, 3, 4, 0, -3 },
  { 143, 3, 4, 4, 0, -3 },
  { 145, 3, 4, 4, 0, -3 },
  { 147, 2, 3, 4, 1, -3 },
  { 148, 3, 3, 4, 0, -3 },
  { 150, 3, 4, 4, 0, -4 },
  { 152, 3, 3, 4, 0, -3 },
  { 154, 3, 3, 4, 0, -3 },
  { 156, 3, 3, 4, 0, -3 },
  { 158, 3, 3, 4, 0, -3 },
  { 160, 4, 4, 4, 0, -3 },
  { 162, 3, 3, 4, 0, -3 },
  { 164, 2, 6, 4, 1, -5 },
  { 166, 1, 5, 4, 1, -4 },
  { 167, 2, 6, 4, 1, -5 },
  { 169, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoMono_Bold6pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold6pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOMONO_BOLD6PT7B_H_
