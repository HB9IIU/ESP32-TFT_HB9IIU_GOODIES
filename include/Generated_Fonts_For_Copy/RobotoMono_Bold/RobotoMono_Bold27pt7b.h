#ifndef _ROBOTOMONO_BOLD27PT7B_H_
#define _ROBOTOMONO_BOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0xFF, 0xF0, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x03,
  0x9C, 0x0E, 0x71, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x1C, 0xE0, 0x73, 0x81,
  0x8C, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0x9C, 0x0E, 0x70, 0x31, 0x80,
  0xC6, 0x03, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3F, 0x83, 0xFF,
  0x3F, 0xF9, 0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0xC0, 0x1F, 0x00, 0x7F, 0x01,
  0xFE, 0x03, 0xF8, 0x03, 0xC0, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1E, 0xFF,
  0xE7, 0xFF, 0x0F, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0x67, 0x10, 0xE7, 0x38, 0xE7, 0x30, 0x67, 0x60, 0x7E, 0x60, 0x3C,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x3C, 0x07, 0x7E, 0x06,
  0xE7, 0x0E, 0xE7, 0x0C, 0xE7, 0x00, 0xE7, 0x00, 0x7E, 0x00, 0x3C, 0x0F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0F, 0x70,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x01, 0xFE, 0x3B, 0xFC, 0xFF, 0x3D, 0xDE,
  0x3F, 0xBC, 0x3F, 0x78, 0x7C, 0x7F, 0xF8, 0xFF, 0xF8, 0xFE, 0x78, 0xFF,
  0xFF, 0xF8, 0x04, 0x1C, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x1C,
  0x1C, 0x10, 0x40, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0xE0, 0x40, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x10, 0xC2,
  0x73, 0x3B, 0xFF, 0xE3, 0xFF, 0x41, 0xC0, 0x0F, 0x80, 0x77, 0x03, 0x8E,
  0x0E, 0x3C, 0x10, 0x60, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x77, 0x77, 0x77, 0xEE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x67, 0xBF, 0xFF, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x1F, 0xC3, 0xFE,
  0x7F, 0xEF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0xF7,
  0xFC, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0x7F, 0xE3, 0xFE,
  0x1F, 0x80, 0x01, 0x87, 0xDF, 0xFF, 0xFF, 0xFE, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x1F, 0xC1, 0xFF, 0x9F, 0xFD, 0xE0, 0xFF, 0x07, 0xF8, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0x9F, 0xFE,
  0xF0, 0xFF, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x07, 0xE0, 0x3F, 0x01,
  0xFC, 0x00, 0xF0, 0x03, 0x80, 0x1F, 0xC0, 0xFF, 0x0F, 0x7F, 0xF9, 0xFF,
  0x87, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3B,
  0xC0, 0xEF, 0x07, 0x3C, 0x3C, 0xF0, 0xE3, 0xC7, 0x0F, 0x3C, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0x00, 0x70, 0x0F, 0x00, 0xF2, 0x0F, 0xFC,
  0xFF, 0xEF, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0xE0, 0xFF, 0x0F,
  0xFF, 0xE7, 0xFE, 0x1F, 0x80, 0x03, 0xE0, 0x7F, 0x07, 0xF8, 0x7C, 0x03,
  0xC0, 0x3C, 0x01, 0xCF, 0x0E, 0xFE, 0xFF, 0xF7, 0xE7, 0xFC, 0x1F, 0xE0,
  0x7F, 0x03, 0xB8, 0x1D, 0xC0, 0xEF, 0x0F, 0x3F, 0xF0, 0xFF, 0x83, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0xE1, 0xFF, 0x9F, 0xFC,
  0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xE7, 0x9E, 0x1F, 0xE0, 0xFF, 0x0F,
  0xFC, 0xF0, 0xF7, 0x07, 0xF8, 0x1F, 0xC1, 0xEF, 0x0F, 0x7F, 0xF9, 0xFF,
  0x87, 0xF0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0xEF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0x70, 0x7B, 0xC7, 0xDF, 0xFE, 0x7F, 0xF0, 0xF7, 0x80,
  0x38, 0x03, 0xC0, 0x3C, 0x1F, 0xE0, 0xFC, 0x07, 0x80, 0x27, 0xBF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x4F, 0x7F, 0xFE, 0x23, 0xFF, 0xF7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9D, 0xCE, 0x00, 0x00, 0x10, 0x07,
  0x01, 0xF0, 0xFF, 0x3F, 0xCF, 0xE0, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xFF,
  0x07, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x00, 0xF0, 0x3F, 0x1F, 0xEF, 0xF8, 0xFE, 0x0F, 0x00,
  0xC0, 0x00, 0x3F, 0xC3, 0xFF, 0x9F, 0xFD, 0xE1, 0xEF, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xE0, 0x1F,
  0xF0, 0x78, 0x70, 0xC0, 0x73, 0x1E, 0x6E, 0x7E, 0xD9, 0xCD, 0xB3, 0x1B,
  0x66, 0x66, 0xDC, 0xCD, 0xB9, 0x9B, 0x73, 0x36, 0xE6, 0x6C, 0xFF, 0x98,
  0xEE, 0x38, 0x00, 0x38, 0x20, 0x3F, 0xC0, 0x1F, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0F,
  0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x3C, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0xF0, 0x0F, 0xFF,
  0xC3, 0xFF, 0xCF, 0xFF, 0x38, 0x1E, 0xE0, 0x7B, 0x81, 0xEE, 0x07, 0xB8,
  0x3C, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0xB8, 0x1E, 0xE0, 0x3B, 0x80, 0xFE,
  0x03, 0xB8, 0x1E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x9E, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xF7, 0x03, 0xDE,
  0x1E, 0x3F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9,
  0xC3, 0xEE, 0x0F, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xDC, 0x3E, 0xFF, 0xE7, 0xFE,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x9E, 0x0E, 0x78,
  0x3F, 0xC0, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xFF, 0x1F, 0xFC,
  0x7F, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0xDE, 0x0F, 0x3F, 0xFC, 0x7F, 0xE0,
  0xFE, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xC0, 0xE7, 0x03,
  0x9E, 0x1E, 0x7F, 0xF0, 0xFF, 0xC1, 0xFC, 0x00, 0xE0, 0x7D, 0xC0, 0xF3,
  0x83, 0xC7, 0x0F, 0x8E, 0x3E, 0x1C, 0x78, 0x39, 0xE0, 0x77, 0xC0, 0xFF,
  0x01, 0xFF, 0x03, 0xFE, 0x07, 0xDE, 0x0F, 0x3E, 0x1C, 0x3C, 0x38, 0x7C,
  0x70, 0x78, 0xE0, 0x79, 0xC0, 0xFB, 0x80, 0xF8, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0xFF, 0xC7, 0xFE, 0x7F, 0xF3, 0xFF, 0x9B, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0x7F, 0x7B, 0xF9, 0xDF, 0xCC, 0xFE, 0x67,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1E, 0xF0, 0x7F,
  0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x7E, 0xE7, 0xEE, 0x7E,
  0x77, 0xE7, 0x7E, 0x77, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0x70, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0xDE, 0x1E, 0x3F, 0xF8, 0xFF, 0xC0, 0xFC,
  0x00, 0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE3, 0xC3, 0xC7, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x9C, 0x0F,
  0x3C, 0x3C, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0x80, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x38, 0x3E, 0xE0, 0x7B, 0x81,
  0xEE, 0x07, 0xB8, 0x1E, 0xE0, 0xF3, 0xFF, 0xCF, 0xFC, 0x3F, 0xF0, 0xE1,
  0xE3, 0x87, 0x8E, 0x0F, 0x38, 0x3C, 0xE0, 0x7B, 0x81, 0xEE, 0x03, 0xC0,
  0x1F, 0xE0, 0xFF, 0xE7, 0xFF, 0xDE, 0x0F, 0x70, 0x1D, 0xC0, 0x07, 0x80,
  0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0xC0,
  0x7F, 0x01, 0xDE, 0x0F, 0x7F, 0xFC, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3B, 0xC1,
  0xDE, 0x1E, 0x7F, 0xF3, 0xFF, 0x07, 0xF0, 0xF8, 0x0F, 0x78, 0x1E, 0x78,
  0x1E, 0x38, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x38, 0x1E,
  0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xF1, 0xCF, 0x73,
  0xCF, 0x73, 0xCF, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x7B, 0xCE, 0x7B,
  0xEE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x38, 0x1C, 0x38, 0x78,
  0x1F, 0x7C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0x70, 0x0F, 0x78, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x1E, 0x7C, 0x1E, 0xF8,
  0x0F, 0xF8, 0x0F, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E,
  0x38, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xF0, 0xF0, 0x0E, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xE0, 0x1E, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFF, 0xF0, 0x0E, 0x03,
  0xC0, 0x7C, 0x1F, 0x83, 0xB8, 0x67, 0x1C, 0x63, 0x8E, 0xE1, 0xDC, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x78, 0x78, 0x04, 0x03, 0xFC, 0x7F,
  0xEF, 0x1F, 0xF0, 0xF0, 0x0F, 0x0F, 0xF7, 0xFF, 0xFC, 0xFF, 0x0F, 0xE0,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x3E, 0x70, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x79, 0x83, 0xFF, 0x1F, 0xFC, 0xFD, 0xF7, 0x87, 0xBC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0E, 0xF0, 0xF7, 0xFF,
  0xBF, 0xF9, 0xDF, 0x80, 0x06, 0x03, 0xFC, 0x7F, 0xE7, 0xFF, 0xF0, 0xFE,
  0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x7F, 0x0F, 0x7F, 0xF3,
  0xFE, 0x1F, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83,
  0x1C, 0x7E, 0xE7, 0xFF, 0x7F, 0xFB, 0xC3, 0xDC, 0x0E, 0xE0, 0x7F, 0x03,
  0xF8, 0x1D, 0xC0, 0xEF, 0x07, 0x78, 0x7B, 0xFF, 0xCF, 0xFE, 0x3F, 0x70,
  0x01, 0x00, 0x3F, 0x83, 0xFF, 0x0F, 0xBE, 0x78, 0x39, 0xE0, 0xF7, 0x03,
  0xFF, 0xFF, 0xFF, 0xFD, 0xC0, 0x07, 0x80, 0x1F, 0x06, 0x3F, 0xFC, 0x7F,
  0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x1F, 0xFE, 0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x00, 0x02, 0x00, 0xFD, 0xCF, 0xFE, 0xFD, 0xF7, 0x83, 0xBC, 0x1D,
  0xC0, 0xFE, 0x07, 0xF0, 0x3B, 0x81, 0xDE, 0x0E, 0xF0, 0xF3, 0xFF, 0x9F,
  0xFC, 0x7E, 0xE0, 0x07, 0x10, 0x79, 0xC7, 0xDF, 0xFC, 0x3F, 0xC0, 0x60,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x83, 0xDF,
  0x9F, 0xFE, 0xFD, 0xF7, 0x83, 0xBC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0x06, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0xFF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x07, 0xC3, 0xE0, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x7F,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x78, 0x7D, 0xFE, 0xFE, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0xBC, 0x78, 0xF3, 0xE3,
  0xDF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x3C, 0xF0,
  0xF1, 0xE3, 0xC3, 0xCF, 0x0F, 0xBC, 0x1F, 0xFF, 0x0F, 0xF0, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x02, 0x13, 0xBD, 0xEF, 0xFF, 0xFD, 0xFF, 0xE7, 0x9F, 0x9E, 0x7E,
  0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F,
  0x9E, 0x7E, 0x79, 0xC0, 0x01, 0x07, 0x3F, 0x3B, 0xFD, 0xFB, 0xEF, 0x07,
  0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xE0, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xFE,
  0x78, 0x79, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x03,
  0x9E, 0x1E, 0x3F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x03, 0x07, 0x7E, 0x3F,
  0xF9, 0xFF, 0xEF, 0x0F, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1D, 0xE1, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x00, 0x06, 0x00, 0xFD, 0xCF, 0xFE, 0xFD, 0xF7,
  0x87, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3B, 0x81, 0xDE, 0x0E, 0xF0,
  0xF7, 0xFF, 0x9F, 0xFC, 0x7E, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0x9C, 0xFF, 0xBF, 0xFF, 0xEF, 0x81, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x06,
  0x01, 0xFE, 0x1F, 0xFD, 0xE1, 0xEF, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xB8, 0x1F, 0xC0, 0xFF, 0x8F, 0x3F, 0xF8, 0xFF, 0x00,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0xFF, 0x7F, 0xF8, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xF7, 0xFF,
  0x7F, 0xF3, 0xE7, 0xF0, 0x3D, 0xC0, 0xF7, 0x83, 0x9E, 0x1E, 0x38, 0x70,
  0xF1, 0xC1, 0xCF, 0x07, 0x38, 0x1E, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF1, 0x8F, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE,
  0x73, 0xCE, 0x73, 0xDE, 0x3F, 0xDC, 0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x78, 0x1C, 0x78, 0x1C, 0x38, 0xF8, 0x3C, 0x78, 0xF0,
  0xF1, 0xE0, 0xF7, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xE0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE3, 0xC7, 0x83, 0xDE, 0x07, 0xC0, 0xF0,
  0x1F, 0xE0, 0x79, 0xE0, 0xF3, 0xC1, 0xE3, 0xC7, 0x87, 0x8F, 0x07, 0x1C,
  0x0F, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0x83, 0xC3, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x1F, 0x8F, 0x07, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x70, 0x38, 0x1E, 0x07, 0x80, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x60, 0x78, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x01, 0xF0, 0x78, 0x7C, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1,
  0xE0, 0xE1, 0xF0, 0x70, 0x20, 0x00, 0x1C, 0x00, 0xFE, 0x1D, 0xFE, 0x3F,
  0x9F, 0xFE, 0x1F, 0xC0, 0x0F, 0x00,
};

const GFXglyph RobotoMono_Bold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 8, 7, 16, 4, -20 },
  { 18, 14, 19, 16, 1, -19 },
  { 52, 13, 25, 16, 2, -22 },
  { 93, 16, 19, 16, 0, -19 },
  { 131, 15, 19, 16, 1, -19 },
  { 167, 3, 7, 16, 6, -20 },
  { 170, 7, 27, 16, 5, -21 },
  { 194, 8, 27, 16, 4, -21 },
  { 221, 14, 13, 16, 2, -19 },
  { 244, 13, 14, 16, 1, -16 },
  { 267, 4, 8, 16, 5, -3 },
  { 271, 11, 3, 16, 4, -10 },
  { 276, 5, 5, 16, 6, -5 },
  { 280, 11, 21, 16, 3, -19 },
  { 309, 12, 19, 16, 2, -19 },
  { 338, 9, 19, 16, 2, -19 },
  { 360, 13, 19, 16, 1, -19 },
  { 391, 13, 19, 16, 1, -19 },
  { 422, 14, 19, 16, 1, -19 },
  { 456, 12, 19, 16, 2, -19 },
  { 485, 13, 19, 16, 1, -19 },
  { 516, 13, 19, 16, 1, -19 },
  { 547, 13, 19, 16, 1, -19 },
  { 578, 13, 19, 16, 1, -19 },
  { 609, 5, 16, 16, 6, -16 },
  { 619, 5, 21, 16, 6, -16 },
  { 633, 12, 13, 16, 2, -15 },
  { 653, 13, 8, 16, 2, -12 },
  { 666, 12, 13, 16, 2, -15 },
  { 686, 13, 19, 16, 2, -19 },
  { 717, 15, 19, 16, 0, -19 },
  { 753, 16, 19, 16, 0, -19 },
  { 791, 14, 19, 16, 2, -19 },
  { 825, 14, 19, 16, 1, -19 },
  { 859, 13, 19, 16, 2, -19 },
  { 890, 13, 19, 16, 2, -19 },
  { 921, 13, 19, 16, 2, -19 },
  { 952, 14, 19, 16, 1, -19 },
  { 986, 12, 19, 16, 2, -19 },
  { 1015, 11, 19, 16, 3, -19 },
  { 1042, 14, 19, 16, 1, -19 },
  { 1076, 15, 19, 16, 2, -19 },
  { 1112, 13, 19, 16, 2, -19 },
  { 1143, 13, 19, 16, 2, -19 },
  { 1174, 12, 19, 16, 2, -19 },
  { 1203, 14, 19, 16, 1, -19 },
  { 1237, 13, 19, 16, 2, -19 },
  { 1268, 15, 22, 16, 1, -19 },
  { 1310, 14, 19, 16, 2, -19 },
  { 1344, 14, 19, 16, 1, -19 },
  { 1378, 16, 19, 16, 0, -19 },
  { 1416, 13, 19, 16, 2, -19 },
  { 1447, 16, 19, 16, 0, -19 },
  { 1485, 16, 19, 16, 0, -19 },
  { 1523, 16, 19, 16, 0, -19 },
  { 1561, 16, 19, 16, 0, -19 },
  { 1599, 14, 19, 16, 1, -19 },
  { 1633, 6, 26, 16, 5, -22 },
  { 1653, 11, 21, 16, 3, -19 },
  { 1682, 6, 26, 16, 5, -22 },
  { 1702, 11, 10, 16, 3, -19 },
  { 1716, 12, 3, 16, 2, 0 },
  { 1721, 7, 3, 16, 5, -19 },
  { 1724, 12, 15, 16, 2, -15 },
  { 1747, 13, 20, 16, 2, -20 },
  { 1780, 12, 15, 16, 2, -15 },
  { 1803, 13, 20, 16, 1, -20 },
  { 1836, 14, 15, 16, 1, -15 },
  { 1863, 13, 21, 16, 2, -21 },
  { 1898, 13, 21, 16, 1, -15 },
  { 1933, 13, 20, 16, 2, -20 },
  { 1966, 11, 20, 16, 3, -20 },
  { 1994, 9, 26, 16, 3, -20 },
  { 2024, 14, 20, 16, 2, -20 },
  { 2059, 12, 20, 16, 3, -20 },
  { 2089, 14, 15, 16, 1, -15 },
  { 2116, 13, 15, 16, 2, -15 },
  { 2141, 14, 15, 16, 1, -15 },
  { 2168, 13, 20, 16, 2, -15 },
  { 2201, 13, 20, 16, 1, -15 },
  { 2234, 11, 15, 16, 4, -15 },
  { 2255, 13, 15, 16, 2, -15 },
  { 2280, 13, 18, 16, 2, -18 },
  { 2310, 12, 14, 16, 2, -14 },
  { 2331, 14, 14, 16, 1, -14 },
  { 2356, 16, 14, 16, 0, -14 },
  { 2384, 15, 14, 16, 1, -14 },
  { 2411, 15, 20, 16, 1, -14 },
  { 2449, 13, 14, 16, 2, -14 },
  { 2472, 9, 26, 16, 4, -21 },
  { 2502, 2, 24, 16, 7, -19 },
  { 2508, 9, 26, 16, 4, -21 },
  { 2538, 15, 6, 16, 0, -11 },
};

const GFXfont RobotoMono_Bold27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold27pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_BOLD27PT7B_H_
