#ifndef _ROBOTOMONO_BOLD11PT7B_H_
#define _ROBOTOMONO_BOLD11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x47, 0xB6, 0x80, 0x28, 0xA7, 0xCA, 0x2B, 0xF5, 0x14, 0x23,
  0xB7, 0x1E, 0x1C, 0x33, 0xF1, 0x00, 0x62, 0xAA, 0x94, 0x10, 0xF7, 0x43,
  0x30, 0xD1, 0xA1, 0x87, 0x5B, 0xB3, 0x3F, 0xF8, 0x29, 0x49, 0x24, 0x89,
  0x80, 0x91, 0x26, 0xDB, 0x4A, 0x00, 0x21, 0x3E, 0x4D, 0xA8, 0x63, 0x3E,
  0xC6, 0x00, 0xF8, 0xF0, 0xF0, 0x18, 0x8C, 0x42, 0x31, 0x08, 0xC0, 0x76,
  0xE7, 0x7D, 0xCF, 0x6E, 0x3E, 0x92, 0x49, 0x39, 0x2C, 0xC2, 0x18, 0xC6,
  0x1F, 0x74, 0xC6, 0xE7, 0x0E, 0x7E, 0x18, 0x62, 0x8A, 0x4B, 0xF0, 0x82,
  0xFE, 0x21, 0xE1, 0x8E, 0x7E, 0x37, 0x21, 0xE9, 0xCE, 0x6E, 0xFC, 0x30,
  0x86, 0x10, 0xC2, 0x18, 0x76, 0xE7, 0xEF, 0x4E, 0x7E, 0x76, 0xA7, 0x3F,
  0x8C, 0xCC, 0x70, 0x70, 0x4C, 0x00, 0x96, 0x0B, 0xF1, 0xE1, 0x80, 0xF8,
  0x3E, 0x87, 0x06, 0xEC, 0x00, 0x76, 0xC6, 0x22, 0x10, 0x8C, 0x39, 0x17,
  0xEB, 0xAE, 0xF4, 0x1E, 0x10, 0x70, 0xE1, 0x46, 0x8F, 0x91, 0x63, 0xF4,
  0xE3, 0xFF, 0xC6, 0x7E, 0x39, 0xB4, 0x70, 0xC3, 0x04, 0xCE, 0xE5, 0xA7,
  0x18, 0xCE, 0x7E, 0xFC, 0x21, 0xFF, 0xC2, 0x1F, 0xFC, 0x21, 0x0F, 0xC2,
  0x10, 0x39, 0xB4, 0x70, 0xDD, 0x16, 0x4F, 0x9C, 0xE7, 0xFF, 0xCE, 0x73,
  0xF9, 0x08, 0x42, 0x10, 0x9F, 0x18, 0xC6, 0x31, 0x8E, 0x7E, 0x8E, 0x6B,
  0x38, 0xF2, 0xC9, 0xA3, 0x84, 0x21, 0x08, 0x42, 0x1F, 0xDE, 0xFF, 0xDA,
  0xC6, 0x31, 0x9E, 0xF7, 0xFB, 0xDE, 0x73, 0x39, 0xB4, 0x71, 0xC7, 0x14,
  0xCE, 0xF4, 0xE3, 0x3F, 0x42, 0x10, 0x38, 0xD9, 0x16, 0x2C, 0x58, 0x93,
  0x1C, 0x06, 0xF4, 0xE3, 0x3F, 0x4A, 0x71, 0x39, 0xB4, 0x1C, 0x1E, 0x14,
  0x5F, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x9C, 0xE7, 0x39, 0xCE, 0x6E,
  0xC5, 0x34, 0xDA, 0x68, 0xE3, 0x8C, 0xD7, 0x5F, 0x5D, 0x75, 0xB6, 0xDA,
  0xC6, 0xD8, 0xA1, 0xC3, 0x85, 0x1B, 0x63, 0xC6, 0x99, 0xA1, 0xC3, 0x02,
  0x04, 0x08, 0xFC, 0x30, 0x84, 0x30, 0x84, 0x3F, 0xFB, 0x6D, 0xB6, 0xDB,
  0x80, 0xC2, 0x10, 0xC2, 0x18, 0xC2, 0x18, 0xED, 0xB6, 0xDB, 0x6F, 0x80,
  0x23, 0x15, 0xB0, 0xF8, 0xC4, 0x74, 0xCF, 0xB9, 0xFC, 0x84, 0x3D, 0xB9,
  0xCE, 0x7E, 0x76, 0xE1, 0x09, 0xB8, 0x18, 0xDF, 0xB9, 0xCE, 0x7F, 0x76,
  0xE3, 0xFC, 0xB8, 0x3B, 0x3E, 0xC6, 0x31, 0x8C, 0x7E, 0xE7, 0x39, 0xFE,
  0x7E, 0x84, 0x2D, 0xB9, 0xCE, 0x73, 0x21, 0x38, 0x42, 0x10, 0x9F, 0x32,
  0x73, 0x33, 0x33, 0x3E, 0x84, 0x27, 0x6E, 0x7A, 0x53, 0xE1, 0x08, 0x42,
  0x10, 0x9F, 0xFF, 0x5D, 0x75, 0xD7, 0x50, 0xB6, 0xE7, 0x39, 0xCC, 0x76,
  0xE7, 0x19, 0xB8, 0xF6, 0xE7, 0x39, 0xFA, 0x10, 0x7E, 0xE7, 0x39, 0xFC,
  0x63, 0xBF, 0x88, 0x88, 0x74, 0xF0, 0xF9, 0xF8, 0x67, 0xD8, 0xC6, 0x31,
  0xE0, 0x9C, 0xE7, 0x39, 0xFC, 0xC5, 0x36, 0x8A, 0x38, 0xC0, 0xD7, 0x57,
  0x5D, 0x6D, 0xA0, 0x4D, 0xA3, 0x8E, 0x2B, 0x30, 0xC6, 0x99, 0xB1, 0x43,
  0x82, 0x0C, 0x30, 0xF8, 0xCC, 0xCC, 0x7C, 0x2D, 0x25, 0x12, 0x4C, 0x80,
  0xFF, 0xC0, 0x99, 0x24, 0x52, 0x4A, 0x00, 0xF6, 0x70,
};

const GFXglyph RobotoMono_Bold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 3, 3, 7, 2, -8 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 5, 10, 7, 1, -9 },
  { 18, 6, 8, 7, 0, -8 },
  { 24, 7, 8, 7, 0, -8 },
  { 31, 2, 3, 7, 2, -8 },
  { 32, 3, 11, 7, 2, -9 },
  { 37, 3, 11, 7, 2, -9 },
  { 42, 5, 6, 7, 1, -8 },
  { 46, 5, 5, 7, 1, -6 },
  { 50, 2, 3, 7, 2, -1 },
  { 51, 4, 1, 7, 2, -4 },
  { 52, 2, 2, 7, 2, -2 },
  { 53, 5, 9, 7, 1, -8 },
  { 59, 5, 8, 7, 1, -8 },
  { 64, 3, 8, 7, 1, -8 },
  { 67, 6, 8, 7, 0, -8 },
  { 73, 5, 8, 7, 1, -8 },
  { 78, 6, 8, 7, 0, -8 },
  { 84, 5, 8, 7, 1, -8 },
  { 89, 5, 8, 7, 1, -8 },
  { 94, 6, 8, 7, 0, -8 },
  { 100, 5, 8, 7, 1, -8 },
  { 105, 5, 8, 7, 1, -8 },
  { 110, 2, 6, 7, 2, -6 },
  { 112, 3, 8, 7, 2, -6 },
  { 115, 5, 5, 7, 1, -6 },
  { 119, 5, 3, 7, 1, -5 },
  { 121, 5, 5, 7, 1, -6 },
  { 125, 5, 8, 7, 1, -8 },
  { 130, 6, 8, 7, 0, -8 },
  { 136, 7, 8, 7, 0, -8 },
  { 143, 5, 8, 7, 1, -8 },
  { 148, 6, 8, 7, 0, -8 },
  { 154, 5, 8, 7, 1, -8 },
  { 159, 5, 8, 7, 1, -8 },
  { 164, 5, 8, 7, 1, -8 },
  { 169, 6, 8, 7, 0, -8 },
  { 175, 5, 8, 7, 1, -8 },
  { 180, 5, 8, 7, 1, -8 },
  { 185, 5, 8, 7, 1, -8 },
  { 190, 6, 8, 7, 1, -8 },
  { 196, 5, 8, 7, 1, -8 },
  { 201, 5, 8, 7, 1, -8 },
  { 206, 5, 8, 7, 1, -8 },
  { 211, 6, 8, 7, 0, -8 },
  { 217, 5, 8, 7, 1, -8 },
  { 222, 7, 9, 7, 0, -8 },
  { 230, 5, 8, 7, 1, -8 },
  { 235, 6, 8, 7, 0, -8 },
  { 241, 6, 8, 7, 0, -8 },
  { 247, 5, 8, 7, 1, -8 },
  { 252, 6, 8, 7, 0, -8 },
  { 258, 6, 8, 7, 0, -8 },
  { 264, 7, 8, 7, 0, -8 },
  { 271, 7, 8, 7, 0, -8 },
  { 278, 6, 8, 7, 0, -8 },
  { 284, 3, 11, 7, 2, -9 },
  { 289, 5, 9, 7, 1, -8 },
  { 295, 3, 11, 7, 2, -9 },
  { 300, 5, 4, 7, 1, -8 },
  { 303, 5, 1, 7, 1, 0 },
  { 304, 3, 2, 7, 2, -8 },
  { 305, 5, 6, 7, 1, -6 },
  { 309, 5, 8, 7, 1, -8 },
  { 314, 5, 6, 7, 1, -6 },
  { 318, 5, 8, 7, 1, -8 },
  { 323, 5, 6, 7, 1, -6 },
  { 327, 5, 8, 7, 1, -8 },
  { 332, 5, 8, 7, 1, -6 },
  { 337, 5, 8, 7, 1, -8 },
  { 342, 5, 8, 7, 1, -8 },
  { 347, 4, 10, 7, 1, -8 },
  { 352, 5, 8, 7, 1, -8 },
  { 357, 5, 8, 7, 1, -8 },
  { 362, 6, 6, 7, 0, -6 },
  { 367, 5, 6, 7, 1, -6 },
  { 371, 5, 6, 7, 1, -6 },
  { 375, 5, 8, 7, 1, -6 },
  { 380, 5, 8, 7, 1, -6 },
  { 385, 4, 6, 7, 2, -6 },
  { 388, 5, 6, 7, 1, -6 },
  { 392, 5, 7, 7, 1, -7 },
  { 397, 5, 6, 7, 1, -6 },
  { 401, 6, 6, 7, 0, -6 },
  { 406, 6, 6, 7, 0, -6 },
  { 411, 6, 6, 7, 0, -6 },
  { 416, 7, 8, 7, 0, -6 },
  { 423, 5, 6, 7, 1, -6 },
  { 427, 3, 11, 7, 2, -9 },
  { 432, 1, 10, 7, 3, -8 },
  { 434, 3, 11, 7, 2, -9 },
  { 439, 6, 2, 7, 0, -4 },
};

const GFXfont RobotoMono_Bold11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold11pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_BOLD11PT7B_H_
