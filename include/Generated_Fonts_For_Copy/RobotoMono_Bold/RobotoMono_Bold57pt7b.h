#ifndef _ROBOTOMONO_BOLD57PT7B_H_
#define _ROBOTOMONO_BOLD57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x3F, 0xDF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x00,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFC, 0x03, 0xFE,
  0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFC, 0x3F, 0x02, 0x00, 0xF8, 0x3F, 0x03, 0x80, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x1F,
  0x00, 0xF8, 0x3F, 0x1F, 0x00, 0xFC, 0x3E, 0x3E, 0x00, 0x7F, 0xFE, 0x3E,
  0x00, 0x7F, 0xFE, 0x7C, 0x00, 0x3F, 0xFC, 0x78, 0x00, 0x1F, 0xF0, 0xF8,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x1F, 0x1F,
  0xFC, 0x00, 0x1E, 0x3F, 0xFE, 0x00, 0x3E, 0x7F, 0xFE, 0x00, 0x3C, 0x7F,
  0x7F, 0x00, 0x7C, 0x7C, 0x3F, 0x00, 0xF8, 0xFC, 0x1F, 0x00, 0xF8, 0xFC,
  0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x00, 0xE0, 0xFC,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x7E, 0x0F, 0xFF, 0xC0,
  0x7E, 0x1F, 0xFF, 0xE0, 0x7E, 0x3F, 0xFF, 0xF0, 0xFE, 0x7F, 0xCF, 0xF0,
  0xFE, 0x7F, 0x8F, 0xF8, 0xFE, 0x7F, 0x07, 0xFC, 0xFE, 0xFF, 0x03, 0xFF,
  0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0xFF,
  0xF8, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xC1,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1E, 0x00, 0x1C, 0x00, 0x08, 0x40, 0x00, 0x70, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x0F, 0x80, 0x21, 0xE0,
  0x7C, 0x07, 0x1F, 0xC3, 0xE1, 0xFC, 0xFF, 0x9F, 0x3F, 0xE7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x08, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x3F, 0x1F, 0xC7, 0xE3, 0xF8, 0x7C, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xCF, 0xE0, 0x40, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x01,
  0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x7F, 0x7F, 0xFF, 0x3F, 0x9F, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0x9F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xF9,
  0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xE1,
  0xFF, 0xC7, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x03, 0xFE,
  0x7F, 0xC0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7E, 0xFF, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x3F,
  0x8F, 0xF0, 0x01, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F,
  0xE0, 0x0F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7E, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8,
  0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE1, 0xC0, 0x01,
  0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F, 0xFC, 0x3F, 0x00, 0xFF, 0x80,
  0x40, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xEF, 0xF0, 0x07, 0xFD, 0xFF, 0x81, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xF1, 0xFF, 0xC0, 0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xCF, 0xFC, 0x07, 0xFE,
  0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xE3, 0xFE, 0x03,
  0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x3F,
  0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xF0,
  0x07, 0xF9, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x9F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xEF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x07, 0xFE, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xF8,
  0x0F, 0xFE, 0x7F, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x3F, 0x8F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x3F,
  0x81, 0x80, 0x02, 0x01, 0xFC, 0x3F, 0xE3, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF3, 0xFF, 0x3F, 0xE1, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFC,
  0x7F, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x1F, 0x03, 0xFE,
  0x3E, 0x1E, 0x0F, 0xFF, 0x1E, 0x3E, 0x1F, 0xFF, 0x1E, 0x3C, 0x1F, 0xFF,
  0x1E, 0x7C, 0x3F, 0x1F, 0x1E, 0x7C, 0x3E, 0x1F, 0x1F, 0x7C, 0x7C, 0x1E,
  0x1F, 0x78, 0x7C, 0x1E, 0x1F, 0xF8, 0x7C, 0x1E, 0x1F, 0xF8, 0xF8, 0x1E,
  0x1E, 0xF8, 0xF8, 0x1E, 0x1E, 0xF8, 0xF8, 0x1E, 0x1E, 0xF8, 0xF8, 0x1E,
  0x1E, 0xF8, 0xF8, 0x3E, 0x1E, 0xF8, 0xF8, 0x3E, 0x1E, 0xF8, 0xF8, 0x3E,
  0x3C, 0xF8, 0xF8, 0x3E, 0x3C, 0xF8, 0xFC, 0x7E, 0x7C, 0x78, 0x7F, 0xFF,
  0xF8, 0x7C, 0x7F, 0xFF, 0xF8, 0x7C, 0x3F, 0xDF, 0xF0, 0x7C, 0x1F, 0x8F,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x02, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0x0F, 0xFC, 0xFE, 0x00, 0x1F, 0xF7,
  0xF0, 0x00, 0xFF, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xFC, 0xFE, 0x00, 0x3F, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xC0, 0x0F, 0xFC, 0xFE, 0x00, 0x1F, 0xF7, 0xF0, 0x00,
  0x7F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xBF, 0x80, 0x3F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F,
  0xE0, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xC7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0,
  0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07,
  0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFD,
  0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFB, 0xFC,
  0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x07,
  0xFE, 0x3F, 0xC1, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xC7, 0xFF,
  0x07, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xF9, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF7,
  0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0,
  0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xF0,
  0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x7F,
  0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xF8, 0x00, 0x3F,
  0xE7, 0xF0, 0x00, 0xFF, 0x8F, 0xE0, 0x03, 0xFE, 0x1F, 0xC0, 0x0F, 0xFC,
  0x3F, 0x80, 0x1F, 0xF0, 0x7F, 0x00, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0x01,
  0xFC, 0x07, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x0F,
  0xE0, 0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x7F,
  0x1F, 0xF0, 0x00, 0xFE, 0x7F, 0xC0, 0x01, 0xFC, 0xFF, 0x80, 0x03, 0xFB,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0x80, 0x7F,
  0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0xFF,
  0x83, 0xF8, 0x00, 0xFF, 0x87, 0xF0, 0x01, 0xFF, 0x8F, 0xE0, 0x01, 0xFF,
  0x1F, 0xC0, 0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFE, 0x7F, 0x00, 0x03, 0xFE,
  0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0xF9, 0xFF, 0xFF, 0xDF, 0x3F, 0xFF, 0xFB, 0xF7, 0xDF, 0xFF, 0x7F,
  0xFB, 0xFF, 0xE7, 0xFF, 0x7F, 0xFC, 0xFF, 0xCF, 0xFF, 0xDF, 0xF9, 0xFF,
  0xF9, 0xFF, 0x3F, 0xFF, 0x3F, 0xC7, 0xFF, 0xE7, 0xF8, 0xFF, 0xFC, 0xFF,
  0x1F, 0xFF, 0x8F, 0xE3, 0xFF, 0xF1, 0xF8, 0x7F, 0xFE, 0x3F, 0x0F, 0xFF,
  0xC3, 0xE1, 0xFF, 0xF8, 0x78, 0x3F, 0xFF, 0x0F, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFB, 0xF0, 0xFF,
  0xFF, 0x7E, 0x1F, 0xFF, 0xEF, 0xE3, 0xFF, 0xFC, 0xFC, 0x7F, 0xFF, 0x9F,
  0x8F, 0xFF, 0xF1, 0xF9, 0xFF, 0xFE, 0x3F, 0x3F, 0xFF, 0xC3, 0xF7, 0xFF,
  0xF8, 0x7E, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xDF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x03, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x07, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x0F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x30, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x0F, 0xFC, 0xFE, 0x00, 0x3F, 0xE7,
  0xF0, 0x00, 0xFF, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01,
  0xFE, 0xFE, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xF9,
  0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x00, 0xFF, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0, 0xFE,
  0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00,
  0x7F, 0xCF, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x3F,
  0xDF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xF8,
  0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFD,
  0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0x03, 0xF0,
  0x3F, 0xBF, 0x81, 0xF8, 0x1F, 0xDF, 0xC0, 0xFC, 0x0F, 0xEF, 0xE0, 0x7E,
  0x07, 0xF7, 0xF0, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0xC1, 0xFC, 0xFE, 0x1F,
  0xE0, 0xFE, 0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x1F, 0xC3,
  0xFC, 0x3F, 0x8F, 0xE1, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x8F, 0xE3, 0xF8,
  0xFF, 0xC7, 0xF0, 0xFE, 0x7F, 0xE3, 0xF8, 0x7F, 0x3F, 0xF1, 0xFC, 0x3F,
  0x9F, 0xF9, 0xFC, 0x1F, 0xCF, 0xFC, 0xFE, 0x0F, 0xE7, 0xFF, 0x7F, 0x07,
  0xF3, 0xFF, 0xBF, 0x83, 0xFB, 0xF7, 0xDF, 0xC0, 0xFD, 0xF3, 0xEF, 0xE0,
  0x7F, 0xF9, 0xF7, 0xF0, 0x3F, 0xFC, 0xFB, 0xF0, 0x1F, 0xFE, 0x7D, 0xF8,
  0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F,
  0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0,
  0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F,
  0xE0, 0xFF, 0xC7, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x7F, 0xC0, 0x1F, 0xC7, 0xF8, 0x01, 0xFC,
  0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xF0,
  0x03, 0xFC, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF9, 0xFE, 0x07,
  0xFF, 0x1F, 0xF0, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x38, 0x01, 0xFE, 0x7F, 0xE0, 0x3F, 0xDF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0,
  0x7F, 0xEF, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFE,
  0x1F, 0xCF, 0xFF, 0x83, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF,
  0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xDF, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x3F, 0xC3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x03, 0xC1, 0xFE, 0x03, 0xFF, 0x3F, 0xC1, 0xFF,
  0xF7, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0x3F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x00,
  0x3F, 0xDF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x1F,
  0xF3, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0xE0, 0xFF, 0xF9, 0xFC, 0x07, 0xFE, 0x3F,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xE7,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0x03, 0xFE, 0x00, 0x38, 0x3F, 0xF0, 0x0F, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF1, 0xFC, 0x0F, 0xFF, 0xBF, 0x87, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9,
  0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0xFF,
  0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x3F,
  0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0xC0, 0x7F, 0xE3, 0xF8, 0x00, 0x40, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x80, 0x03, 0xFC, 0x18, 0x00, 0xFF, 0x87, 0x80,
  0x3F, 0xE1, 0xFC, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x1C, 0x01, 0xFE, 0x3F,
  0xF8, 0x3F, 0xCF, 0xFF, 0x87, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xF0, 0x03,
  0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF4, 0x0F, 0xFC, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFB, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x81, 0xFE, 0x1F,
  0xF8, 0x0F, 0xF1, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0xFF, 0x80,
  0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x00, 0xFF, 0x87, 0xFC,
  0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x0F,
  0xF0, 0x1F, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x1F, 0xE0,
  0x0F, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07,
  0xFE, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x03, 0x83, 0xF9, 0xFE, 0x3F, 0x8F,
  0xEF, 0xFB, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0xFE, 0x1F,
  0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0,
  0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F,
  0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF,
  0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8,
  0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F,
  0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0,
  0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F,
  0xC0, 0x00, 0x01, 0xE0, 0x1F, 0xC3, 0xFF, 0x83, 0xF8, 0xFF, 0xF8, 0x7F,
  0x3F, 0xFF, 0x8F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFE,
  0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xC7, 0xFE, 0x03, 0xF9, 0xFF, 0xF0,
  0x7F, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF,
  0xC0, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE1, 0xFE, 0xFF, 0xF8, 0x3F, 0xCF, 0xFC, 0x07, 0xF8,
  0x08, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xF1, 0xFC, 0x1F,
  0xFF, 0x3F, 0x87, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF0,
  0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFE, 0x00,
  0xFF, 0x3F, 0xE0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xBF, 0xC0, 0x7F, 0xE7,
  0xF8, 0x00, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF1, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xF8, 0x05, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F,
  0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xF7, 0xFE, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x20, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFE,
  0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xEF, 0xF0, 0xFF, 0xF9, 0xFE, 0x07, 0xFC, 0x1F, 0xC0, 0x08,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0xFE,
  0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0xFE, 0xFE, 0x07, 0xE0, 0xFE, 0x7E,
  0x0F, 0xE0, 0xFE, 0x7F, 0x0F, 0xE0, 0xFE, 0x7F, 0x0F, 0xF0, 0xFE, 0x7F,
  0x0F, 0xF0, 0xFE, 0x7F, 0x0F, 0xF0, 0xFC, 0x7F, 0x1F, 0xF0, 0xFC, 0x3F,
  0x1F, 0xF1, 0xFC, 0x3F, 0x1F, 0xF9, 0xFC, 0x3F, 0x1E, 0xF9, 0xFC, 0x3F,
  0x9E, 0xF9, 0xF8, 0x3F, 0x9E, 0x79, 0xF8, 0x1F, 0xBE, 0x79, 0xF8, 0x1F,
  0xBE, 0x79, 0xF8, 0x1F, 0xBC, 0x7D, 0xF8, 0x1F, 0xBC, 0x7F, 0xF8, 0x1F,
  0xBC, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x07,
  0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE,
  0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x1F, 0xF0,
  0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xF9, 0xFF, 0xFC, 0x03, 0xF7, 0xFF,
  0xFC, 0x07, 0xEF, 0xFF, 0xFC, 0x1F, 0xBF, 0xDF, 0xFF, 0xFF, 0x7E, 0x07,
  0xFF, 0xFE, 0xF8, 0x07, 0xFF, 0xF9, 0xF0, 0x03, 0xFF, 0xF0, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph RobotoMono_Bold57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 9, 41, 34, 13, -41 },
  { 48, 17, 15, 34, 8, -43 },
  { 80, 31, 41, 34, 1, -41 },
  { 239, 28, 53, 34, 4, -47 },
  { 425, 32, 42, 34, 1, -41 },
  { 593, 32, 42, 34, 2, -41 },
  { 761, 6, 15, 34, 13, -43 },
  { 773, 15, 58, 34, 10, -45 },
  { 882, 16, 58, 34, 9, -45 },
  { 998, 29, 29, 34, 4, -41 },
  { 1104, 28, 30, 34, 3, -34 },
  { 1209, 10, 18, 34, 10, -7 },
  { 1232, 23, 6, 34, 8, -21 },
  { 1250, 10, 11, 34, 12, -10 },
  { 1264, 23, 44, 34, 6, -41 },
  { 1391, 26, 42, 34, 4, -41 },
  { 1528, 18, 41, 34, 5, -41 },
  { 1621, 28, 41, 34, 2, -41 },
  { 1765, 28, 42, 34, 3, -41 },
  { 1912, 29, 41, 34, 2, -41 },
  { 2061, 27, 42, 34, 3, -41 },
  { 2203, 28, 42, 34, 3, -41 },
  { 2350, 28, 41, 34, 2, -41 },
  { 2494, 27, 42, 34, 3, -41 },
  { 2636, 27, 41, 34, 3, -41 },
  { 2775, 11, 34, 34, 12, -33 },
  { 2822, 12, 44, 34, 12, -33 },
  { 2888, 25, 27, 34, 4, -31 },
  { 2973, 27, 18, 34, 4, -26 },
  { 3034, 26, 27, 34, 4, -31 },
  { 3122, 27, 41, 34, 4, -41 },
  { 3261, 32, 40, 34, 1, -40 },
  { 3421, 33, 41, 34, 1, -41 },
  { 3591, 29, 41, 34, 4, -41 },
  { 3740, 30, 42, 34, 2, -41 },
  { 3898, 29, 41, 34, 3, -41 },
  { 4047, 27, 41, 34, 4, -41 },
  { 4186, 28, 41, 34, 4, -41 },
  { 4330, 30, 42, 34, 2, -41 },
  { 4488, 27, 41, 34, 3, -41 },
  { 4627, 24, 41, 34, 5, -41 },
  { 4750, 28, 42, 34, 3, -41 },
  { 4897, 31, 41, 34, 4, -41 },
  { 5056, 27, 41, 34, 4, -41 },
  { 5195, 27, 41, 34, 4, -41 },
  { 5334, 27, 41, 34, 3, -41 },
  { 5473, 30, 42, 34, 2, -41 },
  { 5631, 28, 41, 34, 4, -41 },
  { 5775, 32, 48, 34, 2, -41 },
  { 5967, 29, 41, 34, 4, -41 },
  { 6116, 30, 42, 34, 2, -41 },
  { 6274, 32, 41, 34, 1, -41 },
  { 6438, 28, 42, 34, 3, -41 },
  { 6585, 32, 41, 34, 1, -41 },
  { 6749, 33, 41, 34, 1, -41 },
  { 6919, 33, 41, 34, 1, -41 },
  { 7089, 33, 41, 34, 1, -41 },
  { 7259, 30, 41, 34, 2, -41 },
  { 7413, 13, 56, 34, 11, -47 },
  { 7504, 22, 44, 34, 7, -41 },
  { 7625, 13, 56, 34, 11, -47 },
  { 7716, 23, 22, 34, 6, -41 },
  { 7780, 26, 6, 34, 4, 0 },
  { 7800, 14, 8, 34, 11, -41 },
  { 7814, 28, 32, 34, 3, -31 },
  { 7926, 27, 44, 34, 4, -43 },
  { 8075, 27, 32, 34, 3, -31 },
  { 8183, 27, 44, 34, 3, -43 },
  { 8332, 28, 32, 34, 3, -31 },
  { 8444, 29, 44, 34, 3, -44 },
  { 8604, 27, 43, 34, 3, -31 },
  { 8750, 27, 43, 34, 4, -43 },
  { 8896, 25, 42, 34, 6, -42 },
  { 9028, 19, 54, 34, 6, -42 },
  { 9157, 29, 43, 34, 4, -43 },
  { 9313, 25, 43, 34, 6, -43 },
  { 9448, 30, 31, 34, 2, -31 },
  { 9565, 27, 31, 34, 4, -31 },
  { 9670, 28, 32, 34, 3, -31 },
  { 9782, 27, 43, 34, 4, -31 },
  { 9928, 27, 43, 34, 3, -31 },
  { 10074, 23, 31, 34, 8, -31 },
  { 10164, 28, 32, 34, 3, -31 },
  { 10276, 28, 38, 34, 3, -37 },
  { 10409, 27, 31, 34, 4, -30 },
  { 10514, 30, 30, 34, 2, -30 },
  { 10627, 32, 30, 34, 1, -30 },
  { 10747, 31, 30, 34, 2, -30 },
  { 10864, 33, 42, 34, 1, -30 },
  { 11038, 29, 30, 34, 3, -30 },
  { 11147, 18, 54, 34, 9, -44 },
  { 11269, 5, 52, 34, 15, -41 },
  { 11302, 19, 54, 34, 9, -44 },
  { 11431, 31, 12, 34, 1, -23 },
};

const GFXfont RobotoMono_Bold57pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold57pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOMONO_BOLD57PT7B_H_
