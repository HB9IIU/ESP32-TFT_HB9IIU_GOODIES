#ifndef _ROBOTOMONO_BOLD37PT7B_H_
#define _ROBOTOMONO_BOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold37pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1E,
  0x00, 0xF1, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE1,
  0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0xC7, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F,
  0xBF, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xF7, 0xC0, 0x3E, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF7, 0xC0,
  0x1F, 0xFC, 0x03, 0xEF, 0x80, 0xF9, 0xF8, 0x3F, 0x3F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xE7, 0x80, 0x0E, 0x3C, 0x38, 0x70, 0xE3, 0x83, 0x87, 0x1C, 0x1C, 0x79,
  0xC0, 0xF3, 0xCE, 0x07, 0xFC, 0xE0, 0x1F, 0xCF, 0x00, 0x3C, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC7,
  0xC0, 0x0E, 0xFF, 0x00, 0xE7, 0xFC, 0x07, 0x78, 0xE0, 0x73, 0xC7, 0x87,
  0x9E, 0x3C, 0x18, 0xF1, 0xE0, 0x07, 0x8E, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0,
  0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC3, 0xE7, 0xFE, 0x1F, 0x7E, 0xF8, 0xF3,
  0xE7, 0xE7, 0x9F, 0x1F, 0xFD, 0xF0, 0x7F, 0xEF, 0x81, 0xFE, 0x7E, 0x0F,
  0xF1, 0xF0, 0x3F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFE, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x70, 0x3C, 0x1E,
  0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xC0, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E,
  0x0F, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x81, 0xE0, 0x18, 0x38, 0x6F, 0xCC, 0x7F, 0xFF, 0x7F, 0x7F,
  0xFF, 0xC1, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0x78, 0x03, 0xCF,
  0x01, 0xE1, 0xE0, 0xF8, 0x7C, 0x1C, 0x0E, 0x02, 0x03, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E,
  0x79, 0xF0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x79,
  0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xF7, 0xE7, 0xE0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x8F, 0xFF, 0xDF, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xEF, 0x81, 0xF7, 0xC0, 0xF9, 0xF0, 0xFC, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x70, 0x1F, 0x0F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC,
  0x1F, 0x1F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0x7F, 0xBF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x03, 0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x86, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0x9F, 0x07, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x18, 0x0F, 0x9F, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F,
  0xFF, 0xEF, 0xC1, 0xFB, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xE1, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x7F, 0x1F, 0x07, 0xE7, 0xC0,
  0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0xBE,
  0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0xC1,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xC0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xF7, 0xF3, 0xE0, 0xFB, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0xFD, 0xFD, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xF7,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x7D, 0xFB, 0xFF, 0xFF,
  0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFD, 0xFF,
  0xFF, 0xF7, 0xC0, 0x3C, 0x7E, 0x7F, 0x7F, 0x7E, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0x60, 0x00, 0x01, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xFE,
  0x00, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xF7, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0,
  0x3C, 0x1C, 0x00, 0xE3, 0x81, 0x0E, 0x78, 0xFE, 0x77, 0x1F, 0xE7, 0x73,
  0xCE, 0x7E, 0x38, 0xE7, 0xE3, 0x8E, 0x7E, 0x70, 0xE7, 0xE7, 0x0E, 0x7E,
  0x70, 0xE7, 0xE7, 0x0E, 0x7E, 0x70, 0xC7, 0xE7, 0x1C, 0x6E, 0x7B, 0xEE,
  0xE3, 0xFF, 0xCF, 0x3E, 0xF8, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x02,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3C, 0x78, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F,
  0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0x80, 0xFD, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x7E, 0x7F, 0xFF,
  0x8F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3E, 0x07, 0xF7, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xE0,
  0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3F,
  0x7C, 0x03, 0xE7, 0xE0, 0x3E, 0x3F, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0x83, 0xF9, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xC0,
  0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x7E, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFB, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xBF, 0x9F,
  0x83, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF,
  0x01, 0xF7, 0xE0, 0x7C, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F,
  0xC0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x0F, 0x9F, 0x07, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFE, 0x00, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0x3E, 0x03, 0xF1, 0xF0,
  0x3F, 0x8F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x7E, 0x07,
  0xE1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x07,
  0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xC0,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFE, 0xEF, 0xFF, 0xFB, 0xFE, 0xFE, 0xFF, 0xBF, 0x3F, 0xEF, 0xCF, 0xFB,
  0xF3, 0xFE, 0x7C, 0xFF, 0x9E, 0x3F, 0xE7, 0x8F, 0xF8, 0xE3, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFE, 0xF1, 0xFF, 0xBC, 0x7F, 0xEF, 0x1F, 0xF9, 0xE7,
  0xFE, 0x79, 0xFF, 0x8F, 0x7F, 0xE3, 0xDF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xE0,
  0x7E, 0x3F, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8,
  0x1F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x87, 0xC0, 0xF8, 0xFC, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0xC0, 0xFC, 0x7E, 0x1F, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E,
  0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07,
  0xCF, 0x80, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x07, 0xEF,
  0x80, 0x3F, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xFB, 0xFC, 0xF8, 0x0F, 0xBF, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFB, 0xFF, 0xFE, 0x3F,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xBF,
  0x00, 0xFC, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x01, 0xF0, 0xF8, 0x1F,
  0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x07, 0xDF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x78, 0x7D, 0xE1, 0xE1, 0xF7, 0x87, 0x87, 0x9F,
  0x1E, 0x1E, 0x7C, 0x7C, 0x79, 0xF3, 0xF3, 0xE7, 0xCF, 0xCF, 0x8F, 0x3F,
  0x3E, 0x3C, 0xFC, 0xF8, 0xF3, 0xF3, 0xC3, 0xCF, 0xCF, 0x0F, 0xBF, 0xBC,
  0x3F, 0xFE, 0xF0, 0xFF, 0xBF, 0xC3, 0xFC, 0xFF, 0x07, 0xF3, 0xFC, 0x1F,
  0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xC7,
  0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0,
  0x07, 0xDF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00,
  0x7E, 0xF8, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xC0,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xC3, 0xE0,
  0x7E, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xEE, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x38, 0x3C, 0x78, 0x70,
  0xF1, 0xE0, 0xF3, 0xC1, 0xEF, 0x01, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0x9F, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF9,
  0xF8, 0x3E, 0xFC, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xF0, 0x7E, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0x9F, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF9, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xC3, 0xF7,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8, 0x3E, 0xFF,
  0xFF, 0x7F, 0xFF, 0x3D, 0xFF, 0x1E, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0x7B,
  0xE0, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x01, 0xF7, 0xC0, 0x79, 0xF8, 0x3E, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x07,
  0xCF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x1F, 0xDF, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x7F, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0x7C, 0x3F, 0x9F, 0x01, 0xF0, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0x1F, 0x9F, 0x81, 0xF7, 0xC0, 0x7F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x11, 0xF8, 0x0E, 0x3F, 0xFF, 0xC7, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xE7, 0xC3, 0xFD, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0x1F, 0xDF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D,
  0xF8, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0x9F, 0x00,
  0x07, 0xC0, 0x03, 0xF1, 0x80, 0xF8, 0xF8, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0xF8,
  0x7D, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x87, 0xEF, 0xFE, 0xFF,
  0xCF, 0xF8, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0xDF, 0x03, 0xF3, 0xE0, 0xFC, 0x7C, 0x3F, 0x0F, 0x8F, 0xC1, 0xF3,
  0xF0, 0x3E, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x81, 0xF1, 0xF8, 0x3E, 0x1F, 0x87, 0xC3,
  0xF0, 0xF8, 0x3F, 0x1F, 0x03, 0xF3, 0xE0, 0x7F, 0x7C, 0x07, 0xF0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xE3, 0x8F, 0xBF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFD, 0xF9, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1,
  0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F,
  0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8,
  0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF0, 0xF8, 0x79,
  0xFF, 0x3D, 0xFF, 0xDF, 0xFF, 0xEF, 0xE3, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0x3F, 0x9F, 0x03, 0xEF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7,
  0xC0, 0xFD, 0xF8, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F,
  0xE0, 0xF1, 0xF0, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xC7, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8, 0x7E, 0xFF,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0x7F, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x1F,
  0xDF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xFD, 0xF8,
  0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xBF, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFE, 0x7C, 0x0F, 0xDF, 0x01, 0xF7, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0x7E, 0x1F, 0xCF, 0xFF, 0xE1, 0xFF,
  0xF0, 0x1F, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFB, 0xE3, 0xF9, 0xF0, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7,
  0xE0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0xF8,
  0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0xF9, 0xF0, 0x07, 0x9E,
  0x00, 0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x78, 0x7B, 0xC3, 0xC3, 0xDE,
  0x1E, 0x3E, 0xF0, 0xF1, 0xF7, 0xCF, 0x8F, 0xBE, 0x7E, 0x78, 0xF3, 0xF3,
  0xC7, 0x9F, 0x9E, 0x3C, 0xFC, 0xF1, 0xE7, 0xE7, 0x8F, 0x77, 0x7C, 0x7B,
  0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xFC,
  0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x03, 0xEF, 0x80, 0xF9, 0xF8, 0x3F, 0x1F, 0x07, 0xC1, 0xF1, 0xF0, 0x3F,
  0x7E, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xEF, 0xC0, 0xF8,
  0xF8, 0x3F, 0x0F, 0x8F, 0xC1, 0xF9, 0xF0, 0x1F, 0x7C, 0x01, 0xF0, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xFC, 0x07, 0xE3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x1E, 0x03, 0xF0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x03,
  0xE0, 0xFE, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xE0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x0F, 0x80, 0xFC,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0,
  0x08, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x03, 0xCF, 0xFC, 0x1E, 0xFF, 0xF1,
  0xE7, 0x8F, 0xFF, 0x38, 0x3F, 0xFB, 0xC0, 0xFF, 0x80, 0x01, 0xF8,
};

const GFXglyph RobotoMono_Bold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 11, 10, 22, 5, -28 },
  { 35, 20, 26, 22, 1, -26 },
  { 100, 19, 35, 22, 2, -31 },
  { 184, 21, 27, 22, 1, -27 },
  { 255, 21, 27, 22, 1, -27 },
  { 326, 4, 10, 22, 8, -28 },
  { 331, 10, 37, 22, 6, -29 },
  { 378, 10, 37, 22, 6, -29 },
  { 425, 18, 18, 22, 3, -26 },
  { 466, 18, 19, 22, 2, -22 },
  { 509, 7, 11, 22, 6, -4 },
  { 519, 15, 4, 22, 5, -14 },
  { 527, 7, 6, 22, 8, -6 },
  { 533, 15, 28, 22, 4, -26 },
  { 586, 17, 27, 22, 3, -27 },
  { 644, 12, 26, 22, 3, -26 },
  { 683, 19, 27, 22, 1, -27 },
  { 748, 18, 27, 22, 2, -27 },
  { 809, 19, 26, 22, 1, -26 },
  { 871, 18, 26, 22, 2, -26 },
  { 930, 18, 27, 22, 2, -27 },
  { 991, 19, 26, 22, 1, -26 },
  { 1053, 18, 27, 22, 2, -27 },
  { 1114, 17, 27, 22, 2, -27 },
  { 1172, 7, 21, 22, 8, -21 },
  { 1191, 8, 28, 22, 8, -21 },
  { 1219, 16, 17, 22, 3, -20 },
  { 1253, 17, 12, 22, 3, -17 },
  { 1279, 16, 17, 22, 3, -20 },
  { 1313, 17, 27, 22, 3, -27 },
  { 1371, 20, 26, 22, 1, -26 },
  { 1436, 22, 26, 22, 0, -26 },
  { 1508, 19, 26, 22, 2, -26 },
  { 1570, 20, 27, 22, 1, -27 },
  { 1638, 19, 26, 22, 2, -26 },
  { 1700, 17, 26, 22, 3, -26 },
  { 1756, 17, 26, 22, 3, -26 },
  { 1812, 18, 27, 22, 2, -27 },
  { 1873, 18, 26, 22, 2, -26 },
  { 1932, 16, 26, 22, 3, -26 },
  { 1984, 18, 26, 22, 2, -26 },
  { 2043, 21, 26, 22, 2, -26 },
  { 2112, 17, 26, 22, 3, -26 },
  { 2168, 18, 26, 22, 2, -26 },
  { 2227, 18, 26, 22, 2, -26 },
  { 2286, 20, 27, 22, 1, -27 },
  { 2354, 18, 26, 22, 3, -26 },
  { 2413, 20, 32, 22, 2, -27 },
  { 2493, 20, 26, 22, 2, -26 },
  { 2558, 19, 27, 22, 2, -27 },
  { 2623, 22, 26, 22, 0, -26 },
  { 2695, 18, 26, 22, 2, -26 },
  { 2754, 21, 26, 22, 1, -26 },
  { 2823, 22, 26, 22, 0, -26 },
  { 2895, 21, 26, 22, 1, -26 },
  { 2964, 21, 26, 22, 1, -26 },
  { 3033, 19, 26, 22, 2, -26 },
  { 3095, 8, 37, 22, 7, -31 },
  { 3132, 15, 28, 22, 4, -26 },
  { 3185, 8, 37, 22, 7, -31 },
  { 3222, 15, 14, 22, 4, -26 },
  { 3249, 16, 4, 22, 3, 0 },
  { 3257, 9, 5, 22, 7, -27 },
  { 3263, 18, 20, 22, 2, -20 },
  { 3308, 17, 28, 22, 3, -28 },
  { 3368, 18, 20, 22, 2, -20 },
  { 3413, 18, 28, 22, 2, -28 },
  { 3476, 18, 20, 22, 2, -20 },
  { 3521, 19, 29, 22, 2, -29 },
  { 3590, 18, 28, 22, 2, -20 },
  { 3653, 17, 28, 22, 3, -28 },
  { 3713, 16, 27, 22, 4, -27 },
  { 3767, 12, 35, 22, 4, -27 },
  { 3820, 19, 28, 22, 3, -28 },
  { 3887, 16, 28, 22, 4, -28 },
  { 3943, 20, 20, 22, 1, -20 },
  { 3993, 17, 20, 22, 3, -20 },
  { 4036, 18, 20, 22, 2, -20 },
  { 4081, 17, 28, 22, 3, -20 },
  { 4141, 18, 28, 22, 2, -20 },
  { 4204, 15, 20, 22, 5, -20 },
  { 4242, 18, 20, 22, 2, -20 },
  { 4287, 18, 24, 22, 2, -24 },
  { 4341, 17, 20, 22, 3, -20 },
  { 4384, 20, 20, 22, 1, -20 },
  { 4434, 21, 20, 22, 0, -20 },
  { 4487, 19, 20, 22, 2, -20 },
  { 4535, 21, 28, 22, 1, -20 },
  { 4609, 19, 20, 22, 2, -20 },
  { 4657, 12, 36, 22, 6, -29 },
  { 4711, 3, 33, 22, 10, -26 },
  { 4724, 12, 36, 22, 6, -29 },
  { 4778, 21, 8, 22, 0, -15 },
};

const GFXfont RobotoMono_Bold37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold37pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_BOLD37PT7B_H_
