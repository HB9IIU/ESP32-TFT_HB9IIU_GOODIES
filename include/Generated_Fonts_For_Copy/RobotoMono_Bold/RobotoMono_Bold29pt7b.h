#ifndef _ROBOTOMONO_BOLD29PT7B_H_
#define _ROBOTOMONO_BOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold29pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00, 0x03,
  0xBF, 0xF7, 0x00, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1B, 0x8D, 0xC6,
  0x07, 0x18, 0x0E, 0x30, 0x1C, 0xE0, 0x31, 0xC0, 0x63, 0x80, 0xC6, 0x1F,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x18, 0xE0, 0x31, 0xC0, 0xE3, 0x01, 0xC6,
  0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x70, 0x18, 0xC0, 0x71, 0x80, 0xE3, 0x01,
  0xCE, 0x03, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xF0, 0x1F,
  0xF0, 0xFF, 0xE7, 0xCF, 0x9E, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0x87, 0xF8, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x0C, 0x73,
  0x8E, 0x39, 0x87, 0x1D, 0xC1, 0xDC, 0xC0, 0xFE, 0xE0, 0x3E, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0xC0, 0x19, 0xF8, 0x1D, 0xFE,
  0x0C, 0xE7, 0x0E, 0x63, 0x86, 0x39, 0xC0, 0x1C, 0xE0, 0x0F, 0xE0, 0x03,
  0xF0, 0x07, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xDE, 0x03, 0xC7, 0x01,
  0xE3, 0x80, 0xF1, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xF0, 0xE7, 0xFC, 0xF3, 0xDF, 0x7B, 0xC7, 0xB9, 0xE1, 0xFC, 0xF0,
  0x7E, 0x7C, 0x3E, 0x1F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFC, 0xF8, 0xFF, 0xEE,
  0xEE, 0xEE, 0x02, 0x06, 0x0F, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x70,
  0x70, 0x38, 0x38, 0x1C, 0x1E, 0x0F, 0x06, 0x40, 0x60, 0xF0, 0x38, 0x3C,
  0x1C, 0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x38, 0x78, 0xF0, 0x60,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x04, 0x38, 0x4E, 0x73, 0xBF,
  0xDF, 0x9F, 0xFE, 0x03, 0x80, 0x0F, 0x80, 0x3B, 0x80, 0xE7, 0x83, 0xC7,
  0x07, 0x0F, 0x02, 0x08, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x7B, 0xDE,
  0xF7, 0xB9, 0xDC, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF,
  0xF7, 0x80, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xF9, 0xE7, 0x87, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFD, 0xFF, 0xFE, 0xFF, 0xC7, 0xFC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0xC7, 0xDF, 0xFC, 0x7F, 0xC1, 0xFC, 0x00,
  0x00, 0x40, 0xF1, 0xFD, 0xFF, 0xFF, 0xFE, 0xFC, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0xF8, 0x7F,
  0xC0, 0xFF, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7,
  0x83, 0xCF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x0F, 0xF0, 0x1F,
  0x80, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x78, 0x0F, 0xF8, 0x3C,
  0xF0, 0x79, 0xFF, 0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xDE, 0x07, 0x3C, 0x1E,
  0x78, 0x38, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x07, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x20, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x20, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xDF, 0xFC, 0x7F, 0xE1, 0xFC, 0x00, 0x00,
  0xE0, 0x07, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFB, 0xF7, 0xC1, 0xEF, 0x03, 0xDE,
  0x03, 0xDC, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xF1, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x78, 0xF1, 0xFF, 0x07, 0xF0, 0xFF, 0xEF,
  0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xFF, 0xFE, 0xFF,
  0xE1, 0xFC, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x79,
  0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE0, 0xF7, 0x87, 0xDF, 0xFF,
  0x3F, 0xFC, 0x7E, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0xC1, 0xFE,
  0x07, 0xF0, 0x1F, 0x00, 0x73, 0xEF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x73, 0xEF, 0xFF, 0x78, 0x39, 0xF7, 0xDF, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x9E, 0x79, 0xE7, 0x9E, 0x73, 0x82, 0x00, 0x00,
  0x08, 0x01, 0xC0, 0x3E, 0x0F, 0xF1, 0xFF, 0x7F, 0xC3, 0xF0, 0x1F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x07, 0x00, 0x3F, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xE0, 0x1F, 0x07, 0xF9, 0xFF, 0x3F, 0xE1, 0xF8, 0x0F, 0x00, 0x40,
  0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0x3E, 0xF8, 0x7F, 0xC0, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0,
  0x07, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3C, 0x1C, 0x30, 0x0E, 0x73, 0xE6,
  0x67, 0xF6, 0xE7, 0x77, 0xCE, 0x67, 0xCC, 0x67, 0xCC, 0x66, 0xCC, 0x66,
  0xCC, 0x66, 0xCC, 0x66, 0xCF, 0xEC, 0xCF, 0xFC, 0xE3, 0x30, 0x70, 0x00,
  0x78, 0x20, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0E, 0xF0, 0x0F,
  0x38, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC3, 0x81, 0xE1, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x1E, 0x07, 0x9E, 0x03, 0xEF, 0x00,
  0xFF, 0x80, 0x78, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03,
  0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xFF, 0xF3, 0xFF, 0xC7,
  0xFF, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF1, 0xF3, 0xE7, 0x83, 0xEF, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x0F, 0x78, 0x1E, 0xF8, 0x78, 0xFF, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0xFC,
  0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x1E, 0xF0, 0xFB, 0xC7, 0xCF, 0xFF, 0x3F, 0xF0, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE7, 0xC3, 0xEF,
  0x03, 0xDE, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF8, 0x3C,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x00, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x7B, 0xC3, 0xEF, 0xFF, 0x1F, 0xF8,
  0x1F, 0xC0, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0,
  0xF1, 0xF0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8,
  0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x7F, 0xE1,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0xFE, 0xDF, 0xFB, 0xFF, 0xEF,
  0xBF, 0xBE, 0xFE, 0x7B, 0xF9, 0xCF, 0xE7, 0x3F, 0x9C, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3C, 0xF0, 0x7F,
  0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE,
  0x7F, 0xBB, 0xFD, 0xDF, 0xEF, 0xFF, 0x3F, 0xF9, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0x80, 0x07, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xCF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF,
  0xFE, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3E,
  0xFC, 0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78,
  0x1E, 0x78, 0x3E, 0x7C, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0x81, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D,
  0xE0, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1E, 0x3C, 0x3C, 0x7C, 0x78,
  0x78, 0xF0, 0xF9, 0xE0, 0xF3, 0xC1, 0xF7, 0x81, 0xEF, 0x03, 0xE0, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF1, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x07, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x1E, 0xF8, 0x3C, 0xFF, 0xF8, 0xFF,
  0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7B, 0xE3, 0xE7, 0xFF, 0x0F, 0xFC, 0x1F,
  0xC0, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F,
  0x01, 0xE7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF1, 0xC7,
  0xB8, 0xE3, 0xDC, 0x71, 0xEE, 0x3C, 0xF7, 0x9E, 0x7B, 0xCF, 0x39, 0xEF,
  0x9C, 0xF7, 0xCE, 0x7B, 0xEF, 0x1D, 0xF7, 0x8E, 0xDF, 0xC7, 0x6F, 0xE3,
  0xB7, 0xE1, 0xFB, 0xF0, 0xFC, 0xF8, 0x7E, 0x7C, 0x1E, 0x3E, 0x0F, 0x1F,
  0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE1, 0xC0, 0x78, 0x0F, 0xBE, 0x07, 0xCF,
  0x07, 0xC7, 0xC3, 0xC1, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x3D, 0xF0, 0x1E, 0x78, 0x1E, 0x3E, 0x1F, 0x0F, 0x0F, 0x07, 0xCF,
  0x81, 0xEF, 0x80, 0xF8, 0xF8, 0x07, 0xBC, 0x07, 0xDF, 0x03, 0xC7, 0x81,
  0xE3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0xFF, 0xFC, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0xBC, 0x39, 0xC3, 0x9C,
  0x70, 0xE7, 0x0E, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xF0,
  0xF0, 0xF0, 0x02, 0x00, 0xFF, 0x87, 0xFF, 0x3E, 0x7E, 0xF0, 0x78, 0x01,
  0xE0, 0x07, 0x8F, 0xFE, 0x7F, 0xFB, 0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0,
  0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xDF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x18, 0x3D, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF,
  0x87, 0xBC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xEF, 0x87, 0xBF, 0xFE, 0xFF, 0xF3, 0xDF, 0x80, 0x02, 0x00, 0xFF,
  0x0F, 0xFC, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0xFF, 0x87, 0xBF, 0xFC, 0xFF, 0xC3, 0xF8, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x31, 0xE7, 0xFF,
  0x7F, 0xFB, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3E, 0xFF, 0xF3, 0xFB, 0x8F, 0x9C, 0x03,
  0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0xF8, 0x7B, 0xC0, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x04, 0xF8, 0x39, 0xFF, 0xF3,
  0xFF, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x06, 0x00, 0xFE, 0xF7, 0xFF, 0xDF,
  0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF, 0xF3, 0xFF, 0xC7, 0xEF, 0x00, 0x78,
  0x81, 0xE7, 0x0F, 0x9F, 0xFC, 0x7F, 0xE0, 0x7F, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x08, 0x3D, 0xFC, 0xFF,
  0xFB, 0xFF, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0,
  0x07, 0x00, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x83, 0xC1, 0xE0, 0x60, 0x00, 0x01, 0xFE, 0xFF, 0x7F, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x1F, 0xFF, 0xFF, 0xBF, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3E, 0xF0, 0xF1, 0xE3,
  0xE3, 0xCF, 0x87, 0xBE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFB, 0xE1, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0xCF, 0x07, 0xDE, 0x07, 0xC0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x02, 0x11, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xFE, 0x71, 0xFC,
  0xE3, 0xF9, 0xC7, 0xF3, 0x8F, 0xE7, 0x1F, 0xCE, 0x3F, 0x9C, 0x7F, 0x38,
  0xFE, 0x71, 0xFC, 0xE3, 0xF9, 0xC7, 0x00, 0x83, 0xDF, 0xCF, 0xFF, 0xBF,
  0xFE, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x03, 0x80,
  0x1F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xDE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE7, 0xC3, 0xC7, 0xFF,
  0x07, 0xFE, 0x07, 0xF0, 0x01, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0,
  0x7B, 0xC1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x1E, 0xF8, 0xFB, 0xFF, 0xEF, 0xFF, 0x3D, 0xF8, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xFD, 0xDF, 0xFE,
  0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x87, 0xBF, 0xFC, 0xFF, 0xE3, 0xEF, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xEF, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFE, 0x2F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x00, 0xFF, 0x87, 0xFF,
  0x9E, 0x3E, 0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xE7, 0xFF, 0x07, 0xF8, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x87,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0x7F, 0xFD, 0xFE, 0xF3, 0xF3, 0xC0,
  0xF0, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3, 0xC1, 0xE3, 0xC3, 0xC7, 0x8F, 0x07,
  0x1E, 0x0F, 0x38, 0x1E, 0x70, 0x1D, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF1, 0xC7, 0xB8, 0xE3, 0x9C, 0x71, 0xCE,
  0x3C, 0xE7, 0xBE, 0x73, 0xDB, 0x78, 0xED, 0xBC, 0x76, 0xDC, 0x3B, 0x6E,
  0x1F, 0xBF, 0x0F, 0x8F, 0x87, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0xF8, 0x1F, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E, 0x78, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E,
  0x78, 0x3C, 0x3C, 0x7C, 0x3E, 0xF8, 0x1F, 0xF0, 0x0F, 0x78, 0x1F, 0x78,
  0x1E, 0x7C, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0E,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x80, 0xF0, 0x7C, 0x1C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x3E, 0x3E, 0x0F, 0x83, 0xF0,
  0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x70,
  0x3C, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81,
  0xE0, 0x7C, 0x1E, 0x3F, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0,
  0x70, 0x38, 0x3C, 0x3C, 0x1C, 0x00, 0x0C, 0x00, 0x3F, 0x07, 0x7F, 0x87,
  0x7F, 0xFF, 0xE1, 0xFE, 0xE0, 0xFE, 0x00, 0x30,
};

const GFXglyph RobotoMono_Bold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 9, 8, 17, 4, -22 },
  { 24, 15, 21, 17, 1, -21 },
  { 64, 14, 27, 17, 2, -24 },
  { 112, 17, 21, 17, 0, -21 },
  { 157, 17, 21, 17, 1, -21 },
  { 202, 4, 8, 17, 6, -22 },
  { 206, 8, 29, 17, 5, -23 },
  { 235, 8, 29, 17, 4, -23 },
  { 264, 15, 15, 17, 2, -21 },
  { 293, 15, 15, 17, 1, -17 },
  { 322, 5, 9, 17, 5, -3 },
  { 328, 12, 4, 17, 4, -11 },
  { 334, 5, 5, 17, 6, -5 },
  { 338, 12, 23, 17, 3, -21 },
  { 373, 13, 21, 17, 2, -21 },
  { 408, 10, 21, 17, 2, -21 },
  { 435, 14, 21, 17, 1, -21 },
  { 472, 15, 21, 17, 1, -21 },
  { 512, 15, 21, 17, 1, -21 },
  { 552, 13, 21, 17, 2, -21 },
  { 587, 15, 21, 17, 1, -21 },
  { 627, 14, 21, 17, 1, -21 },
  { 664, 13, 21, 17, 2, -21 },
  { 699, 14, 21, 17, 1, -21 },
  { 736, 6, 17, 17, 6, -17 },
  { 749, 6, 23, 17, 6, -17 },
  { 767, 13, 14, 17, 2, -16 },
  { 790, 14, 9, 17, 2, -13 },
  { 806, 13, 14, 17, 2, -16 },
  { 829, 14, 21, 17, 2, -21 },
  { 866, 16, 20, 17, 1, -20 },
  { 906, 17, 21, 17, 0, -21 },
  { 951, 15, 21, 17, 2, -21 },
  { 991, 15, 21, 17, 1, -21 },
  { 1031, 14, 21, 17, 2, -21 },
  { 1068, 14, 21, 17, 2, -21 },
  { 1105, 14, 21, 17, 2, -21 },
  { 1142, 15, 21, 17, 1, -21 },
  { 1182, 13, 21, 17, 2, -21 },
  { 1217, 12, 21, 17, 3, -21 },
  { 1249, 14, 21, 17, 2, -21 },
  { 1286, 16, 21, 17, 2, -21 },
  { 1328, 14, 21, 17, 2, -21 },
  { 1365, 14, 21, 17, 2, -21 },
  { 1402, 13, 21, 17, 2, -21 },
  { 1437, 15, 21, 17, 1, -21 },
  { 1477, 15, 21, 17, 2, -21 },
  { 1517, 16, 25, 17, 1, -21 },
  { 1567, 15, 21, 17, 2, -21 },
  { 1607, 15, 21, 17, 1, -21 },
  { 1647, 17, 21, 17, 0, -21 },
  { 1692, 14, 21, 17, 2, -21 },
  { 1729, 17, 21, 17, 0, -21 },
  { 1774, 17, 21, 17, 0, -21 },
  { 1819, 17, 21, 17, 0, -21 },
  { 1864, 17, 21, 17, 0, -21 },
  { 1909, 15, 21, 17, 1, -21 },
  { 1949, 6, 29, 17, 6, -24 },
  { 1971, 12, 23, 17, 3, -21 },
  { 2006, 6, 29, 17, 6, -24 },
  { 2028, 12, 11, 17, 3, -21 },
  { 2045, 13, 3, 17, 2, 0 },
  { 2050, 7, 4, 17, 6, -21 },
  { 2054, 14, 16, 17, 2, -16 },
  { 2082, 14, 22, 17, 2, -22 },
  { 2121, 13, 16, 17, 2, -16 },
  { 2147, 13, 22, 17, 2, -22 },
  { 2183, 14, 16, 17, 2, -16 },
  { 2211, 14, 22, 17, 2, -22 },
  { 2250, 14, 22, 17, 2, -16 },
  { 2289, 14, 22, 17, 2, -22 },
  { 2328, 13, 21, 17, 3, -21 },
  { 2363, 9, 27, 17, 3, -21 },
  { 2394, 15, 22, 17, 2, -22 },
  { 2436, 13, 22, 17, 3, -22 },
  { 2472, 15, 16, 17, 1, -16 },
  { 2502, 14, 16, 17, 2, -16 },
  { 2530, 15, 16, 17, 1, -16 },
  { 2560, 14, 22, 17, 2, -16 },
  { 2599, 13, 22, 17, 2, -16 },
  { 2635, 12, 16, 17, 4, -16 },
  { 2659, 14, 16, 17, 2, -16 },
  { 2687, 14, 19, 17, 2, -19 },
  { 2721, 14, 15, 17, 2, -15 },
  { 2748, 15, 15, 17, 1, -15 },
  { 2777, 17, 15, 17, 0, -15 },
  { 2809, 16, 15, 17, 1, -15 },
  { 2839, 16, 21, 17, 1, -15 },
  { 2881, 14, 15, 17, 2, -15 },
  { 2908, 10, 28, 17, 4, -23 },
  { 2943, 2, 27, 17, 8, -21 },
  { 2950, 9, 28, 17, 5, -23 },
  { 2982, 16, 7, 17, 0, -12 },
};

const GFXfont RobotoMono_Bold29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold29pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_BOLD29PT7B_H_
