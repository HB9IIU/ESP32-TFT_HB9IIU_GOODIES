#ifndef _ROBOTOMONO_BOLD17PT7B_H_
#define _ROBOTOMONO_BOLD17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x0F, 0xCE, 0x73, 0x9C, 0x80, 0x09, 0x06, 0x41, 0xB1,
  0xFF, 0x7F, 0xC4, 0x81, 0x23, 0xFE, 0xFF, 0x8D, 0x82, 0x60, 0x90, 0x08,
  0x08, 0x3E, 0x7F, 0x63, 0x63, 0x70, 0x3C, 0x1F, 0x07, 0xC3, 0xE3, 0x7F,
  0x3E, 0x08, 0x08, 0x78, 0x36, 0x4D, 0xB3, 0x68, 0x76, 0x01, 0x00, 0xC0,
  0x2E, 0x16, 0xCD, 0xB0, 0x6C, 0x0E, 0x3C, 0x3F, 0x19, 0x8C, 0xC7, 0xC1,
  0xC1, 0xE7, 0xBB, 0xCF, 0xE3, 0xBF, 0xCF, 0xF0, 0xFA, 0x80, 0x13, 0x66,
  0xCC, 0xCC, 0xCC, 0xCC, 0x46, 0x23, 0x10, 0x8C, 0x66, 0x33, 0x33, 0x33,
  0x33, 0x36, 0x6C, 0x80, 0x08, 0x04, 0x12, 0x5F, 0xF1, 0xC0, 0xA0, 0xD8,
  0xC6, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x6D, 0xBC,
  0xFF, 0xFC, 0x6F, 0x60, 0x0E, 0x18, 0x70, 0xC1, 0x87, 0x0C, 0x18, 0x70,
  0xC1, 0x86, 0x0C, 0x00, 0x3E, 0x7E, 0xE7, 0xE3, 0xE7, 0xEF, 0xF3, 0xE3,
  0xE3, 0xE7, 0x7E, 0x3C, 0x0D, 0xFF, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x7C, 0xFE, 0xC7, 0xC7, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xFF,
  0xFF, 0x7E, 0xFF, 0xC7, 0x03, 0x07, 0x3E, 0x3E, 0x03, 0x03, 0xC3, 0xFF,
  0x7E, 0x07, 0x03, 0x83, 0xC3, 0x61, 0xB1, 0x99, 0x8C, 0xC6, 0xFF, 0x81,
  0x80, 0xC0, 0x60, 0x7F, 0x7F, 0x60, 0x60, 0xFC, 0xFE, 0x27, 0x03, 0x03,
  0xE7, 0x7E, 0x3C, 0x1C, 0x3C, 0x70, 0xE0, 0xDE, 0xFE, 0xC7, 0xC3, 0xC3,
  0xE7, 0x7E, 0x3C, 0xFF, 0xFF, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x18,
  0x30, 0x30, 0x70, 0x7E, 0x7E, 0xE7, 0xC7, 0xE6, 0x7E, 0x7E, 0xC7, 0xC3,
  0xC7, 0xFF, 0x7E, 0x7C, 0x7E, 0xC7, 0xC3, 0xC3, 0xC7, 0xFF, 0x7B, 0x06,
  0x0E, 0x3C, 0x38, 0xDF, 0x80, 0x06, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x6C,
  0x03, 0x0F, 0x7C, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3E, 0x07, 0x0F, 0x7C, 0xF0, 0x80, 0x3E, 0x7F,
  0xE3, 0x03, 0x07, 0x0E, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x0F, 0x0C,
  0x66, 0x09, 0x3B, 0x5A, 0xF4, 0xBD, 0x2F, 0x4A, 0x5F, 0x90, 0x07, 0x20,
  0x78, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1B, 0x0E, 0xC3, 0x30, 0xFE, 0x7F,
  0x98, 0x66, 0x1F, 0x83, 0xFE, 0x7F, 0xB0, 0xD8, 0x7C, 0x37, 0xF3, 0xFD,
  0x87, 0xC3, 0xE1, 0xFF, 0xDF, 0xC0, 0x3E, 0x7F, 0xE3, 0xC3, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC3, 0xE3, 0x7F, 0x3E, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3E, 0x7F, 0xE3, 0xC3, 0xC0, 0xC0,
  0xCF, 0xCF, 0xC3, 0xE3, 0x7F, 0x3E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF,
  0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x63, 0xFF, 0xF0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xC3, 0xC7, 0xFE, 0x7C, 0xC3, 0xE3, 0xB1, 0x99, 0xCD, 0xC7, 0xC3,
  0xF1, 0xDC, 0xC6, 0x63, 0xB0, 0xF8, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE7, 0xE7, 0xF7, 0xFF, 0xDF,
  0xDB, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE3, 0xE3, 0xF3, 0xD3,
  0xDB, 0xDB, 0xCF, 0xCF, 0xC7, 0xC7, 0xC3, 0x3E, 0x3F, 0xB8, 0xD8, 0x6C,
  0x36, 0x1F, 0x0F, 0x86, 0xC3, 0x71, 0x9F, 0x87, 0x80, 0xFE, 0x7F, 0xB8,
  0xDC, 0x7E, 0x3F, 0x3B, 0xFD, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x3E,
  0x3F, 0xB8, 0xD8, 0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0x71, 0x9F, 0xC7,
  0xE0, 0x38, 0x08, 0xFE, 0x7F, 0xB0, 0xD8, 0x7C, 0x36, 0x3B, 0xF9, 0x9C,
  0xC6, 0x63, 0xB0, 0xD8, 0x70, 0x3E, 0x3F, 0xB8, 0xF8, 0x0F, 0x03, 0xE0,
  0x7C, 0x06, 0xC3, 0xE1, 0xDF, 0xC7, 0xC0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E, 0x3E, 0xE1, 0xD8,
  0x66, 0x19, 0xCE, 0x33, 0x8C, 0xC3, 0xB0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x30, 0xCC, 0xFB, 0x36, 0xCD, 0xB7, 0x6F, 0x9F, 0xE7, 0xF9, 0xEE, 0x7B,
  0x8C, 0xE3, 0x38, 0xCC, 0xE1, 0xDC, 0x63, 0x38, 0xEC, 0x1E, 0x03, 0x81,
  0xE0, 0x7C, 0x3B, 0x0C, 0xE7, 0x1B, 0x87, 0xE1, 0xDC, 0x63, 0x38, 0xCC,
  0x3B, 0x07, 0x81, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0x7F,
  0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x3F, 0xFF, 0xF0,
  0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEF, 0xF0, 0xC0, 0xC1, 0x83,
  0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xE0, 0xFF, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x30, 0x71, 0xE3, 0x64, 0xD8, 0xC0,
  0xFF, 0xFF, 0xE3, 0x7C, 0xFE, 0xC7, 0x07, 0x7F, 0xE7, 0xC7, 0xFF, 0x7B,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF,
  0xDE, 0x3E, 0x7F, 0xE3, 0xC0, 0xC0, 0xC0, 0xE3, 0x7F, 0x3E, 0x03, 0x03,
  0x03, 0x03, 0x7B, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x7B, 0x3E,
  0x7F, 0xE3, 0xC3, 0xFF, 0xC0, 0xE1, 0x7F, 0x3E, 0x0F, 0x8F, 0x86, 0x07,
  0x0F, 0xF7, 0xF8, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x3F,
  0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3B, 0x03, 0x67, 0xFE, 0x10,
  0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x10, 0x70, 0xE0, 0x0F, 0x9F, 0x0E, 0x1C, 0x38, 0x70, 0xE7, 0xFF,
  0xE0, 0x10, 0xC6, 0x07, 0xBC, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xFE, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x77, 0x73, 0xF1, 0xF0, 0xFC, 0x76, 0x3B,
  0x9C, 0xEE, 0x38, 0xF9, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE7, 0xFF, 0xE0, 0xFF, 0x7F, 0xB6, 0xDB, 0x7D, 0xBE, 0xDF, 0x6F, 0xB7,
  0xDB, 0x80, 0xDE, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3C,
  0x7E, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3E, 0xDE, 0xFF, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0x7B, 0x7F, 0xE3, 0xC3,
  0xC3, 0xC3, 0xE3, 0x7F, 0x7B, 0x03, 0x03, 0x03, 0xEF, 0xFF, 0xC7, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0x3E, 0x7F, 0xE3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF7,
  0x7E, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x38, 0x3F, 0x1F,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x7F, 0x7B, 0xC3, 0xE1, 0x99,
  0xCC, 0xC6, 0x61, 0xB0, 0xF0, 0x78, 0x18, 0x00, 0xCC, 0xFB, 0x36, 0xD9,
  0xB6, 0x7F, 0x9F, 0xE7, 0x38, 0xCC, 0x33, 0x00, 0xE3, 0xB3, 0x8D, 0x87,
  0x81, 0xC1, 0xE1, 0xD8, 0xCE, 0xE3, 0x80, 0xE1, 0xDC, 0x73, 0x18, 0xCE,
  0x3B, 0x06, 0xC1, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x00,
  0xFF, 0xFF, 0x0E, 0x0C, 0x18, 0x38, 0x70, 0xFF, 0xFF, 0x19, 0x8C, 0x63,
  0x19, 0x98, 0xE3, 0x8C, 0x63, 0x18, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0xC3,
  0x18, 0xC6, 0x31, 0xC7, 0x3B, 0x18, 0xC6, 0x33, 0x98, 0x30, 0x5F, 0x2C,
  0xF8, 0x1C,
};

const GFXglyph RobotoMono_Bold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 5, 5, 10, 2, -13 },
  { 8, 10, 12, 10, 0, -12 },
  { 23, 8, 16, 10, 1, -14 },
  { 39, 10, 12, 10, 0, -12 },
  { 54, 9, 12, 10, 1, -12 },
  { 68, 2, 5, 10, 4, -13 },
  { 70, 4, 17, 10, 3, -13 },
  { 79, 4, 17, 10, 3, -13 },
  { 88, 9, 8, 10, 1, -12 },
  { 97, 8, 9, 10, 1, -10 },
  { 106, 3, 5, 10, 3, -2 },
  { 108, 7, 2, 10, 2, -6 },
  { 110, 4, 3, 10, 3, -3 },
  { 112, 7, 13, 10, 2, -12 },
  { 124, 8, 12, 10, 1, -12 },
  { 136, 6, 12, 10, 1, -12 },
  { 145, 8, 12, 10, 1, -12 },
  { 157, 8, 12, 10, 1, -12 },
  { 169, 9, 12, 10, 0, -12 },
  { 183, 8, 12, 10, 1, -12 },
  { 195, 8, 12, 10, 1, -12 },
  { 207, 8, 12, 10, 1, -12 },
  { 219, 8, 12, 10, 1, -12 },
  { 231, 8, 12, 10, 1, -12 },
  { 243, 3, 10, 10, 4, -10 },
  { 247, 3, 13, 10, 4, -10 },
  { 252, 8, 8, 10, 1, -9 },
  { 260, 8, 6, 10, 1, -8 },
  { 266, 8, 8, 10, 1, -9 },
  { 274, 8, 12, 10, 1, -12 },
  { 286, 10, 12, 10, 0, -12 },
  { 301, 10, 12, 10, 0, -12 },
  { 316, 9, 12, 10, 1, -12 },
  { 330, 8, 12, 10, 1, -12 },
  { 342, 8, 12, 10, 1, -12 },
  { 354, 8, 12, 10, 1, -12 },
  { 366, 8, 12, 10, 1, -12 },
  { 378, 8, 12, 10, 1, -12 },
  { 390, 8, 12, 10, 1, -12 },
  { 402, 7, 12, 10, 2, -12 },
  { 413, 8, 12, 10, 1, -12 },
  { 425, 9, 12, 10, 1, -12 },
  { 439, 8, 12, 10, 1, -12 },
  { 451, 8, 12, 10, 1, -12 },
  { 463, 8, 12, 10, 1, -12 },
  { 475, 9, 12, 10, 1, -12 },
  { 489, 9, 12, 10, 1, -12 },
  { 503, 9, 14, 10, 1, -12 },
  { 519, 9, 12, 10, 1, -12 },
  { 533, 9, 12, 10, 1, -12 },
  { 547, 10, 12, 10, 0, -12 },
  { 562, 8, 12, 10, 1, -12 },
  { 574, 10, 12, 10, 0, -12 },
  { 589, 10, 12, 10, 0, -12 },
  { 604, 10, 12, 10, 0, -12 },
  { 619, 10, 12, 10, 0, -12 },
  { 634, 9, 12, 10, 1, -12 },
  { 648, 4, 17, 10, 3, -14 },
  { 657, 7, 13, 10, 2, -12 },
  { 669, 4, 17, 10, 3, -14 },
  { 678, 7, 6, 10, 2, -12 },
  { 684, 8, 2, 10, 1, 0 },
  { 686, 4, 2, 10, 3, -12 },
  { 687, 8, 9, 10, 1, -9 },
  { 696, 8, 13, 10, 1, -13 },
  { 709, 8, 9, 10, 1, -9 },
  { 718, 8, 13, 10, 1, -13 },
  { 731, 8, 9, 10, 1, -9 },
  { 740, 9, 13, 10, 1, -13 },
  { 755, 8, 13, 10, 1, -9 },
  { 768, 8, 13, 10, 1, -13 },
  { 781, 7, 13, 10, 2, -13 },
  { 793, 5, 17, 10, 2, -13 },
  { 804, 9, 13, 10, 1, -13 },
  { 819, 7, 13, 10, 2, -13 },
  { 831, 9, 9, 10, 1, -9 },
  { 842, 8, 9, 10, 1, -9 },
  { 851, 8, 9, 10, 1, -9 },
  { 860, 8, 12, 10, 1, -9 },
  { 872, 8, 12, 10, 1, -9 },
  { 884, 7, 9, 10, 2, -9 },
  { 892, 8, 9, 10, 1, -9 },
  { 901, 8, 11, 10, 1, -11 },
  { 912, 8, 9, 10, 1, -9 },
  { 921, 9, 9, 10, 1, -9 },
  { 932, 10, 9, 10, 0, -9 },
  { 944, 9, 9, 10, 1, -9 },
  { 955, 10, 13, 10, 0, -9 },
  { 972, 8, 9, 10, 1, -9 },
  { 981, 5, 16, 10, 3, -13 },
  { 991, 2, 15, 10, 4, -12 },
  { 995, 5, 16, 10, 3, -13 },
  { 1005, 10, 4, 10, 0, -7 },
};

const GFXfont RobotoMono_Bold17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold17pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_BOLD17PT7B_H_
