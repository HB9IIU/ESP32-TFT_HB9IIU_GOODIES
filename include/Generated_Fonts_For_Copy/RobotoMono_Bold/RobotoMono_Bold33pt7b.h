#ifndef _ROBOTOMONO_BOLD33PT7B_H_
#define _ROBOTOMONO_BOLD33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold33pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x80, 0x00, 0x03, 0x1E, 0xFF, 0xE7, 0x80, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x07, 0x0C, 0x01, 0xC7, 0x07, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC1, 0x87, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03,
  0x8E, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x18, 0x70, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7E, 0x3F, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF8, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0x9E, 0x20, 0xE3, 0x8E, 0x38, 0xE7, 0x0E,
  0x39, 0xC3, 0x9E, 0xE0, 0xFF, 0x30, 0x1F, 0x9C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x39, 0xF0, 0x0E, 0xFE, 0x07, 0x7F,
  0xC1, 0xDC, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x04, 0x71, 0xC0, 0x1E, 0x70,
  0x03, 0xF8, 0x00, 0x7E, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xF1, 0xE0, 0x1E,
  0x78, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0xC7, 0x9F, 0xFC, 0xF3, 0xCF, 0x9E, 0xF8, 0xFB, 0xDF, 0x0F, 0xF3, 0xE0,
  0xFE, 0x7C, 0x1F, 0x87, 0xC7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x01, 0x07, 0x0F, 0x1E, 0x1C, 0x3C,
  0x38, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E,
  0x0F, 0x07, 0x03, 0x40, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1C,
  0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1,
  0xC1, 0xE1, 0xE0, 0x40, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x06, 0x1C, 0x13, 0xCE, 0x79, 0xFF, 0xFF, 0x7F, 0xFE, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xDC, 0x01, 0xEF, 0x00, 0xE3, 0xC1, 0xF0, 0xF0, 0x70,
  0x70, 0x08, 0x10, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x7B, 0xDE, 0xF7, 0xBD, 0xEE, 0xF7, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x23, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x3E, 0x78,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB,
  0xDF, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0x78,
  0x1E, 0x7C, 0x3E, 0x7E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x01,
  0xC1, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xC7, 0xC3, 0xE7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x03, 0xC0, 0x1F, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFC, 0xF8, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0xFC,
  0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0x83, 0x83, 0xC3, 0xC1,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x3F, 0xFE, 0x3F, 0xFE,
  0x7F, 0xFE, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0xF8, 0x7E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0x7C, 0x7E,
  0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x30, 0x03, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0xC0,
  0xF7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x3E, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7E, 0x7E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xFC, 0x7C, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x78,
  0x3E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFC, 0x78,
  0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0xFC,
  0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xEF, 0xC7, 0xDF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0xC7, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F,
  0xEF, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC1, 0xFF, 0x03, 0xFE,
  0x07, 0xF0, 0x0F, 0x80, 0x11, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x47, 0xFF, 0xFF, 0xF7, 0x80, 0x10, 0xF9, 0xFB, 0xF7, 0xEF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0x8F, 0x1E, 0x78, 0xE0, 0x40, 0x00, 0x04, 0x00, 0x70, 0x0F, 0xC0,
  0xFF, 0x1F, 0xFD, 0xFF, 0x8F, 0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0xF3, 0xFF,
  0x3F, 0xF0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x7F,
  0xE1, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDE, 0x07, 0xFC, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x78,
  0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xF1,
  0xF0, 0xF0, 0x1C, 0x38, 0x03, 0x9C, 0x7E, 0x67, 0x3F, 0x9F, 0x8E, 0x67,
  0xE7, 0x19, 0xF9, 0xC6, 0x7C, 0xE3, 0x9F, 0x38, 0xE7, 0xCE, 0x39, 0xF3,
  0x8E, 0x6C, 0xE3, 0x9B, 0x9D, 0xEE, 0xE7, 0xFF, 0x38, 0xE7, 0x87, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x38, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07,
  0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3C, 0x03, 0xC3, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0xF8, 0x01, 0xF0, 0xFF, 0xF8, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0x07, 0xEF, 0x81, 0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0,
  0x1E, 0xF8, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7,
  0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xE1, 0xFB, 0xE0, 0x7D, 0xE0, 0x1E,
  0xF0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xDF,
  0x01, 0xEF, 0x81, 0xF3, 0xF3, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0xF8, 0xFC, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E,
  0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xE3, 0xE1, 0xFB, 0xE0, 0x7D, 0xF0, 0x1E, 0xF0, 0x0F, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDF, 0x01, 0xEF, 0xC0,
  0xF3, 0xF1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3E, 0xFC, 0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xF8, 0x0F,
  0xFE, 0x07, 0xEF, 0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F,
  0x9F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xCF, 0x83, 0xE3, 0xF0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0xBE, 0x03, 0xEF,
  0x80, 0x7C, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xF7, 0xEF, 0xF7, 0xEF, 0xF7, 0xEF, 0xF7, 0xCF, 0xF3, 0xCF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0x8F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFB, 0x9F, 0xFB, 0xDF, 0xF9, 0xDF,
  0xF9, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0x03, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x7D, 0xE0, 0x3E, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDF, 0x03,
  0xEF, 0x83, 0xE3, 0xF7, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0x07, 0xEF, 0x81, 0xF7, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0xFF,
  0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xE1, 0xF0,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0xFB,
  0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0x8F, 0x00, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC3,
  0xF7, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x80, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0x07, 0xEF, 0x81, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1E,
  0xF8, 0x0F, 0x7C, 0x0F, 0xBE, 0x3F, 0xDF, 0xFF, 0xCF, 0xFF, 0x87, 0xFF,
  0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x03, 0xEF, 0x81, 0xF7, 0xC0, 0x7F, 0xE0, 0x3E, 0x01, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x0F, 0x9F, 0x01, 0xE7, 0xC0, 0x7D,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x01,
  0xF7, 0x80, 0x7D, 0xF0, 0x1F, 0x7F, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7E,
  0x7E, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xFC, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x07, 0x83, 0xE0,
  0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0xF8, 0xF1, 0xEF, 0x1E, 0x3D, 0xE3, 0xC7, 0xBC, 0x78, 0xF7,
  0x8F, 0x1E, 0xF3, 0xE3, 0xDE, 0x7E, 0xF1, 0xEF, 0xDE, 0x3D, 0xFB, 0xC7,
  0xBF, 0x78, 0xF7, 0xEF, 0x1E, 0xFD, 0xE3, 0xFB, 0xBC, 0x7F, 0x3F, 0x8F,
  0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7C, 0x7E, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x7C, 0x03, 0xF3,
  0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF9, 0xF0,
  0x07, 0x9F, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7D,
  0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x7C, 0x3E,
  0x07, 0xC7, 0xE0, 0x3E, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xFF, 0x00, 0xF9,
  0xF0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x07, 0x87, 0x80,
  0xF9, 0xF0, 0x0F, 0x3C, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x73, 0x81, 0xCF, 0x0F, 0x1C, 0x38, 0x79, 0xE1, 0xE7, 0x83, 0xBC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0xF0, 0xF0,
  0xE0, 0x03, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0xF8, 0x3E, 0xF8,
  0x3E, 0x00, 0x1E, 0x01, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0xFC, 0x1E, 0xF8,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7E, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F,
  0x9F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF9, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xFE, 0x7E, 0xFF, 0xFE, 0xFF,
  0xFC, 0xF3, 0xF0, 0x03, 0xC0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xF7, 0xC3,
  0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x81, 0xEF, 0x03, 0xDF, 0x9F, 0x9F, 0xFE, 0x1F, 0xF8, 0x1F,
  0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x83, 0x8F, 0x1F, 0xDE, 0x7F, 0xFD, 0xFF, 0xFB, 0xE1, 0xFF,
  0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x83, 0xEF, 0xCF, 0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0xDE,
  0x03, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x04, 0x7F, 0x1E, 0x3F, 0xFF, 0x1F, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFC, 0x10, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x80,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7E, 0x7F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xDF, 0x00, 0x1F, 0x20, 0x1E, 0x30, 0x3E,
  0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xE0,
  0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC1, 0xF0, 0x7C, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xDF, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7F, 0xFE, 0xFF, 0xBF, 0xCF, 0xC0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x3F, 0x7C, 0x3F, 0x3E, 0x3F, 0x1F, 0x3F, 0x0F,
  0xBF, 0x07, 0xDF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0x7C, 0x1F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xF3, 0xE0, 0xF9, 0xF0,
  0x3E, 0xF8, 0x1F, 0x80, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0x8E, 0x7B, 0xEF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9E, 0x7F, 0x8F, 0x3F, 0xC7, 0x9F, 0xE3, 0xCF, 0xF1, 0xE7, 0xF8, 0xF3,
  0xFC, 0x79, 0xFE, 0x3C, 0xFF, 0x1E, 0x7F, 0x8F, 0x3F, 0xC7, 0x9F, 0xE3,
  0xCF, 0xF1, 0xE7, 0xF8, 0xF3, 0xC0, 0x00, 0xE0, 0xF3, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x7E, 0x7E,
  0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFE, 0x7E,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFB, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3F, 0xBC,
  0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xDF, 0x9F,
  0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF7, 0x9F, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1F, 0x78,
  0x1F, 0x78, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC2, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFE, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C,
  0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0x8F, 0xF8, 0x07, 0xDE, 0x03, 0xE7,
  0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0xE1,
  0xEF, 0x1E, 0x3D, 0xE3, 0xC7, 0xBC, 0x79, 0xE7, 0x9F, 0x3C, 0xF3, 0xE7,
  0x8E, 0x7E, 0xF1, 0xED, 0xDE, 0x3D, 0xBB, 0x87, 0xF7, 0x70, 0xFE, 0x6E,
  0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0x78,
  0x1F, 0x0F, 0x00, 0x7C, 0x0F, 0xCF, 0x83, 0xE1, 0xF1, 0xF0, 0x7C, 0xF8,
  0x0F, 0xBE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0x3E, 0x07, 0xC7, 0xC3, 0xE0,
  0xF1, 0xF0, 0x3E, 0xFC, 0x07, 0xC0, 0xF8, 0x07, 0xEF, 0x80, 0xF9, 0xF0,
  0x1E, 0x1E, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x07, 0x87, 0xC0, 0xF8,
  0xF0, 0x0F, 0x3E, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x78, 0x0F, 0x83, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x3F, 0x87, 0xC0, 0xF8,
  0x1F, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x0F, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xF8, 0x1F, 0x03, 0xE1, 0xFC, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC1, 0xF0, 0x1E, 0x03,
  0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x77, 0xFE, 0x1D, 0xEF, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1F, 0xE0, 0x01, 0xE0,
};

const GFXglyph RobotoMono_Bold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 23, 20, 7, -23 },
  { 19, 9, 9, 20, 5, -25 },
  { 30, 18, 23, 20, 1, -23 },
  { 82, 16, 30, 20, 2, -27 },
  { 142, 18, 24, 20, 1, -24 },
  { 196, 19, 24, 20, 1, -24 },
  { 253, 4, 9, 20, 7, -25 },
  { 258, 8, 33, 20, 6, -26 },
  { 291, 9, 33, 20, 5, -26 },
  { 329, 17, 16, 20, 2, -23 },
  { 363, 16, 17, 20, 2, -19 },
  { 397, 5, 11, 20, 6, -4 },
  { 404, 13, 3, 20, 5, -12 },
  { 409, 6, 6, 20, 7, -6 },
  { 414, 13, 25, 20, 4, -23 },
  { 455, 16, 24, 20, 2, -24 },
  { 503, 10, 23, 20, 3, -23 },
  { 532, 17, 24, 20, 1, -24 },
  { 583, 16, 24, 20, 2, -24 },
  { 631, 17, 23, 20, 1, -23 },
  { 680, 16, 23, 20, 2, -23 },
  { 726, 16, 24, 20, 2, -24 },
  { 774, 17, 23, 20, 1, -23 },
  { 823, 16, 24, 20, 2, -24 },
  { 871, 15, 24, 20, 2, -24 },
  { 916, 6, 19, 20, 7, -19 },
  { 931, 7, 26, 20, 7, -19 },
  { 954, 14, 16, 20, 3, -18 },
  { 982, 15, 10, 20, 3, -15 },
  { 1001, 14, 16, 20, 3, -18 },
  { 1029, 15, 24, 20, 3, -24 },
  { 1074, 18, 23, 20, 1, -23 },
  { 1126, 20, 23, 20, 0, -23 },
  { 1184, 17, 23, 20, 2, -23 },
  { 1233, 17, 24, 20, 1, -24 },
  { 1284, 16, 23, 20, 2, -23 },
  { 1330, 16, 23, 20, 2, -23 },
  { 1376, 16, 23, 20, 2, -23 },
  { 1422, 17, 24, 20, 1, -24 },
  { 1473, 16, 23, 20, 2, -23 },
  { 1519, 14, 23, 20, 3, -23 },
  { 1560, 16, 23, 20, 2, -23 },
  { 1606, 18, 23, 20, 2, -23 },
  { 1658, 16, 23, 20, 2, -23 },
  { 1704, 16, 23, 20, 2, -23 },
  { 1750, 16, 23, 20, 2, -23 },
  { 1796, 17, 24, 20, 1, -24 },
  { 1847, 17, 23, 20, 2, -23 },
  { 1896, 19, 28, 20, 1, -24 },
  { 1963, 17, 23, 20, 2, -23 },
  { 2012, 18, 24, 20, 1, -24 },
  { 2066, 19, 23, 20, 0, -23 },
  { 2121, 16, 23, 20, 2, -23 },
  { 2167, 19, 23, 20, 0, -23 },
  { 2222, 19, 23, 20, 0, -23 },
  { 2277, 20, 23, 20, 0, -23 },
  { 2335, 19, 23, 20, 1, -23 },
  { 2390, 18, 23, 20, 1, -23 },
  { 2442, 8, 32, 20, 6, -27 },
  { 2474, 13, 25, 20, 4, -23 },
  { 2515, 8, 32, 20, 6, -27 },
  { 2547, 14, 12, 20, 3, -23 },
  { 2568, 15, 4, 20, 2, 0 },
  { 2576, 7, 5, 20, 7, -24 },
  { 2581, 16, 18, 20, 2, -18 },
  { 2617, 16, 25, 20, 2, -25 },
  { 2667, 15, 18, 20, 2, -18 },
  { 2701, 15, 25, 20, 2, -25 },
  { 2748, 16, 18, 20, 2, -18 },
  { 2784, 17, 25, 20, 2, -25 },
  { 2838, 16, 25, 20, 2, -18 },
  { 2888, 16, 25, 20, 2, -25 },
  { 2938, 15, 24, 20, 3, -24 },
  { 2983, 10, 31, 20, 4, -24 },
  { 3022, 17, 25, 20, 2, -25 },
  { 3076, 15, 25, 20, 3, -25 },
  { 3123, 17, 18, 20, 1, -18 },
  { 3162, 16, 18, 20, 2, -18 },
  { 3198, 16, 18, 20, 2, -18 },
  { 3234, 16, 25, 20, 2, -18 },
  { 3284, 15, 25, 20, 2, -18 },
  { 3331, 13, 18, 20, 5, -18 },
  { 3361, 16, 18, 20, 2, -18 },
  { 3397, 16, 22, 20, 2, -22 },
  { 3441, 16, 17, 20, 2, -17 },
  { 3475, 18, 17, 20, 1, -17 },
  { 3514, 19, 17, 20, 0, -17 },
  { 3555, 18, 17, 20, 1, -17 },
  { 3594, 19, 24, 20, 1, -17 },
  { 3651, 16, 17, 20, 2, -17 },
  { 3685, 11, 32, 20, 5, -26 },
  { 3729, 2, 30, 20, 9, -23 },
  { 3737, 11, 32, 20, 5, -26 },
  { 3781, 18, 7, 20, 0, -13 },
};

const GFXfont RobotoMono_Bold33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold33pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_BOLD33PT7B_H_
