#ifndef _ROBOTOMONO_BOLD31PT7B_H_
#define _ROBOTOMONO_BOLD31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x00, 0x00,
  0x3D, 0xFF, 0xF8, 0xE3, 0xF8, 0xFE, 0x3F, 0x8E, 0xE3, 0xB8, 0xEE, 0x3B,
  0x8E, 0x03, 0x8C, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x38, 0xC1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03, 0x8C,
  0x01, 0xC6, 0x00, 0xC7, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x1C,
  0x60, 0x0C, 0x30, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFF, 0x03, 0xFF, 0x0F,
  0xFF, 0x3E, 0x1F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x01, 0xFF, 0x03, 0xDF, 0x0F, 0xBF, 0xFE, 0x3F, 0xF8, 0x1F,
  0xE0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x39,
  0xC4, 0x18, 0xE3, 0x8C, 0x71, 0x86, 0x39, 0xC3, 0x9C, 0xC1, 0xFC, 0xE0,
  0x7E, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x19,
  0xF8, 0x1D, 0xFC, 0x0C, 0xE7, 0x0E, 0xE3, 0x8E, 0x71, 0xC3, 0x38, 0xE0,
  0x0E, 0x70, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0xF9, 0xE0, 0x3C, 0x38, 0x0F, 0x0E, 0x03, 0xC7, 0x80, 0x7B, 0xC0,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x0E, 0x3F, 0xC7, 0x9E,
  0xF9, 0xEF, 0x9F, 0x7B, 0xC3, 0xFC, 0xF0, 0x7F, 0x3E, 0x1F, 0x8F, 0x87,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFB, 0xF0, 0xFF, 0xFF, 0xFF, 0x01,
  0x01, 0x81, 0xE1, 0xE1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1C, 0x0E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81,
  0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x3C, 0x0C, 0x02, 0x80,
  0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E,
  0x1C, 0x3C, 0x38, 0x78, 0xF0, 0xE0, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x61, 0x82, 0x79, 0x8E, 0xFF, 0xFF, 0x3F, 0xFE, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x1C, 0x78, 0x3C, 0x3C, 0x08,
  0x18, 0x00, 0x10, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF7, 0x9E, 0xF1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x79, 0xFF, 0xDF, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x9F, 0x1F, 0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC7,
  0xFF, 0x3F, 0xFD, 0xEF, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8,
  0x3D, 0xE0, 0xF7, 0xC7, 0xCF, 0xFE, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x83,
  0xCF, 0xFF, 0xFF, 0xFF, 0xBE, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x7C, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x78, 0x78, 0x70, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x3F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7F, 0xF0, 0xFF, 0xF3, 0xFF, 0xF1, 0x83, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xE1, 0xF3, 0xFF,
  0xC3, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE,
  0x07, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0xE0, 0xF7, 0xF1, 0xFF, 0xF3,
  0xFF, 0xF7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3D, 0xF0, 0x79, 0xF1, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF,
  0x9E, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0x78, 0x78, 0xFF,
  0xE1, 0xFE, 0x0F, 0xFC, 0x7E, 0xFB, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x87, 0xDF, 0xFE, 0x3F, 0xF8, 0x7F, 0x80, 0x0F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1E, 0xF0, 0x3D, 0xF0, 0xFB, 0xF3, 0xF3, 0xFF, 0xE3, 0xFF,
  0xC1, 0xE7, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x1F, 0xE0, 0x7F, 0x80,
  0xFE, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x9E, 0x79, 0xE7, 0x9E, 0x73, 0xCE, 0x10, 0x00, 0x04,
  0x00, 0x70, 0x0F, 0xC0, 0xFF, 0x0F, 0xF9, 0xFF, 0x8F, 0xF0, 0x3E, 0x00,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x70, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x01, 0xFC,
  0x3F, 0xF7, 0xFE, 0x3F, 0xE0, 0xFC, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0x83, 0xFF, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x87,
  0x81, 0xC3, 0x80, 0x73, 0x8F, 0x99, 0x8F, 0xED, 0xCE, 0x67, 0xE6, 0x33,
  0xE7, 0x19, 0xF3, 0x8C, 0xF9, 0xC6, 0x7C, 0xE3, 0x36, 0x71, 0x9B, 0x39,
  0xDD, 0xDF, 0xFC, 0xE7, 0xBC, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x86, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xEF, 0x00, 0x3D, 0xE0, 0x07,
  0xBC, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xF0, 0x3C,
  0x1E, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x80, 0xF0, 0xF0,
  0x1E, 0x3E, 0x03, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xC0, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF0, 0xFE, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x3E,
  0x3E, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3E, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07,
  0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x9F, 0xCF, 0x07, 0xDE, 0x07,
  0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xCF,
  0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x3E, 0x3E, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x3E, 0x1F, 0x3F, 0xFF, 0x1F,
  0xFE, 0x07, 0xF8, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xE1, 0xF3, 0xFF, 0xC3, 0xFF,
  0x03, 0xFC, 0x00, 0xF0, 0x1F, 0xF8, 0x1F, 0xBC, 0x0F, 0x9E, 0x0F, 0x8F,
  0x0F, 0x87, 0x87, 0xC3, 0xC7, 0xC1, 0xE7, 0xC0, 0xF7, 0xC0, 0x7B, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xEF, 0x83, 0xE7, 0xC1, 0xE1,
  0xF0, 0xF0, 0x7C, 0x78, 0x3E, 0x3C, 0x0F, 0x9E, 0x07, 0xEF, 0x01, 0xF7,
  0x80, 0x7C, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xEF, 0xBF, 0xDF, 0x7F, 0xBC, 0xFF, 0x39, 0xFE, 0x73, 0xFC, 0xC7,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xC0, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0x3F, 0xEE, 0x7F, 0xDE, 0xFF, 0x9D,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFE,
  0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xC7, 0xC7, 0xC1, 0xF3, 0xC0,
  0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0x78, 0x0F,
  0x3E, 0x0F, 0x8F, 0x8F, 0x87, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xF0, 0xFE, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E,
  0xF0, 0x1F, 0xF0, 0x1F, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xC3,
  0xE7, 0xC0, 0xF3, 0xC0, 0x7D, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3D,
  0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0x9F, 0x87, 0xC7, 0xFF, 0xE1, 0xFF,
  0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xF0, 0x79, 0xF1, 0xF3, 0xFF, 0xC3, 0xFF, 0x81, 0xFC, 0x00, 0xF8,
  0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x83,
  0xC3, 0xE0, 0xF0, 0x78, 0x7C, 0x1E, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0xF8, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0xF0, 0xE3, 0xDC, 0x38, 0xF7, 0x9E, 0x3D, 0xE7, 0x8F, 0x79, 0xE3,
  0xDE, 0x7C, 0xF7, 0x9F, 0x39, 0xE7, 0xDE, 0x39, 0xF7, 0x8E, 0xFD, 0xE3,
  0xFB, 0x78, 0xFE, 0xFE, 0x3F, 0xBF, 0x8F, 0xEF, 0xC3, 0xF3, 0xF0, 0x7C,
  0xFC, 0x1F, 0x3F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x1E,
  0x07, 0x87, 0x80, 0x7C, 0x07, 0xCF, 0x80, 0xF0, 0xF8, 0x3E, 0x0F, 0x07,
  0x81, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xE0, 0xF8, 0x3E,
  0x1F, 0x07, 0xC7, 0xC0, 0x7D, 0xF8, 0x0F, 0xC0, 0xF8, 0x03, 0xEF, 0x80,
  0xF8, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xE0, 0xF0, 0x3E, 0x3E, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF,
  0x80, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x81,
  0xDC, 0x0E, 0xE0, 0xF3, 0x87, 0x1C, 0x78, 0xF3, 0x83, 0x9C, 0x1D, 0xE0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3C, 0x1E, 0x0F, 0x03,
  0x00, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xCF, 0x87, 0xDE, 0x07, 0x80, 0x0F,
  0x07, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xDF,
  0x1F, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0xBE, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x70, 0x7B, 0xF8, 0xFF, 0xF9,
  0xFF, 0xFB, 0xE1, 0xF7, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0xF7, 0xE3, 0xEF, 0xFF, 0xDF, 0xFF,
  0x3C, 0xFC, 0x00, 0x03, 0x80, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x78, 0x7F,
  0xE0, 0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x0F,
  0xF8, 0x3D, 0xF1, 0xF7, 0xFF, 0x8F, 0xFE, 0x0F, 0xE0, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x63, 0xC7, 0xFF, 0x7F,
  0xFD, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xDF, 0x1F, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFB, 0xC0, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xDF,
  0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x8F, 0x87, 0x8F, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0xFE,
  0x03, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x3F, 0xBC, 0xFF,
  0xFB, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xEF, 0x8F, 0xDF, 0xFF, 0x9F,
  0xFF, 0x1F, 0xBE, 0x00, 0x7C, 0x80, 0xF1, 0x83, 0xE7, 0xFF, 0x8F, 0xFF,
  0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x30, 0x79, 0xFC, 0xF7, 0xFD, 0xFF, 0xFB, 0xE0, 0xFF,
  0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0x80, 0x03,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0xF0, 0x7C, 0x0F, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0x3F, 0xCF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xF7, 0xFB, 0xFE, 0xFF, 0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x7E, 0xF0, 0xFC,
  0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x7C,
  0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x0C, 0xF7,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0x00, 0xC1, 0xE7, 0xF3, 0xFF,
  0xF7, 0xFF, 0xEF, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1E, 0x07, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x87,
  0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFF, 0x83, 0xCF, 0x8F, 0x9F, 0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x01,
  0xC1, 0xEF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDE, 0x07, 0xBC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x83, 0xDF,
  0x8F, 0xBF, 0xFE, 0x7F, 0xFC, 0xF7, 0xF1, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0xFF, 0x77, 0xFF,
  0xDF, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3D, 0xF1, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F,
  0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0xF7, 0x9F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xF3, 0xE7, 0xEF,
  0x83, 0xFF, 0x07, 0xDE, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xDF, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x82, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xE0, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xF7, 0x87, 0xEF, 0xFF, 0xCF, 0xF7, 0x8F, 0xCF, 0xF8, 0x0F, 0xBC, 0x07,
  0x9E, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x78, 0x07, 0xBC, 0x03, 0xDC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0xF0, 0xE3, 0xDE, 0x78, 0xF7, 0x9E,
  0x39, 0xE7, 0x8E, 0x79, 0xE7, 0x9E, 0x7D, 0xE3, 0xBF, 0x78, 0xEF, 0xDC,
  0x3B, 0xB7, 0x0F, 0xCD, 0xC3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x1F, 0x07,
  0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x7C, 0x0F, 0x9E, 0x0F, 0x07, 0x8F,
  0x83, 0xEF, 0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xEF, 0x81, 0xE3, 0xE1, 0xF0, 0xF1,
  0xF0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xDE, 0x03, 0xE7, 0xC0, 0xF1, 0xF0,
  0x7C, 0x3C, 0x1E, 0x0F, 0x87, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x0F, 0x3C,
  0x03, 0xDE, 0x00, 0x77, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x81, 0xF0, 0x78, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x3F, 0x0F, 0x03, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0,
  0x1F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0xF0, 0x3C, 0x3F, 0x0F, 0x07,
  0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x83,
  0xE0, 0xF0, 0x00, 0x3F, 0x03, 0x3F, 0xE1, 0xDF, 0xF9, 0xEE, 0x3F, 0xFE,
  0x0F, 0xF0, 0x01, 0xF0,
};

const GFXglyph RobotoMono_Bold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 22, 19, 7, -22 },
  { 15, 10, 8, 19, 4, -23 },
  { 25, 17, 22, 19, 1, -22 },
  { 72, 15, 29, 19, 2, -26 },
  { 127, 17, 22, 19, 1, -22 },
  { 174, 18, 22, 19, 1, -22 },
  { 224, 3, 8, 19, 7, -23 },
  { 227, 9, 32, 19, 5, -25 },
  { 263, 8, 32, 19, 5, -25 },
  { 295, 16, 16, 19, 2, -22 },
  { 327, 16, 16, 19, 1, -18 },
  { 359, 6, 10, 19, 5, -4 },
  { 367, 13, 3, 19, 4, -11 },
  { 372, 6, 5, 19, 6, -5 },
  { 376, 13, 24, 19, 3, -22 },
  { 415, 14, 22, 19, 2, -22 },
  { 454, 9, 22, 19, 3, -22 },
  { 479, 16, 22, 19, 1, -22 },
  { 523, 16, 22, 19, 1, -22 },
  { 567, 16, 22, 19, 1, -22 },
  { 611, 15, 22, 19, 2, -22 },
  { 653, 15, 22, 19, 2, -22 },
  { 695, 16, 22, 19, 1, -22 },
  { 739, 14, 22, 19, 2, -22 },
  { 778, 15, 22, 19, 1, -22 },
  { 820, 5, 18, 19, 7, -18 },
  { 832, 6, 24, 19, 7, -18 },
  { 850, 14, 15, 19, 2, -17 },
  { 877, 15, 10, 19, 2, -14 },
  { 896, 14, 15, 19, 2, -17 },
  { 923, 15, 22, 19, 2, -22 },
  { 965, 17, 22, 19, 1, -22 },
  { 1012, 19, 22, 19, 0, -22 },
  { 1065, 16, 22, 19, 2, -22 },
  { 1109, 16, 22, 19, 1, -22 },
  { 1153, 15, 22, 19, 2, -22 },
  { 1195, 15, 22, 19, 2, -22 },
  { 1237, 15, 22, 19, 2, -22 },
  { 1279, 16, 22, 19, 1, -22 },
  { 1323, 15, 22, 19, 2, -22 },
  { 1365, 13, 22, 19, 3, -22 },
  { 1401, 15, 22, 19, 2, -22 },
  { 1443, 17, 22, 19, 2, -22 },
  { 1490, 15, 22, 19, 2, -22 },
  { 1532, 15, 22, 19, 2, -22 },
  { 1574, 15, 22, 19, 2, -22 },
  { 1616, 16, 22, 19, 1, -22 },
  { 1660, 16, 22, 19, 2, -22 },
  { 1704, 17, 26, 19, 1, -22 },
  { 1760, 16, 22, 19, 2, -22 },
  { 1804, 17, 22, 19, 1, -22 },
  { 1851, 18, 22, 19, 0, -22 },
  { 1901, 15, 22, 19, 2, -22 },
  { 1943, 18, 22, 19, 0, -22 },
  { 1993, 18, 22, 19, 0, -22 },
  { 2043, 19, 22, 19, 0, -22 },
  { 2096, 19, 22, 19, 0, -22 },
  { 2149, 16, 22, 19, 1, -22 },
  { 2193, 7, 31, 19, 6, -26 },
  { 2221, 12, 24, 19, 4, -22 },
  { 2257, 7, 31, 19, 6, -26 },
  { 2285, 13, 12, 19, 3, -22 },
  { 2305, 14, 3, 19, 2, 0 },
  { 2311, 8, 4, 19, 6, -22 },
  { 2315, 15, 17, 19, 2, -17 },
  { 2347, 15, 23, 19, 2, -23 },
  { 2391, 14, 17, 19, 2, -17 },
  { 2421, 14, 23, 19, 2, -23 },
  { 2462, 15, 17, 19, 2, -17 },
  { 2494, 15, 24, 19, 2, -24 },
  { 2539, 15, 23, 19, 2, -17 },
  { 2583, 15, 23, 19, 2, -23 },
  { 2627, 14, 23, 19, 3, -23 },
  { 2668, 10, 30, 19, 3, -23 },
  { 2706, 16, 23, 19, 2, -23 },
  { 2752, 14, 23, 19, 3, -23 },
  { 2793, 16, 17, 19, 1, -17 },
  { 2827, 15, 17, 19, 2, -17 },
  { 2859, 15, 17, 19, 2, -17 },
  { 2891, 15, 23, 19, 2, -17 },
  { 2935, 14, 23, 19, 2, -17 },
  { 2976, 13, 17, 19, 4, -17 },
  { 3004, 15, 17, 19, 2, -17 },
  { 3036, 15, 20, 19, 2, -20 },
  { 3074, 15, 16, 19, 2, -16 },
  { 3104, 17, 16, 19, 1, -16 },
  { 3138, 18, 16, 19, 0, -16 },
  { 3174, 17, 16, 19, 1, -16 },
  { 3208, 18, 23, 19, 1, -16 },
  { 3260, 15, 16, 19, 2, -16 },
  { 3290, 10, 29, 19, 5, -24 },
  { 3327, 3, 28, 19, 8, -22 },
  { 3338, 10, 29, 19, 5, -24 },
  { 3375, 17, 6, 19, 0, -12 },
};

const GFXfont RobotoMono_Bold31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold31pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_BOLD31PT7B_H_
