#ifndef _ROBOTOMONO_BOLD30PT7B_H_
#define _ROBOTOMONO_BOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x03, 0x1C, 0x07,
  0x1C, 0x07, 0x18, 0x07, 0x18, 0x06, 0x38, 0x06, 0x38, 0x7F, 0xFF, 0x7F,
  0xFF, 0x0E, 0x30, 0x0E, 0x70, 0x0C, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0xFF,
  0xFE, 0xFF, 0xFE, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38,
  0xC0, 0x39, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x01, 0xFF,
  0x07, 0xFF, 0x1F, 0xFF, 0x3C, 0x1E, 0x78, 0x3E, 0xF0, 0x3D, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7B, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x07, 0x9F, 0xFF, 0x1F, 0xFC,
  0x1F, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xC7, 0x10, 0xC7, 0x18, 0xC7, 0x38, 0xC7, 0x70, 0xFE, 0x60,
  0x7E, 0xE0, 0x18, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x3E,
  0x07, 0x7F, 0x06, 0xF7, 0x0E, 0xE3, 0x1C, 0xE3, 0x08, 0xE3, 0x00, 0xE7,
  0x00, 0x7F, 0x00, 0x3E, 0x01, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x79, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x7B, 0xDE, 0x3B, 0xE7, 0x9D,
  0xE3, 0xFE, 0xF0, 0xFF, 0x78, 0x3F, 0x3E, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFE, 0x7C, 0xFF, 0xFF, 0xFE, 0x01, 0x07, 0x0F, 0x0E, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E,
  0x1C, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xC0, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x06, 0x18, 0xEF, 0xB7, 0xFF, 0xFF, 0x87, 0xF8, 0x03,
  0xC0, 0x0F, 0xC0, 0x3B, 0x80, 0xE3, 0x83, 0xC7, 0x83, 0x06, 0x02, 0x08,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x39, 0xCE, 0x73, 0xBD, 0xEE,
  0xF1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0x78, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x7B, 0xE1, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFF, 0x3F, 0xFD, 0xEF, 0xFE, 0x3F, 0xF0, 0xFF, 0x83,
  0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xE7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F,
  0x80, 0x01, 0x87, 0xDF, 0xFF, 0xFF, 0xFF, 0x3E, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x03, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xDE, 0x07,
  0xBC, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xE7, 0x83, 0xCF, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0xF0, 0x1E, 0xF0, 0x3D, 0xF0, 0xFB, 0xFF, 0xE3, 0xFF, 0x81, 0xFE,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF,
  0x03, 0xDE, 0x07, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7,
  0x07, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1D, 0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0x8F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xE1,
  0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0x20, 0x1F, 0x80, 0xFE, 0x07,
  0xF8, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF7, 0xE3, 0xFF, 0xCF,
  0xFF, 0xBE, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0x03, 0x00, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0xF8, 0x7B, 0xC1, 0xEF,
  0x07, 0xBC, 0x1E, 0x78, 0x79, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xFB,
  0xE1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x87, 0x9F, 0xFE,
  0x7F, 0xF0, 0x7F, 0x80, 0x03, 0x80, 0x1F, 0xC0, 0xFF, 0xC1, 0xFF, 0xC7,
  0xC7, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x0F, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0,
  0xFB, 0xE3, 0xF3, 0xFF, 0xE7, 0xFF, 0x83, 0xEF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x01, 0xE0, 0x00, 0x79, 0xFF,
  0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xFF, 0x78, 0x3C,
  0xF9, 0xFB, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F,
  0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x1E, 0x08, 0x00, 0x00, 0x08, 0x03, 0xC0,
  0x7E, 0x1F, 0xF3, 0xFE, 0x7F, 0x83, 0xE0, 0x1F, 0x80, 0xFF, 0x80, 0xFF,
  0x81, 0xFE, 0x03, 0xF0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xC0, 0x3F, 0x07, 0xFC, 0xFF, 0x8F, 0xF8, 0x3F, 0x00, 0xF0, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x78, 0x7F, 0xE0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1E, 0x1C, 0x38,
  0x0E, 0x70, 0xC6, 0x63, 0xF3, 0xE7, 0xF3, 0xE6, 0x33, 0xCE, 0x33, 0xCE,
  0x73, 0xCC, 0x73, 0xCC, 0x73, 0xCC, 0x73, 0xCE, 0x66, 0xCF, 0xFE, 0xE7,
  0xBC, 0xE0, 0x10, 0x70, 0x00, 0x3C, 0x20, 0x1F, 0xF0, 0x0F, 0xE0, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7B, 0x80, 0x1E, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF1, 0xE0,
  0x38, 0x78, 0x1E, 0x1E, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0xFF,
  0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0x83, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x1E, 0xF0, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF,
  0xCF, 0xFE, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C,
  0x3E, 0x78, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x78,
  0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x87, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0x79, 0xE3, 0xF3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7,
  0xFF, 0xCF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01,
  0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x1F, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x3E,
  0x1F, 0x3F, 0xFF, 0x1F, 0xFE, 0x07, 0xF8, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xE3, 0xE7,
  0xFF, 0x9F, 0xFC, 0x1F, 0xC0, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0,
  0xF8, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x7F, 0xE1, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xB3, 0xFF, 0xFD,
  0xFF, 0xF7, 0xFF, 0xDF, 0xDE, 0x7F, 0x79, 0xFD, 0xE7, 0xF3, 0x1F, 0xCC,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1C, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFF, 0x3F, 0xDC, 0xFF, 0x7B, 0xFC, 0xEF, 0xF3, 0xBF,
  0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x3C, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E,
  0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1E,
  0x78, 0x1E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0xFF, 0xE1,
  0xFF, 0xF3, 0xFF, 0xF7, 0x83, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x01, 0x80, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3,
  0xE3, 0xC0, 0xF1, 0xE0, 0x7D, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xF0, 0x1E,
  0x78, 0x1E, 0x3C, 0x0F, 0x1F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C,
  0xF0, 0x3E, 0xF0, 0x1F, 0x00, 0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE,
  0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F,
  0xE0, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x87, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0xCF, 0x80,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0xF1, 0xE3, 0xDC, 0x78, 0xE7, 0x1E, 0x39, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0xDE, 0x3B, 0xF7, 0x0E, 0xFD, 0xC3,
  0xBF, 0x70, 0xFF, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x00, 0x7C, 0x07, 0xCF, 0x03, 0xE3, 0xE0, 0xF0, 0x78, 0x7C, 0x1F, 0x1E,
  0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFB, 0xC0, 0x3C,
  0xF8, 0x1F, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF9, 0xF0, 0x3E, 0xFC, 0x07,
  0xC0, 0xF8, 0x07, 0xDF, 0x01, 0xE3, 0xC0, 0xF8, 0xF8, 0x3C, 0x1E, 0x1F,
  0x07, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x07, 0xBC, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0,
  0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1D, 0xC3, 0x9C, 0x39, 0xE3,
  0x8E, 0x70, 0xE7, 0x07, 0xF0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0xF0, 0xF0, 0xF0, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBE, 0x1E, 0xF0,
  0x78, 0x01, 0xE0, 0x7F, 0x8F, 0xFE, 0x7F, 0xFB, 0xE1, 0xEF, 0x07, 0xBC,
  0x1E, 0xF0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xCF, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF8, 0xFF, 0xF3,
  0xFF, 0xEF, 0xCF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xFB, 0xFF, 0xCF, 0x7E,
  0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0x3E, 0xF8, 0x3F, 0xC0, 0xFF,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x0F, 0x78, 0x79,
  0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xCF, 0x3F, 0xFD, 0xFF, 0xFF, 0xCF,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFE, 0x1F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFB, 0xC0, 0x0F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xE3, 0xE3, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x47, 0xC3, 0x8F, 0xFF,
  0x8F, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3E, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x1F, 0xBC, 0xFF, 0xF7, 0xFF, 0xDF, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF,
  0xF3, 0xFF, 0xC7, 0xEF, 0x00, 0x3C, 0x81, 0xF3, 0x07, 0x9F, 0xFE, 0x7F,
  0xF0, 0x7F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0xF8, 0xF7, 0xFB, 0xFF, 0xEF, 0xC7, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x07, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0xFF, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x81, 0xF0, 0x7C,
  0x0E, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xBF, 0xEF, 0xF3, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x7E, 0xF0,
  0x78, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF0, 0x3F, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF7, 0xBC, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xF3, 0xDF, 0xEF, 0xFF, 0xBF, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF,
  0x9F, 0x3E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0xF7,
  0xE3, 0xFF, 0xCF, 0xFF, 0xBE, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xEF,
  0xFF, 0x3D, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x1F, 0xBC, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x7D, 0xFF, 0xF3, 0xFF, 0xC7, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0xBE, 0x1F,
  0xF0, 0x3F, 0xE0, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x3D, 0xFF, 0xF3, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x87, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x7D, 0xFF, 0xF3, 0xFF, 0xC7, 0xCF,
  0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xF1, 0xC3, 0xB8, 0xE3,
  0xDC, 0x79, 0xEF, 0x3C, 0xF7, 0x9E, 0x7B, 0xCF, 0x38, 0xEF, 0x9C, 0x77,
  0xEE, 0x3B, 0x77, 0x1D, 0x9F, 0x8E, 0xCF, 0x87, 0xE7, 0xC1, 0xF3, 0xE0,
  0xF1, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x78, 0x0F, 0x7C, 0x1E, 0x3E, 0x3E,
  0x1E, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1E, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E,
  0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0x9E, 0x03, 0xCF, 0x83, 0xE3, 0xC1,
  0xE1, 0xE1, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x07, 0xBC, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x83, 0xC3, 0xC1, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x8F, 0xC7, 0x83, 0xC1,
  0xF8, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0xC1, 0xF0, 0x7C, 0x7E, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x80, 0x1E, 0x00, 0x1F,
  0xC1, 0xDF, 0xF1, 0xEE, 0x7F, 0xEE, 0x0F, 0xF1, 0x03, 0xF0,
};

const GFXglyph RobotoMono_Bold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 21, 18, 7, -21 },
  { 12, 9, 8, 18, 4, -23 },
  { 21, 16, 21, 18, 1, -21 },
  { 63, 15, 28, 18, 2, -25 },
  { 116, 16, 22, 18, 1, -22 },
  { 160, 17, 22, 18, 1, -22 },
  { 207, 3, 8, 18, 7, -23 },
  { 210, 8, 31, 18, 5, -24 },
  { 241, 8, 31, 18, 5, -24 },
  { 272, 15, 15, 18, 2, -21 },
  { 301, 15, 16, 18, 1, -18 },
  { 331, 5, 10, 18, 5, -4 },
  { 338, 12, 3, 18, 4, -11 },
  { 343, 6, 5, 18, 6, -5 },
  { 347, 12, 23, 18, 3, -21 },
  { 382, 14, 22, 18, 2, -22 },
  { 421, 9, 21, 18, 3, -21 },
  { 445, 15, 22, 18, 1, -22 },
  { 487, 15, 22, 18, 1, -22 },
  { 529, 15, 21, 18, 1, -21 },
  { 569, 14, 21, 18, 2, -21 },
  { 606, 14, 22, 18, 2, -22 },
  { 645, 15, 21, 18, 1, -21 },
  { 685, 14, 22, 18, 2, -22 },
  { 724, 15, 22, 18, 1, -22 },
  { 766, 6, 17, 18, 6, -17 },
  { 779, 7, 23, 18, 6, -17 },
  { 800, 13, 14, 18, 2, -16 },
  { 823, 14, 10, 18, 2, -14 },
  { 841, 14, 14, 18, 2, -16 },
  { 866, 14, 22, 18, 2, -22 },
  { 905, 16, 21, 18, 1, -21 },
  { 947, 18, 21, 18, 0, -21 },
  { 995, 15, 21, 18, 2, -21 },
  { 1035, 16, 22, 18, 1, -22 },
  { 1079, 15, 21, 18, 2, -21 },
  { 1119, 15, 21, 18, 2, -21 },
  { 1159, 15, 21, 18, 2, -21 },
  { 1199, 16, 22, 18, 1, -22 },
  { 1243, 14, 21, 18, 2, -21 },
  { 1280, 12, 21, 18, 3, -21 },
  { 1312, 14, 21, 18, 2, -21 },
  { 1349, 16, 21, 18, 2, -21 },
  { 1391, 14, 21, 18, 2, -21 },
  { 1428, 14, 21, 18, 2, -21 },
  { 1465, 14, 21, 18, 2, -21 },
  { 1502, 16, 22, 18, 1, -22 },
  { 1546, 15, 21, 18, 2, -21 },
  { 1586, 17, 26, 18, 1, -22 },
  { 1642, 16, 21, 18, 2, -21 },
  { 1684, 16, 22, 18, 1, -22 },
  { 1728, 18, 21, 18, 0, -21 },
  { 1776, 14, 21, 18, 2, -21 },
  { 1813, 18, 21, 18, 0, -21 },
  { 1861, 18, 21, 18, 0, -21 },
  { 1909, 18, 21, 18, 0, -21 },
  { 1957, 18, 21, 18, 0, -21 },
  { 2005, 16, 21, 18, 1, -21 },
  { 2047, 6, 30, 18, 6, -25 },
  { 2070, 11, 23, 18, 4, -21 },
  { 2102, 6, 30, 18, 6, -25 },
  { 2125, 12, 11, 18, 3, -21 },
  { 2142, 14, 3, 18, 2, 0 },
  { 2148, 7, 4, 18, 6, -22 },
  { 2152, 14, 16, 18, 2, -16 },
  { 2180, 14, 23, 18, 2, -23 },
  { 2221, 14, 16, 18, 2, -16 },
  { 2249, 14, 23, 18, 2, -23 },
  { 2290, 15, 16, 18, 2, -16 },
  { 2320, 15, 23, 18, 2, -23 },
  { 2364, 14, 22, 18, 2, -16 },
  { 2403, 14, 23, 18, 2, -23 },
  { 2444, 13, 22, 18, 3, -22 },
  { 2480, 10, 28, 18, 3, -22 },
  { 2515, 16, 23, 18, 2, -23 },
  { 2561, 13, 23, 18, 3, -23 },
  { 2599, 16, 16, 18, 1, -16 },
  { 2631, 14, 16, 18, 2, -16 },
  { 2659, 14, 16, 18, 2, -16 },
  { 2687, 14, 22, 18, 2, -16 },
  { 2726, 14, 22, 18, 2, -16 },
  { 2765, 12, 16, 18, 4, -16 },
  { 2789, 14, 16, 18, 2, -16 },
  { 2817, 14, 20, 18, 2, -20 },
  { 2852, 14, 16, 18, 2, -16 },
  { 2880, 16, 16, 18, 1, -16 },
  { 2912, 17, 16, 18, 0, -16 },
  { 2946, 16, 16, 18, 1, -16 },
  { 2978, 17, 22, 18, 1, -16 },
  { 3025, 15, 16, 18, 2, -16 },
  { 3055, 9, 28, 18, 5, -23 },
  { 3087, 2, 27, 18, 8, -21 },
  { 3094, 10, 28, 18, 5, -23 },
  { 3129, 17, 6, 18, 0, -12 },
};

const GFXfont RobotoMono_Bold30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold30pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_BOLD30PT7B_H_
