#ifndef _ROBOTOMONO_BOLD38PT7B_H_
#define _ROBOTOMONO_BOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF0, 0x00, 0x00, 0x07, 0xDF, 0xFD, 0xF7, 0xC0, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF,
  0x0E, 0x01, 0xE3, 0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x38, 0x70, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x0F, 0xC7, 0xC0, 0xFD, 0xF8, 0x0F, 0xBF,
  0x01, 0xF7, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF8,
  0x1F, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xC7, 0x86, 0x0E, 0x1C, 0x38, 0x70, 0xE3,
  0x83, 0x87, 0x1C, 0x1C, 0x79, 0xC0, 0xFF, 0xCE, 0x03, 0xFC, 0xE0, 0x0F,
  0xC7, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC7, 0xE0, 0x0E, 0x7F, 0x80, 0xE7, 0xFE, 0x07,
  0x38, 0xF0, 0x71, 0xC3, 0x87, 0x8E, 0x1C, 0x18, 0x70, 0xE0, 0x03, 0x8F,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x3C,
  0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7E, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x07, 0x8F, 0xFE, 0x1E, 0x7E, 0xFC, 0x79, 0xF1, 0xFB, 0xE7, 0xC7, 0xEF,
  0xBF, 0x0F, 0xFC, 0xFC, 0x1F, 0xF3, 0xF0, 0x3F, 0x87, 0xE0, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x8F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x38, 0x0F, 0x83, 0xE0, 0x78,
  0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x1C, 0x01, 0x80, 0x40, 0x38,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78,
  0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xC0,
  0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x81, 0xC0,
  0x9E, 0x38, 0xF7, 0xF7, 0x7E, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0E, 0x78, 0x03, 0xC7, 0x80, 0xF0, 0xF0,
  0x3E, 0x0F, 0x03, 0x81, 0xC0, 0x10, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7B, 0xEF, 0x38,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xFF, 0xFF,
  0xFF, 0xEF, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF7, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x9F, 0xFF, 0xDF, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFD, 0xF0, 0x7C, 0xFF,
  0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x0F, 0x07,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0,
  0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0xBF, 0x03, 0xFF, 0x80, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFD, 0xFF, 0xFE,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0xF8,
  0xF8, 0x0F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x78,
  0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x3C, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x8F, 0xE0, 0x80,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0x03, 0xF7, 0xE0, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x3F, 0x0F, 0xBF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x87, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFC, 0x07, 0xDF, 0x03, 0xF7, 0xE1, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F, 0x03, 0xE7,
  0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xE1, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xF1, 0xFC, 0x7E, 0x7C, 0x0F,
  0xBF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xE1, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x07,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0xBF, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x0F, 0xDF, 0x87, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xF7, 0xC3, 0xFB, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x00,
  0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0xF8, 0x70, 0x20,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE0, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0xC1,
  0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0x07, 0x81,
  0xE0, 0x0E, 0x1E, 0x00, 0x38, 0xE1, 0xF1, 0xCE, 0x1F, 0xEE, 0x71, 0xFE,
  0x33, 0x9E, 0x71, 0xF8, 0xE3, 0x8F, 0xC7, 0x1C, 0x7E, 0x78, 0xE3, 0xF3,
  0x87, 0x1F, 0x9C, 0x38, 0xDC, 0xE1, 0xC6, 0xE7, 0x0E, 0x77, 0x3C, 0x73,
  0xB9, 0xFF, 0xB9, 0xC7, 0xFF, 0xCF, 0x1E, 0x7C, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x40, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xDF,
  0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x1E, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xF8, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x07, 0xE3,
  0xE0, 0x3F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x1F, 0x7E, 0x01, 0xF3, 0xE0, 0x3F, 0x3F, 0x07, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xC7, 0xF9, 0xF8, 0x3F, 0x3F, 0x03, 0xF7,
  0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xEF, 0xC0, 0xFD, 0xF8, 0x3F, 0x3F,
  0x0F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7,
  0xE0, 0xFC, 0xF8, 0x0F, 0xBF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x81, 0xF9, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03,
  0xF7, 0xE1, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1,
  0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFE, 0x07,
  0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0x7E, 0x07, 0xF3, 0xF0, 0x3F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x3F,
  0x9F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0x77, 0x7F,
  0xEF, 0xEF, 0xFD, 0xFD, 0xFF, 0xBF, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF,
  0xCF, 0x1F, 0xF8, 0xE3, 0xFF, 0x1C, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFD, 0xE7, 0xFF, 0x79,
  0xFF, 0xCF, 0x7F, 0xF3, 0xDF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7C, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x0F, 0xE3, 0xE0, 0x7E, 0x7E, 0x03, 0xF7,
  0xC0, 0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xE0,
  0x7E, 0x3F, 0x0F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0x81, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0x81, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xE0, 0xFC, 0x3E, 0x03, 0xE3, 0xF0,
  0x1F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x1F, 0xEF, 0xC0, 0x7E, 0xFC, 0x03,
  0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0,
  0x7E, 0xFC, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xC3, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x8F,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF,
  0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x7E, 0x07,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x7C,
  0x07, 0xDF, 0x03, 0xF7, 0xE0, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0x7F, 0xC0, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0xF8, 0x78, 0x3D, 0xE1, 0xE1, 0xF7, 0xC7, 0xC7, 0xDF, 0x1F,
  0x1F, 0x7C, 0x7C, 0x7D, 0xF1, 0xF1, 0xF7, 0xC7, 0xC7, 0x8F, 0x3F, 0x1E,
  0x3C, 0xFC, 0x78, 0xF3, 0xFB, 0xE3, 0xEF, 0xEF, 0x8F, 0xBF, 0xBE, 0x3E,
  0xEE, 0xF8, 0xFB, 0xBB, 0xE3, 0xFE, 0xEF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF,
  0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0,
  0x7F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x00, 0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0xFC,
  0x03, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0xFC, 0x7E,
  0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xFC, 0x0F,
  0x81, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00,
  0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E,
  0xF0, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x78,
  0x1E, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xF1, 0xFD, 0xFE, 0x7C, 0x0F, 0x9F, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x0F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF,
  0x7C, 0x7F, 0x9F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x07, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xFC, 0x1F, 0xBF,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0xDF, 0x01, 0xF7, 0xC0,
  0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x3F, 0x3F, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC3, 0xF9, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0x83, 0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F,
  0x7E, 0x0F, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xE7, 0xC0,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC,
  0xF8, 0x0F, 0x9F, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x43,
  0xF8, 0x1C, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xF3, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7E, 0x0F, 0xDF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x3F, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xF1, 0x80,
  0xFC, 0xF8, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xC0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x7F, 0x0F, 0xBF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x04, 0x00,
  0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x7F, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x03, 0xFB, 0xE0, 0xFE, 0x7C, 0x1F,
  0x8F, 0x87, 0xE1, 0xF1, 0xF8, 0x3E, 0x7E, 0x07, 0xDF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xF9, 0xF8,
  0x3E, 0x3F, 0x07, 0xC3, 0xF0, 0xF8, 0x3F, 0x1F, 0x07, 0xF3, 0xE0, 0x7E,
  0x7C, 0x07, 0xEF, 0x80, 0x7E, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFB, 0xF7, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF9, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8,
  0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F,
  0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8,
  0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF1, 0xFC, 0x3C,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x1F, 0xBE, 0x03, 0xEF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xFB, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFC, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xBE,
  0x03, 0xEF, 0x80, 0xFB, 0xF0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xE3, 0xEF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0xF7, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7E, 0x0F, 0xDF, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x3F, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0x9F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xF8, 0xFF, 0xF9, 0xFF, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F,
  0x8F, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x00, 0x0B, 0xF8, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0xFB, 0xE0, 0x3E, 0x7F, 0x1F, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFC, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7F,
  0xFF, 0xBF, 0xFF, 0xCF, 0xF9, 0xE3, 0xF8, 0xF0, 0xFC, 0x01, 0xF7, 0xC0,
  0x1F, 0x7E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x00,
  0x79, 0xF0, 0x07, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x78,
  0x7D, 0xE1, 0xE1, 0xF7, 0xC7, 0x87, 0x9F, 0x1F, 0x1E, 0x7C, 0x7C, 0x79,
  0xF3, 0xF3, 0xE3, 0xCF, 0xCF, 0x8F, 0x3F, 0x3E, 0x3C, 0xFE, 0xF0, 0xF3,
  0xBB, 0xC3, 0xEE, 0xEF, 0x07, 0xF3, 0xBC, 0x1F, 0xCE, 0xF0, 0x7F, 0x3F,
  0xC1, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x80,
  0xF8, 0x7E, 0x03, 0xE0, 0xF0, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x3E, 0x0F,
  0xC3, 0xF0, 0xF8, 0x1F, 0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0x9F, 0x01, 0xF1, 0xF8, 0x3F, 0x0F, 0xC7,
  0xE0, 0x7C, 0x7C, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03,
  0xE7, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x20, 0x0F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0,
  0x7F, 0x0F, 0xE0, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0x03,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0x01, 0xDF, 0xFC, 0x1E, 0xFF, 0xF9, 0xF7, 0x8F, 0xFF,
  0xB8, 0x1F, 0xFB, 0xC0, 0x7F, 0x80, 0x00, 0xF8,
};

const GFXglyph RobotoMono_Bold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 27, 23, 8, -27 },
  { 22, 12, 10, 23, 5, -29 },
  { 37, 20, 27, 23, 1, -27 },
  { 105, 19, 35, 23, 2, -31 },
  { 189, 21, 27, 23, 1, -27 },
  { 260, 22, 27, 23, 1, -27 },
  { 335, 4, 11, 23, 8, -29 },
  { 341, 11, 38, 23, 6, -30 },
  { 394, 10, 38, 23, 6, -30 },
  { 442, 19, 19, 23, 3, -27 },
  { 488, 18, 19, 23, 2, -22 },
  { 531, 6, 13, 23, 7, -5 },
  { 541, 16, 4, 23, 5, -14 },
  { 549, 7, 6, 23, 8, -6 },
  { 555, 15, 29, 23, 4, -27 },
  { 610, 17, 27, 23, 3, -27 },
  { 668, 12, 27, 23, 3, -27 },
  { 709, 19, 27, 23, 1, -27 },
  { 774, 18, 27, 23, 2, -27 },
  { 835, 20, 27, 23, 1, -27 },
  { 903, 18, 27, 23, 2, -27 },
  { 964, 18, 27, 23, 2, -27 },
  { 1025, 19, 27, 23, 1, -27 },
  { 1090, 18, 27, 23, 2, -27 },
  { 1151, 18, 27, 23, 2, -27 },
  { 1212, 7, 21, 23, 8, -21 },
  { 1231, 8, 29, 23, 8, -21 },
  { 1260, 16, 17, 23, 3, -20 },
  { 1294, 17, 13, 23, 3, -18 },
  { 1322, 17, 17, 23, 3, -20 },
  { 1359, 17, 27, 23, 3, -27 },
  { 1417, 21, 27, 23, 1, -27 },
  { 1488, 22, 27, 23, 1, -27 },
  { 1563, 20, 27, 23, 2, -27 },
  { 1631, 20, 27, 23, 1, -27 },
  { 1699, 19, 27, 23, 2, -27 },
  { 1764, 18, 27, 23, 3, -27 },
  { 1825, 18, 27, 23, 3, -27 },
  { 1886, 19, 27, 23, 2, -27 },
  { 1951, 18, 27, 23, 2, -27 },
  { 2012, 15, 27, 23, 4, -27 },
  { 2063, 18, 27, 23, 2, -27 },
  { 2124, 21, 27, 23, 2, -27 },
  { 2195, 18, 27, 23, 3, -27 },
  { 2256, 19, 27, 23, 2, -27 },
  { 2321, 18, 27, 23, 2, -27 },
  { 2382, 20, 27, 23, 1, -27 },
  { 2450, 19, 27, 23, 3, -27 },
  { 2515, 21, 32, 23, 2, -27 },
  { 2599, 20, 27, 23, 2, -27 },
  { 2667, 20, 27, 23, 2, -27 },
  { 2735, 22, 27, 23, 0, -27 },
  { 2810, 18, 27, 23, 2, -27 },
  { 2871, 21, 27, 23, 1, -27 },
  { 2942, 22, 27, 23, 0, -27 },
  { 3017, 22, 27, 23, 1, -27 },
  { 3092, 22, 27, 23, 1, -27 },
  { 3167, 19, 27, 23, 2, -27 },
  { 3232, 9, 37, 23, 7, -31 },
  { 3274, 15, 29, 23, 4, -27 },
  { 3329, 9, 37, 23, 7, -31 },
  { 3371, 16, 14, 23, 4, -27 },
  { 3399, 17, 4, 23, 3, 0 },
  { 3408, 9, 5, 23, 8, -27 },
  { 3414, 18, 20, 23, 2, -20 },
  { 3459, 18, 29, 23, 3, -29 },
  { 3525, 18, 20, 23, 2, -20 },
  { 3570, 18, 29, 23, 2, -29 },
  { 3636, 19, 20, 23, 2, -20 },
  { 3684, 19, 29, 23, 2, -29 },
  { 3753, 18, 28, 23, 2, -20 },
  { 3816, 18, 29, 23, 3, -29 },
  { 3882, 16, 28, 23, 4, -28 },
  { 3938, 12, 36, 23, 4, -28 },
  { 3992, 19, 29, 23, 3, -29 },
  { 4061, 17, 29, 23, 4, -29 },
  { 4123, 20, 20, 23, 1, -20 },
  { 4173, 18, 20, 23, 3, -20 },
  { 4218, 19, 20, 23, 2, -20 },
  { 4266, 18, 28, 23, 3, -20 },
  { 4329, 18, 28, 23, 2, -20 },
  { 4392, 16, 20, 23, 5, -20 },
  { 4432, 19, 20, 23, 2, -20 },
  { 4480, 18, 25, 23, 2, -25 },
  { 4537, 17, 20, 23, 3, -20 },
  { 4580, 20, 20, 23, 1, -20 },
  { 4630, 22, 20, 23, 0, -20 },
  { 4685, 20, 20, 23, 2, -20 },
  { 4735, 22, 28, 23, 1, -20 },
  { 4812, 19, 20, 23, 2, -20 },
  { 4860, 12, 37, 23, 6, -30 },
  { 4916, 3, 35, 23, 10, -27 },
  { 4930, 13, 37, 23, 6, -30 },
  { 4991, 21, 8, 23, 0, -15 },
};

const GFXfont RobotoMono_Bold38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold38pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_BOLD38PT7B_H_
