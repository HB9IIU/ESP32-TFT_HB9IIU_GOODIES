#ifndef _ROBOTOMONO_BOLD39PT7B_H_
#define _ROBOTOMONO_BOLD39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xE0, 0x00, 0x00, 0x02, 0x3E, 0xFF, 0xFF, 0xFE, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80,
  0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03,
  0xC3, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x07, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0x8F, 0xE3, 0xE0, 0x7E, 0x3E, 0x03, 0xE7, 0xE0, 0x3F, 0x7E, 0x03, 0xF3,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0,
  0x7E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3C, 0xF0, 0x40, 0xE1, 0xC3, 0xC3, 0x87,
  0x8E, 0x0E, 0x1E, 0x78, 0x38, 0x71, 0xC0, 0xF3, 0xCF, 0x03, 0xFF, 0x38,
  0x07, 0xF9, 0xC0, 0x07, 0xC7, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x07, 0x9F, 0xC0, 0x1C,
  0xFF, 0x80, 0xE7, 0xDE, 0x03, 0x9E, 0x3C, 0x1C, 0x70, 0xF0, 0xF1, 0xC3,
  0xC1, 0x87, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x3E,
  0x3F, 0xFC, 0x7C, 0xFD, 0xF8, 0xF9, 0xF1, 0xF9, 0xE3, 0xE1, 0xFF, 0xCF,
  0xC1, 0xFF, 0x9F, 0x83, 0xFE, 0x1F, 0x03, 0xFC, 0x3F, 0x07, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xC7, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFE, 0xEE, 0x00, 0x80, 0x70, 0x3C, 0x1F, 0x0F, 0x87, 0xC1,
  0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x18, 0x02, 0x40, 0x0C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x18, 0x02,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x81, 0xC0, 0x1C, 0x38, 0x37, 0xE7, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0x78, 0x03, 0xE7,
  0x80, 0x78, 0xF0, 0x1E, 0x0F, 0x07, 0xC1, 0xF0, 0x30, 0x18, 0x02, 0x02,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x9F, 0x3E, 0x7C, 0xF3, 0xE7, 0x82,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7E, 0x3F, 0x3F, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x7F, 0xFF,
  0xBE, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0xC0, 0xF9, 0xF8, 0x7E, 0x7F, 0xFF,
  0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x08, 0x03, 0xC0, 0xFE,
  0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0x9F, 0xC7, 0xE0, 0x7E, 0x7C, 0x07, 0xEF, 0xC0,
  0x3E, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xF1, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7E,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x07,
  0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3C, 0x0F, 0x87, 0x80, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF7, 0xF0, 0x3F, 0xFF,
  0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF7, 0xF8, 0x7D, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xBF, 0x83, 0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xF3, 0xF8, 0x7E,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0xFC, 0x1F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x3E, 0x1F, 0xDF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7E, 0x0F,
  0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xF3, 0xF0, 0x7E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0x3F, 0x9F, 0x03, 0xEF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xF7, 0xE1,
  0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7E, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x10, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x7E,
  0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x08, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0xF0, 0x10,
  0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF9, 0xFF, 0xE1, 0xFF, 0x80, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x07,
  0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x83, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFB, 0xF8, 0x3E,
  0x01, 0xC1, 0xC0, 0x07, 0x1E, 0x0C, 0x38, 0xE1, 0xFC, 0xEE, 0x1F, 0xE7,
  0x71, 0xE7, 0x3F, 0x9E, 0x39, 0xF8, 0xE1, 0xCF, 0xC7, 0x0E, 0x7E, 0x78,
  0x73, 0xF3, 0xC7, 0x1F, 0x9E, 0x38, 0xFC, 0xF1, 0xC7, 0xE7, 0x8E, 0x37,
  0x3C, 0x73, 0xB8, 0xFF, 0xFD, 0xE7, 0xEF, 0xC7, 0x1E, 0x3C, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x40, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x00, 0xFB, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC0, 0x7E, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0xFE, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xCF,
  0xC0, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0xBF, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xF0, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC7, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03,
  0xF7, 0xF0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x3F,
  0xE0, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF3, 0xF0,
  0x7E, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F,
  0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x03,
  0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFD, 0xF8,
  0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFE, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xEF, 0xFF, 0xBD, 0xFF, 0x77, 0xBF, 0xEF, 0xF7, 0xFD, 0xFC, 0xFF,
  0x9F, 0x9F, 0xF3, 0xF3, 0xFE, 0x7C, 0x7F, 0xCF, 0x9F, 0xF8, 0xF3, 0xFF,
  0x1C, 0x7F, 0xE3, 0x8F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xF0, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xDE, 0x7F, 0xFB, 0xCF, 0xFF,
  0x3D, 0xFF, 0xE7, 0xBF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0x1F, 0xC7, 0xE0, 0xFC,
  0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xEF, 0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xF0, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0x07, 0xF9, 0xFC, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x9F, 0x80, 0x7C, 0xF8,
  0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xF1,
  0xF8, 0x1F, 0x8F, 0xE1, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x40, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xDF,
  0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07,
  0xCF, 0xC0, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0,
  0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x3F, 0x7C, 0x03,
  0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7E,
  0xF8, 0x0F, 0xDF, 0x81, 0xF3, 0xF8, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0,
  0x1F, 0x9F, 0x00, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x3F,
  0x0F, 0x80, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x7E, 0x07,
  0xC1, 0xF0, 0x1F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3,
  0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x3C,
  0x3E, 0xF8, 0x78, 0x7D, 0xF1, 0xF0, 0xFB, 0xE3, 0xE1, 0xF7, 0xC7, 0xC3,
  0xCF, 0x8F, 0x8F, 0x9F, 0x1F, 0x9F, 0x3E, 0x3F, 0x3E, 0x3C, 0x7E, 0x7C,
  0x7D, 0xFC, 0xF8, 0xFB, 0xF9, 0xF1, 0xF7, 0xF3, 0xC3, 0xEF, 0xE7, 0x87,
  0xDD, 0xFF, 0x0F, 0xBB, 0xFE, 0x0F, 0x77, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F,
  0xCF, 0xF0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8,
  0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x3E,
  0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0x0F, 0x87,
  0xC0, 0x3E, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C,
  0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0,
  0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xE1,
  0xFC, 0xF8, 0x1F, 0x9F, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xC1, 0xFF,
  0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xE0, 0x7D, 0xF8, 0x0F, 0xBE, 0x01,
  0xF7, 0xE0, 0x3E, 0xFC, 0x1F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE1, 0xFE, 0x7E, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF9, 0xF8, 0x3E,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x3F, 0xBF, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xF9, 0xFC, 0x00, 0x01, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xF1, 0xFC, 0xFC, 0x0F, 0x9F,
  0x01, 0xFB, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFB, 0xF0, 0x3E, 0x7F,
  0x0F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE7, 0xE1, 0xFE, 0xFC, 0x7F,
  0xFF, 0x9F, 0xFF, 0xF7, 0xF1, 0xFE, 0xFC, 0x0F, 0xDF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFD, 0xF0, 0x7F, 0x3E, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xF9, 0xFC, 0xFC, 0x0F, 0xDF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x04, 0x7F, 0x03,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x10, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE3, 0xE1, 0xFF, 0x7C, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xF9,
  0xFE, 0xFC, 0x0F, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xF0, 0x3F, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFD,
  0xF0, 0x7F, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0xC0, 0x3E, 0x3C, 0x1F,
  0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0xFC, 0x3E, 0x7F, 0xCF, 0xBF, 0xF3, 0xFF,
  0xFE, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xF7,
  0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xEF, 0x81, 0xFC, 0xF8, 0x3F, 0x8F, 0x83,
  0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF9, 0xF8, 0x0F, 0xBF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F,
  0xCF, 0xC0, 0xF8, 0x7E, 0x0F, 0x87, 0xF0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8,
  0xF8, 0x0F, 0xCF, 0x80, 0xFE, 0xF8, 0x07, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF9, 0xE3,
  0xC7, 0xDF, 0xBF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xCF, 0xDF, 0xFC,
  0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7,
  0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3,
  0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x3F,
  0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0x80, 0xF8, 0xFC, 0x3E, 0xFF, 0xCF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x3F, 0x7E, 0x0F, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xF9, 0xF8, 0x3E, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x7F, 0xBF, 0x07, 0xEF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xF9, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE3, 0xE1, 0xFF, 0x7C, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7,
  0xF9, 0xFE, 0xFC, 0x0F, 0xDF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF,
  0x01, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0x7F, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0xF8,
  0x3F, 0xF8, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE7, 0xE0, 0x7E, 0xF8, 0x0F, 0xDF, 0x00, 0xFB, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0xF3, 0xFC,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x40,
  0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0x1F, 0xC7, 0xC0, 0xFC, 0x01, 0xFB,
  0xE0, 0x0F, 0xDF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x81,
  0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x03,
  0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0x7C,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x70, 0x7F, 0xE1, 0xC1, 0xEF, 0x8F,
  0x8F, 0xBE, 0x3E, 0x3E, 0xF8, 0xF8, 0xFB, 0xE3, 0xE3, 0xE7, 0x8F, 0x8F,
  0x1E, 0x7F, 0x3C, 0x79, 0xDC, 0xF1, 0xF7, 0x73, 0xC7, 0xDD, 0xDF, 0x1F,
  0x77, 0x7C, 0x3D, 0xDD, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x81, 0xF8, 0x7E,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC1,
  0xF8, 0x7E, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x3E, 0x01,
  0xF8, 0xFC, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0x87, 0xE0,
  0x3E, 0x1F, 0x00, 0xFC, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x0F, 0x80, 0xFE, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0xFF, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x40, 0x7C, 0x01, 0xE0, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x78, 0x03, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0,
  0x7E, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x3F, 0x00,
  0xF0, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0xC3, 0xFF, 0x03,
  0xDF, 0xFE, 0x1F, 0x7F, 0xFF, 0xF9, 0xE1, 0xFF, 0xE7, 0x03, 0xFF, 0x2C,
  0x03, 0xF8, 0x00, 0x03, 0xC0,
};

const GFXglyph RobotoMono_Bold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 28, 23, 9, -28 },
  { 22, 12, 10, 23, 5, -29 },
  { 37, 21, 28, 23, 1, -28 },
  { 111, 20, 36, 23, 2, -32 },
  { 201, 22, 28, 23, 1, -28 },
  { 278, 23, 28, 23, 1, -28 },
  { 359, 4, 10, 23, 9, -29 },
  { 364, 10, 40, 23, 7, -31 },
  { 414, 11, 40, 23, 6, -31 },
  { 469, 19, 20, 23, 3, -28 },
  { 517, 19, 20, 23, 2, -23 },
  { 565, 7, 13, 23, 7, -5 },
  { 577, 16, 4, 23, 5, -14 },
  { 585, 7, 7, 23, 8, -7 },
  { 592, 16, 30, 23, 4, -28 },
  { 652, 18, 28, 23, 3, -28 },
  { 715, 13, 28, 23, 3, -28 },
  { 761, 20, 28, 23, 1, -28 },
  { 831, 19, 28, 23, 2, -28 },
  { 898, 20, 28, 23, 1, -28 },
  { 968, 19, 28, 23, 2, -28 },
  { 1035, 19, 28, 23, 2, -28 },
  { 1102, 20, 28, 23, 1, -28 },
  { 1172, 19, 28, 23, 2, -28 },
  { 1239, 18, 28, 23, 2, -28 },
  { 1302, 8, 23, 23, 8, -23 },
  { 1325, 8, 31, 23, 8, -23 },
  { 1356, 17, 18, 23, 3, -21 },
  { 1395, 18, 13, 23, 3, -18 },
  { 1425, 17, 18, 23, 3, -21 },
  { 1464, 18, 28, 23, 3, -28 },
  { 1527, 21, 27, 23, 1, -27 },
  { 1598, 22, 28, 23, 1, -28 },
  { 1675, 20, 28, 23, 2, -28 },
  { 1745, 21, 28, 23, 1, -28 },
  { 1819, 20, 28, 23, 2, -28 },
  { 1889, 18, 28, 23, 3, -28 },
  { 1952, 19, 28, 23, 3, -28 },
  { 2019, 20, 28, 23, 2, -28 },
  { 2089, 19, 28, 23, 2, -28 },
  { 2156, 16, 28, 23, 4, -28 },
  { 2212, 19, 28, 23, 2, -28 },
  { 2279, 22, 28, 23, 2, -28 },
  { 2356, 18, 28, 23, 3, -28 },
  { 2419, 19, 28, 23, 2, -28 },
  { 2486, 19, 28, 23, 2, -28 },
  { 2553, 20, 28, 23, 2, -28 },
  { 2623, 19, 28, 23, 3, -28 },
  { 2690, 21, 33, 23, 2, -28 },
  { 2777, 21, 28, 23, 2, -28 },
  { 2851, 20, 28, 23, 2, -28 },
  { 2921, 22, 28, 23, 1, -28 },
  { 2998, 19, 28, 23, 2, -28 },
  { 3065, 22, 28, 23, 1, -28 },
  { 3142, 23, 28, 23, 0, -28 },
  { 3223, 22, 28, 23, 1, -28 },
  { 3300, 22, 28, 23, 1, -28 },
  { 3377, 20, 28, 23, 2, -28 },
  { 3447, 8, 38, 23, 8, -32 },
  { 3485, 15, 30, 23, 5, -28 },
  { 3542, 8, 38, 23, 8, -32 },
  { 3580, 16, 15, 23, 4, -28 },
  { 3610, 17, 4, 23, 3, 0 },
  { 3619, 9, 5, 23, 8, -28 },
  { 3625, 19, 21, 23, 2, -21 },
  { 3675, 18, 29, 23, 3, -29 },
  { 3741, 19, 21, 23, 2, -21 },
  { 3791, 19, 29, 23, 2, -29 },
  { 3860, 19, 21, 23, 2, -21 },
  { 3910, 20, 30, 23, 2, -30 },
  { 3985, 19, 29, 23, 2, -21 },
  { 4054, 18, 29, 23, 3, -29 },
  { 4120, 17, 29, 23, 4, -29 },
  { 4182, 13, 37, 23, 4, -29 },
  { 4243, 20, 29, 23, 3, -29 },
  { 4316, 17, 29, 23, 4, -29 },
  { 4378, 21, 21, 23, 1, -21 },
  { 4434, 18, 21, 23, 3, -21 },
  { 4482, 19, 21, 23, 2, -21 },
  { 4532, 18, 29, 23, 3, -21 },
  { 4598, 19, 29, 23, 2, -21 },
  { 4667, 16, 21, 23, 5, -21 },
  { 4709, 19, 21, 23, 2, -21 },
  { 4759, 19, 26, 23, 2, -26 },
  { 4821, 18, 21, 23, 3, -21 },
  { 4869, 21, 21, 23, 1, -21 },
  { 4925, 22, 21, 23, 1, -21 },
  { 4983, 21, 21, 23, 2, -21 },
  { 5039, 22, 29, 23, 1, -21 },
  { 5119, 20, 21, 23, 2, -21 },
  { 5172, 13, 37, 23, 6, -30 },
  { 5233, 3, 36, 23, 10, -28 },
  { 5247, 13, 37, 23, 6, -30 },
  { 5308, 22, 9, 23, 0, -16 },
};

const GFXfont RobotoMono_Bold39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold39pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_BOLD39PT7B_H_
