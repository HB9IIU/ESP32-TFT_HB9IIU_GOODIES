#ifndef _ROBOTOMONO_BOLD18PT7B_H_
#define _ROBOTOMONO_BOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0x7E, 0xCF, 0x3C, 0xF3, 0xCC, 0x0D, 0x82,
  0x60, 0x98, 0x64, 0x7F, 0xC6, 0xC1, 0x30, 0x4C, 0xFF, 0xCC, 0x83, 0x20,
  0xD8, 0x26, 0x00, 0x0C, 0x06, 0x07, 0x8F, 0xE6, 0x3B, 0x0D, 0x80, 0xF0,
  0x3E, 0x07, 0x80, 0xFC, 0x3E, 0x3B, 0xFC, 0xF8, 0x10, 0x08, 0x00, 0x70,
  0x36, 0x0C, 0x9B, 0x2C, 0x7A, 0x0D, 0x80, 0x40, 0x30, 0x0B, 0xC6, 0x93,
  0x64, 0x09, 0x03, 0xC0, 0x3C, 0x1F, 0x86, 0x61, 0x98, 0x6E, 0x1F, 0x03,
  0x83, 0xF7, 0xCD, 0xB3, 0xEC, 0x7B, 0xFE, 0x7D, 0xC0, 0xFF, 0xC0, 0x19,
  0x8C, 0xC6, 0x63, 0x18, 0xC6, 0x31, 0x8E, 0x31, 0x86, 0x18, 0x40, 0x86,
  0x18, 0x63, 0x18, 0xE7, 0x18, 0xCE, 0x73, 0x19, 0xCC, 0xC4, 0x00, 0x0C,
  0x06, 0x03, 0x0D, 0xBF, 0xF8, 0x60, 0x58, 0x66, 0x63, 0x00, 0x18, 0x0C,
  0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x6D, 0xBC,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x1C, 0x30, 0x61, 0xC3, 0x06, 0x18,
  0x30, 0x61, 0x83, 0x0E, 0x18, 0x00, 0x3C, 0x3F, 0x98, 0xDC, 0x6E, 0x3F,
  0x3F, 0xFF, 0xE7, 0xE3, 0xF1, 0x98, 0xCF, 0xE3, 0xE0, 0x09, 0xFF, 0xB1,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x80, 0x3C, 0x3F, 0xB9, 0xD8, 0x60, 0x30,
  0x38, 0x38, 0x38, 0x18, 0x18, 0x1C, 0x1F, 0xFF, 0xF8, 0x3E, 0x3F, 0xB8,
  0xD8, 0x60, 0x30, 0x78, 0x78, 0x0E, 0x03, 0x81, 0xF8, 0xDF, 0xE3, 0xE0,
  0x06, 0x07, 0x07, 0x83, 0xC3, 0x61, 0xB1, 0x99, 0x8C, 0xFF, 0xFF, 0xC1,
  0x80, 0xC0, 0x60, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x07, 0xF3, 0xFC, 0x06,
  0x03, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0x0E, 0x1F, 0x1E, 0x0C, 0x0E, 0x46,
  0xFB, 0xDD, 0x87, 0xC3, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFF, 0xFF, 0xC0,
  0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x00,
  0x3C, 0x3F, 0xB9, 0xDC, 0x6E, 0x33, 0xF8, 0xF8, 0xEE, 0xE3, 0x61, 0xF8,
  0xCF, 0xE3, 0xE0, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x3B,
  0x07, 0x0E, 0x3E, 0x38, 0xFF, 0x80, 0x07, 0xFC, 0x6F, 0xE0, 0x00, 0x00,
  0x66, 0x6E, 0xC4, 0x01, 0x07, 0x1F, 0xFC, 0xE0, 0xFC, 0x1F, 0x07, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x80, 0xE0, 0xFC, 0x1F, 0x03, 0x1F,
  0xFC, 0xE0, 0x80, 0x3E, 0x3F, 0x98, 0xFC, 0x70, 0x38, 0x38, 0x38, 0x18,
  0x1C, 0x00, 0x02, 0x03, 0x81, 0xC0, 0x06, 0x07, 0xE3, 0x0D, 0xBD, 0x4B,
  0x56, 0xDD, 0x37, 0x4D, 0xDA, 0xD7, 0xE6, 0x00, 0xC4, 0x1F, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x81, 0xB0, 0x36, 0x0E, 0xE1, 0x8C, 0x3F, 0x8F,
  0xF9, 0xC7, 0x30, 0x6E, 0x0E, 0xFE, 0x7F, 0xB8, 0xFC, 0x3E, 0x3F, 0x3B,
  0xFD, 0xC7, 0xE1, 0xF0, 0xF8, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0xB8, 0xFC,
  0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0xF8, 0xEF, 0xE3, 0xE0, 0xF8,
  0x7F, 0x39, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xDF,
  0xCF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0xFB, 0xFD, 0xC0, 0xE0,
  0x70, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03,
  0xFD, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3E, 0x3F, 0xB8, 0xFC,
  0x7C, 0x06, 0x03, 0x3F, 0x9F, 0xC3, 0xF1, 0xF8, 0xEF, 0xF3, 0xF0, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x38, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE7,
  0xFF, 0xE0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xE1, 0xF8, 0xEE, 0x73, 0xB8, 0xEE, 0x3F,
  0x0F, 0xC3, 0xF8, 0xEE, 0x39, 0xCE, 0x33, 0x8E, 0xE1, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF,
  0xF8, 0xE3, 0xFB, 0xFD, 0xFE, 0xFD, 0x5E, 0xEF, 0x77, 0xB3, 0xC9, 0xE0,
  0xF0, 0x78, 0x3C, 0x18, 0xE3, 0xF1, 0xFC, 0xFE, 0x7F, 0x3F, 0xDF, 0xEF,
  0xDF, 0xEF, 0xF3, 0xF9, 0xFC, 0xFE, 0x38, 0x3C, 0x3F, 0xB8, 0xD8, 0x7C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFE, 0x7F,
  0xB8, 0xFC, 0x3E, 0x1F, 0x1F, 0xFF, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x00, 0x3C, 0x1F, 0xCE, 0x33, 0x8E, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC1,
  0xB0, 0xEE, 0x39, 0xFC, 0x3F, 0x00, 0xF0, 0x18, 0xFE, 0x3F, 0xCE, 0x3B,
  0x86, 0xE1, 0xB8, 0xEF, 0xF3, 0xF8, 0xE6, 0x39, 0xCE, 0x33, 0x8E, 0xE1,
  0xC0, 0x3E, 0x3F, 0xB8, 0xFC, 0x3E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xE0,
  0xF8, 0x6F, 0xF3, 0xF0, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xCF, 0xE3,
  0xE0, 0xE0, 0xEC, 0x39, 0xC7, 0x38, 0xE3, 0x18, 0x67, 0x0E, 0xE1, 0xD8,
  0x1B, 0x03, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0xEC, 0xFD, 0x99, 0xBB, 0x37,
  0x66, 0xEC, 0xDD, 0x9A, 0xB3, 0xDE, 0x7B, 0x87, 0x70, 0xEE, 0x19, 0xC3,
  0x18, 0xE0, 0xEE, 0x38, 0xC6, 0x1D, 0xC1, 0xB0, 0x3E, 0x03, 0x80, 0xF8,
  0x1B, 0x07, 0x70, 0xC6, 0x38, 0xEE, 0x0E, 0xE0, 0xEE, 0x39, 0xC7, 0x18,
  0xC3, 0xB8, 0x36, 0x07, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38,
  0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xFC, 0xC0,
  0xC1, 0x83, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0xC0,
  0xFD, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0xFC, 0x18, 0x70, 0xA3, 0x66, 0xD8,
  0xF1, 0x80, 0xFF, 0xFF, 0xE7, 0x1C, 0x3F, 0xB9, 0xC0, 0x63, 0xF3, 0xFB,
  0x8D, 0xC6, 0xFF, 0x3D, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xC7, 0xFB,
  0xDD, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xF7, 0xF0, 0x1C, 0x3F, 0x9D,
  0xDC, 0x7E, 0x06, 0x03, 0x83, 0xC6, 0x7F, 0x1F, 0x00, 0x03, 0x81, 0xC0,
  0xE0, 0x71, 0xBB, 0xFF, 0xDF, 0xC7, 0xC3, 0xE1, 0xF8, 0xFC, 0x77, 0xF9,
  0xFC, 0x1C, 0x3F, 0x9C, 0xDC, 0x7F, 0xFF, 0xFF, 0x81, 0xC2, 0x7F, 0x9F,
  0x00, 0x07, 0x8F, 0xC7, 0x03, 0x0F, 0xF7, 0xF8, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x1B, 0xBF, 0xDD, 0xFC, 0x7C, 0x3E, 0x1F,
  0x8F, 0xC7, 0x7F, 0x9F, 0xC0, 0xEC, 0xE7, 0xF0, 0xE0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0xE7, 0xFB, 0x9F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1C, 0x18, 0x38, 0x00, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x1C, 0x70, 0x1F, 0x7C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xBE, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xB9, 0xCE, 0xE3,
  0xF0, 0xF8, 0x3F, 0x0E, 0xE3, 0x9C, 0xE7, 0x38, 0xF0, 0xF8, 0xF8, 0xF8,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xDB,
  0x7F, 0xF7, 0x7B, 0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xD9, 0xEC, 0xC0, 0xCE,
  0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x1C,
  0x3F, 0x99, 0xDC, 0x7C, 0x3E, 0x1F, 0x0F, 0xC6, 0x7F, 0x1F, 0x00, 0xEC,
  0x7F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC6, 0xFF, 0x7F, 0x38, 0x1C,
  0x0E, 0x07, 0x00, 0x1B, 0xBF, 0xFD, 0xFC, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7,
  0x7F, 0x9F, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0xCF, 0xFF, 0xFE, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x80, 0x1C, 0x3F, 0xB8, 0xFC, 0x07, 0xC1, 0xF8, 0x1F,
  0xC7, 0x7F, 0x1F, 0x00, 0x38, 0x1C, 0x3F, 0xDF, 0xE3, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x07, 0xE3, 0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0x7F, 0x9F, 0xC0, 0xC1, 0xF1, 0xF8, 0xCC, 0x66, 0x71,
  0xB0, 0xD8, 0x7C, 0x1C, 0x0E, 0x00, 0xCC, 0xFB, 0x36, 0xCD, 0xBB, 0x6E,
  0xDA, 0xA7, 0xB9, 0xEE, 0x33, 0x8C, 0xE0, 0xE1, 0xB1, 0xDD, 0xC7, 0xC1,
  0xE0, 0xE0, 0xF8, 0xEE, 0x63, 0x71, 0xC0, 0xE0, 0xEE, 0x19, 0xC7, 0x18,
  0xC3, 0x98, 0x37, 0x06, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0x60, 0x00, 0xFF, 0xFF, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xC0, 0x18, 0x73, 0x0C, 0x30, 0xC3, 0x1C, 0xC3, 0x83, 0x0C,
  0x30, 0xC3, 0x07, 0x18, 0xFF, 0xFF, 0x80, 0xC1, 0x86, 0x1C, 0x71, 0xC7,
  0x0E, 0x1C, 0xE3, 0x1C, 0x71, 0xC6, 0x18, 0xC0, 0x78, 0xFF, 0x3C, 0x78,
  0x0C,
};

const GFXglyph RobotoMono_Bold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 6, 5, 11, 2, -14 },
  { 10, 10, 13, 11, 0, -13 },
  { 27, 9, 17, 11, 1, -15 },
  { 47, 10, 13, 11, 0, -13 },
  { 64, 10, 13, 11, 1, -13 },
  { 81, 2, 5, 11, 4, -14 },
  { 83, 5, 18, 11, 3, -14 },
  { 95, 5, 18, 11, 3, -14 },
  { 107, 9, 9, 11, 1, -13 },
  { 118, 9, 10, 11, 1, -11 },
  { 130, 3, 6, 11, 3, -2 },
  { 133, 8, 2, 11, 2, -7 },
  { 135, 3, 3, 11, 4, -3 },
  { 137, 7, 14, 11, 2, -13 },
  { 150, 9, 13, 11, 1, -13 },
  { 165, 5, 13, 11, 2, -13 },
  { 174, 9, 13, 11, 1, -13 },
  { 189, 9, 13, 11, 1, -13 },
  { 204, 9, 13, 11, 1, -13 },
  { 219, 9, 13, 11, 1, -13 },
  { 234, 9, 13, 11, 1, -13 },
  { 249, 9, 13, 11, 1, -13 },
  { 264, 9, 13, 11, 1, -13 },
  { 279, 8, 13, 11, 1, -13 },
  { 292, 3, 10, 11, 4, -10 },
  { 296, 4, 14, 11, 4, -10 },
  { 303, 8, 9, 11, 1, -10 },
  { 312, 9, 5, 11, 1, -8 },
  { 318, 8, 9, 11, 1, -10 },
  { 327, 9, 13, 11, 1, -13 },
  { 342, 10, 13, 11, 0, -13 },
  { 359, 11, 13, 11, 0, -13 },
  { 377, 9, 13, 11, 1, -13 },
  { 392, 9, 13, 11, 1, -13 },
  { 407, 9, 13, 11, 1, -13 },
  { 422, 9, 13, 11, 1, -13 },
  { 437, 9, 13, 11, 1, -13 },
  { 452, 9, 13, 11, 1, -13 },
  { 467, 9, 13, 11, 1, -13 },
  { 482, 7, 13, 11, 2, -13 },
  { 494, 9, 13, 11, 1, -13 },
  { 509, 10, 13, 11, 1, -13 },
  { 526, 9, 13, 11, 1, -13 },
  { 541, 9, 13, 11, 1, -13 },
  { 556, 9, 13, 11, 1, -13 },
  { 571, 9, 13, 11, 1, -13 },
  { 586, 9, 13, 11, 1, -13 },
  { 601, 10, 15, 11, 1, -13 },
  { 620, 10, 13, 11, 1, -13 },
  { 637, 9, 13, 11, 1, -13 },
  { 652, 11, 13, 11, 0, -13 },
  { 670, 9, 13, 11, 1, -13 },
  { 685, 11, 13, 11, 0, -13 },
  { 703, 11, 13, 11, 0, -13 },
  { 721, 11, 13, 11, 0, -13 },
  { 739, 11, 13, 11, 0, -13 },
  { 757, 9, 13, 11, 1, -13 },
  { 772, 3, 18, 11, 4, -15 },
  { 779, 7, 14, 11, 2, -13 },
  { 792, 3, 18, 11, 4, -15 },
  { 799, 7, 7, 11, 2, -13 },
  { 806, 8, 2, 11, 1, 0 },
  { 808, 4, 2, 11, 4, -13 },
  { 809, 9, 10, 11, 1, -10 },
  { 821, 9, 14, 11, 1, -14 },
  { 837, 9, 10, 11, 1, -10 },
  { 849, 9, 14, 11, 1, -14 },
  { 865, 9, 10, 11, 1, -10 },
  { 877, 9, 14, 11, 1, -14 },
  { 893, 9, 14, 11, 1, -10 },
  { 909, 9, 14, 11, 1, -14 },
  { 925, 8, 13, 11, 2, -13 },
  { 938, 6, 17, 11, 2, -13 },
  { 951, 10, 14, 11, 1, -14 },
  { 969, 8, 14, 11, 2, -14 },
  { 983, 9, 10, 11, 1, -10 },
  { 995, 9, 10, 11, 1, -10 },
  { 1007, 9, 10, 11, 1, -10 },
  { 1019, 9, 14, 11, 1, -10 },
  { 1035, 9, 14, 11, 1, -10 },
  { 1051, 7, 10, 11, 3, -10 },
  { 1060, 9, 10, 11, 1, -10 },
  { 1072, 9, 12, 11, 1, -12 },
  { 1086, 9, 10, 11, 1, -10 },
  { 1098, 9, 10, 11, 1, -10 },
  { 1110, 10, 10, 11, 0, -10 },
  { 1123, 9, 10, 11, 1, -10 },
  { 1135, 11, 14, 11, 0, -10 },
  { 1155, 9, 10, 11, 1, -10 },
  { 1167, 6, 17, 11, 3, -14 },
  { 1180, 1, 17, 11, 5, -13 },
  { 1183, 6, 17, 11, 3, -14 },
  { 1196, 10, 4, 11, 0, -7 },
};

const GFXfont RobotoMono_Bold18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold18pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_BOLD18PT7B_H_
