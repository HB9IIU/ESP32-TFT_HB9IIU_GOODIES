#ifndef _ROBOTOMONO_BOLD9PT7B_H_
#define _ROBOTOMONO_BOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x33, 0xD5, 0xF5, 0x28, 0x4F, 0x9E, 0x39, 0xF4,
  0xF7, 0x88, 0x75, 0x8C, 0x72, 0x98, 0xDD, 0xBC, 0xE0, 0x6A, 0xAA, 0x40,
  0x88, 0x92, 0x4A, 0x80, 0x4F, 0x6B, 0x27, 0xFE, 0x40, 0xE0, 0xF0, 0xB0,
  0x32, 0x64, 0x48, 0x80, 0xE9, 0xF9, 0xBE, 0xFD, 0xB6, 0xC0, 0x76, 0xC4,
  0x44, 0x7C, 0x7C, 0xCC, 0x3C, 0xB8, 0x31, 0x95, 0xAF, 0x88, 0xF8, 0xE1,
  0x9E, 0x72, 0x1D, 0x94, 0xB8, 0xF8, 0x84, 0x42, 0x30, 0x72, 0xDC, 0xBD,
  0xB8, 0x76, 0xD6, 0xF1, 0x30, 0xB0, 0xB0, 0xB0, 0x2A, 0x1E, 0xC3, 0xF0,
  0xF0, 0x8E, 0x3C, 0xF1, 0x24, 0x04, 0x7D, 0xF7, 0xBB, 0x38, 0x31, 0x94,
  0xB7, 0xE4, 0xF9, 0xE9, 0x9F, 0x7E, 0x71, 0x84, 0xB8, 0xE9, 0x99, 0xBE,
  0xF8, 0xF8, 0x8F, 0xF8, 0xF8, 0x88, 0x7E, 0x71, 0xB4, 0xBC, 0x99, 0xF9,
  0x99, 0xF4, 0x44, 0x4F, 0x08, 0x42, 0x1C, 0xB8, 0xB5, 0x31, 0x4B, 0x4C,
  0x88, 0x88, 0x8F, 0xBF, 0xDD, 0x99, 0x9D, 0xDD, 0xBB, 0x7E, 0x73, 0x94,
  0xB8, 0xF9, 0xBE, 0x88, 0x7E, 0x73, 0x94, 0xB8, 0x20, 0xF9, 0xBE, 0xB9,
  0x7A, 0x1C, 0x3C, 0xBC, 0xF9, 0x08, 0x42, 0x10, 0x99, 0x99, 0x9E, 0xCA,
  0xD4, 0xE3, 0x10, 0xAD, 0x5E, 0xB5, 0xA8, 0xDB, 0x8C, 0x65, 0xE4, 0xCA,
  0x8C, 0x42, 0x10, 0xF8, 0x8C, 0x44, 0x7C, 0xEA, 0xAB, 0xC4, 0x46, 0x22,
  0x30, 0xD5, 0x57, 0x66, 0xB0, 0xF0, 0x90, 0x72, 0xDF, 0xB7, 0x80, 0x88,
  0xEB, 0x99, 0xE0, 0xEB, 0x89, 0xE0, 0x08, 0x5A, 0xBC, 0xA5, 0xE0, 0x32,
  0x7E, 0x87, 0x80, 0x74, 0xF4, 0x44, 0x40, 0x6A, 0xF2, 0x97, 0xAD, 0xC0,
  0x88, 0xE9, 0x99, 0x90, 0x46, 0xE6, 0x66, 0xF0, 0x2F, 0x92, 0x4B, 0xC0,
  0x88, 0xBE, 0xCA, 0xB0, 0xE6, 0x66, 0x66, 0xF0, 0xBF, 0x6B, 0x5A, 0x80,
  0xE9, 0x99, 0x90, 0x72, 0xF2, 0x97, 0x00, 0xEB, 0x99, 0xE8, 0x80, 0x6A,
  0xF2, 0x97, 0x84, 0x20, 0xBD, 0x88, 0x80, 0xE9, 0xE9, 0xF0, 0x4F, 0x44,
  0x47, 0x99, 0x99, 0xF0, 0xCA, 0xD4, 0x62, 0x00, 0xAD, 0x5A, 0xB5, 0x00,
  0xCB, 0x8C, 0xEC, 0x80, 0xCA, 0x54, 0x63, 0x11, 0x00, 0xF2, 0x6C, 0xF0,
  0x25, 0xAC, 0xD9, 0x20, 0xFF, 0xC9, 0x22, 0x92, 0x80, 0x45, 0xC0,
};

const GFXglyph RobotoMono_Bold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 5, 1, -7 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 3, 5, 2, -7 },
  { 21, 2, 9, 5, 2, -7 },
  { 24, 3, 9, 5, 1, -7 },
  { 28, 4, 4, 5, 1, -6 },
  { 30, 5, 4, 5, 0, -5 },
  { 33, 1, 3, 5, 2, -1 },
  { 34, 4, 1, 5, 1, -3 },
  { 35, 2, 2, 5, 2, -2 },
  { 36, 4, 7, 5, 1, -6 },
  { 40, 4, 6, 5, 1, -6 },
  { 43, 3, 6, 5, 1, -6 },
  { 46, 5, 6, 5, 0, -6 },
  { 50, 5, 6, 5, 0, -6 },
  { 54, 5, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 1, -6 },
  { 61, 5, 6, 5, 0, -6 },
  { 65, 5, 6, 5, 0, -6 },
  { 69, 5, 6, 5, 0, -6 },
  { 73, 5, 6, 5, 0, -6 },
  { 77, 2, 6, 5, 2, -6 },
  { 79, 2, 8, 5, 2, -6 },
  { 81, 4, 4, 5, 1, -5 },
  { 83, 4, 3, 5, 1, -4 },
  { 85, 4, 4, 5, 1, -5 },
  { 87, 4, 6, 5, 1, -6 },
  { 90, 5, 6, 5, 0, -6 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 4, 6, 5, 1, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 4, 6, 5, 1, -6 },
  { 108, 4, 6, 5, 1, -6 },
  { 111, 4, 6, 5, 1, -6 },
  { 114, 5, 6, 5, 0, -6 },
  { 118, 4, 6, 5, 1, -6 },
  { 121, 4, 6, 5, 1, -6 },
  { 124, 5, 6, 5, 0, -6 },
  { 128, 5, 6, 5, 1, -6 },
  { 132, 4, 6, 5, 1, -6 },
  { 135, 4, 6, 5, 1, -6 },
  { 138, 4, 6, 5, 1, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 4, 6, 5, 1, -6 },
  { 148, 5, 7, 5, 0, -6 },
  { 153, 4, 6, 5, 1, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 4, 6, 5, 1, -6 },
  { 167, 5, 6, 5, 0, -6 },
  { 171, 5, 6, 5, 0, -6 },
  { 175, 5, 6, 5, 0, -6 },
  { 179, 5, 6, 5, 0, -6 },
  { 183, 5, 6, 5, 0, -6 },
  { 187, 2, 8, 5, 2, -7 },
  { 189, 4, 7, 5, 1, -6 },
  { 193, 2, 8, 5, 2, -7 },
  { 195, 4, 3, 5, 1, -6 },
  { 197, 4, 1, 5, 1, 0 },
  { 198, 2, 2, 5, 2, -7 },
  { 199, 5, 5, 5, 0, -5 },
  { 203, 4, 7, 5, 1, -7 },
  { 207, 4, 5, 5, 1, -5 },
  { 210, 5, 7, 5, 0, -7 },
  { 215, 5, 5, 5, 0, -5 },
  { 219, 4, 7, 5, 1, -7 },
  { 223, 5, 7, 5, 0, -5 },
  { 228, 4, 7, 5, 1, -7 },
  { 232, 4, 7, 5, 1, -7 },
  { 236, 3, 9, 5, 1, -7 },
  { 240, 4, 7, 5, 1, -7 },
  { 244, 4, 7, 5, 1, -7 },
  { 248, 5, 5, 5, 0, -5 },
  { 252, 4, 5, 5, 1, -5 },
  { 255, 5, 5, 5, 0, -5 },
  { 259, 4, 7, 5, 1, -5 },
  { 263, 5, 7, 5, 0, -5 },
  { 268, 4, 5, 5, 1, -5 },
  { 271, 4, 5, 5, 1, -5 },
  { 274, 4, 6, 5, 1, -6 },
  { 277, 4, 5, 5, 1, -5 },
  { 280, 5, 5, 5, 0, -5 },
  { 284, 5, 5, 5, 0, -5 },
  { 288, 5, 5, 5, 0, -5 },
  { 292, 5, 7, 5, 0, -5 },
  { 297, 4, 5, 5, 1, -5 },
  { 300, 3, 9, 5, 1, -7 },
  { 304, 1, 8, 5, 2, -6 },
  { 305, 3, 9, 5, 1, -7 },
  { 309, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoMono_Bold9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold9pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_BOLD9PT7B_H_
