#ifndef _ROBOTOMONO_BOLD44PT7B_H_
#define _ROBOTOMONO_BOLD44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF3,
  0xF7, 0xFF, 0xFF, 0x9F, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x01,
  0xE1, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01,
  0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x83, 0x80, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0x87, 0x80, 0x07, 0x07, 0x80, 0x0F,
  0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7,
  0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x3F, 0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x9F, 0xF3, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x06, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0x1F, 0x04, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE1,
  0xE3, 0xC0, 0xF0, 0xF1, 0xC0, 0x78, 0x79, 0xE0, 0x3F, 0xFC, 0xE0, 0x0F,
  0xFC, 0xF0, 0x03, 0xFC, 0x70, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x3F, 0x80, 0x0F, 0x3F, 0xE0, 0x07, 0x3F, 0xF8, 0x07, 0x9E,
  0x3C, 0x03, 0x9F, 0x1F, 0x03, 0xCF, 0x07, 0x83, 0xC7, 0x83, 0xC1, 0xE3,
  0xC1, 0xE0, 0x21, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC,
  0x0F, 0x8F, 0xFF, 0x07, 0xCF, 0xDF, 0xC7, 0xEF, 0xE7, 0xF3, 0xE7, 0xE1,
  0xF9, 0xF3, 0xF0, 0xFF, 0xF9, 0xF8, 0x3F, 0xFC, 0xFC, 0x0F, 0xFC, 0x7E,
  0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xF8, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x20, 0x40,
  0x0E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0x01, 0xE0, 0x07,
  0x03, 0x81, 0x9F, 0x0E, 0x1E, 0x7F, 0xBB, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0xF3, 0xE0, 0x07, 0xC7, 0x80, 0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0xFC, 0x06, 0x01, 0x80, 0x08, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0xBF, 0x7C, 0xFB, 0xE7, 0xC7, 0x04,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE,
  0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFD, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x07, 0xE3, 0xFD, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x03, 0xF0, 0x3F, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0x1F, 0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x01,
  0xF9, 0xF8, 0x03, 0xEF, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xE0, 0x3F, 0x9F,
  0x80, 0x7E, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFB, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0xF3, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xEF,
  0xC0, 0x07, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xFC,
  0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x04, 0x00, 0xFB, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xC1, 0xFC, 0x08, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFB,
  0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0x9F, 0xE7,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x7E, 0xFF, 0x81,
  0xF7, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0x87, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE3,
  0xF0, 0x3F, 0x8F, 0xFB, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xC3, 0xF9, 0xFC, 0x0F,
  0xCF, 0xC0, 0x7F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0xFE, 0x07, 0xE7, 0xE0,
  0x1F, 0xBF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFB,
  0xF0, 0x0F, 0xDF, 0xC0, 0xFE, 0xFF, 0x9F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF1, 0xFC, 0x1F,
  0xCF, 0xC0, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0x7F,
  0x7F, 0x07, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xDF, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFB,
  0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x1F,
  0x0F, 0xE7, 0xF9, 0xFF, 0x7F, 0x8F, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF,
  0xF0, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x3F, 0xC3, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0xFC,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xF1, 0xF8, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x3C,
  0x3F, 0x8E, 0x38, 0x7F, 0xCF, 0x78, 0xFF, 0xC7, 0x78, 0xF1, 0xC7, 0x71,
  0xE1, 0xC7, 0xF1, 0xE3, 0xC7, 0xF1, 0xC3, 0xC7, 0xF3, 0xC3, 0xC7, 0xF3,
  0xC3, 0xC7, 0xE3, 0xC3, 0xC7, 0xE3, 0xC3, 0x87, 0xF3, 0xC3, 0x8E, 0xF3,
  0xC3, 0x8E, 0xF3, 0xE7, 0x9E, 0xF1, 0xFF, 0xFC, 0xF1, 0xFF, 0xFC, 0x78,
  0xF9, 0xF8, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x81, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x83,
  0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x0F, 0xCF,
  0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x07, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0,
  0x1F, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xF0, 0x7F, 0x8F, 0xC0, 0x7F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x7F, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0x0F,
  0xE7, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xF9,
  0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xE0,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0x7E, 0x01,
  0xF9, 0xFC, 0x0F, 0xE7, 0xFD, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFC,
  0xFC, 0x03, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00,
  0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9E,
  0xFF, 0xDE, 0xF7, 0xFE, 0xFF, 0xBF, 0xF7, 0xF9, 0xFF, 0xBF, 0xCF, 0xFC,
  0xFE, 0x7F, 0xE7, 0xF3, 0xFF, 0x3F, 0x1F, 0xF9, 0xF8, 0xFF, 0xC7, 0xC7,
  0xFE, 0x3C, 0x3F, 0xF1, 0xE1, 0xFF, 0x87, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xDF, 0x3F, 0xFD, 0xF3,
  0xFF, 0xCF, 0xBF, 0xFC, 0xFB, 0xFF, 0xC7, 0xBF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xC0,
  0xFE, 0x3F, 0x00, 0xFC, 0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF1, 0xFC, 0x0F, 0xE1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xCF, 0xF8, 0x7F, 0x03, 0xF8,
  0x7E, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F,
  0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80,
  0x7F, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x9F, 0xC0, 0x3F, 0x3F,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xFC, 0x03, 0xFB, 0xFF, 0x3F, 0xE3,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7E, 0xFE, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xBF, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0,
  0x07, 0xE3, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xF8,
  0x3C, 0x1F, 0xFC, 0x1F, 0x0F, 0xFE, 0x0F, 0x87, 0xFF, 0x8F, 0xC3, 0xEF,
  0xC7, 0xE1, 0xF7, 0xE3, 0xF0, 0xFB, 0xF1, 0xF8, 0x7C, 0xF8, 0xFC, 0x7E,
  0x7C, 0x7F, 0x3F, 0x3E, 0x3F, 0x9F, 0x9F, 0x3F, 0xCF, 0x8F, 0xDF, 0xE7,
  0xC7, 0xEF, 0xF3, 0xE3, 0xF7, 0xF9, 0xF0, 0xFB, 0xFE, 0xF8, 0x7D, 0xEF,
  0xFC, 0x3E, 0xF7, 0xFE, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFC,
  0xFF, 0x83, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F,
  0x87, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0xC7,
  0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x8F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0xC7, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0xC7, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x3F,
  0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xDE,
  0x00, 0xF7, 0xC0, 0x7D, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x83, 0xE1, 0xE0,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x03, 0xCF, 0x80, 0xFB, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0x07, 0xE7, 0xF0,
  0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x3F,
  0x9F, 0xC3, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0x83,
  0xFE, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE1, 0xC0, 0x3F, 0x3F, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFC, 0x3F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFD, 0xFC, 0x0F, 0xEF, 0xFD, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xBF, 0xF0, 0xFC, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF8, 0xFF, 0x7E, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xF9, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0x0F, 0xC1, 0xFF, 0x7E, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFE, 0x1F, 0xEF, 0xE0, 0x7F, 0x7E,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7E, 0x01, 0xFB, 0xF0,
  0x0F, 0xDF, 0x80, 0x7E, 0xFE, 0x07, 0xF3, 0xFC, 0xFF, 0x9F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xDF, 0x03, 0xF8, 0xF8, 0x00, 0x3C, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0x0F,
  0xE3, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x83, 0xF8, 0x07,
  0x0F, 0xFC, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0xF3, 0xF0, 0xFF, 0xEF, 0xC7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0x1F, 0xF7, 0xF0, 0x1F, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xFC,
  0x07, 0xF7, 0xF0, 0x1F, 0xCF, 0xFB, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xEF, 0xC0, 0xFF, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x80, 0x1F, 0x87, 0x80, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0xE0, 0x3F, 0x3F, 0xE1,
  0xFB, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFC, 0x3F, 0xDF, 0xC0,
  0x7E, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8,
  0xFF, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x3F, 0x80,
  0xFC, 0xFE, 0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF,
  0x3F, 0x01, 0xFC, 0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xFE, 0xFC, 0x01,
  0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0xC1, 0xF7, 0xF7, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0x9F, 0x9F, 0xBE, 0x3F, 0x1F, 0xFC, 0x7E, 0x3F, 0xF8,
  0xFC, 0x7F, 0xF1, 0xF8, 0xFF, 0xE3, 0xF1, 0xFF, 0xC7, 0xE3, 0xFF, 0x8F,
  0xC7, 0xFF, 0x1F, 0x8F, 0xFE, 0x3F, 0x1F, 0xFC, 0x7E, 0x3F, 0xF8, 0xFC,
  0x7F, 0xF1, 0xF8, 0xFF, 0xE3, 0xF1, 0xFF, 0xC7, 0xE3, 0xFF, 0x8F, 0xC7,
  0xFF, 0x1F, 0x8F, 0xFE, 0x3F, 0x1F, 0xFC, 0x7E, 0x3F, 0x00, 0x0E, 0x07,
  0xE7, 0xFC, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x87,
  0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0xF3, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x07, 0xE7, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x87, 0xFB, 0xF8, 0x1F,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x81, 0xFD, 0xFF, 0x3F, 0xEF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE3, 0xF7, 0xFE, 0x1F, 0x9F, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0xE7, 0xC3, 0xFF, 0xBE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xC3,
  0xFD, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0xFE, 0x7F,
  0x9F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x3F, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFC, 0x1B, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x01, 0xFB, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xE7, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFB, 0xF0,
  0x1F, 0xDF, 0xE7, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF, 0x8F, 0xFC, 0xFC,
  0x3F, 0xC7, 0xE0, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F,
  0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C,
  0x3E, 0x00, 0xFC, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x3C,
  0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x1F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0xFF,
  0x3E, 0x7C, 0xFF, 0x3E, 0x7C, 0xEF, 0x3C, 0x3E, 0xE7, 0x7C, 0x3E, 0xE7,
  0x7C, 0x3F, 0xE7, 0x7C, 0x3F, 0xE7, 0xFC, 0x3F, 0xC7, 0xFC, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x83,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xF8, 0xFE, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x01, 0xFC, 0xFC,
  0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x1F, 0x8F, 0xE0, 0x7F,
  0x0F, 0xC1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0xCF, 0xC0, 0x1F, 0xBF, 0x80,
  0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xC7,
  0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x03, 0xF0, 0x1F,
  0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x0F, 0xF8, 0x3F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x0F,
  0xE0, 0x3F, 0x00, 0x78, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xE0,
  0x10, 0x7F, 0xF0, 0x1F, 0x7F, 0xF8, 0x1E, 0xFF, 0xFE, 0x3E, 0xF8, 0xFF,
  0xFE, 0xF0, 0x3F, 0xFC, 0xF0, 0x1F, 0xFC, 0x20, 0x0F, 0xF8, 0x00, 0x03,
  0xE0,
};

const GFXglyph RobotoMono_Bold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 31, 26, 10, -31 },
  { 29, 13, 11, 26, 6, -33 },
  { 47, 24, 31, 26, 1, -31 },
  { 140, 22, 41, 26, 3, -36 },
  { 253, 25, 32, 26, 1, -32 },
  { 353, 25, 32, 26, 2, -32 },
  { 453, 4, 12, 26, 10, -33 },
  { 459, 12, 45, 26, 7, -35 },
  { 527, 12, 45, 26, 7, -35 },
  { 595, 22, 22, 26, 3, -31 },
  { 656, 22, 23, 26, 2, -26 },
  { 720, 7, 14, 26, 8, -5 },
  { 733, 18, 5, 26, 6, -16 },
  { 745, 8, 7, 26, 9, -7 },
  { 752, 17, 34, 26, 5, -31 },
  { 825, 20, 32, 26, 3, -32 },
  { 905, 14, 31, 26, 4, -31 },
  { 960, 22, 32, 26, 1, -32 },
  { 1048, 22, 32, 26, 2, -32 },
  { 1136, 23, 31, 26, 1, -31 },
  { 1226, 21, 31, 26, 3, -31 },
  { 1308, 22, 32, 26, 2, -32 },
  { 1396, 22, 31, 26, 1, -31 },
  { 1482, 21, 32, 26, 2, -32 },
  { 1566, 21, 32, 26, 2, -32 },
  { 1650, 9, 25, 26, 9, -25 },
  { 1679, 10, 34, 26, 9, -25 },
  { 1722, 19, 21, 26, 3, -24 },
  { 1772, 21, 14, 26, 3, -20 },
  { 1809, 20, 21, 26, 3, -24 },
  { 1862, 21, 32, 26, 3, -32 },
  { 1946, 24, 31, 26, 1, -31 },
  { 2039, 25, 31, 26, 1, -31 },
  { 2136, 22, 31, 26, 3, -31 },
  { 2222, 23, 32, 26, 2, -32 },
  { 2314, 22, 31, 26, 3, -31 },
  { 2400, 21, 31, 26, 3, -31 },
  { 2482, 21, 31, 26, 3, -31 },
  { 2564, 22, 32, 26, 2, -32 },
  { 2652, 20, 31, 26, 3, -31 },
  { 2730, 18, 31, 26, 4, -31 },
  { 2800, 22, 31, 26, 2, -31 },
  { 2886, 24, 31, 26, 3, -31 },
  { 2979, 21, 31, 26, 3, -31 },
  { 3061, 21, 31, 26, 3, -31 },
  { 3143, 20, 31, 26, 3, -31 },
  { 3221, 23, 32, 26, 2, -32 },
  { 3313, 22, 31, 26, 3, -31 },
  { 3399, 24, 38, 26, 2, -32 },
  { 3513, 23, 31, 26, 3, -31 },
  { 3603, 23, 32, 26, 2, -32 },
  { 3695, 25, 31, 26, 1, -31 },
  { 3792, 21, 31, 26, 3, -31 },
  { 3874, 25, 31, 26, 1, -31 },
  { 3971, 25, 31, 26, 1, -31 },
  { 4068, 25, 31, 26, 1, -31 },
  { 4165, 25, 31, 26, 1, -31 },
  { 4262, 23, 31, 26, 2, -31 },
  { 4352, 9, 43, 26, 9, -36 },
  { 4401, 17, 34, 26, 5, -31 },
  { 4474, 9, 43, 26, 9, -36 },
  { 4523, 18, 16, 26, 5, -31 },
  { 4559, 20, 5, 26, 3, 0 },
  { 4572, 10, 6, 26, 9, -32 },
  { 4580, 22, 24, 26, 2, -24 },
  { 4646, 21, 33, 26, 3, -33 },
  { 4733, 20, 24, 26, 3, -24 },
  { 4793, 21, 33, 26, 2, -33 },
  { 4880, 22, 24, 26, 2, -24 },
  { 4946, 22, 34, 26, 3, -34 },
  { 5040, 22, 33, 26, 2, -24 },
  { 5131, 21, 33, 26, 3, -33 },
  { 5218, 19, 32, 26, 5, -32 },
  { 5294, 14, 41, 26, 5, -32 },
  { 5366, 23, 33, 26, 3, -33 },
  { 5461, 20, 33, 26, 4, -33 },
  { 5544, 23, 24, 26, 2, -24 },
  { 5613, 21, 24, 26, 3, -24 },
  { 5676, 22, 24, 26, 2, -24 },
  { 5742, 21, 33, 26, 3, -24 },
  { 5829, 21, 33, 26, 2, -24 },
  { 5916, 18, 24, 26, 6, -24 },
  { 5970, 21, 24, 26, 3, -24 },
  { 6033, 21, 29, 26, 3, -29 },
  { 6110, 21, 23, 26, 3, -23 },
  { 6171, 23, 23, 26, 2, -23 },
  { 6238, 24, 23, 26, 1, -23 },
  { 6307, 23, 23, 26, 2, -23 },
  { 6374, 25, 32, 26, 1, -23 },
  { 6474, 21, 23, 26, 3, -23 },
  { 6535, 14, 42, 26, 7, -34 },
  { 6609, 4, 40, 26, 11, -31 },
  { 6629, 14, 42, 26, 7, -34 },
  { 6703, 24, 10, 26, 1, -18 },
};

const GFXfont RobotoMono_Bold44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold44pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_BOLD44PT7B_H_
