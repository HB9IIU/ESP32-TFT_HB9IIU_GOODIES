#ifndef _ROBOTOMONO_BOLD45PT7B_H_
#define _ROBOTOMONO_BOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF7, 0xFF, 0xFF, 0xFF, 0xBE, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07,
  0xBC, 0x1E, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x03,
  0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07,
  0x87, 0x80, 0x07, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0xEF, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x0F,
  0x06, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE1, 0xE3, 0xC0, 0xF0,
  0xF1, 0xE0, 0x7C, 0xF9, 0xE0, 0x3F, 0xFC, 0xE0, 0x0F, 0xFC, 0xF0, 0x03,
  0xFC, 0x70, 0x00, 0x10, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x08, 0x00, 0x0F, 0x3F,
  0xC0, 0x0F, 0x3F, 0xF0, 0x07, 0x3F, 0xFC, 0x07, 0x9F, 0x3E, 0x03, 0x8F,
  0x0F, 0x03, 0xC7, 0x87, 0x83, 0xC3, 0xC3, 0xC0, 0xE1, 0xE1, 0xE0, 0x20,
  0xF0, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x80,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xE3, 0xE0,
  0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0x1F, 0xFE, 0x0F, 0x8F, 0xFF,
  0x87, 0xCF, 0xCF, 0xC3, 0xEF, 0xE7, 0xF3, 0xF7, 0xE1, 0xFD, 0xFB, 0xF0,
  0x7F, 0xF9, 0xF8, 0x1F, 0xFC, 0xFC, 0x0F, 0xFE, 0x7E, 0x03, 0xFE, 0x3F,
  0x80, 0xFE, 0x1F, 0xF7, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFD, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7,
  0xBD, 0xE0, 0x00, 0x20, 0x06, 0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1E, 0x00, 0xE0, 0x06, 0x40,
  0x06, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E,
  0x07, 0xE0, 0xFC, 0x0F, 0x80, 0x70, 0x04, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x08, 0x0F, 0x03, 0x3E, 0x1C, 0x1E, 0x7F, 0x38, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80,
  0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF0, 0x1E, 0x00, 0x40, 0x38, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0xF8, 0xF8, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x08,
  0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFD, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x9F, 0xBF, 0xFD, 0xF9, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F,
  0xC1, 0xFC, 0x7F, 0xBF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC3, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFB,
  0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xE3,
  0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x03,
  0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFD, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x7C, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xBF, 0x81, 0xFC, 0xFF, 0xBF, 0xE7, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x9F, 0xE0, 0x7E, 0xFF, 0xE1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80,
  0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFE,
  0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC3, 0xF8, 0x7F, 0x1F, 0xC0, 0x7E, 0x7E, 0x01,
  0xF9, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFD,
  0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7,
  0xE0, 0x3F, 0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x1F,
  0xDF, 0xC0, 0xFF, 0x7F, 0x87, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x07, 0xFD, 0xF8, 0x03, 0x87, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x10,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x0C, 0x1F, 0x9F, 0xCF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1,
  0xF8, 0xF8, 0x78, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x9F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0x70,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7C, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x78, 0x3F,
  0x1E, 0x3C, 0x3F, 0xC7, 0x3C, 0x3F, 0xF3, 0x9E, 0x3F, 0x71, 0xEE, 0x1E,
  0x38, 0xFF, 0x1E, 0x1C, 0x7F, 0x8F, 0x0E, 0x3F, 0xC7, 0x07, 0x1F, 0xE7,
  0x83, 0x8F, 0xF3, 0xC1, 0xC7, 0x79, 0xE1, 0xE3, 0xBC, 0xF0, 0xF1, 0xDE,
  0x78, 0x78, 0xEF, 0x3C, 0x3C, 0xF7, 0x8F, 0x3E, 0x73, 0xC7, 0xFF, 0xF8,
  0xE3, 0xFB, 0xF8, 0x78, 0x78, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFC, 0x1C, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0,
  0x3F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF0,
  0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFE, 0x01, 0xF8, 0xFC,
  0x07, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0x7F, 0x8F, 0xC0, 0x7F, 0x3F,
  0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFC, 0x03,
  0xFB, 0xF0, 0x1F, 0xCF, 0xC1, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F,
  0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0xFC, 0xFE, 0x03, 0xF9, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00,
  0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0x7E,
  0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x8F, 0xC0, 0x7F, 0x87,
  0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0xC0, 0xFC, 0x1F, 0xC0,
  0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xE0, 0x0F, 0xCF, 0xE0,
  0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xF7, 0xF0, 0x0F, 0xF3,
  0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC,
  0x07, 0xF0, 0x7E, 0x03, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F,
  0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xFD, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xEF, 0x7F, 0xFF, 0xBD, 0xEF, 0xFE, 0xF7, 0xBF, 0xFB, 0xFE, 0xFF,
  0xE7, 0xF3, 0xFF, 0x9F, 0xCF, 0xFE, 0x7F, 0x3F, 0xF8, 0xFC, 0xFF, 0xE3,
  0xE3, 0xFF, 0x8F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0x70, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFE, 0xF8, 0xFF, 0xF7, 0xC7, 0xFF, 0x9F, 0x3F, 0xFC, 0xF9,
  0xFF, 0xE3, 0xCF, 0xFF, 0x1F, 0x7F, 0xF8, 0xFB, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x3F, 0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF9, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0x7E,
  0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80, 0xFF,
  0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF,
  0x01, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03,
  0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F,
  0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xDF, 0xC1, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xF8,
  0x3E, 0x0F, 0xFE, 0x0F, 0x83, 0xEF, 0xC3, 0xE0, 0xFB, 0xF0, 0xF8, 0x7E,
  0xFC, 0x3E, 0x1F, 0xBF, 0x1F, 0x87, 0xEF, 0xC7, 0xF1, 0xF9, 0xF1, 0xFC,
  0x7C, 0x7C, 0x7F, 0x1F, 0x1F, 0x1F, 0xC7, 0xC7, 0xC7, 0xF1, 0xF1, 0xF9,
  0xFC, 0xFC, 0x7E, 0xFF, 0xBF, 0x1F, 0xBD, 0xEF, 0xC3, 0xEF, 0x7B, 0xE0,
  0xFB, 0xDE, 0xF8, 0x3E, 0xF7, 0xBE, 0x0F, 0xBD, 0xEF, 0x83, 0xEF, 0x7B,
  0xE0, 0xFF, 0x9F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x81, 0xFE,
  0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01,
  0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0xDF, 0xC0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x07, 0xE3, 0xF8,
  0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xFB,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE7, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0x81, 0xF8,
  0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3C, 0xF0, 0x1F, 0x3E,
  0x07, 0x8F, 0x83, 0xE1, 0xE0, 0xF8, 0x7C, 0x3C, 0x1F, 0x1F, 0x03, 0xE7,
  0xC0, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xF9, 0xFE, 0x7F, 0x03, 0xFB, 0xF0, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFF, 0x7F, 0x81, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC7, 0xF0, 0x3F, 0x7F, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x3F, 0xC1, 0xFC, 0xFE, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x80,
  0xFE, 0xFF, 0x03, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFD, 0xFF, 0xC3, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xFB, 0xF8, 0x0F,
  0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0xC0, 0xFC, 0xFF, 0xBF, 0xE3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x8F, 0xC1, 0xFF, 0xBF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0x7F, 0x01, 0xFD, 0xF8, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0xC0, 0x7F, 0x3F, 0x83, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFE, 0xFC, 0x0F, 0xF3, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x3F,
  0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x20, 0xFE,
  0x01, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x10, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0xFC, 0x1F, 0xFB, 0xF0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFE, 0x0F, 0xF7, 0xF0, 0x0F,
  0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80,
  0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x1F, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xEF, 0xC0, 0xFF, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x80, 0x1F, 0xC7, 0x80, 0xFE, 0x1F, 0xDF,
  0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x0F, 0xE1, 0xF9, 0xFF, 0x8F, 0xDF, 0xFE, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFF, 0xBF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF,
  0xE3, 0xFF, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF0,
  0x7E, 0x1F, 0xC0, 0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03, 0xF7, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xFE, 0x7E, 0x01,
  0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF1, 0xF9, 0xF7,
  0xF7, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0x8F, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8,
  0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87,
  0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F,
  0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE,
  0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3F, 0x87, 0xE7, 0xFF, 0x3F, 0x7F,
  0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF8,
  0xFC, 0x0F, 0xE1, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFC, 0x7F, 0x07, 0xEF, 0xFC, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFD, 0xFF, 0xBF, 0xEF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xF7, 0xFF, 0x1F, 0x9F, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x1F,
  0xFB, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFE, 0x0F,
  0xF7, 0xF0, 0x1F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x1F,
  0xCF, 0xFB, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xEF, 0xC0,
  0xFF, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0xFC, 0x1F, 0xFF, 0x8F, 0xFB, 0xF3, 0xFF, 0x7E, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xF0,
  0x7F, 0xBF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xF7, 0xE1, 0xFE,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00,
  0xFC, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xF7, 0xE0, 0x03,
  0xEF, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xF8, 0x3C,
  0x1F, 0xFC, 0x1F, 0x0F, 0xFE, 0x0F, 0x87, 0xFF, 0x87, 0xC3, 0xEF, 0xC7,
  0xE1, 0xF3, 0xE3, 0xF0, 0xF9, 0xF1, 0xF8, 0x7C, 0xF8, 0xFE, 0x7E, 0x7C,
  0x7F, 0x3E, 0x3E, 0x3F, 0x9F, 0x1F, 0x3D, 0xCF, 0x87, 0xDE, 0xE7, 0xC3,
  0xEF, 0x7B, 0xE1, 0xF7, 0x3D, 0xF0, 0xFB, 0x9E, 0xF0, 0x7F, 0xC7, 0xF8,
  0x3F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F,
  0x81, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x03,
  0xF0, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xC7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x13, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x3F, 0xE0, 0xFE, 0x03, 0xF0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x00, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xE0, 0x0F, 0x7F, 0xF8, 0x0F, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0x3F, 0xF8,
  0x7F, 0xFE, 0xF0, 0x3F, 0xFE, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xE0,
};

const GFXglyph RobotoMono_Bold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 32, 27, 10, -32 },
  { 29, 14, 12, 27, 6, -34 },
  { 50, 24, 32, 27, 1, -32 },
  { 146, 22, 42, 27, 3, -37 },
  { 262, 25, 32, 27, 1, -32 },
  { 362, 25, 32, 27, 2, -32 },
  { 462, 5, 12, 27, 10, -34 },
  { 470, 12, 46, 27, 8, -36 },
  { 539, 12, 46, 27, 7, -36 },
  { 608, 23, 23, 27, 3, -32 },
  { 675, 22, 24, 27, 2, -27 },
  { 741, 8, 14, 27, 8, -5 },
  { 755, 19, 5, 27, 6, -17 },
  { 767, 9, 8, 27, 9, -8 },
  { 776, 18, 35, 27, 5, -32 },
  { 855, 21, 32, 27, 3, -32 },
  { 939, 14, 32, 27, 4, -32 },
  { 995, 22, 32, 27, 2, -32 },
  { 1083, 22, 32, 27, 2, -32 },
  { 1171, 24, 32, 27, 1, -32 },
  { 1267, 21, 32, 27, 3, -32 },
  { 1351, 22, 32, 27, 2, -32 },
  { 1439, 22, 32, 27, 2, -32 },
  { 1527, 22, 32, 27, 2, -32 },
  { 1615, 22, 32, 27, 2, -32 },
  { 1703, 8, 26, 27, 10, -26 },
  { 1729, 9, 35, 27, 10, -26 },
  { 1769, 20, 21, 27, 3, -24 },
  { 1822, 21, 15, 27, 3, -21 },
  { 1862, 19, 21, 27, 4, -24 },
  { 1912, 20, 32, 27, 4, -32 },
  { 1992, 25, 32, 27, 1, -32 },
  { 2092, 26, 32, 27, 1, -32 },
  { 2196, 23, 32, 27, 3, -32 },
  { 2288, 23, 32, 27, 2, -32 },
  { 2380, 22, 32, 27, 3, -32 },
  { 2468, 22, 32, 27, 3, -32 },
  { 2556, 22, 32, 27, 3, -32 },
  { 2644, 23, 32, 27, 2, -32 },
  { 2736, 21, 32, 27, 3, -32 },
  { 2820, 19, 32, 27, 4, -32 },
  { 2896, 22, 32, 27, 2, -32 },
  { 2984, 25, 32, 27, 3, -32 },
  { 3084, 21, 32, 27, 3, -32 },
  { 3168, 22, 32, 27, 3, -32 },
  { 3256, 21, 32, 27, 3, -32 },
  { 3340, 23, 32, 27, 2, -32 },
  { 3432, 23, 32, 27, 3, -32 },
  { 3524, 25, 38, 27, 2, -32 },
  { 3643, 23, 32, 27, 3, -32 },
  { 3735, 24, 32, 27, 2, -32 },
  { 3831, 25, 32, 27, 1, -32 },
  { 3931, 21, 32, 27, 3, -32 },
  { 4015, 25, 32, 27, 1, -32 },
  { 4115, 26, 32, 27, 1, -32 },
  { 4219, 26, 32, 27, 1, -32 },
  { 4323, 26, 32, 27, 1, -32 },
  { 4427, 23, 32, 27, 2, -32 },
  { 4519, 10, 44, 27, 9, -37 },
  { 4574, 18, 35, 27, 5, -32 },
  { 4653, 10, 44, 27, 9, -37 },
  { 4708, 18, 17, 27, 5, -32 },
  { 4747, 20, 5, 27, 3, 0 },
  { 4760, 11, 6, 27, 9, -32 },
  { 4769, 21, 24, 27, 3, -24 },
  { 4832, 22, 34, 27, 3, -34 },
  { 4926, 21, 24, 27, 3, -24 },
  { 4989, 22, 34, 27, 2, -34 },
  { 5083, 23, 24, 27, 2, -24 },
  { 5152, 22, 35, 27, 3, -35 },
  { 5249, 22, 33, 27, 2, -24 },
  { 5340, 21, 34, 27, 3, -34 },
  { 5430, 19, 33, 27, 5, -33 },
  { 5509, 14, 43, 27, 5, -33 },
  { 5585, 23, 34, 27, 3, -34 },
  { 5683, 20, 34, 27, 4, -34 },
  { 5768, 23, 24, 27, 2, -24 },
  { 5837, 21, 24, 27, 3, -24 },
  { 5900, 23, 24, 27, 2, -24 },
  { 5969, 21, 33, 27, 3, -24 },
  { 6056, 22, 33, 27, 2, -24 },
  { 6147, 19, 24, 27, 6, -24 },
  { 6204, 21, 24, 27, 3, -24 },
  { 6267, 21, 30, 27, 3, -30 },
  { 6346, 21, 24, 27, 3, -24 },
  { 6409, 23, 24, 27, 2, -24 },
  { 6478, 25, 24, 27, 1, -24 },
  { 6553, 24, 24, 27, 2, -24 },
  { 6625, 26, 34, 27, 1, -24 },
  { 6736, 22, 24, 27, 3, -24 },
  { 6802, 14, 43, 27, 7, -35 },
  { 6878, 4, 41, 27, 12, -32 },
  { 6899, 15, 43, 27, 7, -35 },
  { 6980, 24, 10, 27, 1, -18 },
};

const GFXfont RobotoMono_Bold45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold45pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_BOLD45PT7B_H_
