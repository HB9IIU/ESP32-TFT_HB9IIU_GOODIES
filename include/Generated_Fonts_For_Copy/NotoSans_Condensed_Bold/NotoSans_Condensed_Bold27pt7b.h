#ifndef _NOTOSANS_CONDENSED_BOLD27PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xB9, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x0E, 0xFF,
  0xDC, 0xF3, 0xDC, 0xF7, 0x3D, 0xCF, 0x73, 0xDC, 0xE7, 0x18, 0x0E, 0x70,
  0x73, 0x03, 0x38, 0x19, 0xC1, 0xCE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0xC0, 0xCE, 0x06, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE6, 0x06, 0x70,
  0x33, 0x81, 0x9C, 0x1C, 0xE0, 0x06, 0x00, 0xC0, 0x18, 0x1F, 0xF7, 0xFF,
  0xFF, 0xBD, 0x97, 0xB0, 0xF6, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F,
  0xC1, 0xBC, 0x37, 0xE7, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x10, 0x01, 0x07, 0xC0, 0xE0, 0x7E, 0x0E, 0x0E, 0x71, 0xC0, 0xE7,
  0x1C, 0x0E, 0x71, 0x80, 0xE7, 0x38, 0x0E, 0x73, 0x80, 0xE7, 0x73, 0xCE,
  0x77, 0x7E, 0x7E, 0xE7, 0xE7, 0xCE, 0xE7, 0x18, 0xCE, 0x70, 0x1C, 0xE7,
  0x01, 0xCE, 0x70, 0x38, 0xE7, 0x03, 0x8E, 0x70, 0x70, 0xE7, 0x07, 0x07,
  0xE0, 0xE0, 0x3C, 0x04, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x79,
  0xE0, 0x79, 0xE0, 0x79, 0xC0, 0x3B, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x7F,
  0x1E, 0x7F, 0x9E, 0xF7, 0xBC, 0xF3, 0xFC, 0xF1, 0xF8, 0xF0, 0xF8, 0xF0,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0x9F, 0xF7, 0x77, 0x77, 0x70, 0x0E,
  0x38, 0xF1, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x38, 0x70, 0xE1, 0xE1, 0xC3, 0xC3, 0x83, 0x80, 0xE1, 0xC7, 0x0E, 0x38,
  0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xF3, 0x8E, 0x71,
  0xCE, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x47, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF8, 0x3B, 0x8F, 0x79, 0xC6, 0x08, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x7B, 0x9D, 0xEE, 0x73, 0x80, 0xFF, 0xFF, 0xF8, 0x77,
  0xFE, 0xE0, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x00, 0x04, 0x07, 0xF0, 0xFF, 0x3F, 0xE7, 0x1F,
  0xE3, 0xFC, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x7F, 0x8F, 0x79, 0xEF, 0xF8, 0xFF, 0x0F, 0x80, 0x07, 0x87, 0xC7,
  0xE7, 0xF7, 0xFF, 0xBC, 0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x04, 0x07, 0xF3, 0xFF, 0x7F,
  0xF6, 0x1E, 0x83, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x04,
  0x0F, 0xF3, 0xFF, 0x3F, 0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x0F, 0xC7,
  0xE0, 0xFE, 0x1F, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xFF, 0xFF,
  0xFF, 0x7F, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x37, 0x83, 0xBC, 0x19, 0xE1, 0xCF, 0x1C, 0x78, 0xE3, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x7F, 0xCF,
  0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFC, 0x7F, 0xCF, 0xFC,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7E, 0x1F, 0xFF, 0xDF, 0xF9, 0xFC,
  0x00, 0x01, 0x00, 0xFC, 0x1F, 0xC3, 0xFC, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x20, 0xEF, 0xCF, 0xFE, 0xFF, 0xEF, 0x1E, 0xF0, 0xEF, 0x0F, 0xF0, 0xEF,
  0x0E, 0x79, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x00,
  0x04, 0x03, 0xF8, 0x7F, 0xC7, 0xBE, 0xF1, 0xEF, 0x1E, 0xF1, 0xE7, 0xBC,
  0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xFC, 0xF1, 0xEF, 0x1E, 0xE0, 0xEE, 0x0F,
  0xF0, 0xEF, 0xFE, 0x7F, 0xC3, 0xF8, 0x04, 0x07, 0xF1, 0xFF, 0x7F, 0xEF,
  0x1F, 0xE3, 0xF8, 0x3F, 0x07, 0xF1, 0xFE, 0x3F, 0xFF, 0xBF, 0xF3, 0xEE,
  0x01, 0xC0, 0x78, 0x0E, 0x03, 0xCF, 0xF1, 0xFC, 0x3F, 0x00, 0x73, 0xFE,
  0xE2, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFD, 0xC0, 0x73, 0xDE, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xB9, 0xDE, 0xF7, 0x38, 0x00, 0x30, 0x0F, 0x03,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x01, 0xF0, 0x7E, 0x1F, 0x8F, 0xE0, 0xF8, 0x0E, 0x00,
  0x80, 0x00, 0x04, 0x1F, 0xEF, 0xFD, 0xFF, 0x41, 0xC0, 0x70, 0x1C, 0x0F,
  0x07, 0x83, 0xE0, 0xF0, 0x78, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x07,
  0x81, 0xE0, 0x70, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x78, 0x1E, 0x1E, 0x01,
  0xC3, 0x80, 0x1C, 0xE3, 0xFB, 0x9C, 0xFF, 0x3F, 0x3C, 0xE7, 0xE7, 0x1C,
  0xFC, 0xE3, 0x9F, 0x9C, 0x73, 0xF3, 0x8E, 0x7E, 0x73, 0xCD, 0xCF, 0x7B,
  0x98, 0xFB, 0xE3, 0x8E, 0x38, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x38,
  0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x78, 0x1C,
  0x78, 0x3C, 0x78, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x78, 0x3C, 0x78,
  0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x1F, 0xFF, 0xCF, 0xFE, 0xFF, 0xEF,
  0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0xEF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFE, 0xFF, 0x80,
  0x01, 0x00, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7, 0xC1, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x11, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xFF,
  0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xDE, 0x7E, 0xFF,
  0xE7, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00,
  0x00, 0x80, 0x1F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3E, 0x09, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x3D, 0xE0,
  0xF7, 0x83, 0xDE, 0x0F, 0x3C, 0x3C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xFF, 0xFD, 0xF1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0xFF, 0xFF, 0xF8, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFE, 0xFE, 0xFC, 0x70,
  0xF0, 0x7F, 0x87, 0xBC, 0x79, 0xE3, 0xCF, 0x3C, 0x7B, 0xE3, 0xDE, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0x3C, 0x79, 0xE3, 0xC7,
  0x9E, 0x3C, 0xF0, 0xF7, 0x87, 0xBC, 0x1E, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFB, 0x87, 0x7E, 0xE1, 0xDF, 0xB8,
  0x77, 0xEF, 0x39, 0xFD, 0xCE, 0x7F, 0x73, 0x9F, 0xDC, 0xE7, 0xF3, 0xF1,
  0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0xCF, 0x87, 0xF1, 0xE1, 0xFC, 0x78, 0x7F,
  0x1E, 0x1C, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xB8,
  0x7E, 0xF1, 0xFB, 0xC7, 0xE7, 0x9F, 0x9E, 0x7F, 0x3D, 0xFC, 0xF7, 0xF1,
  0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xC0,
  0x01, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC3, 0xCF, 0x03, 0xDE,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1F, 0x7C, 0x7C, 0x7F, 0xF8, 0x7F, 0xE0,
  0x7F, 0x00, 0xFF, 0x9F, 0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F,
  0x8F, 0xF3, 0xFF, 0xFB, 0xFF, 0x7F, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF,
  0xE7, 0xC3, 0xCF, 0x03, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1F, 0x7C,
  0x7C, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xE3, 0xCF, 0x1E,
  0x78, 0x7B, 0xC7, 0x9E, 0x3C, 0xFF, 0xE7, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F,
  0x3C, 0x79, 0xE3, 0xC7, 0x9E, 0x3C, 0xF0, 0xF7, 0x87, 0xBC, 0x3E, 0x06,
  0x07, 0xFD, 0xFF, 0x3F, 0xEF, 0x0D, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0x7C, 0x0E, 0xE3, 0xDF, 0xFB,
  0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x1F, 0x7F, 0xF1,
  0xFF, 0x07, 0xF0, 0xF0, 0x1F, 0xE0, 0x39, 0xC0, 0xF3, 0xC1, 0xE7, 0x83,
  0xC7, 0x07, 0x0E, 0x1E, 0x1E, 0x3C, 0x3C, 0x70, 0x38, 0xE0, 0x73, 0xC0,
  0xF7, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xDC,
  0x3E, 0x0E, 0x70, 0xFC, 0x79, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F,
  0x1E, 0x39, 0xCE, 0x70, 0xE7, 0x3B, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC,
  0x1D, 0xCE, 0xE0, 0x7E, 0x1B, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x7D, 0xE1, 0xE3,
  0xC7, 0x8F, 0x3C, 0x1E, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7B, 0xC3, 0xCF, 0x0F, 0x1E,
  0x78, 0x79, 0xE1, 0xFF, 0x03, 0xC0, 0xF0, 0x3D, 0xE1, 0xE7, 0x87, 0x8E,
  0x1C, 0x3C, 0xF0, 0xF3, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0xFF, 0xC0, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x0E, 0xE0, 0xE7, 0x07,
  0x1C, 0x70, 0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0x70, 0xFF, 0xFF, 0xFC, 0xF0,
  0xF0, 0xF0, 0xE0, 0xE0, 0x1F, 0x8F, 0xF8, 0xFF, 0x90, 0xF0, 0x1E, 0x03,
  0xCF, 0xFB, 0xFF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xFF, 0xFD, 0xDF,
  0x38, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8E,
  0xFC, 0xFF, 0xEF, 0x1E, 0xF1, 0xEE, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0xEE,
  0x0E, 0xF1, 0xEF, 0x1E, 0xFF, 0xEF, 0xFC, 0xEF, 0x80, 0x0F, 0x8F, 0xF7,
  0xFD, 0xE2, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE1,
  0x7F, 0xCF, 0xF1, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x1E, 0xF3, 0xFF, 0x7F, 0xF7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F, 0xF7, 0xFF, 0x3E, 0x70,
  0x1F, 0x03, 0xFC, 0x7F, 0xE7, 0x1E, 0xF0, 0xEF, 0x0E, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x07, 0x82, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0x03,
  0x07, 0xF1, 0xF8, 0xFE, 0x3C, 0x0F, 0x03, 0xFB, 0xFE, 0xFF, 0x8F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x00, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F, 0xF7, 0xFF, 0x3E,
  0xF0, 0x0F, 0x00, 0xF4, 0x0F, 0x7F, 0xE7, 0xFE, 0x7F, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xE7, 0x7E, 0xFF, 0xFF, 0x3F,
  0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1E, 0x4E, 0xFE, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xE0, 0x08, 0x38, 0x78, 0xE0, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0xFD,
  0xFB, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xFE, 0x1E, 0xE3, 0xCE, 0x3C, 0xE7, 0x8E, 0xF0, 0xEE, 0x0F, 0xF0, 0xFF,
  0x0F, 0x78, 0xE3, 0xCE, 0x3C, 0xE1, 0xEE, 0x1E, 0xE0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE7, 0x8F, 0x3B, 0xF7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xCF, 0xF1, 0xE1, 0xFC, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87,
  0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8,
  0x78, 0x7E, 0x1E, 0x1C, 0xE7, 0x9D, 0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x78, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80,
  0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x1E, 0xF1, 0xEE, 0x0E, 0xE0, 0xEE, 0x0F,
  0xE0, 0xEE, 0x0E, 0xF1, 0xEF, 0x1E, 0xFF, 0xEE, 0xFC, 0xEF, 0x8E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x73, 0xF7, 0x7F,
  0xF7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x8F, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0xE7, 0xEF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x3F, 0xFF, 0xFE, 0x2F,
  0x07, 0xC3, 0xF8, 0xFE, 0x1F, 0x83, 0xC0, 0xF0, 0x7F, 0xFF, 0xFB, 0xF8,
  0x1C, 0x0E, 0x07, 0x07, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0x1F, 0x8F, 0xC0, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF9, 0xFF, 0xFF, 0xFD, 0xDF, 0x38, 0xF0, 0x7F, 0x83, 0xDC, 0x1C, 0xF1,
  0xE7, 0x8F, 0x1C, 0x70, 0xE3, 0x87, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0x70,
  0x3F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x0E,
  0x71, 0xF1, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0x9B, 0x9C, 0x39, 0x99,
  0xC3, 0xB9, 0xBC, 0x3F, 0x9B, 0xC3, 0xF9, 0xF8, 0x1F, 0x1F, 0x81, 0xF1,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF3, 0xC7,
  0x9E, 0x78, 0x7B, 0xC3, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xFE, 0x0F, 0xF0, 0x7B, 0xC7, 0x9E, 0x3C, 0x7B, 0xC3, 0xE0, 0xF0, 0x7F,
  0x83, 0xDE, 0x1C, 0xF1, 0xE7, 0x8F, 0x1C, 0x70, 0xF3, 0x87, 0xBC, 0x1D,
  0xC0, 0xEE, 0x07, 0x70, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0x87, 0xC7, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x3F, 0x1E, 0x0F, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xF8, 0x7C, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C,
  0x3C, 0x1F, 0x07, 0x1F, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8,
  0xF8, 0xF0, 0x38, 0x1F, 0xE3, 0xFF, 0xF8, 0xFE, 0x81, 0x80,
};

const GFXglyph NotoSans_Condensed_Bold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 10, 7, 12, 1, -19 },
  { 22, 13, 19, 15, 1, -19 },
  { 53, 11, 23, 13, 1, -21 },
  { 85, 20, 20, 22, 1, -20 },
  { 135, 16, 20, 17, 1, -20 },
  { 175, 4, 7, 7, 1, -19 },
  { 179, 7, 23, 9, 1, -19 },
  { 200, 6, 23, 9, 1, -19 },
  { 218, 11, 12, 13, 1, -21 },
  { 235, 12, 13, 13, 1, -16 },
  { 255, 5, 7, 7, 1, -3 },
  { 260, 7, 3, 8, 1, -9 },
  { 263, 5, 4, 7, 1, -4 },
  { 266, 11, 19, 11, 0, -19 },
  { 293, 11, 20, 13, 1, -20 },
  { 321, 9, 19, 13, 1, -19 },
  { 343, 11, 20, 13, 1, -20 },
  { 371, 11, 20, 13, 1, -20 },
  { 399, 13, 19, 13, 0, -19 },
  { 430, 11, 19, 13, 1, -19 },
  { 457, 12, 20, 13, 1, -20 },
  { 487, 12, 19, 13, 1, -19 },
  { 516, 12, 20, 13, 1, -20 },
  { 546, 11, 20, 13, 1, -20 },
  { 574, 5, 15, 7, 1, -15 },
  { 584, 5, 19, 7, 1, -15 },
  { 596, 12, 13, 13, 1, -16 },
  { 616, 12, 9, 13, 1, -14 },
  { 630, 12, 13, 13, 1, -16 },
  { 650, 10, 20, 11, 0, -20 },
  { 675, 19, 21, 21, 1, -19 },
  { 725, 16, 19, 16, 0, -19 },
  { 763, 12, 19, 15, 2, -19 },
  { 792, 13, 20, 14, 1, -20 },
  { 825, 13, 19, 17, 2, -19 },
  { 856, 9, 19, 13, 2, -19 },
  { 878, 9, 19, 13, 2, -19 },
  { 900, 14, 20, 17, 1, -20 },
  { 935, 13, 19, 17, 2, -19 },
  { 966, 7, 19, 9, 1, -19 },
  { 983, 8, 25, 8, -2, -19 },
  { 1008, 13, 19, 15, 2, -19 },
  { 1039, 10, 19, 12, 2, -19 },
  { 1063, 18, 19, 22, 2, -19 },
  { 1106, 14, 19, 19, 2, -19 },
  { 1140, 15, 20, 18, 1, -20 },
  { 1178, 11, 19, 14, 2, -19 },
  { 1205, 15, 25, 18, 1, -20 },
  { 1252, 13, 19, 15, 2, -19 },
  { 1283, 11, 20, 12, 1, -20 },
  { 1311, 12, 19, 13, 0, -19 },
  { 1340, 13, 19, 17, 2, -19 },
  { 1371, 15, 19, 15, 0, -19 },
  { 1407, 22, 19, 22, 0, -19 },
  { 1460, 14, 19, 14, 0, -19 },
  { 1494, 14, 19, 14, 0, -19 },
  { 1528, 12, 19, 12, 0, -19 },
  { 1557, 6, 23, 9, 2, -19 },
  { 1575, 11, 19, 11, 0, -19 },
  { 1602, 6, 23, 9, 1, -19 },
  { 1620, 13, 12, 15, 1, -19 },
  { 1640, 11, 2, 11, 0, 2 },
  { 1643, 7, 5, 9, 1, -21 },
  { 1648, 11, 15, 14, 1, -15 },
  { 1669, 12, 21, 15, 2, -21 },
  { 1701, 10, 15, 12, 1, -15 },
  { 1720, 12, 21, 15, 1, -21 },
  { 1752, 12, 15, 13, 1, -15 },
  { 1775, 10, 21, 9, 0, -21 },
  { 1802, 12, 21, 15, 1, -15 },
  { 1834, 11, 21, 15, 2, -21 },
  { 1863, 4, 21, 7, 2, -21 },
  { 1874, 7, 27, 7, -1, -21 },
  { 1898, 12, 21, 14, 2, -21 },
  { 1930, 3, 21, 7, 2, -21 },
  { 1938, 18, 15, 22, 2, -15 },
  { 1972, 11, 15, 15, 2, -15 },
  { 1993, 12, 15, 14, 1, -15 },
  { 2016, 12, 21, 15, 2, -15 },
  { 2048, 12, 21, 15, 1, -15 },
  { 2080, 8, 15, 10, 2, -15 },
  { 2095, 9, 15, 11, 1, -15 },
  { 2112, 9, 18, 10, 0, -18 },
  { 2133, 11, 15, 15, 2, -15 },
  { 2154, 13, 15, 13, 0, -15 },
  { 2179, 20, 15, 20, 0, -15 },
  { 2217, 13, 15, 13, 0, -15 },
  { 2242, 13, 21, 13, 0, -15 },
  { 2277, 9, 15, 11, 1, -15 },
  { 2294, 9, 23, 10, 0, -19 },
  { 2320, 3, 27, 13, 5, -21 },
  { 2331, 8, 23, 10, 1, -19 },
  { 2354, 12, 5, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_Bold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_BOLD27PT7B_H_
