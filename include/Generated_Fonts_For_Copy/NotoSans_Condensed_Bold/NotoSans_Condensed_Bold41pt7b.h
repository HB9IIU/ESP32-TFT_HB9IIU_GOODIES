#ifndef _NOTOSANS_CONDENSED_BOLD41PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0xFD, 0xFF,
  0xFF, 0xE7, 0xC0, 0xFC, 0x7F, 0xF8, 0xFB, 0xF1, 0xF7, 0xE3, 0xEF, 0xC7,
  0xCF, 0x8F, 0x9E, 0x1F, 0x3C, 0x3E, 0x78, 0x7C, 0xF0, 0xF8, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x1E, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0x8F, 0x00, 0x78, 0xF8, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03,
  0xE7, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0x81,
  0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0x7C, 0xFD, 0x82, 0x7C, 0xC0,
  0x3E, 0x60, 0x1F, 0xB0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x37, 0xE0, 0x19, 0xF8,
  0x0C, 0xFE, 0x06, 0x7F, 0x83, 0x3E, 0xF9, 0xBF, 0x7F, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0x81, 0xFF, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0xFF, 0x80,
  0x78, 0x03, 0xFF, 0x00, 0xF0, 0x07, 0xDF, 0x03, 0xC0, 0x0F, 0x1E, 0x07,
  0x80, 0x3E, 0x3C, 0x1F, 0x00, 0x7C, 0x78, 0x3C, 0x00, 0xF8, 0xF8, 0xF8,
  0x01, 0xF1, 0xF1, 0xE0, 0x03, 0xE3, 0xE3, 0xC0, 0x07, 0xC7, 0x8F, 0x00,
  0x0F, 0x8F, 0x1E, 0x3E, 0x0F, 0x1E, 0x7C, 0xFF, 0x1F, 0x7C, 0xF3, 0xFE,
  0x3F, 0xF3, 0xE7, 0xFE, 0x3F, 0xE7, 0x9F, 0x3C, 0x3F, 0x9F, 0x3C, 0x7C,
  0x1C, 0x3C, 0x78, 0xF8, 0x00, 0x78, 0xF0, 0xF0, 0x01, 0xE1, 0xE1, 0xE0,
  0x03, 0xC3, 0xC3, 0xC0, 0x0F, 0x87, 0x87, 0x80, 0x1E, 0x0F, 0x1F, 0x00,
  0x7C, 0x1E, 0x3E, 0x00, 0xF0, 0x3E, 0x78, 0x01, 0xE0, 0x3F, 0xF0, 0x07,
  0x80, 0x7F, 0xE0, 0x0F, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3E, 0x1F, 0xF0, 0x7E, 0x3F,
  0xF8, 0x7E, 0x7F, 0xFC, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0x7F, 0xFC, 0xFC,
  0x3F, 0xFC, 0xFC, 0x1F, 0xF8, 0xFC, 0x0F, 0xF8, 0xFC, 0x0F, 0xF0, 0xFE,
  0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFE, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0x9E, 0x79,
  0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C,
  0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xF0,
  0xF8, 0x3C, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x04, 0x1E, 0x1B, 0xCF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0xC1, 0xF9, 0xF0, 0xF8,
  0xFC, 0x3C, 0x38, 0x04, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFB, 0xFF, 0xFF,
  0xCF, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x0F, 0xCF, 0xC7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C,
  0x0F, 0xDF, 0x03, 0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xDF, 0x7C,
  0xF9, 0xC7, 0xC4, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0x8F, 0xE3,
  0x81, 0xF8, 0x40, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0x07, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0x0F, 0xE3, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xBF, 0x3F, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0xF7, 0xE0, 0x3C, 0xFC, 0x07, 0x9F, 0x81, 0xE3, 0xF0, 0x3C, 0x7E, 0x0F,
  0x0F, 0xC3, 0xE1, 0xF8, 0x78, 0x3F, 0x1F, 0x07, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x70, 0x0F, 0xFF,
  0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0x41, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFD,
  0x80, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF3, 0xF0, 0x7D, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0x8F, 0xEF, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x9F, 0x87, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F,
  0x87, 0xE3, 0xE1, 0xF8, 0xFC, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC7, 0xE3, 0xF9, 0xF0, 0x7E,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF,
  0x87, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xCF,
  0xC7, 0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xF7, 0xE1, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFD, 0xF1, 0xFE, 0xFC, 0x1E, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x08, 0x7F, 0x83, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xEF,
  0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xF7,
  0xFF, 0xFF, 0x9F, 0x00, 0x1C, 0x3E, 0x7F, 0x7F, 0x7F, 0x3E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xF8,
  0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x78, 0x7F, 0x20, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C,
  0x3C, 0x0F, 0xE1, 0xE7, 0xC3, 0xFF, 0x9E, 0x78, 0x7F, 0xF1, 0xF7, 0x8F,
  0xCF, 0x0F, 0xF0, 0xF8, 0xF0, 0xFF, 0x1F, 0x0F, 0x0F, 0xF1, 0xF0, 0xF0,
  0xFF, 0x1E, 0x0F, 0x0F, 0xF1, 0xE0, 0xF0, 0xFF, 0x1E, 0x0F, 0x0F, 0xF1,
  0xE0, 0xF0, 0xFF, 0x1E, 0x0F, 0x0F, 0xF1, 0xF1, 0xF1, 0xEF, 0x0F, 0x1F,
  0x9E, 0xF0, 0xFF, 0xBF, 0xCF, 0x87, 0xF3, 0xFC, 0x78, 0x3E, 0x1F, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x04, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xEF,
  0x80, 0x03, 0xEF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xE7,
  0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFB, 0xF3, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0x8F, 0x0F, 0xE0, 0x23, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC3,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFE, 0x1E, 0x3F,
  0x80, 0x27, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xF0, 0x1F, 0x3F, 0x81, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x87, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7E, 0xBF, 0xDF, 0xFB, 0xFE, 0x7F, 0xCF, 0xE0, 0xE0,
  0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC,
  0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F,
  0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFB, 0xC0, 0x7F, 0xFF, 0xBE, 0x07, 0xFF, 0xFB, 0xE0, 0x7B, 0xFF,
  0xBE, 0x0F, 0xBF, 0xF9, 0xE0, 0xFB, 0xFF, 0x9F, 0x0F, 0x3F, 0xF9, 0xF0,
  0xF3, 0xFF, 0x8F, 0x1F, 0x3F, 0xF8, 0xF1, 0xF3, 0xFF, 0x8F, 0x9E, 0x3F,
  0xF8, 0xFB, 0xE3, 0xFF, 0x87, 0xBE, 0x3F, 0xF8, 0x7F, 0xC3, 0xFF, 0x87,
  0xFC, 0x3F, 0xF8, 0x7F, 0xC3, 0xFF, 0x83, 0xF8, 0x3F, 0xF8, 0x3F, 0x83,
  0xFF, 0x83, 0xF8, 0x3F, 0xF8, 0x3F, 0x83, 0xFF, 0x81, 0xF0, 0x3F, 0xF8,
  0x1F, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xEF, 0xC1, 0xFF, 0xBF, 0x07, 0xFE, 0x7E, 0x1F,
  0xF9, 0xF8, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x1F, 0x9F, 0xF8,
  0x7E, 0x7F, 0xE0, 0xF9, 0xFF, 0x83, 0xF7, 0xFE, 0x07, 0xDF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xF8, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0xFE, 0x7E, 0x00,
  0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x80, 0xFE, 0x3F, 0x83, 0xF8, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE7, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x1F, 0xC0, 0xFE,
  0x3F, 0x00, 0xFE, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x80,
  0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xF8, 0xFC,
  0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0x7E, 0xFC, 0x07, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xE7, 0xFF,
  0xE3, 0xFF, 0xF3, 0xFF, 0xF1, 0xF8, 0x18, 0xFC, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7D, 0x80, 0x3E, 0xF0, 0x3F, 0x7F, 0xFF, 0xBF,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7E, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3,
  0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F,
  0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xEF,
  0xC0, 0x3F, 0x01, 0xFB, 0xF0, 0x1F, 0xC0, 0x7E, 0x7C, 0x07, 0xF0, 0x1F,
  0x9F, 0x01, 0xFC, 0x07, 0xC7, 0xE0, 0x7F, 0x81, 0xF1, 0xF8, 0x3F, 0xE0,
  0xFC, 0x3E, 0x0F, 0xF8, 0x3F, 0x0F, 0x83, 0xDE, 0x0F, 0xC3, 0xE0, 0xF7,
  0x83, 0xE0, 0xFC, 0x3D, 0xF0, 0xF8, 0x3F, 0x1F, 0x7C, 0x7E, 0x07, 0xC7,
  0xCF, 0x1F, 0x81, 0xF1, 0xF3, 0xC7, 0xE0, 0x7C, 0x78, 0xF9, 0xF0, 0x1F,
  0xBE, 0x3E, 0x7C, 0x07, 0xEF, 0x8F, 0xBF, 0x00, 0xFB, 0xE1, 0xEF, 0xC0,
  0x3E, 0xF8, 0x7B, 0xE0, 0x0F, 0xBC, 0x1E, 0xF8, 0x03, 0xEF, 0x07, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF9, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0x7E,
  0xFE, 0x01, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x03, 0xF1, 0xF8,
  0x0F, 0x8F, 0xC0, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x07,
  0xC3, 0xE0, 0x7C, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x81, 0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF8, 0x40, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xC7,
  0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xDF, 0x8F, 0xEF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF,
  0x3C, 0x7F, 0x1E, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x38,
  0x1F, 0x9F, 0xC3, 0xF7, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFE, 0x3F,
  0xBF, 0x83, 0xF7, 0xF0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F,
  0x7E, 0x03, 0xFF, 0xC0, 0x7D, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xE0, 0x7E,
  0xFE, 0x0F, 0xDF, 0xC1, 0xFB, 0xFE, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xF3, 0xFE, 0x3E, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0xCF, 0xC1, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xFC, 0x09, 0xFC, 0xF3, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x07, 0x8F, 0xC7, 0xF3, 0xF3,
  0xFE, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xF7,
  0xF3, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xF9, 0xF1, 0xFC, 0x7C, 0x03,
  0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xF7, 0xF3, 0xE0, 0xFB,
  0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x9F, 0xC1, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8,
  0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFC, 0xC3, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x83, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0x80, 0x07, 0xF9, 0xF3, 0xFE, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x07, 0xF7, 0xF3, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFB,
  0xF1, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE8, 0x01, 0xF9,
  0x80, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x7C, 0x3F, 0x7F,
  0x8F, 0xDF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC,
  0x7F, 0xFF, 0xFF, 0x7C, 0xE0, 0x00, 0x01, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xC0,
  0x0F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC7, 0xE3, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0xF8, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFB, 0xE0,
  0x7E, 0x7C, 0x1F, 0x8F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x3F, 0x07, 0xCF,
  0xC0, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xBF, 0x07, 0xE7, 0xE0, 0xF8, 0x7E, 0x1F, 0x07,
  0xC3, 0xE0, 0xFC, 0x7C, 0x0F, 0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x03,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7C, 0x0F, 0x87, 0xCF, 0xF0, 0xFF, 0x3E, 0xFF, 0xCF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xF8,
  0x7F, 0x07, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x0F, 0xC1, 0xFF, 0xE0, 0x7E,
  0x0F, 0xFF, 0x03, 0xF0, 0x7F, 0xF8, 0x1F, 0x83, 0xFF, 0xC0, 0xFC, 0x1F,
  0xFE, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x81, 0xF8, 0x3F, 0xFC,
  0x0F, 0xC1, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x03, 0xF0, 0x7F, 0xF8, 0x1F,
  0x83, 0xFF, 0xC0, 0xFC, 0x1F, 0xFE, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0x07,
  0xE0, 0x00, 0x7C, 0x3E, 0x7F, 0xCF, 0xBF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0x9F, 0x07, 0xE7, 0xF3, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x78, 0x1F,
  0x1F, 0xC3, 0xF7, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFE, 0x3F, 0xBF,
  0x83, 0xF7, 0xF0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E,
  0x03, 0xFF, 0xC0, 0x7D, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xE0, 0x7E, 0xFE,
  0x0F, 0xDF, 0xC1, 0xFB, 0xFC, 0x7E, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFB,
  0xFE, 0x3F, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x07, 0xF9, 0xF3, 0xFE, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xF7, 0xF3, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFB, 0xF1, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x1F, 0xF3, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xF8, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0x9F, 0x81, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFF, 0xC3, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x1F,
  0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x67, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7E, 0x1F,
  0xDF, 0xDF, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0x3F, 0xF7, 0xC7, 0xF1, 0xF0,
  0xFC, 0x03, 0xF7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x07,
  0xC3, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1,
  0xF8, 0x1F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x07,
  0xBE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFD, 0xF0,
  0x3F, 0x83, 0xE7, 0xC1, 0xFE, 0x0F, 0x9F, 0x87, 0xF8, 0x7E, 0x7E, 0x1F,
  0xE1, 0xF8, 0xF8, 0x7F, 0x87, 0xC3, 0xE3, 0xCF, 0x1F, 0x0F, 0xCF, 0x3C,
  0xFC, 0x3F, 0x3C, 0xF3, 0xF0, 0x7C, 0xF3, 0xCF, 0x81, 0xF3, 0xCF, 0x3E,
  0x07, 0xCE, 0x1C, 0xF8, 0x1F, 0x78, 0x7B, 0xE0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xEF, 0xC1, 0xF8, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC1, 0xF9, 0xF0, 0x3F, 0x7E, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF8, 0x1F, 0xBF, 0x07, 0xE3,
  0xF0, 0xFC, 0x7E, 0x3F, 0x07, 0xE7, 0xE0, 0xFD, 0xF8, 0x0F, 0xC0, 0xFC,
  0x03, 0xF7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF9, 0xF8,
  0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x1F, 0xF8, 0xFF, 0x87, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81,
  0xFF, 0x0F, 0xF0, 0x1F, 0x0F, 0xF1, 0xFF, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x08, 0x00, 0x1E, 0x00, 0x5F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE8, 0x01, 0xF0,
};

const GFXglyph NotoSans_Condensed_Bold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 15, 10, 19, 2, -29 },
  { 46, 21, 29, 22, 1, -29 },
  { 123, 17, 33, 20, 2, -31 },
  { 194, 31, 30, 33, 1, -30 },
  { 311, 24, 30, 25, 1, -30 },
  { 401, 6, 10, 10, 2, -29 },
  { 409, 10, 35, 13, 2, -29 },
  { 453, 10, 35, 13, 1, -29 },
  { 497, 17, 17, 19, 1, -31 },
  { 534, 18, 19, 20, 1, -24 },
  { 577, 8, 10, 11, 1, -5 },
  { 587, 11, 6, 13, 1, -14 },
  { 596, 7, 6, 11, 2, -6 },
  { 602, 16, 30, 17, 0, -30 },
  { 662, 18, 30, 20, 1, -30 },
  { 730, 13, 29, 20, 2, -29 },
  { 778, 18, 30, 20, 1, -30 },
  { 846, 18, 30, 20, 1, -30 },
  { 914, 19, 29, 20, 1, -29 },
  { 983, 17, 29, 20, 2, -29 },
  { 1045, 18, 30, 20, 1, -30 },
  { 1113, 18, 29, 20, 1, -29 },
  { 1179, 18, 30, 20, 1, -30 },
  { 1247, 18, 30, 20, 1, -30 },
  { 1315, 7, 23, 11, 2, -23 },
  { 1336, 8, 28, 11, 1, -23 },
  { 1364, 18, 20, 20, 1, -25 },
  { 1409, 18, 13, 20, 1, -21 },
  { 1439, 18, 20, 20, 1, -25 },
  { 1484, 16, 30, 16, 0, -30 },
  { 1544, 28, 33, 32, 2, -30 },
  { 1660, 24, 29, 24, 0, -29 },
  { 1747, 18, 29, 23, 3, -29 },
  { 1813, 19, 30, 22, 2, -30 },
  { 1885, 20, 29, 25, 3, -29 },
  { 1958, 14, 29, 19, 3, -29 },
  { 2009, 14, 29, 19, 3, -29 },
  { 2060, 20, 30, 25, 2, -30 },
  { 2135, 20, 29, 26, 3, -29 },
  { 2208, 12, 29, 14, 1, -29 },
  { 2252, 11, 38, 12, -2, -29 },
  { 2305, 20, 29, 23, 3, -29 },
  { 2378, 15, 29, 19, 3, -29 },
  { 2433, 28, 29, 34, 3, -29 },
  { 2535, 22, 29, 28, 3, -29 },
  { 2615, 23, 30, 27, 2, -30 },
  { 2702, 17, 29, 22, 3, -29 },
  { 2764, 23, 37, 27, 2, -30 },
  { 2871, 20, 29, 23, 3, -29 },
  { 2944, 17, 30, 19, 1, -30 },
  { 3008, 18, 29, 19, 1, -29 },
  { 3074, 20, 29, 26, 3, -29 },
  { 3147, 23, 29, 23, 0, -29 },
  { 3231, 34, 29, 33, 0, -29 },
  { 3355, 22, 29, 22, 0, -29 },
  { 3435, 21, 29, 21, 0, -29 },
  { 3512, 17, 29, 19, 1, -29 },
  { 3574, 10, 36, 13, 2, -29 },
  { 3619, 16, 30, 17, 0, -30 },
  { 3679, 10, 36, 13, 1, -29 },
  { 3724, 20, 18, 22, 1, -29 },
  { 3769, 17, 2, 17, 0, 4 },
  { 3774, 10, 6, 13, 2, -31 },
  { 3782, 17, 23, 21, 1, -23 },
  { 3831, 19, 31, 22, 2, -31 },
  { 3905, 15, 23, 18, 2, -23 },
  { 3949, 18, 31, 22, 2, -31 },
  { 4019, 17, 23, 20, 2, -23 },
  { 4068, 15, 31, 13, 0, -31 },
  { 4127, 18, 33, 22, 2, -23 },
  { 4202, 18, 31, 22, 2, -31 },
  { 4272, 6, 31, 11, 2, -31 },
  { 4296, 9, 41, 11, -1, -31 },
  { 4343, 19, 31, 21, 3, -31 },
  { 4417, 6, 31, 11, 2, -31 },
  { 4441, 29, 23, 33, 2, -23 },
  { 4525, 18, 23, 22, 2, -23 },
  { 4577, 18, 23, 22, 2, -23 },
  { 4629, 19, 33, 22, 2, -23 },
  { 4708, 18, 33, 22, 2, -23 },
  { 4783, 12, 23, 15, 3, -23 },
  { 4818, 15, 23, 17, 1, -23 },
  { 4862, 13, 27, 15, 1, -27 },
  { 4906, 18, 22, 22, 2, -22 },
  { 4956, 20, 22, 20, 0, -22 },
  { 5011, 30, 22, 30, 0, -22 },
  { 5094, 19, 22, 19, 0, -22 },
  { 5147, 20, 32, 20, 0, -22 },
  { 5227, 15, 22, 16, 1, -22 },
  { 5269, 13, 36, 15, 0, -29 },
  { 5328, 5, 40, 19, 7, -31 },
  { 5353, 12, 36, 15, 2, -29 },
  { 5407, 18, 7, 20, 1, -18 },
};

const GFXfont NotoSans_Condensed_Bold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_BOLD41PT7B_H_
