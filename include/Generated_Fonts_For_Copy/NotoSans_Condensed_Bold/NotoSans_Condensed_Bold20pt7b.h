#ifndef _NOTOSANS_CONDENSED_BOLD20PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xEF, 0xDF, 0xBF, 0x7E, 0x60,
  0x0D, 0x81, 0xB0, 0x66, 0x0C, 0xC7, 0xFE, 0xFF, 0xC6, 0xC0, 0xD8, 0xFF,
  0xDF, 0xF8, 0xCC, 0x19, 0x03, 0x60, 0x6C, 0x00, 0x18, 0x1C, 0x7F, 0xFE,
  0xF8, 0xF8, 0xF8, 0x7C, 0x1E, 0x1F, 0x1B, 0x9F, 0xFE, 0xFC, 0x18, 0x18,
  0xF8, 0x61, 0xB1, 0x83, 0x73, 0x06, 0xE6, 0x0D, 0xD8, 0x1B, 0xB7, 0x36,
  0xDF, 0x3D, 0xB6, 0x06, 0x6E, 0x0C, 0xDC, 0x39, 0xB8, 0x63, 0x60, 0xC7,
  0xC3, 0x07, 0x00, 0x3E, 0x0F, 0xC1, 0x9C, 0x33, 0x87, 0xE0, 0xF8, 0x1E,
  0x3F, 0xE7, 0xEE, 0xD8, 0xFB, 0x1E, 0x73, 0xCF, 0xFC, 0xFD, 0xC0, 0xFF,
  0xFE, 0x39, 0x9C, 0xCE, 0x73, 0x18, 0xC6, 0x31, 0xCE, 0x31, 0xC6, 0x38,
  0xE1, 0xC3, 0x0E, 0x18, 0x61, 0x87, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x1C,
  0xE0, 0x1C, 0x06, 0x1B, 0x6F, 0xF9, 0xC1, 0xF1, 0xDC, 0x64, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xEC, 0xFF, 0xFE,
  0xFF, 0x80, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30,
  0x30, 0x70, 0x60, 0xE0, 0x10, 0x7C, 0x7E, 0xE7, 0xE7, 0xE7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0x1C, 0xF7, 0xFB, 0x4C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x7E, 0xFE, 0xC7, 0x07, 0x07, 0x06,
  0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0x47, 0x07,
  0x07, 0x1E, 0x78, 0x7E, 0x07, 0x07, 0x07, 0x8F, 0xFE, 0xFC, 0x07, 0x01,
  0xC0, 0xF0, 0x7C, 0x1F, 0x0D, 0xC3, 0x71, 0x9C, 0x67, 0x3F, 0xFF, 0xFC,
  0x1C, 0x07, 0x01, 0xC0, 0x7E, 0xFE, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0x4F,
  0x07, 0x07, 0x07, 0x8F, 0xFE, 0xFC, 0x3E, 0x7E, 0x70, 0xE0, 0xC0, 0xDE,
  0xFF, 0xE7, 0xC7, 0xC3, 0xE7, 0xE7, 0x7E, 0x3C, 0xFF, 0xFF, 0xC0, 0xE0,
  0x70, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x83, 0x81, 0xC0,
  0x7E, 0xFF, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0x7E, 0xE7, 0xC7, 0xC3, 0xE7,
  0xFF, 0x7E, 0x7C, 0xFE, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7B, 0x07,
  0x07, 0x0E, 0xFC, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x1F, 0xFD, 0x80, 0x01, 0x07, 0x1F, 0x7C, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0x3E, 0x07,
  0x0F, 0x3C, 0xF0, 0xC0, 0x80, 0xFE, 0xFE, 0x47, 0x07, 0x06, 0x0E, 0x1C,
  0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38, 0x0F, 0xE0, 0xE1, 0xC7, 0x03,
  0x98, 0xE6, 0xCF, 0xDB, 0x33, 0x3D, 0xCC, 0xF6, 0x33, 0xD8, 0xCF, 0x37,
  0x6C, 0xF7, 0xB9, 0x9C, 0x60, 0x00, 0xE1, 0x81, 0xFE, 0x00, 0xC0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xB8, 0x1B, 0x83, 0xB8, 0x39, 0x83, 0x9C, 0x3F,
  0xC7, 0xFC, 0x7F, 0xE7, 0x0E, 0xE0, 0xEE, 0x0F, 0xFF, 0x7F, 0xF8, 0xFC,
  0x7E, 0x3F, 0xFF, 0xF9, 0xFF, 0xE3, 0xF0, 0xF8, 0xFC, 0x7F, 0xFF, 0xF0,
  0x3F, 0xBF, 0xDC, 0x3E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C,
  0x0F, 0x33, 0xF8, 0xFC, 0xFF, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x9E, 0xFF, 0x3F, 0x80, 0xFF, 0xFC,
  0x30, 0xC3, 0xFF, 0xFF, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xFF, 0xFC, 0x30,
  0xC3, 0x0F, 0xFF, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x1F, 0xCF, 0xF7, 0x89,
  0xC0, 0xE0, 0x38, 0x0E, 0x7F, 0x9F, 0xE1, 0xF8, 0x77, 0x1D, 0xC7, 0x3F,
  0xC7, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xEF, 0xFC, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0xE7, 0xFF, 0x80, 0xC3, 0xE3, 0xB3, 0xD9, 0xCD, 0xC6, 0xE3, 0xF1, 0xF8,
  0xEE, 0x67, 0x33, 0xD8, 0xEC, 0x7E, 0x1C, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xEC, 0xFF, 0x66, 0xFB, 0x37, 0xDD, 0xBE,
  0x7D, 0xF3, 0xCF, 0x9E, 0x7C, 0x73, 0xE3, 0x1C, 0xE0, 0xFC, 0x3F, 0x0F,
  0xE3, 0xF8, 0xF7, 0x3D, 0xCF, 0x3B, 0xCE, 0xF1, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF0, 0x70, 0x04, 0x07, 0xF1, 0xFF, 0x38, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x77, 0x9C, 0x7F, 0x87, 0xC0, 0xFE,
  0x7F, 0xB9, 0xFC, 0x7E, 0x3F, 0x1F, 0x9D, 0xFE, 0xFE, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x38, 0xEE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x77, 0x9C, 0x7F, 0x87, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0xFE, 0x3F, 0xCE, 0x3B, 0x8E, 0xE3, 0xB8, 0xEF,
  0xF3, 0xF8, 0xEE, 0x39, 0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0x70, 0x7F, 0xFE,
  0xE2, 0xE0, 0xE0, 0xF0, 0x7C, 0x3E, 0x0E, 0x07, 0x07, 0xCE, 0xFE, 0xFC,
  0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xCF, 0x7F, 0x8F, 0xC0, 0xE0, 0xFC,
  0x19, 0x83, 0x38, 0xE7, 0x1C, 0x63, 0x0C, 0x61, 0xDC, 0x3B, 0x83, 0x60,
  0x6C, 0x0F, 0x80, 0xE0, 0x1C, 0x00, 0xE1, 0xC7, 0xE1, 0xC7, 0xE3, 0xC7,
  0x63, 0xC7, 0x73, 0xC6, 0x73, 0xEE, 0x77, 0x6E, 0x76, 0x6E, 0x36, 0x6E,
  0x36, 0x6C, 0x3E, 0x6C, 0x3E, 0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0xF1, 0xCE,
  0x70, 0xCE, 0x1D, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0xF0, 0x1F, 0x07, 0xE0,
  0xEE, 0x39, 0xC7, 0x1D, 0xC3, 0xC0, 0xE1, 0xDC, 0x77, 0x38, 0xCE, 0x3B,
  0x0F, 0xC1, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x18, 0x1C,
  0x0C, 0x0F, 0xFF, 0xFC, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9F, 0xF8, 0xE0, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x1C,
  0x0C, 0x0E, 0x06, 0x06, 0x07, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x7F, 0xF8, 0x0C, 0x03, 0x81, 0xE0, 0x6C, 0x3B, 0x0C, 0x67,
  0x19, 0x87, 0xE0, 0xC0, 0xFF, 0xE3, 0x8E, 0x7E, 0x7E, 0x47, 0x07, 0x3F,
  0xFF, 0xE7, 0xC7, 0xE7, 0xFF, 0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xE7,
  0xFB, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x3F, 0xFB, 0xB8, 0x3E,
  0xFF, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE2, 0xFC, 0xF8, 0x03, 0x81, 0xC0,
  0xE0, 0x77, 0xBB, 0xFF, 0x9F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7B,
  0xFD, 0xEE, 0x3C, 0x7E, 0xE7, 0xE3, 0xFF, 0xFF, 0xE0, 0xE0, 0xE1, 0x7F,
  0x3F, 0x3E, 0x7C, 0xC1, 0x87, 0xDF, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x00, 0x7B, 0xBF, 0xF9, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE7, 0xBF, 0xDE, 0xE0, 0x70, 0x37, 0x7B, 0xF8, 0xF8, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0xF7, 0xFB, 0xDF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8E, 0xFD, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x39, 0xC4, 0x03, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFD, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE3, 0xB9, 0xCE, 0x73, 0xB8, 0xFC, 0x3F, 0x0F, 0xE3, 0x9C,
  0xE7, 0x38, 0xEE, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xCF, 0x7B,
  0xFF, 0xFF, 0x79, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xF8, 0xE7,
  0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xC0, 0xCF, 0x7F, 0xBD, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xE0, 0x3E, 0x3F, 0xB9, 0xDC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0x3F, 0x8F, 0x80, 0xEE, 0x7F, 0xBC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xFF, 0xBB, 0x9C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x7B, 0xBF, 0xF9, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7,
  0xBF, 0xDE, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xCF, 0xFF, 0xF8, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x7F, 0xFB, 0x17, 0x0F, 0x0F, 0x8F, 0x07,
  0x8F, 0xFB, 0xE0, 0x30, 0x61, 0xFF, 0xF7, 0x0E, 0x1C, 0x38, 0x70, 0xE0,
  0xC1, 0xF3, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE7, 0xBF, 0xDE, 0xE0, 0xE1, 0xF8, 0xE6, 0x39, 0xCE, 0x73, 0x0D, 0xC3,
  0x70, 0xF8, 0x1E, 0x07, 0x81, 0xC0, 0xE3, 0x8F, 0xC7, 0x19, 0x9E, 0x73,
  0xB6, 0xE7, 0x6D, 0x8E, 0xDB, 0x0D, 0x3E, 0x1E, 0x7C, 0x3C, 0xF0, 0x78,
  0xE0, 0x71, 0xC0, 0xE3, 0xB9, 0x9D, 0xC7, 0xC1, 0xE0, 0xE0, 0xF8, 0x7C,
  0x77, 0x39, 0xF8, 0xE0, 0xE1, 0xD8, 0xE7, 0x39, 0xCE, 0x73, 0x0D, 0xC3,
  0xF0, 0xF8, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x1E, 0x07, 0x81, 0xC0,
  0x7E, 0x7E, 0x0E, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x70, 0xFF, 0xFF, 0x1C,
  0x73, 0x8E, 0x38, 0xE3, 0xBE, 0xE3, 0xE3, 0x8E, 0x38, 0xE3, 0x87, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x0F, 0x1C,
  0xF7, 0x1C, 0x71, 0xC7, 0x3C, 0xE0, 0x61, 0xFF, 0xBF, 0x86,
};

const GFXglyph NotoSans_Condensed_Bold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 11, 14, 11, 0, -14 },
  { 32, 8, 16, 10, 1, -15 },
  { 48, 15, 14, 16, 1, -14 },
  { 75, 11, 14, 12, 1, -14 },
  { 95, 3, 5, 5, 1, -14 },
  { 97, 5, 17, 6, 1, -14 },
  { 108, 6, 17, 6, 0, -14 },
  { 121, 9, 8, 9, 0, -15 },
  { 130, 8, 10, 10, 1, -12 },
  { 140, 3, 5, 5, 1, -2 },
  { 142, 5, 3, 6, 1, -7 },
  { 144, 3, 3, 5, 1, -3 },
  { 146, 8, 14, 8, 0, -14 },
  { 160, 8, 15, 10, 1, -15 },
  { 175, 6, 14, 10, 1, -14 },
  { 186, 8, 14, 10, 1, -14 },
  { 200, 8, 14, 10, 1, -14 },
  { 214, 10, 14, 10, 0, -14 },
  { 232, 8, 14, 10, 1, -14 },
  { 246, 8, 14, 10, 1, -14 },
  { 260, 9, 14, 10, 0, -14 },
  { 276, 8, 14, 10, 1, -14 },
  { 290, 8, 14, 10, 1, -14 },
  { 304, 3, 11, 5, 1, -11 },
  { 309, 3, 14, 5, 1, -11 },
  { 315, 8, 10, 10, 1, -12 },
  { 325, 8, 6, 10, 1, -10 },
  { 331, 8, 10, 10, 1, -12 },
  { 341, 8, 14, 8, 0, -14 },
  { 355, 14, 16, 16, 1, -14 },
  { 383, 12, 14, 12, 0, -14 },
  { 404, 9, 14, 11, 1, -14 },
  { 420, 9, 14, 11, 1, -14 },
  { 436, 10, 14, 12, 1, -14 },
  { 454, 6, 14, 9, 2, -14 },
  { 465, 6, 14, 9, 2, -14 },
  { 476, 10, 14, 12, 1, -14 },
  { 494, 9, 14, 13, 2, -14 },
  { 510, 5, 14, 7, 1, -14 },
  { 519, 5, 18, 6, -1, -14 },
  { 531, 9, 14, 11, 2, -14 },
  { 547, 8, 14, 9, 1, -14 },
  { 561, 13, 14, 16, 2, -14 },
  { 584, 10, 14, 14, 2, -14 },
  { 602, 11, 15, 13, 1, -15 },
  { 623, 9, 14, 11, 1, -14 },
  { 639, 11, 18, 13, 1, -15 },
  { 664, 10, 14, 11, 1, -14 },
  { 682, 8, 14, 9, 1, -14 },
  { 696, 9, 14, 9, 0, -14 },
  { 712, 10, 14, 13, 1, -14 },
  { 730, 11, 14, 11, 0, -14 },
  { 750, 16, 14, 16, 0, -14 },
  { 778, 11, 14, 11, 0, -14 },
  { 798, 10, 14, 10, 0, -14 },
  { 816, 9, 14, 9, 0, -14 },
  { 832, 5, 17, 6, 1, -14 },
  { 843, 8, 14, 8, 0, -14 },
  { 857, 5, 17, 6, 0, -14 },
  { 868, 10, 9, 11, 0, -14 },
  { 880, 8, 1, 8, 0, 2 },
  { 881, 5, 3, 7, 1, -15 },
  { 883, 8, 11, 10, 1, -11 },
  { 894, 9, 15, 11, 1, -15 },
  { 911, 7, 11, 9, 1, -11 },
  { 921, 9, 15, 11, 1, -15 },
  { 938, 8, 11, 10, 1, -11 },
  { 949, 7, 15, 7, 0, -15 },
  { 963, 9, 16, 11, 1, -11 },
  { 981, 9, 15, 11, 1, -15 },
  { 998, 3, 15, 5, 1, -15 },
  { 1004, 5, 20, 5, -1, -15 },
  { 1017, 10, 15, 10, 1, -15 },
  { 1036, 3, 15, 5, 1, -15 },
  { 1042, 14, 11, 16, 1, -11 },
  { 1062, 9, 11, 11, 1, -11 },
  { 1075, 9, 11, 11, 1, -11 },
  { 1088, 9, 16, 11, 1, -11 },
  { 1106, 9, 16, 11, 1, -11 },
  { 1124, 6, 11, 8, 1, -11 },
  { 1133, 7, 11, 8, 1, -11 },
  { 1143, 7, 13, 7, 0, -13 },
  { 1155, 9, 11, 11, 1, -11 },
  { 1168, 10, 11, 10, 0, -11 },
  { 1182, 15, 11, 15, 0, -11 },
  { 1203, 9, 11, 9, 0, -11 },
  { 1216, 10, 16, 10, 0, -11 },
  { 1236, 8, 11, 8, 0, -11 },
  { 1247, 6, 17, 7, 0, -14 },
  { 1260, 2, 20, 9, 4, -15 },
  { 1265, 6, 17, 7, 1, -14 },
  { 1278, 8, 4, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Bold20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_BOLD20PT7B_H_
