#ifndef _NOTOSANS_CONDENSED_BOLD8PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x30, 0xF4, 0x55, 0xF6, 0xF6, 0x2D, 0xC2, 0xB6, 0x4A, 0xCB,
  0x57, 0x2C, 0xB0, 0x63, 0x19, 0xFB, 0x3C, 0xE0, 0x5A, 0x94, 0x95, 0x5C,
  0x4F, 0x60, 0x44, 0xF4, 0x60, 0xC0, 0xC0, 0x25, 0x25, 0x00, 0x6E, 0x99,
  0xB6, 0x3C, 0x92, 0x40, 0x6B, 0x22, 0x4F, 0x6B, 0x26, 0x3E, 0x22, 0x6A,
  0xF2, 0x64, 0xE3, 0x3E, 0x64, 0xAF, 0x96, 0xF3, 0x22, 0x44, 0x69, 0x66,
  0x96, 0x6B, 0x97, 0x26, 0xC3, 0xC1, 0x80, 0x16, 0xC3, 0xFF, 0x86, 0x3C,
  0xF4, 0xA0, 0x80, 0x39, 0x1B, 0x6D, 0xBD, 0x03, 0x80, 0x23, 0x14, 0xAF,
  0x4C, 0xD6, 0xFB, 0xC0, 0x35, 0xCC, 0x47, 0xCA, 0xAB, 0xAE, 0xEB, 0xB0,
  0xEB, 0xA0, 0x34, 0xCF, 0x57, 0xBB, 0xBF, 0xBB, 0xD5, 0x70, 0x55, 0x5E,
  0xBE, 0xCC, 0xAB, 0xAA, 0xB0, 0x9C, 0xF7, 0xDE, 0xD4, 0x9D, 0xDD, 0xBB,
  0x72, 0xF3, 0x95, 0xB8, 0xD6, 0xE9, 0x00, 0x72, 0xF3, 0x95, 0xB8, 0x60,
  0xD6, 0xEF, 0x40, 0x7F, 0x33, 0xC0, 0xF4, 0x44, 0x44, 0xB6, 0xDB, 0xC0,
  0x99, 0x57, 0x66, 0x97, 0x6A, 0xD3, 0xA6, 0xCD, 0x00, 0x97, 0x66, 0x69,
  0x95, 0x66, 0x22, 0xF2, 0x24, 0x4F, 0xEA, 0xAC, 0x89, 0x22, 0x40, 0xD5,
  0x5C, 0x26, 0x59, 0xE0, 0xC0, 0x67, 0xBD, 0xCC, 0xFD, 0xDF, 0x72, 0x30,
  0x11, 0x79, 0x97, 0x7F, 0x86, 0x6B, 0xA4, 0x80, 0x79, 0x97, 0x16, 0xCC,
  0xFD, 0xDD, 0xCF, 0xF0, 0xCF, 0xFE, 0x93, 0xED, 0x40, 0xFF, 0xF0, 0xFF,
  0x5D, 0x75, 0xFD, 0xDD, 0x79, 0x96, 0xFD, 0xDF, 0xCC, 0x79, 0x97, 0x11,
  0xFB, 0x60, 0xF8, 0xF0, 0x5D, 0x26, 0xDD, 0xD7, 0xB6, 0x66, 0xB7, 0xE7,
  0x96, 0xF6, 0x6B, 0xB6, 0x66, 0x4C, 0xE9, 0x70, 0x69, 0x64, 0x98, 0xFF,
  0xC9, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_Condensed_Bold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 4, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 6, 6, 6, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 2, 2, 2, 0, -6 },
  { 20, 2, 7, 3, 0, -6 },
  { 22, 2, 7, 3, 0, -6 },
  { 24, 4, 3, 4, 0, -6 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 2, 2, 2, 0, -1 },
  { 29, 2, 1, 2, 0, -3 },
  { 30, 2, 1, 2, 0, -1 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 4, 6, 4, 0, -6 },
  { 37, 3, 6, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 2, 4, 2, 0, -4 },
  { 65, 2, 5, 2, 0, -4 },
  { 67, 4, 4, 4, 0, -5 },
  { 69, 4, 2, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -5 },
  { 72, 3, 6, 3, 0, -6 },
  { 75, 6, 7, 6, 0, -6 },
  { 81, 5, 6, 5, 0, -6 },
  { 85, 3, 6, 5, 1, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 5, 1, -6 },
  { 94, 2, 6, 4, 1, -6 },
  { 96, 2, 6, 4, 1, -6 },
  { 98, 4, 6, 5, 0, -6 },
  { 101, 4, 6, 5, 1, -6 },
  { 104, 2, 6, 3, 0, -6 },
  { 106, 2, 8, 2, 0, -6 },
  { 108, 4, 6, 4, 1, -6 },
  { 111, 2, 6, 4, 1, -6 },
  { 113, 5, 6, 7, 1, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 5, 6, 5, 0, -6 },
  { 124, 3, 6, 4, 1, -6 },
  { 127, 5, 7, 5, 0, -6 },
  { 132, 3, 6, 4, 1, -6 },
  { 135, 3, 6, 4, 0, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 3, 6, 5, 1, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 7, 6, 7, 0, -6 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 4, 6, 4, 0, -6 },
  { 159, 4, 6, 4, 0, -6 },
  { 162, 2, 7, 3, 0, -6 },
  { 164, 3, 6, 3, 0, -6 },
  { 167, 2, 7, 3, 0, -6 },
  { 169, 4, 4, 4, 0, -6 },
  { 171, 3, 1, 3, 0, 0 },
  { 172, 2, 1, 3, 0, -6 },
  { 173, 4, 4, 4, 0, -4 },
  { 175, 4, 6, 4, 0, -6 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 4, 6, 4, 0, -6 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 6, 3, 0, -6 },
  { 188, 4, 6, 4, 0, -4 },
  { 191, 4, 6, 4, 0, -6 },
  { 194, 2, 6, 2, 0, -6 },
  { 196, 2, 8, 2, 0, -6 },
  { 198, 3, 6, 4, 1, -6 },
  { 201, 2, 6, 2, 0, -6 },
  { 203, 6, 4, 7, 0, -4 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 4, 6, 4, 0, -4 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 3, 4, 3, 0, -4 },
  { 220, 3, 5, 3, 0, -5 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 6, 4, 6, 0, -4 },
  { 229, 4, 4, 4, 0, -4 },
  { 231, 4, 6, 4, 0, -4 },
  { 234, 3, 4, 3, 0, -4 },
  { 236, 3, 7, 3, 0, -6 },
  { 239, 1, 8, 4, 1, -6 },
  { 240, 3, 7, 3, 0, -6 },
  { 243, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_Bold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_BOLD8PT7B_H_
