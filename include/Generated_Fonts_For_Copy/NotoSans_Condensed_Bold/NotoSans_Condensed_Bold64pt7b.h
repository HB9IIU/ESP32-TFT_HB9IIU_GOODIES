#ifndef _NOTOSANS_CONDENSED_BOLD64PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x7F, 0x1F, 0xF3, 0xFE, 0xFF, 0xDF, 0xFF, 0xFF,
  0x3F, 0xE7, 0xFC, 0x7F, 0x03, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0x9F,
  0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE,
  0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0,
  0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0x3F,
  0xE7, 0x83, 0xCF, 0xF9, 0xE0, 0x23, 0xFC, 0x78, 0x00, 0xFF, 0x1E, 0x00,
  0x3F, 0xC7, 0x80, 0x0F, 0xF9, 0xE0, 0x03, 0xFF, 0x78, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7B,
  0xFF, 0x00, 0x1E, 0x7F, 0xC0, 0x07, 0x8F, 0xF0, 0x01, 0xE3, 0xFE, 0x00,
  0x78, 0xFF, 0xC0, 0x1E, 0x3F, 0xFC, 0x07, 0x9F, 0xFF, 0xC1, 0xEF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xE1, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0xE0, 0x7F, 0x0F,
  0xC3, 0xF0, 0xFF, 0xF0, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC7, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x8F, 0xE3, 0xF8, 0xFE, 0x1F, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x0F, 0xFE,
  0x1F, 0xC7, 0xF0, 0x7E, 0x03, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x07,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0xFC, 0x03, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xE1,
  0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0xCF, 0xF8,
  0x7F, 0xC7, 0xFC, 0x7F, 0xE7, 0xFC, 0x7F, 0xE1, 0xFF, 0xBF, 0xE3, 0xFE,
  0x07, 0xFF, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF,
  0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xFB,
  0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xF9, 0xFC, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0x01, 0xF8, 0x04, 0x7C, 0x3F, 0x07, 0xCF,
  0xF7, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFD, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0xC1, 0xFF,
  0x07, 0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0x78, 0x0F, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F,
  0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFD,
  0xFF, 0xFF, 0xF3, 0xFE, 0x7F, 0xC7, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xCF, 0xFC,
  0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0,
  0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x0F, 0xFB,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F,
  0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE,
  0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xDF, 0xFF, 0xFE, 0xFF, 0xBF, 0xE7,
  0xFC, 0xFE, 0x3F, 0xE3, 0xC1, 0xFF, 0x0C, 0x0F, 0xF8, 0x40, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0x1F, 0xFE, 0x3F, 0x00, 0xFF, 0xC3, 0xC0, 0x0F, 0xF8, 0x30,
  0x01, 0xFF, 0x04, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFE, 0x1F, 0xFE, 0x1E, 0x00, 0xFF, 0xC1, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x00, 0x3E, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xDF,
  0xE0, 0x00, 0x3F, 0x7F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xEF, 0xF8,
  0x00, 0x3F, 0xBF, 0xE0, 0x00, 0xFC, 0xFF, 0x80, 0x07, 0xF3, 0xFE, 0x00,
  0x3F, 0x8F, 0xF8, 0x00, 0xFE, 0x3F, 0xE0, 0x07, 0xF0, 0xFF, 0x80, 0x1F,
  0xC3, 0xFE, 0x00, 0xFE, 0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0xE0, 0x1F, 0xC0,
  0xFF, 0x80, 0x7E, 0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F,
  0xE0, 0x7F, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3F, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x80, 0x00, 0xFF, 0xB8, 0x00, 0x7F,
  0xEF, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x08, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x83, 0xE0, 0x07, 0xF8, 0xFF, 0xC0, 0xFF, 0x1F, 0xFE,
  0x0F, 0xF3, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x03,
  0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7,
  0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xF1,
  0xFF, 0x81, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB, 0xFF,
  0x83, 0xFF, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFC, 0x07, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xEF,
  0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xE7, 0xFF, 0x1F, 0xFE, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFC, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFF,
  0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xDF, 0xFC, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x7F, 0x87, 0xFF, 0xCF, 0xF0, 0x7F, 0xF1,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x8F, 0xF9, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xDF, 0xF3,
  0xFE, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xFE, 0x3F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF,
  0xF8, 0xFE, 0x07, 0x00, 0x1F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFF, 0x3F, 0xF3,
  0xFF, 0x3F, 0xE3, 0xFE, 0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF1,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0x0F,
  0xFE, 0x1C, 0x01, 0xFF, 0x08, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xFF, 0xF0, 0xFE, 0x3F, 0x81, 0xFF, 0xFF,
  0x0F, 0xE3, 0xF0, 0x3F, 0xFF, 0xF0, 0x7E, 0x7F, 0x03, 0xFF, 0xFF, 0x07,
  0xE7, 0xE0, 0x7F, 0x87, 0xF0, 0x7F, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xFF,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xE1,
  0xFC, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC,
  0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x07,
  0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xEF, 0xC1, 0xFC, 0x0F, 0xF0, 0x7E,
  0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xEF, 0xC0, 0xFC, 0x0F, 0xF0, 0xFE, 0xFE,
  0x0F, 0xE1, 0xFF, 0x0F, 0xCF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x07,
  0xFF, 0xEF, 0xFF, 0x87, 0xE0, 0x7F, 0xFC, 0xFF, 0xF0, 0x7F, 0x03, 0xFF,
  0x87, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x01, 0xFF,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80,
  0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F,
  0xEF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0x9F,
  0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0xF9, 0xFF, 0x00, 0x7F, 0xEF, 0xF8,
  0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFD,
  0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xFB, 0xFE,
  0x0F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF9, 0xFC, 0x1F, 0xFE, 0x00,
  0xE0, 0xFF, 0xC0, 0x01, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x0F, 0xFE, 0x00, 0x38, 0x7F, 0xFE,
  0x0F, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0x00, 0xFF, 0xF3, 0xFE, 0x00,
  0xFF, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x01,
  0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF,
  0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC,
  0x01, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0x1F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0x00, 0x1C, 0x1F, 0xFC, 0x00, 0x08,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF8, 0x01, 0xFF,
  0x1F, 0xFC, 0x01, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFB, 0x9F, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00,
  0x30, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00,
  0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x07,
  0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0x00,
  0x7F, 0xCF, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x03,
  0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF8, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F,
  0xE7, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFD, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0xFF, 0xDF, 0xC0, 0x0F, 0xF7, 0xFF, 0xFB,
  0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0x9F, 0xFF, 0xEF, 0xF0,
  0x07, 0xF7, 0xFF, 0xFC, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0x9F, 0xC0, 0x3F,
  0x9F, 0xFF, 0xF3, 0xFC, 0x07, 0xF3, 0xFF, 0xFE, 0x3F, 0x81, 0xFE, 0x7F,
  0xFF, 0xC7, 0xF0, 0x3F, 0x8F, 0xFF, 0xF8, 0xFE, 0x07, 0xF1, 0xFF, 0xFF,
  0x1F, 0xE0, 0xFE, 0x3F, 0xFF, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFC, 0x3F,
  0x87, 0xF0, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0x3F,
  0xC3, 0xFF, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xFF, 0xC1, 0xFC, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xDF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xCF,
  0xF8, 0x0F, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF,
  0x1F, 0xF0, 0x3F, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0x8F,
  0xFF, 0xF0, 0x3F, 0xE3, 0xFF, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0x01, 0xFF,
  0x3F, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF9,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F,
  0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0x83, 0xFF, 0xDF, 0xF0, 0x1F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFD, 0xFF, 0x07, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFF,
  0xC3, 0xFE, 0x03, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8,
  0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F,
  0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x03,
  0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F,
  0xF3, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFE,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xE0, 0x3E,
  0x3F, 0xE0, 0x03, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0x9F, 0xFE, 0x0F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x3F,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x7F, 0x3F, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFC, 0xFE, 0x07,
  0xFC, 0x01, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x3F, 0x83, 0xFE, 0x00, 0x7F, 0xC3,
  0xF8, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0xE0, 0x03,
  0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC,
  0x00, 0x3F, 0xC7, 0xF8, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x9F, 0xC0, 0xFE,
  0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x03, 0xF9, 0xFF, 0x00, 0x07, 0xF9, 0xFC,
  0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x3F, 0x9F, 0xE0, 0x00, 0x7F,
  0xBF, 0xC0, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFE, 0x01, 0xFB, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x7F,
  0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0x87, 0xFF, 0x07, 0x00, 0x7F, 0xC1, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F, 0xDF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0x3F,
  0xFF, 0xDF, 0xCF, 0xFF, 0xE7, 0xF1, 0xFF, 0xF0, 0xFC, 0x3F, 0xF0, 0x3F,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x0C, 0x00, 0xFF, 0x87, 0xF8, 0x0F, 0xF9, 0xFF, 0xE0,
  0xFF, 0x3F, 0xFF, 0x0F, 0xF7, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F,
  0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x03, 0xFE,
  0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF,
  0x0F, 0xE1, 0xFF, 0xE0, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xF0,
  0x38, 0xFF, 0xC0, 0x11, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x27, 0xFF, 0x01, 0xCF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x1C, 0x07,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xF9, 0xFF, 0x07, 0xFF, 0xEF, 0xF8,
  0x7F, 0xFF, 0x7F, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xF8, 0x3F, 0xFC, 0xFF, 0x80, 0xFF, 0xEF, 0xFC, 0x03,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE,
  0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00,
  0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF,
  0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x3F,
  0xE0, 0x3F, 0xF9, 0xFF, 0x81, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0x9F,
  0xE0, 0x7F, 0xF8, 0xFF, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF9, 0xFE, 0x00,
  0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x47, 0xFE,
  0x00, 0x38, 0x7F, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0xF1, 0xFE, 0x0F, 0xFF, 0xCF, 0xF0, 0xFF,
  0xFE, 0x7F, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xF0, 0x7F, 0xF9, 0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFE,
  0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF,
  0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFF,
  0xBF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0x7F, 0xC0,
  0x7F, 0xF3, 0xFF, 0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0x7F, 0xC0,
  0xFF, 0xF3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0x80, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF1, 0x00, 0x00, 0xFF, 0x8E, 0x00, 0x0F, 0xFC, 0x7E, 0x01, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0x80,
  0x3F, 0xE3, 0xFF, 0x07, 0xF8, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF, 0x1F, 0xEF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x1C,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x03, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFC,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x83, 0xFF, 0x8F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFE,
  0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0x00, 0xFF, 0xC7,
  0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0xCF,
  0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x0F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xE7, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x01, 0xE0, 0x1F, 0xC1, 0xFF, 0x83, 0xF8, 0x7F, 0xF8, 0x7F,
  0x1F, 0xFF, 0x8F, 0xF7, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1,
  0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xFC,
  0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE,
  0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFD, 0xFF,
  0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00,
  0x7F, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xE0, 0xFF,
  0x80, 0xFE, 0x1F, 0xFE, 0x0F, 0xF3, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0x8F,
  0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0,
  0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFE,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03,
  0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0x7F,
  0xFF, 0x8F, 0xF3, 0xFF, 0xF0, 0xFF, 0x9F, 0xFE, 0x0F, 0xF8, 0xFF, 0x80,
  0xFF, 0x81, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFF, 0xF1, 0xFE, 0x0F, 0xFF, 0xCF, 0xF0, 0xFF, 0xFE, 0x7F, 0x8F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0,
  0x7F, 0xF9, 0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F,
  0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF,
  0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07,
  0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xF3, 0xFF,
  0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xEF, 0xF8, 0x3F, 0xFE, 0x7F, 0xC0, 0xFF, 0xF3, 0xFE,
  0x03, 0xFE, 0x1F, 0xF0, 0x03, 0x80, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xCF, 0xE0, 0x7F, 0xFE, 0x1F, 0xEF, 0xE3, 0xFE, 0xFE, 0x3F, 0xEF, 0xF7,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xC2, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF,
  0xF0, 0x7C, 0xFF, 0x80, 0x73, 0xFE, 0x00, 0x4F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x02, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x03, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0x8F, 0xE1, 0xFF, 0xE1, 0xFC, 0x1F, 0xF8,
  0x3F, 0x80, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F,
  0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF,
  0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8,
  0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF7, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF8,
  0x07, 0xF8, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0x8F, 0xF8, 0x1F, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7E, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xFB, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xEF, 0xC0, 0xFF,
  0x07, 0xFC, 0x3F, 0x3F, 0x87, 0xFC, 0x1F, 0xF0, 0xFC, 0x7E, 0x1F, 0xE0,
  0x3F, 0xC3, 0xF1, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xC7, 0xE1, 0xFE, 0x03,
  0xFC, 0x7F, 0x1F, 0x8F, 0xF8, 0x0F, 0xF9, 0xF8, 0x7F, 0x3F, 0xC0, 0x1F,
  0xE7, 0xE0, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0x83, 0xF3, 0xFC, 0x01, 0xFE,
  0x7E, 0x0F, 0xCF, 0xF0, 0x07, 0xF9, 0xF8, 0x3F, 0x3F, 0xC0, 0x0F, 0xE7,
  0xC0, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x01, 0xF7, 0xF8, 0x00, 0xFF, 0xFC,
  0x07, 0xDF, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF,
  0x80, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F,
  0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8,
  0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x7F,
  0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x13, 0xFF, 0x80, 0x03, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE8, 0x00, 0x1F,
  0xF8, 0x80, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_Condensed_Bold64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 47, 17, 3, -46 },
  { 66, 23, 17, 29, 3, -46 },
  { 115, 33, 46, 35, 1, -46 },
  { 305, 26, 53, 32, 3, -49 },
  { 478, 48, 47, 52, 2, -46 },
  { 760, 37, 47, 39, 2, -46 },
  { 978, 9, 17, 16, 3, -46 },
  { 998, 16, 56, 21, 3, -46 },
  { 1110, 17, 56, 21, 1, -46 },
  { 1229, 27, 27, 30, 2, -49 },
  { 1321, 28, 31, 32, 2, -38 },
  { 1430, 12, 15, 17, 2, -7 },
  { 1453, 16, 8, 20, 2, -21 },
  { 1469, 11, 11, 17, 3, -10 },
  { 1485, 25, 46, 26, 1, -46 },
  { 1629, 27, 47, 32, 2, -46 },
  { 1788, 21, 46, 32, 3, -46 },
  { 1909, 27, 46, 32, 2, -46 },
  { 2065, 27, 47, 32, 2, -46 },
  { 2224, 30, 46, 32, 1, -46 },
  { 2397, 26, 47, 32, 3, -46 },
  { 2550, 28, 47, 32, 2, -46 },
  { 2715, 29, 46, 32, 1, -46 },
  { 2882, 28, 47, 32, 2, -46 },
  { 3047, 27, 47, 32, 2, -46 },
  { 3206, 11, 36, 17, 3, -35 },
  { 3256, 12, 43, 17, 2, -35 },
  { 3321, 28, 32, 32, 2, -39 },
  { 3433, 28, 19, 32, 2, -32 },
  { 3500, 28, 32, 32, 2, -39 },
  { 3612, 25, 47, 26, 0, -46 },
  { 3759, 44, 51, 50, 3, -46 },
  { 4040, 37, 46, 37, 0, -46 },
  { 4253, 29, 46, 36, 5, -46 },
  { 4420, 29, 47, 34, 3, -46 },
  { 4591, 31, 46, 39, 5, -46 },
  { 4770, 22, 46, 30, 5, -46 },
  { 4897, 22, 46, 30, 5, -46 },
  { 5024, 32, 47, 39, 3, -46 },
  { 5212, 31, 46, 41, 5, -46 },
  { 5391, 18, 46, 22, 2, -46 },
  { 5495, 18, 60, 19, -4, -46 },
  { 5630, 31, 46, 36, 5, -46 },
  { 5809, 23, 46, 29, 5, -46 },
  { 5942, 43, 46, 53, 5, -46 },
  { 6190, 34, 46, 44, 5, -46 },
  { 6386, 36, 47, 42, 3, -46 },
  { 6598, 27, 46, 34, 5, -46 },
  { 6754, 36, 57, 42, 3, -46 },
  { 7011, 30, 46, 36, 5, -46 },
  { 7184, 25, 47, 30, 2, -46 },
  { 7331, 28, 46, 30, 1, -46 },
  { 7492, 31, 47, 40, 5, -46 },
  { 7675, 35, 46, 35, 0, -46 },
  { 7877, 54, 46, 52, -1, -46 },
  { 8188, 34, 46, 34, 0, -46 },
  { 8384, 33, 46, 33, 0, -46 },
  { 8574, 27, 46, 30, 1, -46 },
  { 8730, 15, 56, 20, 4, -46 },
  { 8835, 26, 46, 26, 0, -46 },
  { 8985, 14, 56, 20, 2, -46 },
  { 9083, 32, 29, 35, 1, -46 },
  { 9199, 26, 4, 26, 0, 6 },
  { 9212, 15, 10, 21, 3, -49 },
  { 9231, 26, 37, 32, 2, -36 },
  { 9352, 28, 50, 35, 4, -49 },
  { 9527, 23, 37, 28, 3, -36 },
  { 9634, 29, 50, 35, 2, -49 },
  { 9816, 27, 37, 32, 3, -36 },
  { 9941, 22, 49, 21, 1, -49 },
  { 10076, 29, 51, 35, 2, -36 },
  { 10261, 27, 49, 35, 4, -49 },
  { 10427, 9, 49, 17, 4, -49 },
  { 10483, 15, 64, 17, -2, -49 },
  { 10603, 30, 49, 34, 4, -49 },
  { 10787, 9, 49, 17, 4, -49 },
  { 10843, 44, 36, 52, 4, -36 },
  { 11041, 27, 36, 35, 4, -36 },
  { 11163, 29, 37, 34, 2, -36 },
  { 11298, 28, 51, 35, 4, -36 },
  { 11477, 29, 51, 35, 2, -36 },
  { 11662, 20, 36, 24, 4, -36 },
  { 11752, 22, 37, 26, 2, -36 },
  { 11854, 21, 43, 23, 1, -42 },
  { 11967, 27, 36, 35, 4, -35 },
  { 12089, 31, 35, 31, 0, -35 },
  { 12225, 46, 35, 47, 0, -35 },
  { 12427, 30, 35, 30, 0, -35 },
  { 12559, 31, 50, 31, 0, -35 },
  { 12753, 23, 35, 26, 1, -35 },
  { 12854, 20, 56, 23, 1, -46 },
  { 12994, 7, 64, 30, 12, -49 },
  { 13050, 20, 56, 23, 2, -46 },
  { 13190, 28, 11, 32, 2, -28 },
};

const GFXfont NotoSans_Condensed_Bold64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_BOLD64PT7B_H_
