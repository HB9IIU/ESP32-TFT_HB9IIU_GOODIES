#ifndef _NOTOSANS_CONDENSED_BOLD21PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x6C, 0x0F, 0xF8, 0xEF, 0xCF, 0x9F, 0x3E, 0x60,
  0x0C, 0xC1, 0xB8, 0x36, 0x06, 0xC7, 0xFE, 0xFF, 0xC6, 0x60, 0xCC, 0x1B,
  0x1F, 0xFF, 0xFF, 0x99, 0x83, 0x30, 0x66, 0x0D, 0xC0, 0x08, 0x04, 0x1F,
  0xDF, 0xEE, 0x97, 0x43, 0xA0, 0xF0, 0x3E, 0x07, 0x83, 0xC1, 0x7C, 0xF7,
  0xF9, 0xF8, 0x10, 0x08, 0x00, 0x78, 0x71, 0xF0, 0xC3, 0x31, 0x86, 0x66,
  0x0C, 0xCC, 0x19, 0xB0, 0x33, 0x6F, 0x7D, 0xDF, 0x7B, 0x76, 0x06, 0xCC,
  0x19, 0x98, 0x33, 0x30, 0xC7, 0x61, 0x87, 0xC7, 0x0F, 0x00, 0x3E, 0x07,
  0xF0, 0x77, 0x06, 0x70, 0x77, 0x07, 0xE0, 0x3C, 0x07, 0xCF, 0xFE, 0xEE,
  0xEE, 0xE7, 0xCE, 0x3C, 0xF7, 0xCF, 0xFE, 0x7E, 0xF0, 0xFF, 0xFE, 0x19,
  0x9C, 0xE6, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x31, 0x8E, 0x31, 0xC0, 0xE1,
  0xC3, 0x0E, 0x18, 0x61, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0x63, 0x8C, 0x73,
  0x80, 0x0C, 0x06, 0x13, 0x2F, 0xFF, 0xF8, 0xF0, 0xFC, 0xE7, 0x12, 0x00,
  0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00,
  0xFF, 0xEC, 0xFF, 0xFE, 0xFF, 0x80, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C,
  0x1C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0xE0, 0x3C, 0x3F, 0x3D,
  0xDC, 0xEE, 0x37, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xDC, 0xEF, 0x73,
  0xF0, 0xF8, 0x0E, 0x3C, 0xFB, 0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x80, 0x7E, 0x7F, 0xB9, 0xC8, 0xE0, 0x70, 0x38, 0x1C,
  0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0xFF, 0xFF, 0xFE, 0x7E, 0x7F, 0xB1,
  0xC0, 0xE0, 0x70, 0x38, 0xF8, 0x7C, 0x1F, 0x03, 0x80, 0xE0, 0xF8, 0x77,
  0xFB, 0xF8, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x1B, 0x86, 0xE3, 0x38, 0xCE,
  0x63, 0xB8, 0xEF, 0xFF, 0xFF, 0x03, 0x80, 0xE0, 0x38, 0x7F, 0x3F, 0x9F,
  0xDC, 0x0E, 0x07, 0x43, 0xF9, 0xFE, 0x07, 0x01, 0xC0, 0xC0, 0xEC, 0xF7,
  0xF3, 0xF0, 0x1F, 0x1F, 0x9E, 0x1C, 0x0E, 0x06, 0x73, 0x7D, 0xFE, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7F, 0x73, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0x80, 0x3E, 0x3F, 0xB9, 0xDC, 0x6E, 0x73, 0xB9, 0xF8, 0x7C, 0x7F,
  0x73, 0xB0, 0xF8, 0x7E, 0x7F, 0xF9, 0xF8, 0x3C, 0x3F, 0x39, 0xDC, 0xEC,
  0x3E, 0x1F, 0x9F, 0xFF, 0x7F, 0x9D, 0x80, 0xC0, 0xE0, 0xE7, 0xF3, 0xE0,
  0x7F, 0xB0, 0x00, 0x1F, 0xF0, 0x7F, 0xB0, 0x00, 0x03, 0xFF, 0xB0, 0x00,
  0x81, 0xC3, 0xE7, 0xCF, 0x87, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xC0, 0x20,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x60, 0x3C, 0x0F,
  0x81, 0xF0, 0x1C, 0x7C, 0xF8, 0xF0, 0x60, 0x20, 0x00, 0x7E, 0xFF, 0x67,
  0x07, 0x07, 0x07, 0x0E, 0x1C, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38,
  0x0F, 0xE0, 0x7F, 0xC3, 0x83, 0x9C, 0x07, 0x67, 0xEF, 0x3B, 0x3C, 0xCC,
  0xF3, 0x33, 0xCC, 0xCF, 0x33, 0x3C, 0xCC, 0xF3, 0xFE, 0xE2, 0x31, 0xC0,
  0x03, 0x82, 0x07, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0x98, 0x39, 0xC3, 0x9C, 0x39, 0xC3, 0xFE, 0x7F, 0xE7, 0x0E,
  0x70, 0xEF, 0x07, 0xE0, 0x70, 0xFF, 0x3F, 0xEE, 0x3F, 0x87, 0xE1, 0xF8,
  0xEF, 0xFB, 0xFC, 0xE3, 0xB8, 0x7E, 0x1F, 0x87, 0xE3, 0xFF, 0xEF, 0xF0,
  0x1F, 0xCF, 0xE7, 0x99, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x79, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0xF3, 0xFF, 0x70,
  0xEE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x70, 0xEF,
  0xFD, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE1,
  0xC3, 0x87, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38,
  0x7F, 0xFF, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00, 0x1F, 0xCF, 0xF7, 0xCD,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x9F, 0xE7, 0xF8, 0x7E, 0x1D, 0xC7, 0x79,
  0xCF, 0xF1, 0xFC, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF,
  0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xFF, 0xF7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xFF, 0xC0, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0x3B, 0xEF,
  0x00, 0xE3, 0xF8, 0xEE, 0x73, 0xBC, 0xEE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE,
  0x3B, 0x8E, 0xF3, 0x9C, 0xE7, 0xB8, 0xEE, 0x3C, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0x63, 0x7D, 0x8D, 0xF7,
  0x37, 0xCD, 0xDF, 0x36, 0x7C, 0xD9, 0xF3, 0xE7, 0xC7, 0x1F, 0x1C, 0x7C,
  0x71, 0xC0, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xB9, 0xF7, 0x3E,
  0x77, 0xCE, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x78, 0x1F,
  0x83, 0xFC, 0x79, 0xE7, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0xE7, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0xFE, 0x7F,
  0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0x7E, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0x1F, 0x83, 0xFC, 0x79, 0xE7, 0x0E, 0xE0, 0xEE, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xE7, 0x0E, 0x79, 0xE3, 0xFC,
  0x1F, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0xFE, 0x1F, 0xF3, 0x9E,
  0x71, 0xCE, 0x3D, 0xC7, 0x38, 0xE7, 0xF8, 0xFE, 0x1C, 0xE3, 0x9C, 0x71,
  0xCE, 0x39, 0xC3, 0xB8, 0x78, 0x3E, 0x7F, 0xF6, 0xE0, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xEF, 0xFE, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xB8, 0x77, 0x9C, 0xFF, 0x87, 0xE0,
  0xE0, 0x7E, 0x0E, 0x60, 0xE7, 0x0E, 0x70, 0xC3, 0x1C, 0x31, 0xC3, 0x98,
  0x39, 0x81, 0xB8, 0x1B, 0x81, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xE1,
  0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xEC, 0x7C, 0x67, 0x36, 0x73, 0x9B, 0x39,
  0xCD, 0x9C, 0xE6, 0xCE, 0x37, 0x76, 0x1F, 0xBF, 0x0F, 0x8F, 0x87, 0xC7,
  0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0x70, 0x70, 0xF1, 0xEE, 0x38, 0xE7, 0x1D,
  0xC3, 0xB8, 0x3E, 0x07, 0xC0, 0x70, 0x1F, 0x03, 0xE0, 0xEE, 0x1D, 0xC7,
  0x1C, 0xE3, 0xB8, 0x38, 0xE0, 0xEE, 0x39, 0xC7, 0x39, 0xC3, 0xB8, 0x77,
  0x07, 0xC0, 0xF8, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C,
  0x0E, 0x0E, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x07, 0x03, 0xFF, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x06, 0x01, 0xC0, 0x3C, 0x0F, 0x81,
  0xB8, 0x73, 0x0C, 0x73, 0x86, 0xE0, 0xE0, 0xFF, 0x80, 0xE3, 0x8E, 0x1C,
  0x7F, 0x7F, 0x07, 0x07, 0x7F, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF, 0x7B, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE6, 0x3F, 0xCF, 0xFB, 0xCE, 0xE3, 0xB8, 0x6E,
  0x1F, 0x86, 0xE3, 0xBC, 0xEF, 0xFB, 0xBC, 0x1C, 0x7F, 0x7E, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xF2, 0x7E, 0x3E, 0x03, 0x81, 0xC0, 0xE0, 0x73,
  0xBB, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xBD, 0xFE,
  0x7B, 0x1C, 0x3F, 0x1F, 0xDC, 0x6E, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x78,
  0x9F, 0xC7, 0xE0, 0x1F, 0x3E, 0x3A, 0x38, 0x38, 0xFE, 0xFE, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0xFF, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xEF, 0x70, 0x38, 0x1F, 0x1F,
  0xFE, 0x7E, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x67, 0xFB, 0xFF, 0xE7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0x39, 0xCE, 0x00, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xEF, 0xFF, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0xEE, 0x73, 0x9C, 0xEE, 0x3F, 0x0F, 0xE3, 0xD8, 0xE7, 0x38, 0xEE, 0x3B,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x39, 0xFE, 0xFB, 0xFF,
  0xFF, 0x9C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F,
  0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x70, 0x06, 0x7F, 0xBF, 0xFE, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x1C, 0x3F, 0x9F, 0xDC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF9, 0xDF, 0xC7, 0xC0, 0x06, 0x3F,
  0xCF, 0xFB, 0xCE, 0xE3, 0xB8, 0x6E, 0x1F, 0x86, 0xE3, 0xBC, 0xEF, 0xFB,
  0xBC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x3F, 0xFF, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xEF, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0x07, 0xDF, 0xFF, 0x8E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x00, 0x39, 0xFF, 0xF6, 0x0E, 0x1F, 0x1F, 0x0F, 0x0F, 0x1F,
  0xFF, 0xE0, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0xD3, 0xE7, 0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xF7, 0xBF, 0xDF, 0x60, 0xE1, 0xDC, 0x67, 0x39, 0xCE, 0x33, 0x8E, 0xC3,
  0xF0, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0xE3, 0x8E, 0xC7, 0x9D, 0xDF, 0x3B,
  0xB6, 0x67, 0x6D, 0xC6, 0xDB, 0x8D, 0x9F, 0x1B, 0x3C, 0x3C, 0x78, 0x38,
  0xF0, 0x71, 0xE0, 0xF3, 0xDC, 0xE3, 0xF0, 0xFC, 0x1E, 0x07, 0x83, 0xE0,
  0xFC, 0x77, 0x1C, 0xEE, 0x3C, 0xE1, 0xDC, 0x67, 0x39, 0xCE, 0x33, 0x8E,
  0xC3, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0xE0, 0x30, 0x1C, 0x2F, 0x07, 0x81,
  0xC0, 0x7F, 0x7F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xFF, 0xFF,
  0x0E, 0x3C, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0xF9, 0xE0, 0xE1, 0xC1, 0x83,
  0x06, 0x0C, 0x1E, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x3C, 0x73, 0x9C, 0x71, 0xC7, 0x1C, 0xF3, 0x80,
  0xF0, 0xFF, 0xE3, 0xE0,
};

const GFXglyph NotoSans_Condensed_Bold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 15, 6, 1, -15 },
  { 7, 7, 5, 10, 1, -15 },
  { 12, 11, 15, 11, 0, -15 },
  { 33, 9, 17, 10, 1, -16 },
  { 53, 15, 15, 17, 1, -15 },
  { 82, 12, 15, 13, 1, -15 },
  { 105, 3, 5, 5, 1, -15 },
  { 107, 5, 18, 7, 1, -15 },
  { 119, 6, 18, 7, 0, -15 },
  { 133, 9, 9, 10, 0, -16 },
  { 144, 9, 10, 10, 1, -12 },
  { 156, 3, 5, 5, 1, -2 },
  { 158, 5, 3, 6, 1, -7 },
  { 160, 3, 3, 6, 1, -3 },
  { 162, 8, 15, 9, 0, -15 },
  { 177, 9, 15, 10, 1, -15 },
  { 194, 7, 15, 10, 1, -15 },
  { 208, 9, 15, 10, 1, -15 },
  { 225, 9, 15, 10, 1, -15 },
  { 242, 10, 15, 10, 0, -15 },
  { 261, 9, 15, 10, 1, -15 },
  { 278, 9, 15, 10, 1, -15 },
  { 295, 10, 15, 10, 0, -15 },
  { 314, 9, 15, 10, 1, -15 },
  { 331, 9, 15, 10, 1, -15 },
  { 348, 3, 12, 6, 1, -12 },
  { 353, 3, 15, 6, 1, -12 },
  { 359, 9, 11, 10, 1, -13 },
  { 372, 9, 7, 10, 1, -11 },
  { 380, 9, 11, 10, 1, -13 },
  { 393, 8, 15, 8, 0, -15 },
  { 408, 14, 17, 16, 1, -15 },
  { 438, 12, 15, 12, 0, -15 },
  { 461, 10, 15, 12, 1, -15 },
  { 480, 10, 15, 11, 1, -15 },
  { 499, 11, 15, 13, 1, -15 },
  { 520, 7, 15, 10, 2, -15 },
  { 534, 7, 15, 10, 2, -15 },
  { 548, 10, 15, 13, 1, -15 },
  { 567, 10, 15, 13, 2, -15 },
  { 586, 6, 15, 7, 1, -15 },
  { 598, 6, 19, 6, -1, -15 },
  { 613, 10, 15, 12, 2, -15 },
  { 632, 8, 15, 9, 1, -15 },
  { 647, 14, 15, 17, 2, -15 },
  { 674, 11, 15, 14, 2, -15 },
  { 695, 12, 15, 14, 1, -15 },
  { 718, 9, 15, 11, 1, -15 },
  { 735, 12, 19, 14, 1, -15 },
  { 764, 11, 15, 12, 1, -15 },
  { 785, 8, 15, 10, 1, -15 },
  { 800, 10, 15, 10, 0, -15 },
  { 819, 11, 15, 13, 1, -15 },
  { 840, 12, 15, 12, 0, -15 },
  { 863, 17, 15, 17, 0, -15 },
  { 895, 11, 15, 11, 0, -15 },
  { 916, 11, 15, 11, 0, -15 },
  { 937, 9, 15, 10, 0, -15 },
  { 954, 5, 18, 7, 1, -15 },
  { 966, 8, 15, 9, 0, -15 },
  { 981, 4, 18, 7, 1, -15 },
  { 990, 11, 9, 11, 0, -15 },
  { 1003, 9, 1, 9, 0, 2 },
  { 1005, 5, 3, 7, 1, -16 },
  { 1007, 8, 12, 11, 1, -12 },
  { 1019, 10, 16, 11, 1, -16 },
  { 1039, 8, 12, 9, 1, -12 },
  { 1051, 9, 16, 11, 1, -16 },
  { 1069, 9, 12, 10, 1, -12 },
  { 1083, 8, 16, 7, 0, -16 },
  { 1099, 9, 17, 11, 1, -12 },
  { 1119, 9, 16, 11, 1, -16 },
  { 1137, 3, 16, 5, 1, -16 },
  { 1143, 5, 21, 5, -1, -16 },
  { 1157, 10, 16, 11, 1, -16 },
  { 1177, 3, 16, 5, 1, -16 },
  { 1183, 15, 12, 17, 1, -12 },
  { 1206, 9, 12, 11, 1, -12 },
  { 1220, 9, 12, 11, 1, -12 },
  { 1234, 10, 17, 11, 1, -12 },
  { 1256, 9, 17, 11, 1, -12 },
  { 1276, 7, 12, 8, 1, -12 },
  { 1287, 7, 12, 9, 1, -12 },
  { 1298, 7, 14, 8, 0, -14 },
  { 1311, 9, 11, 11, 1, -11 },
  { 1324, 10, 11, 10, 0, -11 },
  { 1338, 15, 11, 15, 0, -11 },
  { 1359, 10, 11, 10, 0, -11 },
  { 1373, 10, 16, 10, 0, -11 },
  { 1393, 8, 11, 8, 0, -11 },
  { 1404, 7, 18, 8, 0, -15 },
  { 1420, 2, 21, 10, 4, -16 },
  { 1426, 6, 18, 8, 1, -15 },
  { 1440, 9, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Bold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_BOLD21PT7B_H_
