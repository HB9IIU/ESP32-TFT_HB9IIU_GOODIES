#ifndef _NOTOSANS_CONDENSED_BOLD45PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x7E, 0x10, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x00, 0xF1, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x78, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xEF,
  0xBF, 0x38, 0x2F, 0xCE, 0x03, 0xF3, 0x80, 0xFC, 0xE0, 0x3F, 0xB8, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0E, 0xFC, 0x03, 0x9F, 0x80, 0xE7,
  0xF0, 0x3B, 0xFF, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC7,
  0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x20, 0x03, 0xF8, 0x00, 0xF0,
  0x03, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x7F, 0xF8, 0x0F,
  0x80, 0x1F, 0x3E, 0x03, 0xE0, 0x07, 0xC7, 0x81, 0xF0, 0x03, 0xE1, 0xF0,
  0x7C, 0x00, 0xF8, 0x7C, 0x1E, 0x00, 0x3E, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC3, 0xC0, 0x03, 0xE1, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x78, 0x00, 0x1E,
  0x1F, 0x3E, 0x1E, 0x07, 0xC7, 0xCF, 0x8F, 0xE1, 0xF3, 0xE7, 0xC7, 0xFC,
  0x7F, 0xF9, 0xF3, 0xFF, 0x8F, 0xFC, 0x79, 0xFF, 0xE1, 0xFF, 0x3E, 0x7C,
  0x78, 0x3F, 0x8F, 0x1F, 0x1F, 0x03, 0x07, 0xC7, 0xC7, 0xC0, 0x01, 0xF1,
  0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x7C, 0x00, 0x3E, 0x1E, 0x1F, 0x00, 0x1F,
  0x07, 0xC7, 0xC0, 0x07, 0xC1, 0xE1, 0xF0, 0x01, 0xE0, 0x7C, 0x7C, 0x00,
  0xF8, 0x1F, 0x1F, 0x00, 0x3C, 0x07, 0xCF, 0x80, 0x1F, 0x00, 0xFF, 0xE0,
  0x07, 0xC0, 0x3F, 0xF8, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xC3, 0xFF,
  0x83, 0xF0, 0xFF, 0xF8, 0x7E, 0x3F, 0xBF, 0x9F, 0xC7, 0xF3, 0xF3, 0xF8,
  0xFC, 0x7F, 0x7E, 0x3F, 0x87, 0xFF, 0xC7, 0xF0, 0x7F, 0xF0, 0xFE, 0x07,
  0xFE, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFD,
  0xFC, 0x07, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF0, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83,
  0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x04, 0x1F, 0x02, 0xE1, 0xE3, 0x9F, 0xBF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0x7E, 0x07, 0xE7, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F,
  0x00, 0xC1, 0xC0, 0x08, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C,
  0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x7E, 0x10, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0xFE, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF,
  0xC0, 0xFD, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xBF,
  0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F,
  0x8F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xF8, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC7, 0xFF, 0xBF, 0xBF, 0xFE, 0x7E, 0xFC, 0xFC, 0xE1, 0xF8, 0x87,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3E, 0x0F, 0xE1, 0x80, 0xFE, 0x10, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x38, 0x0F, 0xE1, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x80, 0x0F, 0xE6, 0x01, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0xF9, 0xF8, 0x07, 0x8F,
  0xC0, 0x7C, 0x7E, 0x03, 0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xE0, 0xFC, 0x1F,
  0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF9, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC8, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x03,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x7C, 0xFF, 0x07, 0xDF, 0xFC, 0x7D,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x8F, 0xEF, 0xF0, 0x7E, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F,
  0x7E, 0x07, 0xF7, 0xF0, 0x7E, 0x3F, 0x8F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF9, 0xFE, 0x7F, 0x07, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x9F,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xF9, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7,
  0xE0, 0x7E, 0x7F, 0x9F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xE7, 0xE0, 0x7E, 0xFE,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0x7E, 0x0F, 0xF7, 0xF9, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFB, 0xE0, 0xFF, 0x3E, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3C,
  0x7E, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E,
  0x08, 0x1E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF9, 0xF8, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFB,
  0xFF, 0xFC, 0xE0, 0xFE, 0x40, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x07, 0xF8,
  0x7C, 0x78, 0x3F, 0xFC, 0x79, 0xF0, 0xFF, 0xF8, 0xF3, 0xE1, 0xFF, 0xF1,
  0xF7, 0x87, 0xC3, 0xE3, 0xFF, 0x0F, 0x87, 0xC7, 0xFE, 0x3E, 0x0F, 0x87,
  0xFC, 0x7C, 0x1E, 0x0F, 0xF0, 0xF8, 0x3C, 0x1F, 0xE1, 0xF0, 0x78, 0x7F,
  0xC3, 0xC0, 0xF0, 0xFF, 0x87, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xC3, 0xDF,
  0x1F, 0x0F, 0x87, 0xBE, 0x3F, 0x3F, 0x9F, 0x7C, 0x3F, 0xFF, 0xFC, 0x78,
  0x7F, 0xEF, 0xF8, 0xF8, 0x7F, 0x9F, 0xE1, 0xF0, 0x3C, 0x0F, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xC0, 0x07, 0xFC, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xDF, 0x80,
  0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF,
  0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0,
  0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x07, 0xFB, 0xF8, 0x1F,
  0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC,
  0x0F, 0xCF, 0xE1, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0,
  0x3F, 0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF7,
  0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x83,
  0x87, 0xF0, 0x04, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x04, 0x7F, 0xC1, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xF8,
  0xFF, 0xCF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xBF, 0x80, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x3F, 0xCF, 0xE7, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x07, 0xFC, 0x0E, 0x1F, 0xE0, 0x04, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F,
  0xDF, 0x80, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0x7E, 0x01, 0xFC,
  0xFE, 0x03, 0xF9, 0xFF, 0x07, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80,
  0xFD, 0x0F, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0x80,
  0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFC,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x3F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0x80, 0xFE, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xC0, 0xFE, 0x3F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3E, 0xFF,
  0xF7, 0xC0, 0x7D, 0xFF, 0xEF, 0x80, 0xFB, 0xFF, 0xDF, 0x03, 0xE7, 0xFF,
  0x9F, 0x07, 0xCF, 0xFF, 0x3E, 0x0F, 0x9F, 0xFE, 0x7C, 0x3F, 0x3F, 0xFC,
  0xFC, 0x7C, 0x7F, 0xF8, 0xF8, 0xF8, 0xFF, 0xF1, 0xF1, 0xF1, 0xFF, 0xE3,
  0xE7, 0xC3, 0xFF, 0xC7, 0xEF, 0x87, 0xFF, 0x87, 0xDF, 0x0F, 0xFF, 0x0F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0x7F, 0xF8, 0x3F,
  0xE0, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xC0, 0xFE,
  0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFE, 0x07, 0xE0,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFD, 0xF8, 0x1F, 0xFD, 0xFC,
  0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0x7E, 0x1F, 0xFC, 0x7E,
  0x1F, 0xFC, 0x3F, 0x1F, 0xFC, 0x3F, 0x1F, 0xFC, 0x1F, 0x9F, 0xFC, 0x1F,
  0x9F, 0xFC, 0x1F, 0xDF, 0xFC, 0x0F, 0xDF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xEF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFD, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x3F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xEF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFD, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0,
  0x3F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xF8, 0xFF, 0x8F, 0xE0, 0xFE, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0x9F, 0x80, 0xFE, 0x7F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3,
  0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x80, 0x7F, 0x00, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFB, 0xFC, 0x3D, 0xFC, 0x04, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x3F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF8, 0x7F, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0xC0, 0x3F, 0x3F, 0x01, 0xFE, 0x01, 0xF9, 0xF8, 0x0F, 0xF0,
  0x1F, 0xCF, 0xC0, 0x7F, 0xC0, 0xFC, 0x7F, 0x03, 0xFE, 0x07, 0xE1, 0xF8,
  0x3F, 0xF0, 0x3F, 0x0F, 0xC1, 0xF7, 0x81, 0xF8, 0x7E, 0x0F, 0xBE, 0x1F,
  0x83, 0xF0, 0x7D, 0xF0, 0xFC, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0x7E, 0x3E,
  0x7C, 0x3F, 0x03, 0xF1, 0xF3, 0xE1, 0xF8, 0x1F, 0x8F, 0x8F, 0x9F, 0x80,
  0xFC, 0x7C, 0x7C, 0xFC, 0x03, 0xE7, 0xE3, 0xE7, 0xE0, 0x1F, 0xBE, 0x1F,
  0x3F, 0x00, 0xFD, 0xF0, 0xF9, 0xF8, 0x07, 0xEF, 0x83, 0xFF, 0x80, 0x3F,
  0x7C, 0x1F, 0xFC, 0x00, 0xFB, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x83, 0xF8,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC3, 0xF0,
  0x1F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE,
  0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0x87,
  0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F,
  0x8F, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0x7C, 0x03, 0xE1,
  0xF0, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x18, 0x1F, 0xC2, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xF3, 0xFE, 0xFF, 0xFF, 0xCF, 0xFE, 0xF9,
  0xFF, 0x9F, 0x1F, 0xE3, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0xFC, 0xFF, 0x0F, 0xDF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x1F, 0xCF, 0xE0, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xBF,
  0xF8, 0xF9, 0xFF, 0x0F, 0x8F, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFE, 0x7F, 0x86, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0x7F, 0x03, 0x7F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x7C, 0x7F, 0x1F, 0xF7, 0xF3,
  0xFF, 0xBF, 0x3F, 0xFB, 0xF7, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0xFE, 0x1F, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x1F, 0x9F,
  0x83, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x67, 0xFE, 0xFC, 0x7F,
  0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x07, 0xC3, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xF3, 0xFF, 0xBF, 0x7F,
  0xFF, 0xF7, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF1, 0xFF,
  0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE4, 0x00, 0xFE, 0x7E, 0x3F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x8F, 0xC3, 0xF7, 0xFC, 0x7F, 0xFF, 0xCF,
  0xBF, 0xFD, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFC, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0x87, 0xC0, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xBF, 0x01,
  0xFD, 0xF8, 0x1F, 0xCF, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F,
  0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0x7E, 0x07, 0xF3, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xF7, 0xE0,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7E, 0x07, 0xE1, 0xF3, 0xFE, 0x1F, 0xF3,
  0xEF, 0xFE, 0x7F, 0xF7, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xE3, 0xFF, 0x3F, 0xFF, 0x83, 0xFC, 0x3F, 0xFF, 0x07, 0xF0, 0x3F, 0xFC,
  0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xE0,
  0x7E, 0x03, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x03,
  0xF0, 0x1F, 0xFE, 0x07, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x7F, 0xF8, 0x1F,
  0x80, 0xFF, 0xF0, 0x3F, 0x01, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xC0, 0xFC,
  0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFE, 0x07, 0xE0,
  0x3F, 0xFC, 0x0F, 0xC0, 0x7E, 0xF8, 0x7E, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE,
  0x7D, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xE0,
  0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x7C, 0x0F, 0x9F,
  0xF0, 0xF9, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF1, 0xFC, 0xFE,
  0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFE, 0x0F, 0xEF, 0xF0, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xDF, 0xF0, 0xFC, 0xFE, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC3, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xF3, 0xFF, 0xBF,
  0x7F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF1,
  0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x7F, 0xE3, 0xEF,
  0x9F, 0xBE, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xF8, 0xBF, 0xC0, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7E, 0x0E, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x60, 0x3F, 0x7F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0x9F, 0x1F, 0xE3, 0xE0, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0x7F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0x07, 0xE0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xBF, 0x03, 0xF8, 0x1F, 0x9F, 0x81, 0xFC, 0x0F, 0xCF, 0xC1, 0xFF, 0x07,
  0xE7, 0xE0, 0xFF, 0x83, 0xF3, 0xF0, 0x7F, 0xC1, 0xF0, 0xFC, 0x3D, 0xE1,
  0xF8, 0x7E, 0x1E, 0xF0, 0xFC, 0x3F, 0x1F, 0x7C, 0x7E, 0x1F, 0x8F, 0xBE,
  0x3E, 0x07, 0xE7, 0x8F, 0x3F, 0x03, 0xF3, 0xC7, 0x9F, 0x81, 0xF9, 0xE3,
  0xCF, 0xC0, 0xFD, 0xF1, 0xE7, 0xE0, 0x3E, 0xF8, 0xFB, 0xE0, 0x1F, 0x78,
  0x3F, 0xF0, 0x0F, 0xBC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC,
  0x7F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x3F, 0x7F, 0x01, 0xFB,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFE, 0x1F,
  0x83, 0xF1, 0xFC, 0x1F, 0xCF, 0xC0, 0x7E, 0xFE, 0x03, 0xF8, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0x7F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0x7C, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE1, 0xFF,
  0x83, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x07, 0xFC, 0x3F, 0xF1,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x13, 0xFC, 0x01, 0x7F,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x3F, 0xE8,
  0x00, 0x78,
};

const GFXglyph NotoSans_Condensed_Bold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 33, 12, 2, -32 },
  { 34, 16, 11, 20, 2, -32 },
  { 56, 23, 32, 25, 1, -32 },
  { 148, 18, 37, 22, 2, -34 },
  { 232, 34, 33, 37, 1, -33 },
  { 373, 27, 33, 28, 1, -33 },
  { 485, 7, 11, 11, 2, -32 },
  { 495, 12, 39, 14, 2, -32 },
  { 554, 11, 39, 14, 1, -32 },
  { 608, 19, 19, 21, 1, -34 },
  { 654, 20, 22, 22, 1, -27 },
  { 709, 9, 11, 12, 1, -5 },
  { 722, 12, 6, 14, 1, -15 },
  { 731, 8, 8, 12, 2, -7 },
  { 739, 18, 32, 18, 0, -32 },
  { 811, 19, 33, 22, 2, -33 },
  { 890, 15, 32, 22, 2, -32 },
  { 950, 20, 33, 22, 1, -33 },
  { 1033, 20, 33, 22, 1, -33 },
  { 1116, 21, 32, 22, 1, -32 },
  { 1200, 18, 32, 22, 2, -32 },
  { 1272, 20, 32, 22, 1, -32 },
  { 1352, 20, 32, 22, 1, -32 },
  { 1432, 20, 33, 22, 1, -33 },
  { 1515, 20, 32, 22, 1, -32 },
  { 1595, 8, 26, 12, 2, -25 },
  { 1621, 9, 31, 12, 1, -25 },
  { 1656, 20, 22, 22, 1, -27 },
  { 1711, 20, 14, 22, 1, -23 },
  { 1746, 20, 22, 22, 1, -27 },
  { 1801, 17, 34, 18, 0, -33 },
  { 1874, 31, 36, 35, 2, -32 },
  { 2014, 26, 32, 26, 0, -32 },
  { 2118, 21, 32, 26, 3, -32 },
  { 2202, 21, 33, 24, 2, -33 },
  { 2289, 22, 32, 28, 3, -32 },
  { 2377, 16, 32, 21, 3, -32 },
  { 2441, 16, 32, 21, 3, -32 },
  { 2505, 23, 33, 28, 2, -33 },
  { 2600, 22, 32, 29, 3, -32 },
  { 2688, 13, 32, 15, 1, -32 },
  { 2740, 13, 42, 13, -3, -32 },
  { 2809, 22, 32, 25, 3, -32 },
  { 2897, 16, 32, 20, 3, -32 },
  { 2961, 31, 32, 37, 3, -32 },
  { 3085, 24, 32, 31, 3, -32 },
  { 3181, 25, 33, 29, 2, -33 },
  { 3285, 19, 32, 24, 3, -32 },
  { 3361, 25, 41, 29, 2, -33 },
  { 3490, 22, 32, 25, 3, -32 },
  { 3578, 17, 33, 21, 2, -33 },
  { 3649, 20, 32, 21, 1, -32 },
  { 3729, 22, 32, 28, 3, -32 },
  { 3817, 25, 32, 25, 0, -32 },
  { 3917, 37, 32, 37, 0, -32 },
  { 4065, 24, 32, 24, 0, -32 },
  { 4161, 23, 32, 23, 0, -32 },
  { 4253, 19, 32, 21, 1, -32 },
  { 4329, 10, 39, 14, 3, -32 },
  { 4378, 18, 32, 18, 0, -32 },
  { 4450, 11, 39, 14, 1, -32 },
  { 4504, 22, 20, 24, 1, -32 },
  { 4559, 19, 3, 18, 0, 4 },
  { 4567, 11, 7, 15, 2, -34 },
  { 4577, 19, 25, 23, 1, -25 },
  { 4637, 20, 34, 24, 3, -34 },
  { 4722, 16, 25, 20, 2, -25 },
  { 4772, 20, 34, 24, 2, -34 },
  { 4857, 19, 25, 22, 2, -25 },
  { 4917, 15, 34, 15, 1, -34 },
  { 4981, 20, 36, 24, 2, -25 },
  { 5071, 19, 34, 25, 3, -34 },
  { 5152, 6, 34, 12, 3, -34 },
  { 5178, 11, 45, 12, -2, -34 },
  { 5240, 21, 34, 24, 3, -34 },
  { 5330, 6, 34, 12, 3, -34 },
  { 5356, 31, 25, 37, 3, -25 },
  { 5453, 19, 25, 25, 3, -25 },
  { 5513, 20, 25, 24, 2, -25 },
  { 5576, 20, 36, 24, 3, -25 },
  { 5666, 20, 36, 24, 2, -25 },
  { 5756, 14, 25, 17, 3, -25 },
  { 5800, 16, 25, 19, 1, -25 },
  { 5850, 14, 30, 16, 1, -30 },
  { 5903, 19, 25, 25, 3, -25 },
  { 5963, 22, 25, 22, 0, -25 },
  { 6032, 33, 25, 33, 0, -25 },
  { 6136, 21, 25, 21, 0, -25 },
  { 6202, 22, 36, 22, 0, -25 },
  { 6301, 16, 25, 18, 1, -25 },
  { 6351, 15, 39, 16, 0, -32 },
  { 6425, 5, 44, 21, 8, -34 },
  { 6453, 14, 39, 16, 2, -32 },
  { 6522, 20, 8, 22, 1, -20 },
};

const GFXfont NotoSans_Condensed_Bold45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_BOLD45PT7B_H_
