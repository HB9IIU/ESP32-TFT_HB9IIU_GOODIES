#ifndef _NOTOSANS_CONDENSED_BOLD71PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF1,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xF3, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0x07,
  0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xDF, 0xF8,
  0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF,
  0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF,
  0xF0, 0x3F, 0xE7, 0xF8, 0x1F, 0xF3, 0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xFC,
  0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F,
  0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xDF, 0xF1,
  0xFF, 0x9E, 0x07, 0x9F, 0xF8, 0xF0, 0x08, 0xFF, 0xC7, 0x80, 0x07, 0xFC,
  0x3C, 0x00, 0x3F, 0xE1, 0xE0, 0x01, 0xFF, 0x8F, 0x00, 0x07, 0xFE, 0x78,
  0x00, 0x3F, 0xFB, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xEF, 0xFE, 0x00, 0x0F, 0x3F, 0xF0, 0x00, 0x78, 0xFF, 0x80,
  0x03, 0xC7, 0xFC, 0x00, 0x1E, 0x3F, 0xF0, 0x00, 0xF1, 0xFF, 0xE0, 0x07,
  0x8F, 0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0xC1, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x83, 0xFC,
  0x00, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC0, 0x3F,
  0x83, 0xFC, 0x3F, 0x83, 0xFF, 0x81, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xFE,
  0x0F, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0xCF, 0xF1, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F,
  0x1F, 0xF7, 0xFC, 0x3F, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xE0, 0xFF, 0xFC,
  0x3F, 0x87, 0xF0, 0x7F, 0x83, 0xFF, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x07,
  0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x7F, 0x81, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC1,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0x87, 0xFF, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xEF, 0xFC, 0x3F, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF0, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x10, 0x07, 0xF0, 0x02,
  0x78, 0x1F, 0xC0, 0x71, 0xFC, 0x3F, 0x0F, 0xE7, 0xFE, 0xFD, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x03, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x0F, 0xF3,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE,
  0x07, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x00, 0xFF,
  0x8F, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE,
  0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0x3F, 0xE0,
  0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80,
  0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01,
  0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x7F, 0xDF, 0xE1, 0xFF, 0x3F, 0x07, 0xFC, 0x78, 0x1F, 0xF0, 0xC0, 0x7F,
  0xC2, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF0, 0x7F, 0xF8, 0x7E, 0x00, 0xFF, 0xE1, 0xF0, 0x01, 0xFF, 0x83, 0x80,
  0x07, 0xFE, 0x04, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xC0, 0x7F, 0xF8, 0x3C, 0x00, 0xFF, 0xE0, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0x7F, 0xE0, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x3F, 0x9F, 0xF8, 0x00, 0x3F,
  0xCF, 0xFC, 0x00, 0x1F, 0xC7, 0xFE, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x0F,
  0xE1, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0xE0, 0x07,
  0xF8, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x0F, 0xFC, 0x03,
  0xFC, 0x07, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x80,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x3F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1C, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0x00, 0x03, 0xFF, 0xBF,
  0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x10, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x07,
  0xF0, 0x03, 0xFE, 0x3F, 0xFC, 0x07, 0xFC, 0xFF, 0xFC, 0x0F, 0xF3, 0xFF,
  0xFC, 0x1F, 0xEF, 0xFF, 0xFC, 0x7F, 0xDF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0x80, 0xFF,
  0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE3, 0xFF,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x0F, 0xF8,
  0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x9F, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFC,
  0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xF9, 0xFF,
  0x80, 0x3F, 0xF3, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFB,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0x7F,
  0xF0, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xFE, 0xFF, 0x83, 0xFF,
  0xF9, 0xFF, 0x01, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0xF1, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x8F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xE0, 0x70, 0x0F, 0xE0, 0xFF, 0x8F, 0xFE,
  0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0x83,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0xE3, 0xC0, 0x0F, 0xFC, 0x60, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0xFF, 0x83, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0xE1, 0xFE, 0x3F, 0xC0, 0x7F,
  0xFF, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xCF, 0xF0, 0x3F, 0xE0, 0xFE, 0x07, 0xF7, 0xF0, 0x3F,
  0xC0, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFD, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x07,
  0xF0, 0x0F, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0x81,
  0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0x01, 0xFF, 0xF8,
  0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0xFE,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xBF,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xDF, 0xE0, 0xFF, 0x07, 0xFE, 0x1F, 0xCF,
  0xF0, 0x3F, 0xC7, 0xFF, 0x1F, 0xE3, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFC, 0x07, 0xFF, 0xF7, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xF0,
  0x7F, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x04,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x07, 0xFF, 0x80, 0x0E,
  0x07, 0xFF, 0x80, 0x01, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x02, 0x0F, 0xFF, 0x80, 0x03,
  0x03, 0xFF, 0xF0, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F,
  0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xCF, 0xFC,
  0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFD,
  0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0x83, 0xFF, 0xF0, 0x00, 0xE0, 0x7F, 0xF8, 0x00, 0x04, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x1F,
  0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x80,
  0x0F, 0xFC, 0x7F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F,
  0xF1, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x3F,
  0xFC, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01,
  0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0,
  0x03, 0xFD, 0xFF, 0xFF, 0xBF, 0xC0, 0x03, 0xFD, 0xFF, 0xFF, 0xBF, 0xC0,
  0x03, 0xFD, 0xFF, 0xFF, 0x9F, 0xE0, 0x07, 0xF9, 0xFF, 0xFF, 0x9F, 0xE0,
  0x07, 0xF9, 0xFF, 0xFF, 0x9F, 0xE0, 0x07, 0xF9, 0xFF, 0xFF, 0x9F, 0xE0,
  0x07, 0xF9, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0,
  0x0F, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0xCF, 0xF8,
  0x1F, 0xE1, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0xC7, 0xF8,
  0x1F, 0xE1, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0xC7, 0xFC,
  0x3F, 0xC1, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xC3, 0xFC,
  0x3F, 0xC1, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x81, 0xFF, 0xFF, 0xC1, 0xFE,
  0x7F, 0x81, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0xC1, 0xFE,
  0x7F, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xFF, 0xBF, 0xF0, 0x07, 0xFF,
  0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0xE7, 0xFE,
  0x01, 0xFF, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF,
  0xE0, 0x7F, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0xFE, 0x03, 0xFF,
  0x1F, 0xFF, 0xF8, 0x07, 0xFE, 0x7F, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0xFF,
  0x80, 0x3F, 0xF7, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0x01, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x1F, 0xFE, 0xFF, 0xC7, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xFE, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F,
  0xF3, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFE, 0x01, 0xF3, 0xFF, 0x80, 0x0E, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF,
  0xF7, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFB, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x9F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF3, 0xFC, 0x0F, 0xFC, 0x01, 0xFF,
  0x81, 0xFE, 0x7F, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFE,
  0x1F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0x8F, 0xF8, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xF1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7,
  0xF8, 0x1F, 0xE7, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0xC0,
  0x01, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x0F,
  0xF3, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x7F,
  0xDF, 0xE0, 0x1F, 0xCF, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0xF8, 0x0E, 0x00, 0x7F,
  0xE0, 0x20, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC0,
  0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F,
  0xF0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFD, 0xFF, 0x3F, 0xFF, 0xE7, 0xFC, 0x7F, 0xFF, 0x8F, 0xF0, 0xFF, 0xF8,
  0x3F, 0xC1, 0xFF, 0xC0, 0xFF, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0xDF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFC, 0xFF, 0xF0, 0x0F,
  0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07,
  0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07,
  0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03,
  0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07,
  0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07,
  0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xF8, 0x1F,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF,
  0xE0, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFE, 0x01, 0xC7, 0xFF, 0x00,
  0x11, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x09, 0xFF, 0xE0, 0x0E, 0x3F, 0xFF, 0x7F,
  0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x02, 0x01,
  0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x03, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0xCF,
  0xFC, 0x3F, 0xFF, 0xCF, 0xF8, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x1F, 0xFF,
  0x7F, 0xF0, 0x1F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x03,
  0xFF, 0xCF, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0x9F,
  0xF0, 0x3F, 0xFE, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF,
  0x80, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x43, 0xFF, 0x00, 0x07, 0x0F, 0xFF, 0x00,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0x04, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0x9F, 0xF0,
  0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0xFD, 0xFF,
  0xC0, 0x7F, 0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xEF, 0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF,
  0x3F, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xDF, 0xF0, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xFE, 0xFF, 0xC0,
  0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0x3C, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x88, 0x00, 0x03, 0xFF, 0x1C, 0x00,
  0x0F, 0xFE, 0x3F, 0x80, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x04, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF,
  0x7F, 0xFF, 0xC7, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0,
  0x1F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0x00,
  0x3F, 0xEF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0x0F, 0xF3, 0xFF, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xC7, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD,
  0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF,
  0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x3F,
  0xF8, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F,
  0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x02, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x18, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0x07, 0xF8,
  0x7F, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF0,
  0x3F, 0xFB, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0xFF, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xC0,
  0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0x9F,
  0xFF, 0xE0, 0xFF, 0xBF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFC, 0xFF, 0xF0,
  0x0F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0,
  0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0,
  0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0,
  0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xF8,
  0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xFF, 0xE0, 0xFF, 0xCF,
  0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC0,
  0x78, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0x03, 0xFC, 0x0F, 0xFF, 0x8F, 0xF8, 0x3F, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF,
  0x3F, 0xE3, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0xFD, 0xFF, 0xC0, 0x7F,
  0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xFC,
  0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xDF, 0xF0, 0xFF, 0xFF, 0x3F, 0xE0, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xF1,
  0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0x3C, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x23, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF1, 0xBF, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x7F, 0xE0, 0x7E, 0x7F, 0xE0, 0x06, 0x3F, 0xF0, 0x01, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x83, 0xFF, 0xDF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x03, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x03, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xE3, 0xFC, 0x1F,
  0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xBF, 0x80, 0xFF, 0x81, 0xFF, 0x83, 0xF9, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0x9F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xF9,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0x9F, 0xC1, 0xFF, 0x00, 0xFF, 0x87,
  0xF0, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0x0F, 0xE3, 0xFF, 0x00, 0x7F,
  0xC7, 0xF0, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0x0F, 0xE3, 0xFE, 0x00,
  0x7F, 0xC7, 0xF0, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7E, 0x07, 0xE3, 0xFE,
  0x00, 0x3F, 0xCF, 0xE0, 0x7E, 0x7F, 0xC0, 0x03, 0xFE, 0xFE, 0x07, 0xF7,
  0xFC, 0x00, 0x3F, 0xEF, 0xE0, 0x7F, 0x7F, 0xC0, 0x03, 0xFE, 0xFE, 0x07,
  0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xC0, 0x3F, 0x7F, 0x80, 0x01, 0xFE, 0xFC,
  0x03, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xC0, 0x3F, 0x7F, 0x80, 0x01, 0xFE,
  0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xFB, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x0F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x47,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x02, 0x3F,
  0xFC, 0x00, 0x04, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFB, 0x00, 0x01,
  0xFF, 0xC4, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_Condensed_Bold71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 52, 19, 4, -51 },
  { 73, 25, 19, 32, 4, -51 },
  { 133, 35, 51, 39, 2, -51 },
  { 357, 29, 58, 35, 3, -54 },
  { 568, 53, 52, 58, 2, -51 },
  { 913, 42, 52, 44, 2, -51 },
  { 1186, 10, 19, 17, 4, -51 },
  { 1210, 19, 62, 23, 3, -51 },
  { 1358, 19, 62, 23, 1, -51 },
  { 1506, 30, 30, 34, 2, -54 },
  { 1619, 31, 34, 35, 2, -42 },
  { 1751, 13, 17, 18, 2, -8 },
  { 1779, 18, 8, 22, 2, -23 },
  { 1797, 11, 12, 19, 4, -11 },
  { 1814, 27, 52, 29, 1, -51 },
  { 1990, 31, 52, 35, 2, -51 },
  { 2192, 22, 51, 35, 4, -51 },
  { 2333, 30, 51, 35, 2, -51 },
  { 2525, 30, 52, 35, 2, -51 },
  { 2720, 33, 51, 35, 1, -51 },
  { 2931, 29, 52, 35, 3, -51 },
  { 3120, 31, 52, 35, 2, -51 },
  { 3322, 31, 51, 35, 2, -51 },
  { 3520, 31, 52, 35, 2, -51 },
  { 3722, 31, 52, 35, 2, -51 },
  { 3924, 11, 40, 19, 4, -39 },
  { 3979, 13, 48, 19, 2, -39 },
  { 4057, 31, 35, 35, 2, -43 },
  { 4193, 31, 22, 35, 2, -36 },
  { 4279, 31, 35, 35, 2, -43 },
  { 4415, 27, 52, 29, 0, -51 },
  { 4591, 49, 57, 55, 3, -51 },
  { 4941, 41, 51, 41, 0, -51 },
  { 5203, 32, 51, 40, 5, -51 },
  { 5407, 33, 52, 38, 3, -51 },
  { 5622, 35, 51, 43, 5, -51 },
  { 5846, 25, 51, 34, 5, -51 },
  { 6006, 25, 51, 33, 5, -51 },
  { 6166, 35, 52, 43, 4, -51 },
  { 6394, 35, 51, 46, 5, -51 },
  { 6618, 20, 51, 24, 2, -51 },
  { 6746, 19, 66, 21, -4, -51 },
  { 6903, 35, 51, 40, 5, -51 },
  { 7127, 26, 51, 32, 5, -51 },
  { 7293, 48, 51, 58, 5, -51 },
  { 7599, 38, 51, 49, 5, -51 },
  { 7842, 40, 52, 46, 3, -51 },
  { 8102, 30, 51, 38, 5, -51 },
  { 8294, 40, 63, 46, 3, -51 },
  { 8609, 34, 51, 39, 5, -51 },
  { 8826, 27, 52, 33, 3, -51 },
  { 9002, 32, 51, 34, 1, -51 },
  { 9206, 34, 52, 45, 5, -51 },
  { 9427, 39, 51, 39, 0, -51 },
  { 9676, 59, 51, 58, -1, -51 },
  { 10053, 38, 51, 38, 0, -51 },
  { 10296, 37, 51, 37, 0, -51 },
  { 10532, 31, 51, 33, 1, -51 },
  { 10730, 17, 62, 23, 4, -51 },
  { 10862, 28, 52, 29, 0, -51 },
  { 11044, 16, 62, 23, 2, -51 },
  { 11168, 35, 32, 39, 2, -51 },
  { 11308, 29, 5, 29, 0, 6 },
  { 11327, 17, 11, 23, 3, -54 },
  { 11351, 30, 41, 36, 2, -40 },
  { 11505, 32, 55, 38, 4, -54 },
  { 11725, 26, 41, 31, 3, -40 },
  { 11859, 31, 55, 38, 3, -54 },
  { 12073, 30, 40, 35, 3, -39 },
  { 12223, 25, 54, 23, 1, -54 },
  { 12392, 31, 57, 38, 3, -40 },
  { 12613, 31, 54, 39, 4, -54 },
  { 12823, 11, 54, 18, 4, -54 },
  { 12898, 17, 71, 18, -3, -54 },
  { 13049, 32, 54, 37, 5, -54 },
  { 13265, 10, 54, 18, 4, -54 },
  { 13333, 50, 40, 58, 4, -40 },
  { 13583, 31, 40, 39, 4, -40 },
  { 13738, 32, 41, 38, 3, -40 },
  { 13902, 32, 57, 38, 4, -40 },
  { 14130, 31, 57, 38, 3, -40 },
  { 14351, 22, 40, 27, 4, -40 },
  { 14461, 25, 41, 29, 2, -40 },
  { 14590, 23, 48, 26, 1, -47 },
  { 14728, 30, 40, 39, 4, -39 },
  { 14878, 34, 39, 34, 0, -39 },
  { 15044, 52, 39, 52, 0, -39 },
  { 15298, 33, 39, 33, 0, -39 },
  { 15459, 34, 56, 34, 0, -39 },
  { 15697, 25, 39, 28, 2, -39 },
  { 15819, 22, 62, 26, 1, -51 },
  { 15990, 8, 70, 34, 13, -54 },
  { 16060, 22, 62, 26, 3, -51 },
  { 16231, 31, 12, 35, 2, -31 },
};

const GFXfont NotoSans_Condensed_Bold71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_BOLD71PT7B_H_
