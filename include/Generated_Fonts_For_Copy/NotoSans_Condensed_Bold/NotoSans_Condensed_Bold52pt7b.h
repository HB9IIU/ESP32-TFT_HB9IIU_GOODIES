#ifndef _NOTOSANS_CONDENSED_BOLD52PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x10, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFB, 0xF8, 0x7E, 0xFC, 0x1F, 0xBF,
  0x07, 0xEF, 0xC1, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x0F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF8, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFE,
  0xEF, 0xCF, 0xF3, 0x82, 0x3F, 0x8E, 0x00, 0xFE, 0x38, 0x03, 0xF8, 0xE0,
  0x07, 0xF3, 0x80, 0x1F, 0xEE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xEF, 0xE0, 0x03, 0x9F,
  0xC0, 0x0E, 0x7F, 0x80, 0x39, 0xFF, 0x80, 0xE7, 0xEF, 0xC3, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x00, 0x1F, 0xDF, 0x80, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x7E, 0x07,
  0xE0, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x3F, 0x00, 0x07,
  0xC1, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE1, 0xF8, 0x00, 0x1F, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F, 0x1F, 0x07, 0xC0,
  0xF8, 0x7E, 0x3E, 0x3F, 0xE1, 0xF8, 0xFC, 0xFC, 0xFF, 0xE1, 0xFB, 0xF1,
  0xF1, 0xFF, 0xE3, 0xFF, 0xE7, 0xE7, 0xFF, 0xC3, 0xFF, 0x8F, 0x8F, 0xCF,
  0xC7, 0xFE, 0x3F, 0x3F, 0x1F, 0x87, 0xF8, 0x7C, 0x7E, 0x1F, 0x01, 0xC1,
  0xF8, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xF0,
  0xFC, 0x00, 0x1F, 0x87, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0x83, 0xF0, 0x00,
  0xFC, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0x7E,
  0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x01, 0xFB, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x03,
  0xFF, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x07, 0xF0, 0x7F, 0xF8, 0x1F, 0xE1, 0xFF, 0xF8, 0x3F, 0x87, 0xFF, 0xF8,
  0x7F, 0x0F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F, 0x0F, 0xF7,
  0xF0, 0xFE, 0x0F, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF, 0x87, 0xF8, 0x1F, 0xFF,
  0x0F, 0xF0, 0x1F, 0xFC, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x7F, 0xC0,
  0x7F, 0xF0, 0x7F, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF3, 0xE7, 0xC0, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x06, 0x07, 0xC1,
  0x9F, 0x1F, 0x3E, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xE1, 0xF8,
  0x07, 0x83, 0xC0, 0x0C, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x9F, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC,
  0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x10, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x1F,
  0xE1, 0xFC, 0x7F, 0x07, 0xF9, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0x7F, 0x03, 0xF9,
  0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x9F, 0xE1, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFE, 0x7F, 0x7C, 0x7F, 0x38, 0x7F, 0x10, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x1F, 0x81, 0xFE, 0x38, 0x07, 0xF8, 0x40, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFB, 0xFF, 0x0E, 0x01,
  0xFE, 0x10, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xB8, 0x03, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xF7, 0xF0, 0x03, 0xF7, 0xF0, 0x03, 0xE7, 0xF0, 0x07, 0xE7, 0xF0,
  0x07, 0xC7, 0xF0, 0x0F, 0xC7, 0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0x07, 0xF0,
  0x3F, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7C, 0x07, 0xF0,
  0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFD, 0xE0, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0x9F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFA, 0x00, 0x1F, 0xEF, 0x00, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xE3, 0x0F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x3F, 0xBF, 0xF0, 0xFC,
  0xFF, 0xE3, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x87,
  0xFB, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xFC,
  0x0F, 0xF7, 0xF0, 0x3F, 0x9F, 0xE1, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE,
  0x7E, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F,
  0x03, 0xF9, 0xFE, 0x1F, 0xC3, 0xFC, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0x1F, 0xE1, 0xFE, 0xFF, 0x03, 0xFB, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xC1,
  0xFC, 0x7F, 0x03, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0xFF,
  0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0x87, 0xFE, 0x7E, 0x03,
  0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x38, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x10, 0x1E, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0x7E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x3F, 0x9F, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8,
  0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF3, 0x80, 0xFF, 0x20, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x3F, 0x03, 0xFF, 0xE3, 0xE3,
  0xE0, 0x7F, 0xFE, 0x3E, 0x3E, 0x0F, 0xFF, 0xC3, 0xF7, 0xE1, 0xFE, 0xFC,
  0x1F, 0x7C, 0x1F, 0x87, 0xC1, 0xF7, 0xC3, 0xF0, 0x7C, 0x1F, 0x7C, 0x3F,
  0x07, 0xC1, 0xFF, 0xC3, 0xE0, 0x7C, 0x1F, 0xFC, 0x7E, 0x07, 0xC1, 0xFF,
  0x87, 0xE0, 0x7C, 0x1F, 0xF8, 0x7E, 0x07, 0xC1, 0xFF, 0x87, 0xE0, 0x7C,
  0x1F, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF, 0x87, 0xE0, 0xFC, 0x3F, 0xFC, 0x3E,
  0x0F, 0xC3, 0xEF, 0xC3, 0xF0, 0xFC, 0x3E, 0x7C, 0x3F, 0xBF, 0xE7, 0xC7,
  0xC1, 0xFF, 0xDF, 0xFC, 0x7C, 0x1F, 0xFD, 0xFF, 0x87, 0xE0, 0xFF, 0x8F,
  0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x08, 0x00,
  0xFF, 0x00, 0x07, 0x00, 0x07, 0xFF, 0x87, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F,
  0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF,
  0xC0, 0x7F, 0xBF, 0x83, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xC0,
  0x7F, 0xBF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x0E, 0x1F, 0xE0, 0x04,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x02, 0x1F, 0xF8, 0x0E, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x02, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE3, 0xF8, 0x3F, 0xF9, 0xFC, 0x07, 0xFC, 0xFE, 0x01, 0xFF, 0x7F, 0x00,
  0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x1F,
  0xE7, 0xF0, 0x1F, 0xF3, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xE0, 0x0E, 0x3F, 0xE0, 0x01, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD,
  0xFF, 0x00, 0xFE, 0x7F, 0xC0, 0x7F, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x00, 0x08, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF8,
  0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x3F, 0xCF, 0xE0,
  0x3F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0x8F, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F,
  0xE7, 0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0,
  0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC,
  0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xBF, 0x00,
  0x7F, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0xFE, 0xFC, 0x01, 0xF7, 0xFF, 0xDF,
  0x80, 0x7E, 0xFF, 0xF9, 0xF8, 0x0F, 0xDF, 0xFF, 0x3F, 0x01, 0xF3, 0xFF,
  0xF7, 0xE0, 0x7E, 0x7F, 0xFE, 0xFC, 0x0F, 0xCF, 0xFF, 0xCF, 0xC1, 0xF9,
  0xFF, 0xF9, 0xF8, 0x3E, 0x3F, 0xFF, 0x3F, 0x0F, 0xC7, 0xFF, 0xE3, 0xE1,
  0xF8, 0xFF, 0xFC, 0x7E, 0x3E, 0x1F, 0xFF, 0x8F, 0xCF, 0xC3, 0xFF, 0xF1,
  0xF9, 0xF8, 0x7F, 0xFE, 0x1F, 0xBF, 0x0F, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xE0, 0x3F, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0xFE,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xDF, 0xC0, 0x7F, 0xFD, 0xFE, 0x07, 0xFF, 0xCF, 0xE0,
  0x7F, 0xFC, 0xFF, 0x07, 0xFF, 0xC7, 0xF0, 0x7F, 0xFC, 0x7F, 0x87, 0xFF,
  0xE3, 0xF8, 0x7F, 0xFE, 0x3F, 0xC7, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE, 0x1F,
  0xE7, 0xFF, 0xE0, 0xFE, 0x7F, 0xFE, 0x0F, 0xE7, 0xFF, 0xE0, 0x7F, 0x7F,
  0xFE, 0x07, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xBF, 0x81, 0xFE, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFE, 0xFE, 0x07, 0xFB,
  0xF8, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xF8,
  0x3F, 0xE1, 0xFC, 0x0F, 0xF8, 0xFE, 0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x3F,
  0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFF, 0x3F, 0x80, 0x7F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF8,
  0x00, 0x38, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF8, 0x3E, 0xFF, 0x00, 0x4F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xF9, 0xFE,
  0x07, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x7F, 0x1F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F,
  0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF0,
  0x03, 0xFB, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x1F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFF, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFF,
  0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF7, 0xC0, 0xFE, 0x07, 0xF0, 0x7C, 0xF8, 0x1F, 0xC0,
  0xFE, 0x1F, 0x9F, 0x87, 0xF0, 0x1F, 0xC3, 0xF3, 0xF0, 0xFE, 0x03, 0xF8,
  0x7E, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xCF, 0xC3, 0xF8, 0x07, 0xF1, 0xF8,
  0xFC, 0x7E, 0x00, 0xFE, 0x7E, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC3, 0xF3,
  0xF8, 0x03, 0xF9, 0xF8, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x07, 0xCF, 0xE0,
  0x07, 0xE7, 0xE0, 0xF9, 0xF8, 0x00, 0xFE, 0xF8, 0x1F, 0xBF, 0x00, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xE3, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFF,
  0x0F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFB, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xC7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xEF,
  0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x03,
  0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xEF, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x38, 0x1F, 0xE1, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xDF, 0xFF, 0x7E,
  0x7F, 0xF1, 0xF1, 0xFE, 0x0F, 0x81, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x0F, 0xE3, 0xFC, 0x1F, 0xCF, 0xFE,
  0x3F, 0xBF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0x8F, 0xFB,
  0xFE, 0x0F, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFE, 0xFF, 0x01, 0xFD, 0xFF, 0x07, 0xFB, 0xFF, 0x9F,
  0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xDF, 0xFE, 0x3F, 0x1F, 0xF8,
  0x7E, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xF0, 0x73, 0xFC,
  0x02, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x5F, 0xE0,
  0x19, 0xFF, 0xBF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0xCF, 0xE1, 0xFF, 0xDF, 0xC7, 0xFF,
  0xBF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0x8F, 0xFD, 0xFE, 0x0F,
  0xFB, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF,
  0x80, 0xFF, 0x7F, 0x01, 0xFE, 0xFF, 0x07, 0xFD, 0xFF, 0x3F, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0xC3, 0xFF, 0x1F, 0x83, 0xFC,
  0x3F, 0x00, 0x40, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xF8, 0x3F, 0x9F,
  0xC0, 0x7E, 0x7F, 0x01, 0xFD, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0x8F, 0xF8, 0x3E, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0x10, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xF8, 0xFC, 0x3F, 0xFB, 0xF8, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xBF, 0xC1, 0xFF, 0x7F, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F,
  0xDF, 0xE0, 0xFF, 0xBF, 0xF7, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFB, 0xF8, 0x7F, 0xE7, 0xF0, 0x7F, 0x8F, 0xE0, 0x08, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x80, 0x03, 0xF9, 0xC0,
  0x0F, 0xF3, 0xFD, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x87, 0xE0, 0xFE, 0x7F, 0xE3, 0xFB, 0xFF, 0xCF, 0xEF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x10, 0x7E, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0x00, 0x80, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F,
  0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xE7, 0xFF, 0x3F, 0xF1,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE,
  0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xC0, 0xFF, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x80, 0x7E, 0x0F, 0xC7, 0xFE, 0x0F, 0xF8, 0xFC, 0xFF,
  0xF3, 0xFF, 0xCF, 0xDF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0,
  0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0x01,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0,
  0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x01,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0,
  0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x01,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0x83, 0xF1, 0xFF, 0x8F, 0xCF, 0xFF, 0x3F, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F, 0x01, 0xFE, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F,
  0xE0, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0xFF, 0xC3, 0xF3, 0xFF, 0xC7, 0xF7, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x01,
  0xFD, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xDF,
  0xE0, 0x3F, 0xBF, 0xE0, 0xFF, 0x7F, 0xF7, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFB, 0xFF, 0xC7, 0xF3, 0xFF, 0x0F, 0xE3, 0xFC, 0x1F, 0xC0,
  0x40, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xF8, 0xFC, 0x3F, 0xFB, 0xF8, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xBF, 0xC0, 0xFF, 0x7F, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F,
  0xDF, 0xE0, 0xFF, 0xBF, 0xF7, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFB, 0xF8, 0x7F, 0xE7, 0xF0, 0x7F, 0x8F, 0xE0, 0x18, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xE0, 0x73, 0xF8, 0x04, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xF1, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x60,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC3, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0x78, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81,
  0xFF, 0x80, 0x18, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFE,
  0xFC, 0xFF, 0xFB, 0xF1, 0xFF, 0xCF, 0xC3, 0xFE, 0x1F, 0x01, 0x80, 0x00,
  0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x01,
  0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xF8,
  0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF8,
  0x0F, 0xE7, 0xF0, 0x1F, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0xC0, 0xFE, 0x7F,
  0x03, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0xF0,
  0x7F, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x3F, 0x87, 0xCF, 0x87, 0xF0, 0x7F,
  0x1F, 0x3E, 0x1F, 0x81, 0xFC, 0x7C, 0xF8, 0xFE, 0x07, 0xF1, 0xF3, 0xE3,
  0xF8, 0x1F, 0xCF, 0xC7, 0xCF, 0xE0, 0x3F, 0x3E, 0x1F, 0x3F, 0x00, 0xFE,
  0xF8, 0x7C, 0xFC, 0x03, 0xFB, 0xE1, 0xF7, 0xF0, 0x0F, 0xEF, 0x87, 0xDF,
  0xC0, 0x1F, 0xBE, 0x0F, 0x7E, 0x00, 0x7E, 0xF0, 0x3D, 0xF8, 0x01, 0xFB,
  0xC0, 0xF7, 0xE0, 0x07, 0xFF, 0x03, 0xDF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFE, 0x3F,
  0xC1, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F,
  0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF8, 0x1F,
  0xC3, 0xF8, 0x1F, 0xC3, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFE, 0x7F,
  0x80, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x1F,
  0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB,
  0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0x0C, 0x00, 0x05, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x80, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_Bold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 38, 14, 3, -37 },
  { 39, 18, 13, 24, 3, -37 },
  { 69, 26, 37, 28, 1, -37 },
  { 190, 22, 42, 26, 2, -39 },
  { 306, 39, 38, 42, 2, -38 },
  { 492, 31, 39, 32, 1, -38 },
  { 644, 7, 13, 13, 3, -37 },
  { 656, 14, 45, 17, 2, -37 },
  { 735, 13, 45, 17, 1, -37 },
  { 809, 22, 22, 25, 1, -40 },
  { 870, 22, 25, 26, 2, -31 },
  { 939, 9, 13, 13, 2, -6 },
  { 954, 14, 6, 16, 1, -17 },
  { 965, 8, 9, 14, 3, -8 },
  { 974, 21, 37, 21, 0, -37 },
  { 1072, 22, 39, 26, 2, -38 },
  { 1180, 16, 37, 26, 3, -37 },
  { 1254, 22, 38, 26, 2, -38 },
  { 1359, 22, 39, 26, 2, -38 },
  { 1467, 24, 37, 26, 1, -37 },
  { 1578, 22, 38, 26, 2, -37 },
  { 1683, 22, 39, 26, 2, -38 },
  { 1791, 23, 37, 26, 1, -37 },
  { 1898, 22, 39, 26, 2, -38 },
  { 2006, 23, 39, 26, 1, -38 },
  { 2119, 8, 30, 14, 3, -29 },
  { 2149, 9, 36, 14, 2, -29 },
  { 2190, 22, 25, 26, 2, -31 },
  { 2259, 22, 16, 26, 2, -26 },
  { 2303, 22, 25, 26, 2, -31 },
  { 2372, 20, 39, 21, 0, -38 },
  { 2470, 36, 41, 40, 2, -37 },
  { 2655, 30, 37, 30, 0, -37 },
  { 2794, 23, 37, 30, 4, -37 },
  { 2901, 24, 39, 28, 2, -38 },
  { 3018, 25, 37, 32, 4, -37 },
  { 3134, 18, 37, 25, 4, -37 },
  { 3218, 18, 37, 24, 4, -37 },
  { 3302, 25, 39, 32, 3, -38 },
  { 3424, 25, 37, 33, 4, -37 },
  { 3540, 15, 37, 18, 1, -37 },
  { 3610, 14, 48, 15, -3, -37 },
  { 3694, 25, 37, 29, 4, -37 },
  { 3810, 18, 37, 24, 4, -37 },
  { 3894, 35, 37, 43, 4, -37 },
  { 4056, 28, 37, 36, 4, -37 },
  { 4186, 30, 39, 34, 2, -38 },
  { 4333, 22, 37, 28, 4, -37 },
  { 4435, 30, 47, 34, 2, -38 },
  { 4612, 25, 37, 29, 4, -37 },
  { 4728, 20, 39, 24, 2, -38 },
  { 4826, 23, 37, 25, 1, -37 },
  { 4933, 25, 38, 33, 4, -37 },
  { 5052, 29, 37, 29, 0, -37 },
  { 5187, 43, 37, 42, 0, -37 },
  { 5386, 28, 37, 28, 0, -37 },
  { 5516, 27, 37, 27, 0, -37 },
  { 5641, 22, 37, 24, 1, -37 },
  { 5743, 12, 45, 16, 3, -37 },
  { 5811, 21, 37, 21, 0, -37 },
  { 5909, 12, 45, 16, 1, -37 },
  { 5977, 26, 23, 28, 1, -37 },
  { 6052, 21, 3, 21, 0, 5 },
  { 6060, 13, 8, 17, 2, -40 },
  { 6073, 21, 30, 26, 2, -29 },
  { 6152, 23, 41, 28, 3, -40 },
  { 6270, 19, 30, 23, 2, -29 },
  { 6342, 23, 41, 28, 2, -40 },
  { 6460, 22, 30, 26, 2, -29 },
  { 6543, 18, 40, 17, 1, -40 },
  { 6633, 23, 41, 28, 2, -29 },
  { 6751, 22, 40, 28, 3, -40 },
  { 6861, 8, 40, 14, 3, -40 },
  { 6901, 13, 52, 14, -2, -40 },
  { 6986, 24, 40, 27, 3, -40 },
  { 7106, 7, 40, 13, 3, -40 },
  { 7141, 36, 29, 42, 3, -29 },
  { 7272, 22, 29, 28, 3, -29 },
  { 7352, 23, 30, 28, 2, -29 },
  { 7439, 23, 41, 28, 3, -29 },
  { 7557, 23, 41, 28, 2, -29 },
  { 7675, 16, 29, 20, 3, -29 },
  { 7733, 18, 30, 21, 2, -29 },
  { 7801, 17, 35, 19, 1, -34 },
  { 7876, 22, 29, 28, 3, -28 },
  { 7956, 25, 28, 25, 0, -28 },
  { 8044, 38, 28, 38, 0, -28 },
  { 8177, 24, 28, 24, 0, -28 },
  { 8261, 25, 40, 25, 0, -28 },
  { 8386, 19, 28, 21, 1, -28 },
  { 8453, 16, 45, 19, 1, -37 },
  { 8543, 6, 52, 25, 9, -40 },
  { 8582, 16, 45, 19, 2, -37 },
  { 8672, 22, 9, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_Bold52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_BOLD52PT7B_H_
