#ifndef _NOTOSANS_CONDENSED_BOLD70PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7F, 0x8F, 0xFB, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xF0, 0x38, 0x00,
  0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE,
  0xFF, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFE,
  0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x83, 0xF8, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xF3, 0xC7, 0xE3,
  0xFF, 0x1E, 0x07, 0x1F, 0xF8, 0xF0, 0x00, 0xFF, 0x87, 0x80, 0x07, 0xFC,
  0x3C, 0x00, 0x3F, 0xE1, 0xE0, 0x01, 0xFF, 0x8F, 0x00, 0x07, 0xFE, 0x78,
  0x00, 0x3F, 0xFB, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xEF, 0xFE, 0x00, 0x0F, 0x3F, 0xF0, 0x00, 0x78, 0xFF, 0x80,
  0x03, 0xC7, 0xFE, 0x00, 0x1E, 0x3F, 0xF8, 0x00, 0xF1, 0xFF, 0xF8, 0x07,
  0x9F, 0xF7, 0xF0, 0x3D, 0xFF, 0xBF, 0xFD, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x0F, 0x00, 0x3F, 0x83, 0xFC, 0x3F, 0x83,
  0xFF, 0x01, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F,
  0xC3, 0xFF, 0xF0, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x8F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x87, 0xF0, 0xFF, 0x1F, 0xC0, 0xFF, 0xFC, 0x3F, 0x8F, 0xF0, 0xFF,
  0x03, 0xFF, 0xC3, 0xF8, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC0, 0x1E, 0x01, 0xFE, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xCF, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xDF, 0xF8, 0x7F, 0xE0,
  0x7F, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0xFE, 0x1F, 0xF8, 0x07, 0xFF,
  0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF,
  0xEF, 0xFB, 0xFE, 0xFF, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x18, 0x07, 0xF0, 0x0C, 0x7C, 0x1F, 0xC1, 0xF1, 0xFE, 0x7F, 0x3F,
  0xC7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFD, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0x8F,
  0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x0F, 0xF3,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF9, 0xFE,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0x9F,
  0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF,
  0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80,
  0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x1F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xDF, 0xF3, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF9,
  0xFF, 0x9F, 0xE3, 0xFF, 0x1F, 0x87, 0xFE, 0x1E, 0x0F, 0xFC, 0x10, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xC1, 0xF8, 0x03, 0xFF, 0x83,
  0x80, 0x07, 0xFE, 0x0C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7E, 0x01, 0xFF, 0xC0, 0xE0, 0x03, 0xFF, 0x82,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFB, 0x80, 0x00, 0xFF, 0xEF, 0x80, 0x07, 0xFF, 0xBF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00,
  0x7F, 0x7F, 0xC0, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0x3F, 0x9F, 0xF0, 0x00,
  0x3F, 0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xC3, 0xFE, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0,
  0x07, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xF8, 0x0F, 0xF8,
  0x03, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xE1,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xD0, 0x00, 0x0F,
  0xFE, 0xE0, 0x00, 0x7F, 0xF7, 0xE0, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFD, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x06, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0x81,
  0xFE, 0x7F, 0xFF, 0x07, 0xFB, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xBF, 0xFC,
  0x07, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFD,
  0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x03, 0xFF, 0x3F,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0x87, 0xFF,
  0xBF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x03,
  0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF,
  0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x8F, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0x7F, 0xF7,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x0F,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC7, 0xFE, 0x03, 0xFF,
  0x1F, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x07,
  0xFF, 0x7F, 0xE0, 0x3F, 0xFD, 0xFF, 0xE3, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF, 0xF0,
  0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0x87, 0xF8, 0x00,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x06, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0x0F,
  0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF9,
  0xFE, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0xFF, 0x1F, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x9F, 0xE0, 0x70, 0x07, 0x80, 0x7F, 0x07, 0xFC, 0x7F, 0xF3,
  0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0xFF, 0x83, 0xF8, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0xFC,
  0x70, 0x01, 0xFF, 0x88, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0x60, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0x81, 0xFC, 0x1F, 0xC0,
  0x1F, 0xFF, 0xE0, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xE0, 0xFE, 0x3F, 0x80,
  0xFF, 0xFF, 0xE0, 0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x7F, 0x81,
  0xFF, 0x8F, 0xE0, 0x7F, 0x7F, 0x03, 0xFE, 0x0F, 0xE0, 0x7F, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x07,
  0xF0, 0x1F, 0xE0, 0x7E, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0xFE, 0x07,
  0xF8, 0x3F, 0xE0, 0xFE, 0xFE, 0x07, 0xF8, 0x7F, 0xF1, 0xFC, 0x7F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xFB, 0xFF, 0xF8, 0x7F, 0x01,
  0xFF, 0xF9, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0x80,
  0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF8,
  0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7C, 0x0F, 0xFF, 0x00, 0x1C,
  0x1F, 0xFE, 0x00, 0x04, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x02,
  0x1F, 0xFF, 0x00, 0x0E, 0x0F, 0xFF, 0x80, 0x3E, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F,
  0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xF8,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x3F,
  0xFB, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xCF, 0xFC, 0x00,
  0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0xC7, 0xFE,
  0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xF0, 0x3F, 0xFE, 0x00, 0x0E, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xF0, 0x1F,
  0xFF, 0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xF8,
  0x0F, 0xFF, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0xC0, 0x0F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF4, 0x0F, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x1F, 0xFC, 0xFF,
  0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00,
  0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0x03,
  0xFD, 0xFF, 0xFF, 0xBF, 0xC0, 0x07, 0xFB, 0xFF, 0xFF, 0x7F, 0x80, 0x0F,
  0xF7, 0xFF, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0x00, 0x7F,
  0x9F, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xFF, 0xF1, 0xFE, 0x01, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F, 0xF1,
  0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0x87,
  0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0x3F, 0xC1, 0xFF,
  0xFF, 0x83, 0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xF8,
  0x01, 0xFF, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF,
  0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xFF, 0x8F, 0xFC,
  0x07, 0xFF, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF,
  0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xFF,
  0x80, 0xFF, 0xC7, 0xFF, 0xFE, 0x03, 0xFF, 0x1F, 0xFF, 0xF8, 0x07, 0xFE,
  0x7F, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0xFE,
  0x00, 0xFF, 0xDF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xFD,
  0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFF, 0xFB, 0xFF, 0x01, 0xFF, 0xEF,
  0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x07, 0xFF,
  0xBF, 0xF0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFF, 0x80,
  0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x8F,
  0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF,
  0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xF3, 0xFF, 0x80, 0x3C,
  0x7F, 0xE0, 0x00, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFB, 0xFC, 0x0F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0x7F,
  0xF0, 0x03, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0xFF,
  0xDF, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xBF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xEF, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xFE, 0x03,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xBF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07,
  0xF3, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x7F, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xC7, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFC, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFF, 0x80,
  0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xF3,
  0xFC, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x01, 0xFC, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x1F,
  0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFE,
  0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0x80, 0x3F, 0xBF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x03,
  0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFF,
  0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x3F, 0xF8, 0x18, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0x07, 0xFD, 0xFF, 0xC0, 0x3F, 0xEF,
  0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFD, 0xFE, 0x7F, 0xFF, 0xCF, 0xF1, 0xFF,
  0xFC, 0x7F, 0x87, 0xFF, 0xC1, 0xFC, 0x1F, 0xFC, 0x0F, 0xE0, 0x1F, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0x83, 0xFF,
  0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xF7,
  0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0x01, 0xFF, 0xDF, 0xFF, 0x8F, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0x7F, 0xFF, 0xC3, 0xFE, 0x7F, 0xFF, 0x07, 0xF8, 0x7F, 0xFC, 0x0F, 0xF0,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F,
  0x0F, 0xFC, 0x00, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x27, 0xFF, 0x80, 0x38,
  0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0x81, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0xE7, 0xFE, 0x1F,
  0xFF, 0xEF, 0xFC, 0x7F, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x1F, 0xFF, 0xBF, 0xF8,
  0x0F, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFD,
  0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xEF,
  0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xE7, 0xFC, 0x3F, 0xFF, 0x8F, 0xF8, 0x1F,
  0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0x9F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0x9F,
  0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x08,
  0xFF, 0xC0, 0x01, 0xC7, 0xFF, 0x80, 0x7E, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF,
  0x87, 0xFC, 0x1F, 0xFF, 0x8F, 0xF8, 0x7F, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF,
  0x3F, 0xE3, 0xFF, 0xFF, 0x7F, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF8, 0x7F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0x80, 0x7F,
  0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xEF, 0xFC,
  0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xBF, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xBF, 0xF0, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F, 0xE1,
  0xFF, 0x80, 0x1E, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC4, 0x00, 0x03, 0xFF, 0x0E, 0x00, 0x0F, 0xFE, 0x1F, 0xC0, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x1F, 0xC0, 0x3F, 0xF1, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF,
  0x7F, 0xFF, 0x8F, 0xFB, 0xFF, 0xFF, 0x3F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xBF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFC, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x01,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80,
  0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE3,
  0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80,
  0x3F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80,
  0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F,
  0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0x7F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x1F, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0x7F, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0x80,
  0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x7F, 0xDF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF,
  0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x0F,
  0xFE, 0x03, 0xFC, 0x3F, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF,
  0xFE, 0x1F, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xF8, 0x3F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0x3F,
  0xF7, 0xFF, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xFE,
  0x03, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0x7F, 0xFF, 0x3F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0xFF,
  0xFF, 0x0F, 0xFD, 0xFF, 0xFC, 0x1F, 0xF9, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3C, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0x8F, 0xF8, 0x7F, 0xFF, 0x9F, 0xF0, 0xFF,
  0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0x7F, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF8, 0x7F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0x80,
  0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xEF,
  0xFC, 0x03, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xBF, 0xFE, 0x3F, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xBF, 0xF0, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F,
  0xE1, 0xFF, 0x80, 0x1C, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFE, 0xFF, 0x1F, 0xFB, 0xFE, 0xFF,
  0xEF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xF7, 0xFC, 0xFF, 0xC0, 0x3C,
  0x7F, 0xE0, 0x06, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFD, 0xFE, 0x0F, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC7, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0xC1, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xC3, 0xFC,
  0x0F, 0xFE, 0x0F, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xDF, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xBF, 0x80, 0xFF, 0x83,
  0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFE, 0xFE, 0x07, 0xFC,
  0x0F, 0xFC, 0x1F, 0xDF, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xF9, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7E, 0x3F, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xF8, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0x0F,
  0xC3, 0xFE, 0x00, 0xFF, 0x8F, 0xE1, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xF8,
  0x3F, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0x07, 0xF3, 0xFE, 0x00, 0x7F, 0xCF,
  0xE0, 0xFE, 0x7F, 0xC0, 0x07, 0xF9, 0xFC, 0x0F, 0xCF, 0xF8, 0x00, 0xFF,
  0x3F, 0x81, 0xF9, 0xFE, 0x00, 0x1F, 0xF7, 0xE0, 0x3F, 0x3F, 0xC0, 0x03,
  0xFE, 0xFC, 0x07, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0x80, 0xFD, 0xFF, 0x00,
  0x07, 0xFB, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xBF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x1F, 0xF0, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x1B,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF3, 0x00, 0x03, 0xFF, 0xC4, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_Bold70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 51, 18, 4, -50 },
  { 72, 24, 18, 32, 4, -50 },
  { 126, 35, 50, 38, 2, -50 },
  { 345, 29, 57, 35, 3, -53 },
  { 552, 53, 52, 57, 2, -51 },
  { 897, 41, 52, 43, 2, -51 },
  { 1164, 10, 18, 17, 4, -50 },
  { 1187, 18, 61, 23, 3, -50 },
  { 1325, 18, 61, 23, 1, -50 },
  { 1463, 30, 29, 33, 2, -53 },
  { 1572, 30, 34, 35, 2, -42 },
  { 1700, 13, 17, 18, 2, -8 },
  { 1728, 18, 9, 22, 2, -23 },
  { 1749, 11, 12, 18, 4, -11 },
  { 1766, 27, 50, 28, 1, -50 },
  { 1935, 30, 52, 35, 2, -51 },
  { 2130, 23, 50, 35, 3, -50 },
  { 2274, 30, 51, 35, 2, -51 },
  { 2466, 30, 52, 35, 2, -51 },
  { 2661, 33, 50, 35, 1, -50 },
  { 2868, 29, 51, 35, 3, -50 },
  { 3053, 30, 52, 35, 2, -51 },
  { 3248, 30, 50, 35, 2, -50 },
  { 3436, 30, 52, 35, 2, -51 },
  { 3631, 30, 52, 35, 2, -51 },
  { 3826, 11, 40, 19, 4, -39 },
  { 3881, 13, 48, 19, 2, -39 },
  { 3959, 30, 34, 35, 2, -42 },
  { 4087, 30, 21, 35, 2, -35 },
  { 4166, 31, 34, 35, 2, -42 },
  { 4298, 27, 52, 28, 0, -51 },
  { 4474, 48, 56, 54, 3, -50 },
  { 4810, 40, 50, 40, 0, -50 },
  { 5060, 32, 50, 40, 5, -50 },
  { 5260, 32, 52, 37, 3, -51 },
  { 5468, 35, 50, 43, 5, -50 },
  { 5687, 24, 50, 33, 5, -50 },
  { 5837, 24, 50, 33, 5, -50 },
  { 5987, 35, 52, 43, 3, -51 },
  { 6215, 35, 50, 45, 5, -50 },
  { 6434, 20, 50, 24, 2, -50 },
  { 6559, 19, 65, 20, -4, -50 },
  { 6714, 34, 50, 39, 5, -50 },
  { 6927, 25, 50, 32, 5, -50 },
  { 7084, 47, 50, 58, 5, -50 },
  { 7378, 38, 50, 48, 5, -50 },
  { 7616, 39, 52, 46, 3, -51 },
  { 7870, 30, 50, 37, 5, -50 },
  { 8058, 39, 63, 46, 3, -51 },
  { 8366, 34, 50, 39, 5, -50 },
  { 8579, 27, 52, 32, 3, -51 },
  { 8755, 31, 50, 33, 1, -50 },
  { 8949, 34, 51, 44, 5, -50 },
  { 9166, 38, 50, 38, 0, -50 },
  { 9404, 58, 50, 57, -1, -50 },
  { 9767, 37, 50, 37, 0, -50 },
  { 9999, 36, 50, 36, 0, -50 },
  { 10224, 30, 50, 32, 1, -50 },
  { 10412, 17, 61, 22, 4, -50 },
  { 10542, 28, 50, 28, 0, -50 },
  { 10717, 16, 61, 22, 2, -50 },
  { 10839, 34, 31, 38, 2, -50 },
  { 10971, 29, 5, 29, 0, 6 },
  { 10990, 17, 12, 23, 3, -54 },
  { 11016, 29, 40, 35, 2, -39 },
  { 11161, 31, 54, 38, 4, -53 },
  { 11371, 26, 40, 30, 3, -39 },
  { 11501, 31, 54, 38, 3, -53 },
  { 11711, 29, 40, 35, 3, -39 },
  { 11856, 24, 54, 23, 1, -54 },
  { 12018, 31, 56, 38, 3, -39 },
  { 12235, 30, 53, 38, 4, -53 },
  { 12434, 10, 53, 18, 4, -53 },
  { 12501, 17, 70, 18, -3, -53 },
  { 12650, 32, 53, 37, 5, -53 },
  { 12862, 10, 53, 18, 4, -53 },
  { 12929, 49, 39, 57, 4, -39 },
  { 13168, 30, 39, 38, 4, -39 },
  { 13315, 31, 40, 37, 3, -39 },
  { 13470, 31, 56, 38, 4, -39 },
  { 13687, 31, 56, 38, 3, -39 },
  { 13904, 22, 39, 26, 4, -39 },
  { 14012, 25, 40, 29, 2, -39 },
  { 14137, 23, 47, 25, 1, -46 },
  { 14273, 30, 39, 38, 4, -38 },
  { 14420, 34, 38, 34, 0, -38 },
  { 14582, 51, 38, 51, 0, -38 },
  { 14825, 33, 38, 33, 0, -38 },
  { 14982, 34, 55, 34, 0, -38 },
  { 15216, 24, 38, 28, 2, -38 },
  { 15330, 22, 61, 25, 1, -50 },
  { 15498, 7, 69, 33, 13, -53 },
  { 15559, 21, 61, 25, 3, -50 },
  { 15720, 31, 12, 35, 2, -31 },
};

const GFXfont NotoSans_Condensed_Bold70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_BOLD70PT7B_H_
