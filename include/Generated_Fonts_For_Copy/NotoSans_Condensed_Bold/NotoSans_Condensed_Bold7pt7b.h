#ifndef _NOTOSANS_CONDENSED_BOLD7PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xB4, 0x6F, 0x6F, 0x60, 0x79, 0x9E, 0xD6, 0xBA, 0x74, 0x80,
  0x66, 0x5B, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xEB, 0x80, 0x5D, 0x00,
  0xC0, 0xC0, 0x80, 0x29, 0x28, 0x76, 0xD6, 0x74, 0x92, 0xE4, 0xAE, 0xE5,
  0x9E, 0x2E, 0xF2, 0x73, 0x9E, 0x73, 0xD6, 0xE4, 0xA4, 0x75, 0xDE, 0x77,
  0x9E, 0x90, 0x98, 0x38, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0xE5, 0x04, 0x75,
  0xF7, 0xF4, 0x18, 0x66, 0x6F, 0x90, 0xE9, 0xE9, 0xE0, 0x7C, 0x88, 0x60,
  0xE9, 0x99, 0xE0, 0xEE, 0xC0, 0xEE, 0x80, 0x7C, 0xB9, 0x70, 0xB7, 0xDA,
  0xD5, 0xC0, 0x55, 0x60, 0xBB, 0x6A, 0x92, 0x4E, 0x9B, 0xFF, 0xD0, 0xB7,
  0xFA, 0x79, 0x99, 0x70, 0xF7, 0xC8, 0x79, 0x99, 0x71, 0xEB, 0xEA, 0x90,
  0x71, 0x1E, 0xE9, 0x24, 0x99, 0x99, 0x70, 0x9A, 0x66, 0x60, 0xA6, 0xEB,
  0x96, 0x58, 0xB6, 0x46, 0xB0, 0xB6, 0x64, 0x40, 0xE5, 0x2E, 0xEA, 0xB0,
  0x89, 0x22, 0xD5, 0x70, 0x46, 0xB0, 0xE0, 0xC0, 0x6E, 0xF0, 0x8E, 0xAB,
  0xE0, 0x72, 0x30, 0x2E, 0xD6, 0x77, 0x30, 0x79, 0x24, 0x76, 0xB3, 0xC0,
  0x9E, 0xDA, 0xF8, 0xFE, 0x8B, 0xAE, 0xB0, 0xF8, 0xFD, 0x6B, 0x50, 0xF6,
  0xD0, 0x76, 0xB0, 0xEA, 0xBE, 0x88, 0x76, 0xB2, 0x40, 0xBA, 0x40, 0xF1,
  0xF0, 0x7A, 0x40, 0xB6, 0xB0, 0xB5, 0xA0, 0xAD, 0x56, 0xA0, 0xAD, 0x50,
  0xB5, 0xA5, 0x00, 0xE9, 0x70, 0x57, 0x50, 0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_Condensed_Bold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 3, 2, 3, 0, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 5, 3, 0, -5 },
  { 8, 5, 5, 6, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 2, 0, -5 },
  { 16, 2, 6, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 3, 3, 0, -4 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 2, 0, -2 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 3, 5, 3, 0, -5 },
  { 47, 3, 5, 3, 0, -5 },
  { 49, 1, 4, 2, 0, -4 },
  { 50, 1, 5, 2, 0, -4 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 3, 3, 0, -4 },
  { 57, 3, 5, 3, 0, -5 },
  { 59, 5, 6, 5, 0, -5 },
  { 63, 4, 5, 4, 0, -5 },
  { 66, 4, 5, 4, 0, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 2, 5, 3, 1, -5 },
  { 77, 2, 5, 3, 1, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 3, 5, 4, 1, -5 },
  { 84, 2, 5, 2, 0, -5 },
  { 86, 2, 6, 2, 0, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 3, 5, 3, 0, -5 },
  { 92, 4, 5, 6, 1, -5 },
  { 95, 3, 5, 5, 1, -5 },
  { 97, 4, 5, 5, 0, -5 },
  { 100, 3, 5, 4, 0, -5 },
  { 102, 4, 6, 5, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 3, 5, 3, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 6, 5, 6, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 3, 5, 3, 0, -5 },
  { 130, 2, 6, 2, 0, -5 },
  { 132, 3, 5, 3, 0, -5 },
  { 134, 2, 6, 2, 0, -5 },
  { 136, 4, 3, 4, 0, -5 },
  { 138, 3, 1, 3, 0, 0 },
  { 139, 2, 1, 2, 0, -5 },
  { 140, 3, 4, 4, 0, -4 },
  { 142, 4, 5, 4, 0, -5 },
  { 145, 3, 4, 3, 0, -4 },
  { 147, 3, 5, 4, 0, -5 },
  { 149, 3, 4, 4, 0, -4 },
  { 151, 3, 5, 2, 0, -5 },
  { 153, 3, 6, 4, 0, -4 },
  { 156, 3, 5, 4, 0, -5 },
  { 158, 1, 5, 2, 0, -5 },
  { 159, 1, 7, 2, 0, -5 },
  { 160, 4, 5, 4, 0, -5 },
  { 163, 1, 5, 2, 0, -5 },
  { 164, 5, 4, 6, 0, -4 },
  { 167, 3, 4, 4, 0, -4 },
  { 169, 3, 4, 4, 0, -4 },
  { 171, 4, 6, 4, 0, -4 },
  { 174, 3, 6, 4, 0, -4 },
  { 177, 3, 4, 3, 0, -4 },
  { 179, 3, 4, 3, 0, -4 },
  { 181, 2, 5, 3, 0, -5 },
  { 183, 3, 4, 4, 0, -4 },
  { 185, 3, 4, 3, 0, -4 },
  { 187, 5, 4, 5, 0, -4 },
  { 190, 3, 4, 3, 0, -4 },
  { 192, 3, 6, 3, 0, -4 },
  { 195, 3, 4, 3, 0, -4 },
  { 197, 2, 6, 3, 0, -5 },
  { 199, 1, 7, 3, 1, -5 },
  { 200, 2, 6, 3, 0, -5 },
  { 202, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_Bold7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_BOLD7PT7B_H_
