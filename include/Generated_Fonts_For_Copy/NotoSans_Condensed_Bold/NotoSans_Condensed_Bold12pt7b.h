#ifndef _NOTOSANS_CONDENSED_BOLD12PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0xA2, 0xC0, 0xBB, 0xBB, 0x2C, 0xA2, 0x9F, 0x2B, 0xFF, 0xD4,
  0x50, 0x13, 0xD6, 0xA7, 0x0E, 0x7F, 0x10, 0x80, 0x62, 0x39, 0x35, 0x1A,
  0x87, 0xFB, 0x54, 0x6A, 0x25, 0x33, 0x80, 0x30, 0xF1, 0xA3, 0xC7, 0x6B,
  0xF7, 0x66, 0x7E, 0xF0, 0x6B, 0x49, 0x24, 0x99, 0x80, 0xC9, 0x92, 0x49,
  0x6B, 0x00, 0x33, 0x7E, 0xE5, 0x80, 0x30, 0xCF, 0xCC, 0x30, 0xC0, 0x6B,
  0x00, 0xFC, 0xB0, 0x18, 0x84, 0x62, 0x31, 0x88, 0xC0, 0x31, 0xE4, 0xB2,
  0xCF, 0x24, 0x9E, 0x78, 0x2F, 0xD2, 0x49, 0x20, 0x37, 0xD2, 0x11, 0x99,
  0x88, 0xF8, 0x77, 0xC2, 0x37, 0x0C, 0x33, 0xF8, 0x18, 0x63, 0x8E, 0x5B,
  0x6F, 0xC6, 0x18, 0xFF, 0x88, 0xF1, 0x1B, 0xE0, 0x19, 0xE4, 0x14, 0xFB,
  0x3C, 0xDA, 0x78, 0xFF, 0xF0, 0x86, 0x10, 0xC3, 0x08, 0x60, 0x31, 0xE4,
  0x9E, 0x31, 0xEC, 0xF2, 0x78, 0x31, 0xEC, 0xB2, 0xDD, 0xE0, 0x86, 0x70,
  0xB0, 0x2C, 0x4C, 0x00, 0x52, 0xC0, 0x0C, 0xEE, 0x1C, 0x1C, 0x10, 0xFC,
  0x0F, 0xFF, 0xC1, 0xC1, 0xCE, 0xE2, 0x00, 0x67, 0x86, 0x23, 0x30, 0x0C,
  0x60, 0x0C, 0x19, 0x98, 0x4B, 0xD5, 0x6E, 0xA5, 0x5C, 0x96, 0x62, 0x0F,
  0x00, 0x38, 0x70, 0xA1, 0x46, 0xCF, 0x9F, 0x62, 0xC6, 0xE7, 0xF7, 0xBF,
  0x6F, 0x3B, 0xF0, 0x37, 0xF1, 0x08, 0x43, 0x19, 0x78, 0xE3, 0xEC, 0xB3,
  0xCF, 0x3C, 0xFE, 0xF0, 0xFF, 0xCC, 0xFC, 0xCC, 0xF0, 0xFF, 0xCC, 0xFF,
  0xCC, 0xC0, 0x3D, 0xEC, 0x20, 0x9E, 0x7C, 0xF3, 0x7C, 0xCF, 0x3C, 0xF3,
  0xFF, 0x3C, 0xF3, 0xCC, 0xF6, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xE4, 0xCF, 0x6D, 0x3C, 0xF3, 0xCD, 0xB6, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xF0, 0xC3, 0xE7, 0xE7, 0xA7, 0xAF, 0xBF, 0xBB, 0x9B, 0x9B,
  0xC7, 0x1E, 0x69, 0xB6, 0x59, 0xE3, 0x8C, 0x33, 0xEC, 0xE3, 0x8E, 0x3C,
  0xF3, 0x78, 0xE7, 0xF7, 0xBF, 0xFB, 0x18, 0xC0, 0x33, 0xEC, 0xE3, 0x8E,
  0x3C, 0xF3, 0x78, 0x60, 0xC0, 0xE3, 0xED, 0xB6, 0xFB, 0xCD, 0x36, 0xCC,
  0x33, 0xF0, 0xC7, 0x0C, 0x7B, 0xF0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF6, 0x78, 0xC7, 0x89, 0x32, 0x66,
  0x8D, 0x0E, 0x1C, 0x30, 0xCC, 0xF3, 0x3C, 0xC9, 0x72, 0x5D, 0x9D, 0xE7,
  0x39, 0xCC, 0x33, 0x00, 0xCD, 0x37, 0x8E, 0x30, 0xE7, 0x9B, 0xCC, 0xCF,
  0x36, 0x9E, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xC6, 0x23, 0x31, 0x98, 0xF8,
  0xFE, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x10, 0xC2, 0x10, 0xC2, 0x18, 0xFC,
  0x92, 0x49, 0x27, 0x80, 0x10, 0xC3, 0x9A, 0x4F, 0x10, 0xF8, 0xE4, 0x33,
  0xC2, 0xFC, 0xED, 0xE0, 0x84, 0x2D, 0xF9, 0xCE, 0x7B, 0xB0, 0x33, 0xD1,
  0x84, 0x35, 0xE0, 0x0C, 0x32, 0xDF, 0x4F, 0x34, 0xDB, 0x7C, 0x31, 0xE4,
  0xBF, 0x41, 0x97, 0x80, 0x76, 0x7F, 0x66, 0x66, 0x60, 0x2D, 0xF4, 0xF3,
  0x4D, 0xB7, 0xC3, 0x59, 0xC0, 0x84, 0x2D, 0xFD, 0xCE, 0x73, 0x98, 0xFF,
  0x80, 0x55, 0x55, 0x5F, 0x84, 0x27, 0x2B, 0x73, 0xD2, 0x98, 0xFF, 0x80,
  0xB6, 0xFF, 0xDB, 0x9B, 0x9B, 0x9B, 0x9B, 0xB7, 0xF7, 0x39, 0xCE, 0x60,
  0x31, 0xE4, 0xF3, 0x4D, 0xB7, 0x80, 0xB7, 0xE7, 0x39, 0xEE, 0xD0, 0x84,
  0x00, 0x2D, 0xF4, 0xF3, 0x4D, 0xB7, 0xC3, 0x0C, 0x30, 0xBF, 0x49, 0x20,
  0x3F, 0xB0, 0xE3, 0xCF, 0xC0, 0x67, 0xF6, 0x66, 0x67, 0x9C, 0xE7, 0x39,
  0xEF, 0xE0, 0xCF, 0x24, 0x96, 0x78, 0xC3, 0x00, 0xD9, 0xEE, 0x95, 0x4A,
  0xE5, 0x73, 0xB0, 0xD8, 0xCD, 0x67, 0x0C, 0x71, 0x6C, 0xC0, 0xCF, 0x24,
  0x9E, 0x78, 0xC3, 0x0C, 0xE3, 0x80, 0xF7, 0x8C, 0x46, 0x23, 0xE0, 0x13,
  0x66, 0x6C, 0x66, 0x66, 0x30, 0xFF, 0xFF, 0xFF, 0xCE, 0x66, 0x63, 0x66,
  0x66, 0xC0, 0xFE, 0x60,
};

const GFXglyph NotoSans_Condensed_Bold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 4, 5, 1, -9 },
  { 6, 6, 9, 7, 0, -9 },
  { 13, 5, 10, 6, 0, -9 },
  { 20, 9, 9, 10, 0, -9 },
  { 31, 7, 9, 7, 0, -9 },
  { 39, 1, 4, 3, 1, -9 },
  { 40, 3, 11, 4, 1, -9 },
  { 45, 3, 11, 4, 0, -9 },
  { 50, 5, 5, 6, 0, -9 },
  { 54, 6, 6, 6, 0, -7 },
  { 59, 3, 3, 3, 0, -1 },
  { 61, 3, 2, 4, 0, -4 },
  { 62, 2, 2, 3, 1, -2 },
  { 63, 5, 9, 5, 0, -9 },
  { 69, 6, 9, 6, 0, -9 },
  { 76, 3, 9, 6, 1, -9 },
  { 80, 5, 9, 6, 0, -9 },
  { 86, 5, 9, 6, 0, -9 },
  { 92, 6, 9, 6, 0, -9 },
  { 99, 4, 9, 6, 1, -9 },
  { 104, 6, 9, 6, 0, -9 },
  { 111, 6, 9, 6, 0, -9 },
  { 118, 6, 9, 6, 0, -9 },
  { 125, 6, 9, 6, 0, -9 },
  { 132, 2, 7, 3, 1, -7 },
  { 134, 3, 9, 3, 0, -7 },
  { 138, 6, 6, 6, 0, -7 },
  { 143, 6, 4, 6, 0, -6 },
  { 146, 6, 6, 6, 0, -7 },
  { 151, 5, 9, 5, 0, -9 },
  { 157, 9, 10, 9, 0, -9 },
  { 169, 7, 9, 7, 0, -9 },
  { 177, 5, 9, 7, 1, -9 },
  { 183, 5, 9, 6, 1, -9 },
  { 189, 6, 9, 7, 1, -9 },
  { 196, 4, 9, 6, 1, -9 },
  { 201, 4, 9, 6, 1, -9 },
  { 206, 6, 9, 7, 1, -9 },
  { 213, 6, 9, 8, 1, -9 },
  { 220, 4, 9, 4, 0, -9 },
  { 225, 4, 12, 3, -1, -9 },
  { 231, 6, 9, 7, 1, -9 },
  { 238, 4, 9, 5, 1, -9 },
  { 243, 8, 9, 10, 1, -9 },
  { 252, 6, 9, 8, 1, -9 },
  { 259, 6, 9, 8, 1, -9 },
  { 266, 5, 9, 6, 1, -9 },
  { 272, 6, 11, 8, 1, -9 },
  { 281, 6, 9, 7, 1, -9 },
  { 288, 5, 9, 6, 0, -9 },
  { 294, 6, 9, 6, 0, -9 },
  { 301, 6, 9, 8, 1, -9 },
  { 308, 7, 9, 7, 0, -9 },
  { 316, 10, 9, 10, 0, -9 },
  { 328, 6, 9, 6, 0, -9 },
  { 335, 6, 9, 6, 0, -9 },
  { 342, 5, 9, 6, 0, -9 },
  { 348, 3, 11, 4, 1, -9 },
  { 353, 5, 9, 5, 0, -9 },
  { 359, 3, 11, 4, 0, -9 },
  { 364, 6, 6, 7, 0, -9 },
  { 369, 5, 1, 5, 0, 1 },
  { 370, 3, 2, 4, 0, -9 },
  { 371, 5, 7, 6, 0, -7 },
  { 376, 5, 9, 6, 1, -9 },
  { 382, 5, 7, 5, 0, -7 },
  { 387, 6, 9, 6, 0, -9 },
  { 394, 6, 7, 6, 0, -7 },
  { 400, 4, 9, 4, 0, -9 },
  { 405, 6, 10, 6, 0, -7 },
  { 413, 5, 9, 7, 1, -9 },
  { 419, 1, 9, 3, 1, -9 },
  { 421, 2, 12, 3, 0, -9 },
  { 424, 5, 9, 6, 1, -9 },
  { 430, 1, 9, 3, 1, -9 },
  { 432, 8, 7, 10, 1, -7 },
  { 439, 5, 7, 7, 1, -7 },
  { 444, 6, 7, 6, 0, -7 },
  { 450, 5, 10, 6, 1, -7 },
  { 457, 6, 10, 6, 0, -7 },
  { 465, 3, 7, 5, 1, -7 },
  { 468, 5, 7, 5, 0, -7 },
  { 473, 4, 8, 4, 0, -8 },
  { 477, 5, 7, 7, 1, -7 },
  { 482, 6, 7, 6, 0, -7 },
  { 488, 9, 7, 9, 0, -7 },
  { 496, 6, 7, 6, 0, -7 },
  { 502, 6, 10, 6, 0, -7 },
  { 510, 5, 7, 5, 0, -7 },
  { 515, 4, 11, 4, 0, -9 },
  { 521, 2, 12, 6, 2, -9 },
  { 524, 4, 11, 4, 0, -9 },
  { 530, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_Bold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_BOLD12PT7B_H_
