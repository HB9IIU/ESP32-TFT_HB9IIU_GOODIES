#ifndef _NOTOSANS_CONDENSED_BOLD28PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0x9C, 0xE7, 0x38, 0x00, 0x77,
  0xFE, 0xE0, 0xF3, 0xDC, 0xF7, 0x3D, 0xC7, 0x71, 0xDC, 0x77, 0x1C, 0x0E,
  0x70, 0x39, 0xC0, 0xE7, 0x03, 0x98, 0x0C, 0x60, 0x33, 0x8F, 0xFF, 0xFF,
  0xFF, 0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x06, 0x70, 0xFF, 0xFB, 0xFF, 0xE3,
  0x9C, 0x0E, 0x70, 0x39, 0x80, 0xC6, 0x03, 0x38, 0x1C, 0xE0, 0x06, 0x00,
  0x60, 0x1F, 0xC3, 0xFF, 0x7F, 0xEF, 0x66, 0xF6, 0x0F, 0x60, 0x7E, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x06, 0xF8, 0x6F, 0xE7, 0xEF,
  0xFE, 0xFF, 0xC0, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x07, 0x03,
  0xF0, 0x38, 0x3F, 0xC3, 0x81, 0xCE, 0x1C, 0x0E, 0x71, 0xC0, 0x73, 0x8E,
  0x03, 0x9C, 0xE0, 0x1C, 0xE7, 0x00, 0xE7, 0x73, 0xE7, 0xBB, 0xBF, 0x9F,
  0x9D, 0xDC, 0x79, 0xCE, 0x70, 0x0E, 0xE3, 0x80, 0xE7, 0x1C, 0x07, 0x38,
  0xE0, 0x70, 0xC7, 0x03, 0x87, 0x38, 0x1C, 0x3B, 0x81, 0xC0, 0xFC, 0x1E,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x79, 0xE0, 0x78, 0xE0,
  0x79, 0xE0, 0x39, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0x0F, 0x7F, 0x1E,
  0xFF, 0x9E, 0xF3, 0xDE, 0xF1, 0xFC, 0xF1, 0xFC, 0xF0, 0xF8, 0xF8, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x9F, 0xF7, 0x77, 0x77, 0x70, 0x0E, 0x3C,
  0x71, 0xE3, 0x8F, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0x70, 0xE1, 0xE1, 0xC3, 0x87, 0x87, 0x07, 0xE1, 0xE1, 0xC3, 0xC3, 0x87,
  0x87, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0xF1,
  0xC3, 0x8F, 0x1C, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0xEE, 0xFF, 0xEF,
  0xFF, 0x1F, 0x01, 0xF8, 0x3B, 0x87, 0x9C, 0x31, 0x81, 0x10, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7B, 0xDD, 0xEF, 0x73, 0x80,
  0xFF, 0xFF, 0xF8, 0x77, 0xFE, 0xE0, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x00, 0x1F, 0x83,
  0xFC, 0x7F, 0xC7, 0x9E, 0xF1, 0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x1E, 0x79, 0xE7,
  0xFE, 0x3F, 0xC1, 0xF8, 0x03, 0x83, 0xC3, 0xE3, 0xF7, 0xFF, 0xDD, 0xCE,
  0x47, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x3F, 0x87, 0xFC, 0xFF, 0xE7, 0x1E, 0x41, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFC,
  0xFF, 0xE6, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x3F, 0xC3, 0xF0,
  0x3F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0xC1, 0xEF, 0xFE,
  0xFF, 0xC7, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03,
  0x70, 0x3B, 0x81, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0xC7, 0x0E,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0xF0,
  0x7F, 0xC7, 0xFE, 0x7F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0xC3, 0xEF, 0xFE, 0xFF, 0xC7, 0xF0, 0x07, 0xE1, 0xFE, 0x3F, 0xE7, 0xC0,
  0x78, 0x07, 0x00, 0xF0, 0x0F, 0x78, 0xFF, 0xEF, 0xFE, 0xF9, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x79, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0x1E,
  0xF0, 0xEF, 0x0E, 0x79, 0xE7, 0xFE, 0x3F, 0xC1, 0xF0, 0x3F, 0xC7, 0xFE,
  0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFE, 0x7F, 0xE3, 0xF8,
  0x1F, 0x07, 0xFC, 0x7F, 0xCF, 0x9E, 0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x9F, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x03, 0xC7, 0xFC, 0x7F, 0x87, 0xE0, 0x23, 0xFE, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFD, 0xEF, 0x23, 0xDE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3D, 0xEE, 0x77, 0xB9, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F,
  0x87, 0xE0, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x00,
  0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01,
  0xF0, 0x1F, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x3F,
  0x9F, 0xF9, 0xFF, 0x31, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x07, 0x81, 0xC0,
  0x3C, 0x38, 0x01, 0xC7, 0x0F, 0xCE, 0x71, 0xFC, 0xE7, 0x3D, 0xC6, 0xE3,
  0x9C, 0x6E, 0x71, 0xC7, 0xE7, 0x1C, 0x7E, 0x71, 0xC6, 0xE7, 0x1C, 0x6E,
  0x71, 0xCE, 0xE3, 0xFF, 0xE7, 0x3F, 0x7C, 0x71, 0xC3, 0x87, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x60, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x70,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFE, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x0F,
  0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE3, 0xEF, 0x0F, 0x78, 0x7B,
  0xC3, 0xDE, 0x1E, 0xFF, 0xE7, 0xFC, 0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78,
  0x3F, 0xC1, 0xFE, 0x1F, 0xF1, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x00, 0x07,
  0xF0, 0xFF, 0xCF, 0xFE, 0x7C, 0x67, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x11, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0x8F,
  0xFF, 0x3C, 0xFC, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xEF, 0x07, 0xBC, 0x3E,
  0xF7, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xBF, 0xEF, 0xFB, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xEF, 0xFB, 0xFE, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x07, 0xF8, 0x3F,
  0xF1, 0xFF, 0xCF, 0xC2, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDF,
  0x0F, 0x3E, 0x3C, 0xFF, 0xF1, 0xFF, 0xC1, 0xFE, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0xFE, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0xFF, 0xFE, 0xFC, 0xF8, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0x3C, 0x7C,
  0xF1, 0xE3, 0xCF, 0x0F, 0x7C, 0x3D, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFB, 0xC3, 0xCF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF0, 0xF3, 0xC3,
  0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF,
  0xF7, 0x1D, 0xFE, 0xE3, 0xBF, 0xDC, 0x77, 0xFB, 0xDC, 0xFF, 0x3B, 0x9F,
  0xE7, 0x73, 0xFC, 0xFC, 0x7F, 0x9F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3E, 0x3F,
  0xC7, 0x87, 0xF8, 0x70, 0xF0, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xF7, 0x9F, 0xEF, 0x3F,
  0xCF, 0x7F, 0x9E, 0x7F, 0x1E, 0xFE, 0x3D, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x78,
  0x1E, 0x7C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF,
  0x0F, 0xFC, 0xFF, 0xEF, 0x3E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFF, 0x7E, 0xFF, 0xEF, 0xFC, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E,
  0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x7C,
  0x1E, 0x3E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0x0F, 0xFE,
  0x3C, 0xFC, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xFF,
  0x8F, 0xFC, 0x3F, 0xE0, 0xF3, 0xC3, 0xCF, 0x0F, 0x1E, 0x3C, 0x78, 0xF1,
  0xF3, 0xC3, 0xCF, 0x0F, 0xBC, 0x1F, 0x1F, 0xCF, 0xFD, 0xFF, 0x7C, 0x6F,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0xE3, 0xFF, 0xFB, 0xFF, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xF8,
  0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xF0, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x7B,
  0xC0, 0xE7, 0x83, 0xC7, 0x07, 0x8E, 0x0F, 0x1E, 0x1C, 0x3C, 0x78, 0x38,
  0xF0, 0x71, 0xC0, 0xF3, 0x81, 0xEF, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x38, 0x1F, 0xE0,
  0xF0, 0x3F, 0xC1, 0xF0, 0x77, 0x83, 0xE1, 0xE7, 0x07, 0xC3, 0xCF, 0x1F,
  0x87, 0x9E, 0x3B, 0x0F, 0x3C, 0x77, 0x1C, 0x38, 0xEE, 0x78, 0x71, 0xDC,
  0xF0, 0xF7, 0xB9, 0xE1, 0xEE, 0x7B, 0xC3, 0xDC, 0x77, 0x03, 0xB8, 0xFE,
  0x07, 0x71, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3C, 0xF0, 0xF8, 0xF1, 0xE1,
  0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x7C,
  0x3C, 0x78, 0xF0, 0xF9, 0xE0, 0xF7, 0xC1, 0xF0, 0xF0, 0x3E, 0xF0, 0x79,
  0xE1, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x07, 0xBC, 0x0F, 0x70, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xF0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0x07, 0x00, 0x1C, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0xC0, 0x77, 0x03, 0xDE, 0x0E, 0x38, 0x78, 0xF1,
  0xC1, 0xC7, 0x07, 0xB8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x70, 0x70,
  0x02, 0x07, 0xF9, 0xFF, 0x9D, 0xF0, 0x1E, 0x01, 0xC0, 0xF9, 0xFF, 0x7F,
  0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0x1F, 0xFF, 0xDF, 0xFB, 0xF3, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x30, 0xEF, 0xCE, 0xFE, 0xFF, 0xEF,
  0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1E, 0xFF, 0xEE, 0xFC, 0xE7, 0xC0, 0x02, 0x07, 0xF3, 0xFD, 0xFF, 0x78,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x5F, 0xF3,
  0xFC, 0x7F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x87, 0x3F,
  0x77, 0xFF, 0x7F, 0xF7, 0x8F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xF7, 0x8F, 0x7F, 0xF3, 0xF7, 0x1E, 0x70, 0x02, 0x01,
  0xFC, 0x3F, 0xE7, 0x9E, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x27, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xC7,
  0xF3, 0xF8, 0xF0, 0x3C, 0x0F, 0x07, 0xFB, 0xFE, 0xFF, 0x8F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x00, 0x0C, 0x03, 0xF7, 0x7F, 0xF7, 0xFF, 0x78, 0xFF, 0x0F, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0x78, 0xF7, 0xFF, 0x3F, 0x71,
  0xE7, 0x00, 0x70, 0x0F, 0x80, 0xF7, 0xBF, 0x7F, 0xE7, 0xFC, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x10, 0xEF, 0xCE, 0xFE,
  0xFF, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0xEF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x3C, 0x78, 0xE0, 0x00,
  0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0xFD, 0xFB, 0xE7, 0x80, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC3, 0xDE, 0x3C, 0xF3, 0xC7, 0x9E,
  0x3D, 0xE1, 0xFE, 0x0E, 0xF0, 0x7F, 0x83, 0xFE, 0x1E, 0x78, 0xF3, 0xC7,
  0x8F, 0x3C, 0x79, 0xE1, 0xEF, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x02, 0x1D, 0xF9, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0xE3, 0xE3, 0xFC, 0x78, 0x7F, 0x87,
  0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF, 0x0E,
  0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0x01, 0x0E, 0xFC, 0xFF,
  0xEF, 0xFE, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x02, 0x00, 0xFE, 0x0F,
  0xF8, 0xFF, 0xE7, 0x8F, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE1, 0xE7, 0x8F, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x01, 0x0E,
  0xFC, 0xEF, 0xEF, 0xFE, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF, 0xFE, 0xEF, 0xCE, 0x7C, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x0C, 0x03, 0xF7,
  0x7F, 0xF7, 0xFF, 0x78, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0x78, 0xF7, 0xFF, 0x3F, 0x73, 0xE7, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x01, 0xE7, 0xEF, 0xFF,
  0xFC, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x0C, 0x1F, 0xFF, 0xFB, 0xEE, 0xF0, 0x3C, 0x0F, 0xC1, 0xF8, 0x3F, 0x87,
  0xE0, 0x7C, 0x0F, 0x83, 0xFF, 0xEF, 0xFB, 0xFC, 0x1C, 0x0E, 0x07, 0x07,
  0x87, 0xFF, 0xFF, 0xFE, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3F, 0x8F, 0xC7, 0xE0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F,
  0xFF, 0xF7, 0xFF, 0x7E, 0xF0, 0xF0, 0x7B, 0x83, 0xDE, 0x1E, 0xF1, 0xE3,
  0x8F, 0x1C, 0x78, 0xF3, 0x87, 0xBC, 0x1D, 0xE0, 0xEE, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0xF8, 0xF7, 0x0F, 0x8F, 0x78,
  0xF8, 0xF7, 0x9F, 0x8E, 0x79, 0xD9, 0xE3, 0x9D, 0xDE, 0x39, 0x9D, 0xE3,
  0xD9, 0xDC, 0x3F, 0x9D, 0xC1, 0xF8, 0xDC, 0x1F, 0x8F, 0xC1, 0xF8, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0xFB, 0xC7, 0x8F,
  0x78, 0x7B, 0xC1, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0xC0, 0xFE,
  0x0F, 0x78, 0x7B, 0xC7, 0x8F, 0x3C, 0x7B, 0xC1, 0xE0, 0xF0, 0x7B, 0xC3,
  0xDE, 0x1E, 0xF1, 0xE3, 0x8F, 0x1E, 0x78, 0xF3, 0x83, 0xBC, 0x1D, 0xE0,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x38, 0x00, 0xFF, 0xBF, 0xEF,
  0xF8, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x87, 0xC3, 0xE3, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x0F, 0x9F, 0x8F, 0x87, 0xE0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xFC, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x7C, 0x3F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83, 0xF0, 0xF8, 0xFC, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC7, 0xE3, 0xE1, 0xF0, 0x7C, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7E,
};

const GFXglyph NotoSans_Condensed_Bold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 20, 7, 1, -20 },
  { 14, 10, 7, 13, 1, -20 },
  { 23, 14, 20, 15, 1, -20 },
  { 58, 12, 23, 14, 1, -21 },
  { 93, 21, 20, 23, 1, -20 },
  { 146, 16, 20, 17, 1, -20 },
  { 186, 4, 7, 7, 1, -20 },
  { 190, 7, 24, 9, 1, -20 },
  { 211, 7, 24, 9, 1, -20 },
  { 232, 12, 12, 13, 1, -21 },
  { 250, 12, 14, 14, 1, -17 },
  { 271, 5, 7, 7, 1, -3 },
  { 276, 7, 3, 9, 1, -9 },
  { 279, 5, 4, 7, 1, -4 },
  { 282, 11, 20, 11, 0, -20 },
  { 310, 12, 20, 14, 1, -20 },
  { 340, 9, 20, 14, 1, -20 },
  { 363, 12, 20, 14, 1, -20 },
  { 393, 12, 20, 14, 1, -20 },
  { 423, 13, 20, 14, 0, -20 },
  { 456, 12, 20, 14, 1, -20 },
  { 486, 12, 20, 14, 1, -20 },
  { 516, 12, 20, 14, 1, -20 },
  { 546, 12, 20, 14, 1, -20 },
  { 576, 12, 20, 14, 1, -20 },
  { 606, 5, 16, 7, 1, -16 },
  { 616, 5, 20, 7, 1, -16 },
  { 629, 12, 14, 14, 1, -17 },
  { 650, 12, 8, 14, 1, -14 },
  { 662, 12, 14, 14, 1, -17 },
  { 683, 11, 20, 11, 0, -20 },
  { 711, 20, 22, 22, 1, -20 },
  { 766, 16, 20, 16, 0, -20 },
  { 806, 13, 20, 16, 2, -20 },
  { 839, 13, 20, 15, 1, -20 },
  { 872, 14, 20, 17, 2, -20 },
  { 907, 10, 20, 13, 2, -20 },
  { 932, 10, 20, 13, 2, -20 },
  { 957, 14, 20, 17, 1, -20 },
  { 992, 14, 20, 18, 2, -20 },
  { 1027, 8, 20, 9, 1, -20 },
  { 1047, 8, 26, 8, -2, -20 },
  { 1073, 14, 20, 16, 2, -20 },
  { 1108, 10, 20, 13, 2, -20 },
  { 1133, 19, 20, 23, 2, -20 },
  { 1181, 15, 20, 19, 2, -20 },
  { 1219, 16, 20, 18, 1, -20 },
  { 1259, 12, 20, 15, 2, -20 },
  { 1289, 16, 25, 18, 1, -20 },
  { 1339, 14, 20, 16, 2, -20 },
  { 1374, 11, 20, 13, 1, -20 },
  { 1402, 13, 20, 13, 0, -20 },
  { 1435, 14, 20, 18, 2, -20 },
  { 1470, 15, 20, 15, 0, -20 },
  { 1508, 23, 20, 23, 0, -20 },
  { 1566, 15, 20, 15, 0, -20 },
  { 1604, 15, 20, 15, 0, -20 },
  { 1642, 12, 20, 13, 0, -20 },
  { 1672, 6, 24, 9, 2, -20 },
  { 1690, 11, 20, 11, 0, -20 },
  { 1718, 6, 24, 9, 1, -20 },
  { 1736, 14, 12, 15, 1, -20 },
  { 1757, 12, 2, 11, 0, 2 },
  { 1760, 7, 4, 9, 1, -21 },
  { 1764, 11, 16, 14, 1, -16 },
  { 1786, 12, 21, 15, 2, -21 },
  { 1818, 10, 16, 12, 1, -16 },
  { 1838, 12, 21, 15, 1, -21 },
  { 1870, 12, 16, 14, 1, -16 },
  { 1894, 10, 21, 9, 0, -21 },
  { 1921, 12, 23, 15, 1, -16 },
  { 1956, 12, 21, 15, 2, -21 },
  { 1988, 4, 21, 7, 2, -21 },
  { 1999, 7, 28, 7, -1, -21 },
  { 2024, 13, 21, 15, 2, -21 },
  { 2059, 4, 21, 7, 2, -21 },
  { 2070, 19, 16, 23, 2, -16 },
  { 2108, 12, 16, 15, 2, -16 },
  { 2132, 13, 16, 15, 1, -16 },
  { 2158, 12, 23, 15, 2, -16 },
  { 2193, 12, 23, 15, 1, -16 },
  { 2228, 8, 16, 11, 2, -16 },
  { 2244, 10, 16, 12, 1, -16 },
  { 2264, 9, 19, 10, 0, -19 },
  { 2286, 12, 15, 15, 2, -15 },
  { 2309, 13, 15, 14, 0, -15 },
  { 2334, 20, 15, 21, 0, -15 },
  { 2372, 13, 15, 13, 0, -15 },
  { 2397, 13, 22, 14, 0, -15 },
  { 2433, 10, 15, 11, 1, -15 },
  { 2452, 9, 24, 10, 0, -20 },
  { 2479, 3, 27, 13, 5, -21 },
  { 2490, 9, 24, 10, 1, -20 },
  { 2517, 12, 4, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_Bold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_BOLD28PT7B_H_
