#ifndef _NOTOSANS_CONDENSED_BOLD36PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x23, 0xEF, 0xBF, 0xF9, 0xE0, 0xF9, 0xFF, 0xCF,
  0xBE, 0x3D, 0xF1, 0xEF, 0x8F, 0x7C, 0x7B, 0xE3, 0xDE, 0x1E, 0xF0, 0xF3,
  0x87, 0x80, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x1E, 0x38, 0x07,
  0x8E, 0x01, 0xE7, 0x80, 0x79, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFC, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0xC3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x79, 0xE0, 0x1C,
  0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x7C, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xBE, 0xC2, 0xF3, 0x03, 0xEC, 0x0F, 0xB0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x0D, 0xF0, 0x33, 0xE0, 0xCF,
  0xC3, 0x7F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x78, 0x07, 0xF0, 0x0F, 0x01, 0xFF,
  0x03, 0xC0, 0x3D, 0xE0, 0x78, 0x0F, 0x1E, 0x1E, 0x01, 0xE3, 0xC3, 0xC0,
  0x3C, 0x78, 0x70, 0x07, 0x8F, 0x1E, 0x00, 0xF1, 0xE3, 0x80, 0x1E, 0x3C,
  0xF0, 0x03, 0xC7, 0x9E, 0x38, 0x78, 0xF7, 0x9F, 0xC7, 0xBC, 0xF7, 0xFC,
  0xFF, 0xBC, 0xFF, 0x8F, 0xE7, 0x9E, 0x78, 0xF8, 0xE7, 0x8F, 0x00, 0x3C,
  0xF1, 0xE0, 0x07, 0x9E, 0x3C, 0x01, 0xE3, 0xC7, 0x80, 0x3C, 0x78, 0xF0,
  0x0F, 0x0F, 0x1E, 0x01, 0xE0, 0xE3, 0xC0, 0x38, 0x1E, 0xF0, 0x0F, 0x03,
  0xFE, 0x01, 0xC0, 0x3F, 0x80, 0x78, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0x1F, 0xF0, 0xF9, 0xFF, 0xC7, 0xCF,
  0xBF, 0x3E, 0xFC, 0xFB, 0xE7, 0xC3, 0xFF, 0x3E, 0x1F, 0xF1, 0xF0, 0x7F,
  0x8F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF3, 0x80,
  0x07, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0xC3, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F,
  0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0E, 0x04, 0x1C, 0x17, 0x39, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0xC1, 0xF7, 0xC7, 0xC7,
  0xC3, 0x8E, 0x02, 0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x3E, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x78, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x23, 0xEF, 0xBF, 0xFB, 0xE0, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x78, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7E, 0x7C, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0,
  0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7F, 0xDF, 0xFF, 0xDF, 0x73,
  0xE4, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xE7, 0xC7, 0xE6, 0x07, 0xC8,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE3, 0x87, 0xE4, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xE0, 0xFF, 0x81,
  0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0x7C, 0x0F, 0x7C, 0x0E, 0x7C, 0x1E, 0x7C,
  0x1C, 0x7C, 0x3C, 0x7C, 0x38, 0x7C, 0x78, 0x7C, 0xF0, 0x7C, 0xF0, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F,
  0xFE, 0x7F, 0xF9, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x03, 0xFF, 0xFF, 0xBF, 0xFC,
  0xFF, 0xE1, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC,
  0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0xE0,
  0xFB, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3E, 0x7E, 0x3E,
  0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0x7C, 0x3E,
  0x78, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7E, 0x7C, 0x7C, 0x3E, 0xF8, 0x3E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC,
  0x7E, 0x7C, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xDE,
  0x1F, 0x9E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x7B, 0xEF, 0xFF, 0xF9,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x3E, 0xFF, 0xFF, 0x9E, 0x3C,
  0xF9, 0xFB, 0xF7, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x78, 0xF0, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x80, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFE,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFE, 0x78, 0xFC, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3C,
  0x00, 0x1E, 0x78, 0x7F, 0x8F, 0x70, 0xFF, 0xCF, 0xF1, 0xFF, 0xCF, 0xF1,
  0xE3, 0xC7, 0xE3, 0xC3, 0xC7, 0xE3, 0xC3, 0xC7, 0xE3, 0xC3, 0xC7, 0xE3,
  0xC3, 0xC7, 0xE3, 0xC3, 0x87, 0xE3, 0xC7, 0x87, 0xE3, 0xC7, 0x8F, 0xE3,
  0xE7, 0xCE, 0xF1, 0xFF, 0xFE, 0xF1, 0xFC, 0xFC, 0xF0, 0x78, 0x78, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x20, 0x1F, 0xC3, 0xE0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00,
  0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3C, 0xF8, 0x03, 0xE3,
  0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0xFC,
  0x01, 0xF7, 0xE0, 0x0F, 0xC0, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF9, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8,
  0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xFC, 0x0F,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0x9E, 0x7E, 0x02, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7F, 0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFC, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xC3, 0xFB, 0xE0, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x83, 0xF7, 0xCF, 0xF3,
  0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0xC7, 0x9F, 0xC0, 0x27, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F,
  0x7E, 0x07, 0xDF, 0xC1, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xC0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xBF, 0xEF, 0xFB, 0xFC, 0xFE,
  0x1C, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0x07, 0xCF, 0x87,
  0xE7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF3, 0xF0, 0xFB, 0xF0, 0x7D, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFB, 0xE0,
  0xF9, 0xF8, 0x7C, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x8F, 0x87, 0xE7, 0xC1,
  0xF3, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xF7, 0x81, 0xFF, 0xF7, 0x83, 0xDF, 0xF7,
  0x83, 0xDF, 0xF3, 0xC3, 0xDF, 0xF3, 0xC7, 0xDF, 0xF3, 0xC7, 0x9F, 0xF3,
  0xC7, 0x9F, 0xF1, 0xE7, 0x9F, 0xF1, 0xEF, 0x1F, 0xF1, 0xEF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0,
  0xFE, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xF7, 0xC3, 0xFE, 0xF8, 0x7F, 0xCF,
  0x8F, 0xF9, 0xF1, 0xFF, 0x1F, 0x3F, 0xE3, 0xE7, 0xFC, 0x7E, 0xFF, 0x87,
  0xDF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0x9F, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x03,
  0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xEF, 0xFF, 0xDF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0xC3, 0xEF, 0xBF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8,
  0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x9F, 0xC7, 0xE0, 0x7E, 0x7C, 0x07,
  0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7,
  0xF0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xC3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3E, 0x1F, 0x9F, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xFF,
  0xC0, 0xF9, 0xF0, 0x7C, 0xFC, 0x3E, 0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC7,
  0xC3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7E, 0xF8, 0x1F, 0x7C, 0x0F, 0xC0, 0x07,
  0xE0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0x7F, 0xF9, 0xF0, 0x27, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0x78,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x3C, 0x07, 0xC3,
  0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF9, 0xF0, 0x0F, 0x9E,
  0x00, 0x79, 0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xEF, 0x80, 0xF8, 0x0F, 0xBE, 0x03,
  0xF0, 0x3E, 0x78, 0x0F, 0xC0, 0xF9, 0xF0, 0x7F, 0x07, 0xC7, 0xC1, 0xFC,
  0x1F, 0x1F, 0x07, 0xF0, 0x7C, 0x7C, 0x1D, 0xE1, 0xF0, 0xF0, 0xF7, 0x87,
  0xC3, 0xE3, 0xDE, 0x3E, 0x0F, 0x8F, 0x78, 0xF8, 0x3E, 0x3D, 0xE3, 0xE0,
  0x78, 0xF3, 0xCF, 0x81, 0xE7, 0x8F, 0x3E, 0x07, 0xDE, 0x3C, 0xF0, 0x1F,
  0x78, 0xF7, 0xC0, 0x7D, 0xE3, 0xDF, 0x00, 0xF7, 0x87, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03,
  0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7C, 0x07, 0xCF, 0x81, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF1,
  0xF0, 0x3E, 0x3E, 0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xCF,
  0x81, 0xF1, 0xF0, 0x7E, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x7E, 0x7C, 0x07,
  0xDF, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x3E,
  0x01, 0xF7, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1F, 0x3C, 0x07, 0x8F, 0x01, 0xE1,
  0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0x7B, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF0,
  0x3C, 0x07, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE1, 0x87, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xE1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xBD, 0xFF,
  0x79, 0xF8, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xFC, 0xF1, 0xF8, 0x03, 0xF0, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFE, 0x7E, 0x19, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x82, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x9F,
  0x1F, 0xDF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xEF,
  0x0F, 0xCF, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x7E, 0x3E,
  0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x02, 0x3F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x80, 0x3F, 0xC3, 0xFE, 0x3F,
  0xE1, 0xFF, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xE3, 0xFF, 0x3F, 0xF9,
  0xFF, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x8F, 0x1F, 0xCF, 0x3F, 0xEF, 0x3F, 0xFF,
  0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xDF, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x40, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8,
  0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFE, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF7, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFE, 0xFC,
  0x70, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x1F, 0x3E, 0x1F,
  0x1F, 0x1F, 0x8F, 0x8F, 0x87, 0xCF, 0x83, 0xEF, 0x81, 0xF7, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xDF, 0x0F, 0x8F, 0x87, 0xC3, 0xE3,
  0xE1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3F, 0x7C, 0x0F, 0xBE, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF1, 0xF0, 0x7C, 0x79, 0xFE, 0x7F, 0xBF, 0xFF,
  0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xF9, 0xFF, 0xE1, 0xF8, 0x7F, 0xF0,
  0xFC, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE,
  0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F,
  0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07,
  0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xF0, 0xF1, 0xF0, 0xF3, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x07,
  0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9,
  0xF0, 0x7C, 0xF8, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xF7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xFC, 0x7E, 0x3F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xF1, 0xF0, 0xF3, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFE, 0x3E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFC, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xFC, 0xF9, 0xF8, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0x1F, 0xCF, 0x3F, 0xEF, 0x3F, 0xFF,
  0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xDF, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0xF1, 0xFE, 0x7F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xFF, 0xDF, 0xFD, 0xFF,
  0xEF, 0x82, 0x7C, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xFC,
  0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x03, 0xF8, 0x1F, 0xFF, 0xF7, 0xFF, 0xBF,
  0xF8, 0xFF, 0x80, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFE, 0x7F, 0xC7, 0xF8, 0x7F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0x78,
  0xFC, 0xF0, 0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE7, 0xC1,
  0xF1, 0xE0, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07,
  0xCF, 0x03, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0x07,
  0xFE, 0x0F, 0xC1, 0xF7, 0xC3, 0xF0, 0x7D, 0xF0, 0xFE, 0x1E, 0x7C, 0x3F,
  0x8F, 0x9F, 0x1F, 0xE3, 0xE3, 0xC7, 0xB8, 0xF8, 0xF9, 0xCE, 0x3C, 0x3E,
  0x73, 0xDF, 0x0F, 0x9C, 0xF7, 0xC1, 0xEF, 0x3D, 0xF0, 0x7B, 0xC7, 0x78,
  0x1F, 0xF1, 0xDE, 0x07, 0xF8, 0x77, 0x80, 0xFE, 0x1D, 0xE0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x8F, 0x87, 0xC7, 0xC1, 0xF7,
  0xC0, 0xFB, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xF0, 0x7C, 0xF8,
  0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x07, 0xDF, 0x83, 0xF0, 0xF8, 0x0F, 0xFE,
  0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE7, 0xC1, 0xF1, 0xF0, 0xF8, 0xF8, 0x78,
  0x7C, 0x7C, 0x1E, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x01, 0xEF, 0x80, 0xF7,
  0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0x80, 0x00, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x3F, 0x07,
  0xF0, 0x7F, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0C, 0x00, 0x08, 0x01, 0x7F, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0xFC,
};

const GFXglyph NotoSans_Condensed_Bold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 13, 10, 16, 2, -26 },
  { 38, 18, 26, 20, 1, -26 },
  { 97, 14, 29, 18, 2, -27 },
  { 148, 27, 26, 29, 1, -26 },
  { 236, 21, 26, 22, 1, -26 },
  { 305, 5, 10, 9, 2, -26 },
  { 312, 9, 32, 12, 2, -26 },
  { 348, 9, 32, 12, 1, -26 },
  { 384, 15, 15, 17, 1, -27 },
  { 413, 16, 17, 18, 1, -21 },
  { 447, 7, 9, 9, 1, -4 },
  { 455, 9, 5, 11, 1, -12 },
  { 461, 6, 6, 9, 2, -6 },
  { 466, 14, 26, 15, 0, -26 },
  { 512, 16, 26, 18, 1, -26 },
  { 564, 11, 26, 18, 2, -26 },
  { 600, 15, 26, 18, 1, -26 },
  { 649, 15, 26, 18, 1, -26 },
  { 698, 16, 26, 18, 1, -26 },
  { 750, 14, 26, 18, 2, -26 },
  { 796, 16, 26, 18, 1, -26 },
  { 848, 16, 26, 18, 1, -26 },
  { 900, 16, 26, 18, 1, -26 },
  { 952, 16, 26, 18, 1, -26 },
  { 1004, 6, 20, 10, 2, -20 },
  { 1019, 7, 25, 10, 1, -20 },
  { 1041, 16, 18, 18, 1, -22 },
  { 1077, 16, 11, 18, 1, -18 },
  { 1099, 16, 18, 18, 1, -22 },
  { 1135, 14, 26, 14, 0, -26 },
  { 1181, 24, 29, 28, 2, -26 },
  { 1268, 21, 26, 21, 0, -26 },
  { 1337, 16, 26, 20, 3, -26 },
  { 1389, 16, 26, 19, 2, -26 },
  { 1441, 17, 26, 22, 3, -26 },
  { 1497, 12, 26, 17, 3, -26 },
  { 1536, 12, 26, 17, 3, -26 },
  { 1575, 18, 26, 22, 2, -26 },
  { 1634, 17, 26, 23, 3, -26 },
  { 1690, 10, 26, 12, 1, -26 },
  { 1723, 10, 34, 10, -2, -26 },
  { 1766, 17, 26, 20, 3, -26 },
  { 1822, 13, 26, 16, 3, -26 },
  { 1865, 24, 26, 30, 3, -26 },
  { 1943, 19, 26, 25, 3, -26 },
  { 2005, 20, 26, 24, 2, -26 },
  { 2070, 15, 26, 19, 3, -26 },
  { 2119, 20, 32, 24, 2, -26 },
  { 2199, 17, 26, 20, 3, -26 },
  { 2255, 14, 26, 17, 1, -26 },
  { 2301, 15, 26, 17, 1, -26 },
  { 2350, 17, 26, 23, 3, -26 },
  { 2406, 20, 26, 20, 0, -26 },
  { 2471, 30, 26, 29, 0, -26 },
  { 2569, 19, 26, 19, 0, -26 },
  { 2631, 19, 26, 19, 0, -26 },
  { 2693, 15, 26, 17, 1, -26 },
  { 2742, 9, 32, 11, 2, -26 },
  { 2778, 14, 26, 15, 0, -26 },
  { 2824, 8, 32, 11, 1, -26 },
  { 2856, 18, 16, 20, 1, -26 },
  { 2892, 15, 3, 15, 0, 3 },
  { 2898, 9, 6, 12, 1, -28 },
  { 2905, 15, 20, 18, 1, -20 },
  { 2943, 16, 27, 19, 2, -27 },
  { 2997, 14, 20, 16, 1, -20 },
  { 3032, 16, 27, 19, 1, -27 },
  { 3086, 16, 20, 18, 1, -20 },
  { 3126, 13, 28, 12, 0, -28 },
  { 3172, 16, 29, 19, 1, -20 },
  { 3230, 16, 27, 20, 2, -27 },
  { 3284, 5, 27, 9, 2, -27 },
  { 3301, 8, 36, 9, -1, -27 },
  { 3337, 17, 27, 19, 2, -27 },
  { 3395, 5, 27, 9, 2, -27 },
  { 3412, 25, 20, 29, 2, -20 },
  { 3475, 16, 20, 20, 2, -20 },
  { 3515, 17, 20, 19, 1, -20 },
  { 3558, 16, 29, 19, 2, -20 },
  { 3616, 16, 29, 19, 1, -20 },
  { 3674, 11, 20, 14, 2, -20 },
  { 3702, 13, 20, 15, 1, -20 },
  { 3735, 11, 24, 13, 1, -24 },
  { 3768, 15, 20, 20, 2, -20 },
  { 3806, 17, 20, 17, 0, -20 },
  { 3849, 26, 20, 26, 0, -20 },
  { 3914, 17, 20, 17, 0, -20 },
  { 3957, 17, 29, 17, 0, -20 },
  { 4019, 13, 20, 14, 1, -20 },
  { 4052, 12, 32, 13, 0, -26 },
  { 4100, 5, 35, 17, 6, -27 },
  { 4122, 12, 32, 13, 1, -26 },
  { 4170, 16, 6, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_Bold36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_BOLD36PT7B_H_
