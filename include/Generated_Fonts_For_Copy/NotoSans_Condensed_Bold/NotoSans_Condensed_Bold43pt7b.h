#ifndef _NOTOSANS_CONDENSED_BOLD43PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x10, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xF7, 0xC7, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D,
  0xF0, 0xF8, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xC1, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFC, 0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F,
  0x80, 0x1E, 0x3C, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x7C,
  0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x0F, 0xFE, 0x07, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFE, 0xDF,
  0x3F, 0x30, 0x4F, 0xCC, 0x03, 0xF3, 0x00, 0xFC, 0xC0, 0x3F, 0xB0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x37, 0xE0, 0x0C, 0xFC, 0x03, 0x3F, 0x80, 0xCF,
  0xB8, 0x37, 0xEF, 0xEF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0xFC, 0x03,
  0xC0, 0x0F, 0xFE, 0x03, 0xE0, 0x07, 0xCF, 0x81, 0xE0, 0x03, 0xC7, 0xC0,
  0xF0, 0x03, 0xE3, 0xE0, 0xF8, 0x01, 0xF0, 0xF0, 0x78, 0x00, 0xF8, 0x78,
  0x7C, 0x00, 0x7C, 0x3C, 0x3C, 0x00, 0x3E, 0x1E, 0x3E, 0x00, 0x1F, 0x0F,
  0x1E, 0x00, 0x07, 0x8F, 0x9F, 0x0F, 0x03, 0xC7, 0xCF, 0x9F, 0xE1, 0xF3,
  0xE7, 0x9F, 0xF8, 0xFF, 0xE7, 0xCF, 0xFC, 0x3F, 0xF3, 0xCF, 0x9F, 0x0F,
  0xF3, 0xE7, 0xCF, 0x83, 0xF1, 0xE3, 0xC3, 0xC0, 0x01, 0xF1, 0xE1, 0xE0,
  0x00, 0xF8, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x7C, 0x00, 0x7C, 0x3C, 0x3E,
  0x00, 0x3C, 0x1E, 0x1E, 0x00, 0x3E, 0x0F, 0x0F, 0x00, 0x1E, 0x07, 0xC7,
  0x80, 0x1F, 0x03, 0xE7, 0xC0, 0x0F, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x7F,
  0xE0, 0x07, 0xC0, 0x1F, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x02, 0x3F, 0xF0, 0x7E, 0x3F,
  0xFC, 0x3F, 0x3F, 0xFE, 0x1F, 0x9F, 0xDF, 0x9F, 0xCF, 0xCF, 0xEF, 0xCF,
  0xE3, 0xFF, 0xE7, 0xE0, 0xFF, 0xE3, 0xF0, 0x3F, 0xF1, 0xF8, 0x0F, 0xF0,
  0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xF8, 0x1F, 0xF0, 0xFE, 0xFF, 0xFF,
  0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xC0, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07,
  0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x18, 0x78, 0x67, 0xDE, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xEF,
  0x81, 0xF3, 0xF0, 0xFC, 0x7E, 0x1E, 0x1E, 0x01, 0x83, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x18, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7E, 0x3F, 0x1F, 0xC3, 0xF3,
  0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xF7,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xE0, 0x7C, 0xFC, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xC7, 0xE3, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFD, 0xF3, 0xF3, 0x8F, 0xC4, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFC, 0x3F, 0x8E, 0x03, 0xF0, 0x80, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x78, 0x3F, 0x84, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xDC, 0x03, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xF0, 0x07, 0xDF, 0x00,
  0x79, 0xF0, 0x0F, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0,
  0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF9, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x98, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFE,
  0x3D, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x3E,
  0x07, 0xCF, 0xF0, 0xFB, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0x0F,
  0xDF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xF8, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xC7, 0xE1, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF8,
  0xFC, 0x7F, 0x1F, 0xDF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFC, 0xFE, 0x3F, 0x07, 0xE7,
  0xE0, 0xFD, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xEF,
  0xC0, 0xFD, 0xFC, 0x7F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87,
  0xFF, 0xF8, 0xFE, 0x3F, 0x1F, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xDF,
  0x87, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xDF, 0x07,
  0xF3, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0xEF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xF8, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x21, 0xF7, 0xFF, 0xFF, 0xDF,
  0xBE, 0x1C, 0x3F, 0x3F, 0x7F, 0x7F, 0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0xC1, 0xF8, 0x80, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x03,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x07, 0xF0, 0xF1, 0xF0, 0x7F,
  0xF3, 0xE7, 0xC3, 0xFF, 0xC7, 0x9E, 0x1F, 0xFF, 0x1E, 0xF8, 0xF8, 0x78,
  0x7B, 0xE3, 0xE1, 0xE1, 0xEF, 0x0F, 0x07, 0x87, 0xFC, 0x3C, 0x1E, 0x1F,
  0xF1, 0xF0, 0x78, 0x7F, 0xC7, 0xC1, 0xE1, 0xEF, 0x1F, 0x07, 0x87, 0xBC,
  0x7C, 0x3E, 0x1E, 0xF0, 0xF0, 0xF8, 0x7B, 0xC3, 0xE3, 0xE3, 0xCF, 0x8F,
  0xFF, 0xFF, 0x3E, 0x1F, 0xF7, 0xF8, 0x78, 0x7F, 0x9F, 0xE1, 0xF0, 0x7C,
  0x3E, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x18, 0x00, 0xFF, 0x87, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xE7,
  0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE,
  0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F,
  0xEF, 0xC0, 0xFC, 0xFC, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xCF, 0xC7, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFC, 0x1C, 0x3F, 0x80, 0x47, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x0E, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF3, 0xF0, 0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0xFE,
  0xFC, 0x0F, 0xE7, 0xE1, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xF0, 0x38, 0xFF, 0x00, 0x47,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xFE,
  0x0F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0,
  0xFE, 0x7E, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x7F, 0x07,
  0xE3, 0xF0, 0x3F, 0x3F, 0x81, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xDF, 0x81, 0xFC, 0xFC, 0x0F, 0xC7, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFE,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF9, 0xF8,
  0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFB, 0xE0, 0x1E, 0xFF, 0xFF, 0x01, 0xF7,
  0xFF, 0xF8, 0x0F, 0xBF, 0xFB, 0xE0, 0x79, 0xFF, 0xDF, 0x07, 0xCF, 0xFE,
  0xF8, 0x3E, 0xFF, 0xF7, 0xC1, 0xF7, 0xFF, 0x9F, 0x1F, 0x3F, 0xFC, 0xF8,
  0xF9, 0xFF, 0xE7, 0xC7, 0xCF, 0xFF, 0x3E, 0x3C, 0x7F, 0xF8, 0xFB, 0xE3,
  0xFF, 0xC7, 0xDF, 0x1F, 0xFE, 0x3E, 0xF8, 0xFF, 0xF0, 0xFF, 0x87, 0xFF,
  0x87, 0xFC, 0x3F, 0xFC, 0x3F, 0xE1, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0x07,
  0xF0, 0x7F, 0xF8, 0x3F, 0x83, 0xFF, 0xC1, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0,
  0xFF, 0xF0, 0x3E, 0x07, 0xE0, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xF7, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xEF, 0xC1, 0xFF, 0xDF, 0x83, 0xFF, 0x9F, 0x87, 0xFF, 0x3F, 0x0F,
  0xFE, 0x3F, 0x1F, 0xFC, 0x7E, 0x3F, 0xF8, 0x7E, 0x7F, 0xF0, 0xFC, 0xFF,
  0xE0, 0xFD, 0xFF, 0xC1, 0xFB, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0xC1, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7E, 0x3F, 0xE3, 0xF0, 0x7F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7F, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0xCF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xE0, 0x07, 0xF8,
  0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0x3E, 0xFC, 0x06,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFB, 0xF8, 0x3F, 0x9F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xE0,
  0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xEF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFE, 0x01,
  0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x80, 0xFC, 0xFC, 0x07, 0xF0, 0x1F, 0x9F,
  0x81, 0xFE, 0x03, 0xF3, 0xF0, 0x3F, 0xE0, 0x7E, 0x7E, 0x07, 0xFC, 0x0F,
  0xC7, 0xC0, 0xF7, 0x83, 0xF0, 0xFC, 0x1E, 0xF0, 0x7E, 0x1F, 0x87, 0xDF,
  0x0F, 0xC3, 0xF0, 0xFB, 0xE1, 0xF8, 0x7E, 0x1F, 0x7C, 0x3E, 0x07, 0xC3,
  0xEF, 0x8F, 0xC0, 0xFC, 0xF8, 0xF1, 0xF8, 0x1F, 0x9F, 0x1F, 0x3F, 0x03,
  0xF3, 0xE3, 0xE7, 0xE0, 0x3E, 0x7C, 0x7C, 0xF8, 0x07, 0xCF, 0x8F, 0x9F,
  0x00, 0xFB, 0xE0, 0xF7, 0xE0, 0x1F, 0xFC, 0x1E, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7E, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x1F,
  0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE3, 0xF0, 0x1F, 0xC7,
  0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F,
  0xCF, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFD, 0xF8, 0x07,
  0xF7, 0xE0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFC, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDF,
  0x00, 0x3E, 0x78, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0xBE, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF,
  0xDF, 0xE3, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xE1, 0xFD, 0xF8, 0xFF, 0x7F, 0xFF, 0xDF, 0xFD, 0xF3, 0xFE, 0x7C, 0x7F,
  0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x0F,
  0x03, 0xE7, 0xF8, 0x7D, 0xFF, 0x8F, 0xBF, 0xF9, 0xFF, 0xFF, 0x3F, 0x87,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07,
  0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7F, 0x0F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3E, 0xFF, 0xC7, 0xDF, 0xF8, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0x0C, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x02, 0x7F, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0xFC, 0x7F, 0x9F, 0x9F, 0xFB,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xBF,
  0x0F, 0xE3, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x09, 0xFE, 0x1E,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xF8, 0x01, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xF1, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x07,
  0xC3, 0xE3, 0xFC, 0xFC, 0xFF, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x7F, 0xEF, 0xC7, 0xFD, 0xF8, 0x7F, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE6, 0x01, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x1F, 0x0F, 0x9F, 0xE3, 0xEF, 0xFC, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x38,
  0xFB, 0xFF, 0xF7, 0xEF, 0x84, 0x00, 0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0x03, 0x80, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F,
  0x80, 0x40, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0xBF, 0xF7, 0xFE, 0xFF,
  0x9F, 0xF3, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F,
  0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF,
  0x80, 0xFB, 0xF8, 0x0F, 0xBF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE,
  0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xFC, 0x0F, 0xC3, 0xC7, 0xF8, 0x7F, 0x8F,
  0xBF, 0xF3, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xF8,
  0xFF, 0xCF, 0xEF, 0xE1, 0xFC, 0x1F, 0xBF, 0x07, 0xF0, 0x7E, 0xFC, 0x0F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0,
  0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F,
  0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF,
  0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0,
  0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xF0, 0x7C,
  0x3C, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0xBF, 0x83, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xF9, 0xF8,
  0x3F, 0x3F, 0xDF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0xF0, 0x78, 0x1F, 0x3F, 0xC3, 0xEF, 0xFC, 0x7D, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81,
  0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x1F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF8, 0x7F, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xF7, 0xFE, 0x3E, 0x7F, 0xC7, 0xC7, 0xE0, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC3,
  0xE3, 0xFC, 0xFC, 0xFF, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x3F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0x7F, 0xEF, 0xC7, 0xFD, 0xF8, 0x7E, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0xF0, 0x7F, 0x8F, 0xFE, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFB, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0,
  0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xDF, 0x81, 0xBF, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF8, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFD, 0xF3, 0xFE, 0x7C, 0x7F, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7E,
  0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xC0,
  0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F, 0xC0, 0xFD, 0xF8, 0x3F,
  0xC1, 0xFB, 0xF0, 0x7F, 0x83, 0xE7, 0xE1, 0xFF, 0x0F, 0xC7, 0xC3, 0xDE,
  0x1F, 0x8F, 0xC7, 0xBC, 0x3F, 0x1F, 0x8F, 0x7C, 0x7C, 0x3F, 0x1E, 0x79,
  0xF8, 0x3E, 0x7C, 0xF3, 0xF0, 0x7C, 0xF1, 0xE7, 0xE0, 0xFD, 0xE3, 0xCF,
  0x81, 0xFB, 0xC7, 0x9F, 0x01, 0xF7, 0x87, 0xFE, 0x03, 0xEF, 0x0F, 0xFC,
  0x07, 0xDE, 0x1F, 0xF0, 0x0F, 0xB8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF7, 0xF0,
  0xFE, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x9F, 0x80, 0xFD, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0x9F, 0x81, 0xF9, 0xF8, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F,
  0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xF0, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x1F,
  0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x1F, 0xC3, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFC, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x07, 0xE0, 0x3F, 0x81,
  0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFE, 0x07, 0xF0, 0xFF, 0x8F, 0xF8, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x78, 0x00, 0x0C, 0x00, 0x2F,
  0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0,
  0x0F, 0xE0,
};

const GFXglyph NotoSans_Condensed_Bold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 31, 11, 2, -31 },
  { 29, 15, 11, 20, 2, -31 },
  { 50, 22, 31, 23, 1, -31 },
  { 136, 18, 36, 21, 2, -33 },
  { 217, 33, 31, 35, 1, -31 },
  { 345, 25, 31, 26, 1, -31 },
  { 442, 6, 11, 10, 2, -31 },
  { 451, 11, 38, 14, 2, -31 },
  { 504, 11, 38, 14, 1, -31 },
  { 557, 18, 18, 20, 1, -33 },
  { 598, 19, 21, 21, 1, -26 },
  { 648, 8, 11, 11, 1, -5 },
  { 659, 11, 5, 13, 1, -14 },
  { 666, 7, 7, 11, 2, -7 },
  { 673, 17, 31, 18, 0, -31 },
  { 739, 19, 31, 21, 1, -31 },
  { 813, 14, 31, 21, 2, -31 },
  { 868, 19, 31, 21, 1, -31 },
  { 942, 19, 31, 21, 1, -31 },
  { 1016, 20, 31, 21, 1, -31 },
  { 1094, 17, 31, 21, 2, -31 },
  { 1160, 19, 31, 21, 1, -31 },
  { 1234, 19, 31, 21, 1, -31 },
  { 1308, 19, 31, 21, 1, -31 },
  { 1382, 19, 31, 21, 1, -31 },
  { 1456, 7, 24, 11, 2, -24 },
  { 1477, 8, 30, 11, 1, -24 },
  { 1507, 19, 21, 21, 1, -26 },
  { 1557, 19, 13, 21, 1, -22 },
  { 1588, 19, 21, 21, 1, -26 },
  { 1638, 17, 31, 17, 0, -31 },
  { 1704, 30, 34, 33, 2, -31 },
  { 1832, 25, 31, 25, 0, -31 },
  { 1929, 20, 31, 24, 3, -31 },
  { 2007, 20, 31, 23, 2, -31 },
  { 2085, 21, 31, 26, 3, -31 },
  { 2167, 15, 31, 20, 3, -31 },
  { 2226, 15, 31, 20, 3, -31 },
  { 2285, 21, 31, 26, 2, -31 },
  { 2367, 21, 31, 28, 3, -31 },
  { 2449, 12, 31, 14, 1, -31 },
  { 2496, 12, 40, 13, -3, -31 },
  { 2556, 21, 31, 24, 3, -31 },
  { 2638, 16, 31, 19, 3, -31 },
  { 2700, 29, 31, 35, 3, -31 },
  { 2813, 23, 31, 29, 3, -31 },
  { 2903, 24, 31, 28, 2, -31 },
  { 2996, 18, 31, 23, 3, -31 },
  { 3066, 24, 38, 28, 2, -31 },
  { 3180, 21, 31, 24, 3, -31 },
  { 3262, 16, 31, 20, 2, -31 },
  { 3324, 19, 31, 20, 1, -31 },
  { 3398, 21, 31, 27, 3, -31 },
  { 3480, 24, 31, 24, 0, -31 },
  { 3573, 35, 31, 35, 0, -31 },
  { 3709, 23, 31, 23, 0, -31 },
  { 3799, 22, 31, 22, 0, -31 },
  { 3885, 18, 31, 20, 1, -31 },
  { 3955, 10, 38, 14, 3, -31 },
  { 4003, 17, 31, 18, 0, -31 },
  { 4069, 10, 38, 14, 1, -31 },
  { 4117, 21, 19, 23, 1, -31 },
  { 4167, 18, 3, 18, 0, 4 },
  { 4174, 10, 7, 14, 2, -33 },
  { 4183, 18, 24, 22, 1, -24 },
  { 4237, 19, 33, 23, 3, -33 },
  { 4316, 16, 24, 19, 2, -24 },
  { 4364, 19, 33, 23, 2, -33 },
  { 4443, 18, 24, 21, 2, -24 },
  { 4497, 15, 33, 14, 1, -33 },
  { 4559, 19, 34, 23, 2, -24 },
  { 4640, 18, 33, 23, 3, -33 },
  { 4715, 7, 33, 11, 2, -33 },
  { 4744, 11, 43, 11, -2, -33 },
  { 4804, 20, 33, 23, 3, -33 },
  { 4887, 6, 33, 11, 3, -33 },
  { 4912, 30, 24, 35, 3, -24 },
  { 5002, 18, 24, 23, 3, -24 },
  { 5056, 19, 24, 23, 2, -24 },
  { 5113, 19, 34, 23, 3, -24 },
  { 5194, 19, 34, 23, 2, -24 },
  { 5275, 13, 24, 16, 3, -24 },
  { 5314, 15, 24, 18, 1, -24 },
  { 5359, 13, 28, 16, 1, -28 },
  { 5405, 18, 24, 23, 3, -24 },
  { 5459, 21, 24, 21, 0, -24 },
  { 5522, 31, 23, 31, 0, -23 },
  { 5612, 20, 23, 20, 0, -23 },
  { 5670, 21, 34, 21, 0, -24 },
  { 5760, 15, 24, 17, 1, -24 },
  { 5805, 14, 38, 16, 0, -31 },
  { 5872, 5, 43, 20, 8, -33 },
  { 5899, 13, 38, 16, 2, -31 },
  { 5961, 19, 7, 21, 1, -19 },
};

const GFXfont NotoSans_Condensed_Bold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_BOLD43PT7B_H_
