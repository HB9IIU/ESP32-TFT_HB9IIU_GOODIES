#ifndef _NOTOSANS_CONDENSED_BOLD39PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xE7, 0x80, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0xFC, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFE, 0x3E, 0xF8, 0xFB, 0xE1, 0xEF, 0x87, 0x9E, 0x1E,
  0x78, 0x79, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x8F, 0x00, 0x78, 0xF0,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x9E,
  0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03,
  0xC7, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xE0, 0x1F, 0xFF,
  0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xF9, 0x84, 0xF9, 0x80, 0xF9, 0x80,
  0xF9, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x01, 0xBF, 0x01, 0x9F, 0x01, 0x9F, 0x81, 0x9F,
  0xE1, 0xBE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x80, 0x1E, 0x01, 0xFE, 0x01,
  0xE0, 0x1F, 0xF8, 0x0F, 0x00, 0xFF, 0xC0, 0xF0, 0x07, 0x9E, 0x07, 0x80,
  0x7C, 0x78, 0x7C, 0x03, 0xC3, 0xC3, 0xC0, 0x1E, 0x1E, 0x1E, 0x00, 0xF0,
  0xF1, 0xE0, 0x07, 0x87, 0x8F, 0x00, 0x3C, 0x3C, 0xF0, 0x01, 0xF1, 0xE7,
  0x8F, 0x87, 0x9E, 0x78, 0xFE, 0x3F, 0xF3, 0xCF, 0xF9, 0xFF, 0x9E, 0xFF,
  0xE7, 0xF9, 0xE7, 0x8F, 0x1F, 0x8F, 0x3C, 0x78, 0x00, 0xF1, 0xE3, 0xC0,
  0x07, 0x8F, 0x1E, 0x00, 0x78, 0x78, 0xF0, 0x03, 0xC3, 0xC7, 0x80, 0x3E,
  0x1E, 0x3C, 0x01, 0xE0, 0xF1, 0xE0, 0x0F, 0x07, 0x8F, 0x00, 0xF0, 0x3E,
  0xF8, 0x07, 0x80, 0xFF, 0x80, 0x78, 0x03, 0xFC, 0x03, 0xC0, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xF3, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3F,
  0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0x8F, 0xFC, 0x3F, 0x3F, 0xFC, 0x7E, 0x7E, 0xFC,
  0xF9, 0xF9, 0xFB, 0xF3, 0xF1, 0xFF, 0xE7, 0xE1, 0xFF, 0x8F, 0xC1, 0xFF,
  0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x3F, 0x9F, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFB, 0xF0, 0x7F, 0xC7, 0xF0, 0xFF, 0xEF, 0xBE,
  0xFB, 0xEF, 0x9E, 0x79, 0xE0, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F,
  0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78,
  0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0,
  0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03,
  0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x04, 0x3C, 0x13, 0x9E, 0x7B, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x83, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0x81, 0xF3,
  0xE0, 0xF8, 0xF8, 0x18, 0x70, 0x04, 0x10, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x7D, 0xFB, 0xE7, 0xCF, 0x9E, 0x3C, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC3, 0xF7, 0xE3, 0xF1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3E, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xF7,
  0xC1, 0xF3, 0xE0, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0xFF, 0x1F,
  0xF3, 0xFF, 0x7F, 0xFF, 0xDF, 0x79, 0xF3, 0x1F, 0x21, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xC7, 0xE7, 0xF1, 0xC1, 0xF8,
  0x40, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xC7, 0xF1, 0x81, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x81, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFD,
  0xE0, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x07, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0E, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0xF3, 0xE0,
  0x78, 0xF8, 0x1E, 0x3E, 0x0F, 0x0F, 0x83, 0xC3, 0xE1, 0xE0, 0xF8, 0x78,
  0x3E, 0x3C, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFB, 0xC0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x80, 0x7E,
  0xF1, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFE,
  0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFC, 0x11, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x3E, 0x1F, 0x7F, 0xCF,
  0xBF, 0xE7, 0xFF, 0xFB, 0xFC, 0xFD, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0xFD, 0xF8, 0x7E, 0x7E,
  0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3F, 0x1F, 0x8F, 0xDF, 0x83, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0x7F, 0x3F, 0x1F,
  0xBF, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E, 0xF8,
  0x3F, 0x7F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xF7, 0xE3, 0xE1, 0xFB, 0xF0,
  0x7D, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFB, 0xF1, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xEF, 0x8F, 0xE7,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x31, 0xFF,
  0xFF, 0xFF, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0xFD, 0xF0, 0x08, 0x7D, 0xFB, 0xF7, 0xE7, 0xC7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E,
  0x78, 0xF3, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF,
  0xF3, 0xFF, 0xE7, 0xCF, 0xE4, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xF0,
  0x7F, 0x01, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE1,
  0xE0, 0x7C, 0x3C, 0x78, 0x3F, 0xE3, 0xCF, 0x0F, 0xFC, 0x7B, 0xC3, 0xE7,
  0x8F, 0x78, 0xF8, 0xF0, 0xEF, 0x1E, 0x1E, 0x1F, 0xE3, 0xC3, 0xC3, 0xFC,
  0x78, 0x78, 0x7F, 0x9F, 0x0F, 0x0F, 0xF3, 0xE1, 0xE1, 0xDE, 0x3C, 0x3C,
  0x7B, 0xC7, 0x87, 0x8F, 0x78, 0xF1, 0xF1, 0xEF, 0x1F, 0xFF, 0xF9, 0xE1,
  0xFE, 0xFE, 0x3E, 0x1F, 0x8F, 0x83, 0xC0, 0x40, 0x40, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x20, 0x0F, 0xF0, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0x7C, 0xFC, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFC, 0x07, 0xE3, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFE,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xC0, 0x47, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x08, 0xFF, 0xBE, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF0, 0x7F, 0x3E, 0x07, 0xF7, 0xC0, 0x7E,
  0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x3F, 0xBE, 0x0F, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0x7C, 0x7F, 0x00, 0x9F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x07,
  0xDF, 0xC0, 0xF9, 0xFE, 0x3F, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xE3, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xBF, 0xEF, 0xF3, 0xF0, 0xF8, 0x07,
  0xFF, 0x01, 0xFB, 0xE0, 0x7E, 0x7C, 0x0F, 0xCF, 0x83, 0xF1, 0xF0, 0x7E,
  0x3E, 0x1F, 0x87, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x3F, 0x03, 0xEF, 0xC0,
  0x7D, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0x9F, 0x83, 0xE3, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xE1,
  0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC0, 0xFC, 0xF8, 0x1F, 0x9F, 0x01, 0xFB,
  0xE0, 0x3F, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0xF0, 0x3D, 0xFF, 0xBC, 0x0F, 0x7F, 0xEF, 0x87, 0xDF, 0xFB, 0xE1, 0xE7,
  0xFE, 0x78, 0x79, 0xFF, 0x9E, 0x1E, 0x7F, 0xE7, 0xCF, 0x9F, 0xF9, 0xF3,
  0xC7, 0xFE, 0x3C, 0xF1, 0xFF, 0x8F, 0x7C, 0x7F, 0xE3, 0xFE, 0x1F, 0xF8,
  0xFF, 0x87, 0xFE, 0x1F, 0xE1, 0xFF, 0x87, 0xF8, 0x7F, 0xE1, 0xFC, 0x1F,
  0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF, 0x83, 0xE0, 0x7F, 0xE0, 0xF8,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFE, 0xF8, 0x3F, 0xF7, 0xE1, 0xFF, 0x9F, 0x0F, 0xFC,
  0xFC, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x9F, 0xF8, 0x7C, 0xFF, 0xC3, 0xF7,
  0xFE, 0x0F, 0xBF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0x7E, 0x01,
  0xF9, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x0F, 0xF7, 0xFC, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x9F,
  0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0x7E,
  0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x0F, 0xF7, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x87, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0x1F, 0x03,
  0xE3, 0xF0, 0x7C, 0x7E, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7,
  0xC1, 0xF8, 0xF8, 0x1F, 0x9F, 0x03, 0xF3, 0xE0, 0x3F, 0x7C, 0x07, 0xF0,
  0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x0C,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xBF, 0x03, 0xF3, 0xF9, 0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C,
  0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xEF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xE0,
  0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0,
  0x3E, 0x7C, 0x0F, 0xE0, 0x3E, 0x7C, 0x0F, 0xF0, 0x7E, 0x7C, 0x0F, 0xF0,
  0x7C, 0x7E, 0x0F, 0xF0, 0x7C, 0x3E, 0x1F, 0xF0, 0x7C, 0x3E, 0x1E, 0xF0,
  0x7C, 0x3E, 0x1E, 0xF8, 0xFC, 0x3E, 0x1E, 0x78, 0xF8, 0x1F, 0x3E, 0x78,
  0xF8, 0x1F, 0x3E, 0x78, 0xF8, 0x1F, 0x3E, 0x7C, 0xF8, 0x1F, 0x3C, 0x7D,
  0xF8, 0x1F, 0x3C, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xFC, 0x3D,
  0xF0, 0x0F, 0xF8, 0x3D, 0xF0, 0x0F, 0xF8, 0x3D, 0xE0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0xC7,
  0xC0, 0x3E, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xBE, 0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3F, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xFD, 0xF8, 0x07, 0xF0, 0xFC,
  0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3,
  0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF0,
  0x0F, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x3D, 0xE0, 0x0F, 0xBE, 0x01, 0xE3, 0xC0, 0x7C, 0x7C, 0x0F, 0x07, 0x83,
  0xE0, 0xF8, 0x78, 0x0F, 0x1F, 0x01, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF0,
  0x7C, 0x00, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x1F, 0x7F, 0x10,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7F, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x3F, 0xCF, 0x1F, 0x8F, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x70, 0x3F, 0x7F, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF,
  0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0,
  0xFB, 0xF0, 0x3E, 0xFE, 0x1F, 0xBF, 0x8F, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFB, 0xFE, 0x3E, 0x7F, 0x00, 0x01, 0xC0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE,
  0x7F, 0xF9, 0xF8, 0x2F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x05, 0xF8,
  0x77, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x07, 0x1F, 0x8F, 0xEF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFF, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFE, 0xF8, 0xFE, 0x7C,
  0x01, 0xC0, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0x7E, 0xFC, 0x3E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x06,
  0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x01, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0x07, 0x00, 0x0F, 0xE7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFF, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFD, 0xF8, 0xFC, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x40, 0x0F, 0x9C, 0x1F, 0xCF, 0xFF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x78, 0x7E, 0xFF, 0x3E, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7C, 0x31,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x07,
  0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xE7, 0xFF, 0xEF, 0xF7, 0xF3, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x07, 0xEF, 0x83, 0xF3, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E,
  0x3F, 0x0F, 0x9F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xCF, 0x83, 0xE3, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x1F, 0xBE,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x0E, 0x1F, 0x3F, 0xC7, 0xF3, 0xEF, 0xF9, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0x07, 0xE0,
  0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xF0, 0x7F, 0xF0,
  0x7E, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x3F, 0xF8, 0x3F, 0x07,
  0xFF, 0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0x83, 0xFF, 0x83,
  0xF0, 0x7F, 0xF0, 0x7E, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x3F,
  0xF8, 0x3F, 0x07, 0xC0, 0x00, 0x70, 0x7C, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7C, 0x01, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7,
  0xFF, 0xF7, 0xE1, 0xFB, 0xF0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0x3F, 0x1F, 0x9F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0x70, 0x3E, 0x7F, 0x0F, 0xBF, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03,
  0xEF, 0xC0, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB,
  0xF0, 0x3E, 0xFE, 0x1F, 0xBF, 0x8F, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFD,
  0xFE, 0x3F, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0x00, 0x0F, 0xE7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE1,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFD, 0xF8, 0xFC, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x9F, 0xF9, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x03, 0x80, 0x7F, 0xE3, 0xFF, 0xDF, 0xFE, 0xFE, 0xFB,
  0xE0, 0x4F, 0x80, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x83, 0xFF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xF1, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x7E, 0x7F, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE7, 0xFD, 0xF1, 0xFC, 0x78, 0xFC, 0x07, 0xEF, 0x80, 0xF9, 0xF0,
  0x3F, 0x3F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xF8, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF7,
  0xC1, 0xFC, 0x1F, 0x7C, 0x1F, 0xC3, 0xF7, 0xC1, 0xFC, 0x3E, 0x7E, 0x3F,
  0xC3, 0xE3, 0xE3, 0xDC, 0x3E, 0x3E, 0x3D, 0xE3, 0xE3, 0xE3, 0xDE, 0x7C,
  0x3E, 0x39, 0xE7, 0xC1, 0xF7, 0x9E, 0x7C, 0x1F, 0x78, 0xE7, 0xC1, 0xF7,
  0x8E, 0x78, 0x1F, 0x78, 0xFF, 0x80, 0xF7, 0x0F, 0xF8, 0x0F, 0x70, 0xFF,
  0x80, 0xF7, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x0F,
  0xDF, 0x87, 0xE3, 0xE1, 0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7C, 0xF8, 0x3F, 0x3F,
  0x0F, 0x87, 0xC7, 0xE1, 0xF9, 0xF8, 0x3E, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0xEF, 0x80, 0xF9, 0xF0, 0x3F, 0x3F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x7E, 0x1F,
  0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0xBF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x03, 0xFA,
  0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Bold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 28, 10, 2, -28 },
  { 22, 14, 10, 18, 2, -28 },
  { 40, 20, 28, 21, 1, -28 },
  { 110, 16, 32, 19, 2, -30 },
  { 174, 29, 28, 32, 1, -28 },
  { 276, 23, 28, 24, 1, -28 },
  { 357, 6, 10, 10, 2, -28 },
  { 365, 10, 34, 13, 2, -28 },
  { 408, 10, 34, 13, 1, -28 },
  { 451, 17, 17, 18, 1, -30 },
  { 488, 17, 19, 19, 1, -23 },
  { 529, 7, 9, 10, 1, -4 },
  { 537, 10, 5, 12, 1, -13 },
  { 544, 6, 6, 10, 2, -6 },
  { 549, 16, 28, 16, 0, -28 },
  { 605, 17, 28, 19, 1, -28 },
  { 665, 12, 28, 19, 2, -28 },
  { 707, 17, 28, 19, 1, -28 },
  { 767, 17, 28, 19, 1, -28 },
  { 827, 18, 28, 19, 1, -28 },
  { 890, 16, 28, 19, 2, -28 },
  { 946, 17, 28, 19, 1, -28 },
  { 1006, 17, 28, 19, 1, -28 },
  { 1066, 17, 28, 19, 1, -28 },
  { 1126, 17, 28, 19, 1, -28 },
  { 1186, 6, 22, 10, 2, -22 },
  { 1203, 7, 27, 10, 1, -22 },
  { 1227, 17, 20, 19, 1, -24 },
  { 1270, 17, 12, 19, 1, -20 },
  { 1296, 17, 20, 19, 1, -24 },
  { 1339, 15, 28, 16, 0, -28 },
  { 1392, 27, 31, 30, 2, -28 },
  { 1497, 22, 28, 22, 0, -28 },
  { 1574, 17, 28, 22, 3, -28 },
  { 1634, 18, 28, 21, 2, -28 },
  { 1697, 19, 28, 24, 3, -28 },
  { 1764, 13, 28, 18, 3, -28 },
  { 1810, 13, 28, 18, 3, -28 },
  { 1856, 19, 28, 24, 2, -28 },
  { 1923, 19, 28, 25, 3, -28 },
  { 1990, 11, 28, 13, 1, -28 },
  { 2029, 10, 36, 11, -2, -28 },
  { 2074, 19, 28, 22, 3, -28 },
  { 2141, 14, 28, 18, 3, -28 },
  { 2190, 26, 28, 32, 3, -28 },
  { 2281, 21, 28, 27, 3, -28 },
  { 2355, 22, 28, 25, 2, -28 },
  { 2432, 16, 28, 21, 3, -28 },
  { 2488, 22, 35, 25, 2, -28 },
  { 2585, 19, 28, 22, 3, -28 },
  { 2652, 16, 28, 18, 1, -28 },
  { 2708, 17, 28, 18, 1, -28 },
  { 2768, 19, 28, 24, 3, -28 },
  { 2835, 21, 28, 21, 0, -28 },
  { 2909, 32, 28, 32, 0, -28 },
  { 3021, 21, 28, 21, 0, -28 },
  { 3095, 20, 28, 20, 0, -28 },
  { 3165, 16, 28, 18, 1, -28 },
  { 3221, 9, 34, 12, 2, -28 },
  { 3260, 16, 28, 16, 0, -28 },
  { 3316, 9, 34, 12, 1, -28 },
  { 3355, 19, 17, 21, 1, -28 },
  { 3396, 16, 3, 16, 0, 3 },
  { 3402, 9, 6, 13, 2, -30 },
  { 3409, 16, 22, 20, 1, -22 },
  { 3453, 18, 30, 21, 2, -30 },
  { 3521, 14, 22, 17, 2, -22 },
  { 3560, 17, 30, 21, 2, -30 },
  { 3624, 16, 22, 19, 2, -22 },
  { 3668, 14, 30, 13, 0, -30 },
  { 3721, 17, 31, 21, 2, -22 },
  { 3787, 17, 30, 21, 2, -30 },
  { 3851, 6, 30, 10, 2, -30 },
  { 3874, 9, 39, 10, -1, -30 },
  { 3918, 18, 30, 20, 3, -30 },
  { 3986, 6, 30, 10, 2, -30 },
  { 4009, 27, 22, 32, 2, -22 },
  { 4084, 17, 22, 21, 2, -22 },
  { 4131, 17, 22, 21, 2, -22 },
  { 4178, 18, 31, 21, 2, -22 },
  { 4248, 17, 31, 21, 2, -22 },
  { 4314, 12, 22, 15, 2, -22 },
  { 4347, 14, 22, 16, 1, -22 },
  { 4386, 12, 26, 14, 1, -26 },
  { 4425, 17, 21, 21, 2, -21 },
  { 4470, 19, 21, 19, 0, -21 },
  { 4520, 28, 21, 29, 0, -21 },
  { 4594, 18, 21, 18, 0, -21 },
  { 4642, 19, 30, 19, 0, -21 },
  { 4714, 14, 21, 16, 1, -21 },
  { 4751, 13, 34, 14, 0, -28 },
  { 4807, 4, 39, 18, 7, -30 },
  { 4827, 13, 34, 14, 1, -28 },
  { 4883, 17, 7, 19, 1, -17 },
};

const GFXfont NotoSans_Condensed_Bold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_BOLD39PT7B_H_
