#ifndef _NOTOSANS_CONDENSED_BOLD35PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x78,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF1,
  0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xE0, 0x03, 0x8E, 0x01, 0xC7, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0xCF, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0x71,
  0xC0, 0x38, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x3F, 0x81, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFF, 0x3E, 0xCE, 0x79, 0x80, 0xF3, 0x01, 0xF6, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x06,
  0xF8, 0x0D, 0xFC, 0x1B, 0xFF, 0x3F, 0xBF, 0xFF, 0x7F, 0xFC, 0x3F, 0xE0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x70, 0x0F,
  0xE0, 0x3C, 0x07, 0xFC, 0x0E, 0x01, 0xCF, 0x07, 0x80, 0xF1, 0xC1, 0xC0,
  0x3C, 0x70, 0xF0, 0x0F, 0x1E, 0x3C, 0x03, 0xC7, 0x9E, 0x00, 0xF1, 0xE7,
  0x80, 0x3C, 0x71, 0xC0, 0x0F, 0x1C, 0xF3, 0xF1, 0xCF, 0x39, 0xFE, 0x7F,
  0xDE, 0x7F, 0x8F, 0xE7, 0xBC, 0xF1, 0xF3, 0xCF, 0x3C, 0x00, 0xF3, 0xCF,
  0x00, 0x38, 0xF1, 0xC0, 0x1E, 0x3C, 0x70, 0x07, 0x0F, 0x1C, 0x03, 0xC3,
  0xCF, 0x00, 0xE0, 0xF3, 0xC0, 0x78, 0x3C, 0xF0, 0x1E, 0x07, 0xF8, 0x0F,
  0x01, 0xFE, 0x03, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x1F, 0x3F, 0xF1, 0xF1, 0xF7, 0xCF, 0x9F, 0xBF, 0x7C,
  0xF8, 0xFF, 0xC7, 0xC3, 0xFE, 0x3E, 0x0F, 0xE1, 0xF0, 0x3F, 0x0F, 0xC3,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0x7C, 0x1F, 0xF3, 0xF8,
  0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF0, 0x0F, 0x87, 0x87, 0x87, 0xC3, 0xC3,
  0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x78, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F, 0x0F,
  0x87, 0x87, 0x83, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x04,
  0x38, 0xDF, 0x7F, 0xBF, 0xFF, 0x7F, 0xFF, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x81, 0xF7, 0x87, 0xCF, 0x87, 0x8E, 0x02, 0x18, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0xBC, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1,
  0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3E, 0xF0, 0x7D, 0xE0, 0xFB, 0xE3, 0xE7, 0xC7, 0xC7, 0xFF, 0x8F,
  0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDF, 0x73, 0xE4, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE7,
  0x87, 0xC4, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE3, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x7F, 0xC0,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8,
  0x7F, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0xF8, 0x1C, 0xF8,
  0x3C, 0xF8, 0x38, 0xF8, 0x78, 0xF8, 0x70, 0xF8, 0xF0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x3F,
  0xFC, 0xFF, 0xF9, 0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x81, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF7, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF,
  0xDF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFB,
  0xE1, 0xF7, 0xC7, 0xE7, 0xFF, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0xE0,
  0x7F, 0xF0, 0xFF, 0xF3, 0xF7, 0xE7, 0xC3, 0xCF, 0x07, 0xDE, 0x0F, 0xBE,
  0x1E, 0x7C, 0x7C, 0x7D, 0xF0, 0x7F, 0xE0, 0x7F, 0x01, 0xFF, 0x07, 0xFF,
  0x1F, 0xBF, 0x3E, 0x3E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x83, 0xEF, 0xDF, 0xDF, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE3, 0xF7, 0xFF, 0xEF, 0xFB, 0xCF,
  0xF7, 0x8F, 0xDF, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x0F,
  0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x3D, 0xF7, 0xDF, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x7D, 0xF7, 0xDE, 0x79,
  0xEF, 0x3C, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E,
  0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x3E, 0x00, 0x70,
  0x00, 0x80, 0x00, 0x1F, 0xE3, 0xFF, 0xBF, 0xFE, 0xFF, 0xF6, 0x0F, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0xF0, 0x00, 0xF0, 0xF0, 0x7C, 0x3C, 0x70, 0xFF, 0x9E, 0x78, 0xFF, 0xC7,
  0x3C, 0x78, 0xE3, 0x9C, 0x78, 0xF1, 0xEE, 0x3C, 0x78, 0xF7, 0x1C, 0x3C,
  0x7F, 0x8E, 0x1E, 0x3F, 0xC7, 0x0F, 0x1F, 0xE3, 0x87, 0x8E, 0x71, 0xC3,
  0xC7, 0x38, 0xF3, 0xE7, 0x9C, 0x7F, 0xBF, 0x8F, 0x1F, 0xDF, 0x87, 0x87,
  0xC7, 0x81, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x20, 0x0F,
  0xC1, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xDE, 0x00, 0x79, 0xE0, 0x07, 0x9F, 0x00, 0xF9,
  0xF0, 0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F,
  0xF8, 0x01, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7F, 0x04, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x06, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7F, 0x3E, 0x07, 0xEF, 0x81, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0x81, 0xFB, 0xE0, 0xFC, 0xF8, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xFF, 0x07, 0xFF,
  0xC7, 0xFF, 0xE7, 0xFF, 0xE3, 0xF0, 0x33, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x03,
  0xEF, 0x81, 0xF7, 0xE0, 0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07,
  0xFE, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0xCF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xE0, 0xF8, 0x3E, 0xFF, 0xBF, 0xCF, 0xF3, 0xF0, 0xF8, 0x1F, 0xFC, 0x1F,
  0xBE, 0x0F, 0x9F, 0x0F, 0xCF, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xE1, 0xF3,
  0xE0, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0x7C, 0x3E, 0x3E,
  0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xEF, 0xF7, 0x83, 0xDF, 0xEF, 0x07, 0xBF,
  0xDE, 0x1E, 0x7F, 0xBC, 0x3C, 0xFF, 0x3C, 0x79, 0xFE, 0x78, 0xE3, 0xFC,
  0xF3, 0xC7, 0xF8, 0xF7, 0x8F, 0xF1, 0xEF, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xC1, 0xFE, 0x1F, 0x83, 0xFC, 0x3F,
  0x07, 0xF8, 0x3E, 0x0F, 0xF0, 0x78, 0x1E, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xF7, 0xC3, 0xFD, 0xF0, 0xFF, 0x3E, 0x3F, 0xCF, 0x8F, 0xF1, 0xE3,
  0xFC, 0x7C, 0xFF, 0x1F, 0x3F, 0xC3, 0xEF, 0xF0, 0xFB, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xE1, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC3, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0xE1, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0xCF, 0x87, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7E, 0xF8, 0x3E,
  0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0x83, 0xFF,
  0xC1, 0xF3, 0xE0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0xCF,
  0x83, 0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0x0F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xDF, 0xFE, 0x7C, 0x39, 0xF0, 0x2F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0xFF,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xDF, 0x03, 0xEF, 0x81,
  0xF7, 0xE1, 0xFB, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00,
  0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x7C,
  0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xF0, 0x3C, 0x3E, 0x0F, 0x83, 0xC1, 0xF0,
  0x78, 0x3C, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0x7C, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x00, 0xFF, 0xC0, 0x7C, 0x07, 0xBE, 0x03, 0xE0, 0x7D, 0xF0,
  0x3F, 0x03, 0xE7, 0x81, 0xF8, 0x1F, 0x3E, 0x0F, 0xE0, 0xF9, 0xF0, 0x7F,
  0x07, 0x8F, 0x87, 0xF8, 0x7C, 0x3C, 0x3F, 0xC3, 0xE1, 0xE1, 0xEE, 0x1F,
  0x0F, 0x8F, 0x78, 0xF0, 0x7C, 0x7B, 0xC7, 0x83, 0xE7, 0x9E, 0x7C, 0x0F,
  0x3C, 0xF3, 0xE0, 0x79, 0xE3, 0x9F, 0x03, 0xCF, 0x1E, 0xF0, 0x1F, 0x70,
  0xF7, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00,
  0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xCF, 0x81, 0xF0,
  0xF8, 0x3E, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x7C, 0x03, 0xEF, 0x80,
  0x7D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x1F,
  0x83, 0xE3, 0xE0, 0x7E, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xDF, 0x03, 0xF7,
  0xC0, 0xF9, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xF1, 0xE0, 0x7C,
  0xF8, 0x0F, 0x3E, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x07,
  0x87, 0x83, 0xC7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x80,
  0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE1, 0xC7, 0xC2, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x07, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xF1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x3F, 0xFC, 0xFE, 0xFF, 0xFD, 0xFE, 0x79, 0xF8, 0xF0,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFB, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x3E, 0xFF, 0xFC,
  0xFF, 0xFC, 0xF7, 0xF8, 0xF3, 0xF0, 0x00, 0x80, 0x7F, 0xC7, 0xFE, 0x7F,
  0xF3, 0xFF, 0x3E, 0x09, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC1, 0x7F, 0xF9, 0xFF, 0xC7,
  0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x02, 0x1F, 0x1F, 0x9F, 0x3F, 0xDF, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7C, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7C,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x0F, 0x8F, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xF1, 0xF3, 0xE7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x01, 0x1F, 0xDE, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x03, 0xE0, 0x7F,
  0xC3, 0xFC, 0x3F, 0xE1, 0xF1, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0xE7,
  0xFF, 0x3F, 0xF9, 0xFF, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x02, 0x00, 0x1F, 0xCF, 0x3F, 0xDF, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7C, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7C,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x40, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x20, 0xFB, 0xF9, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF,
  0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xF8, 0x37, 0xFF, 0xFF, 0x90, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x06, 0x1F, 0x1F,
  0x1F, 0x1F, 0x04, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFE, 0xFE, 0xFC, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF0,
  0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x10, 0xF3, 0xF8,
  0xFC, 0xF7, 0xFD, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0x00, 0x41, 0xE7, 0xF3, 0xDF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF0, 0x00, 0x80, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7E, 0x7C, 0x3E, 0x7C, 0x1F, 0x78,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78,
  0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xF0, 0x00, 0x40, 0xF3, 0xF8, 0xF7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8,
  0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x3E, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFB, 0xF8, 0xF9, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x02, 0x00, 0x1F,
  0xCF, 0x3F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x3F, 0x7C, 0x1F, 0x78,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78,
  0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x0F,
  0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x5E, 0x3F, 0xCF, 0xFB, 0xFF, 0xFF,
  0xFE, 0x7F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x02, 0x03, 0xFE,
  0x7F, 0xF7, 0xFF, 0xFC, 0xEF, 0x82, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFC, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0xF3, 0xFE, 0x3F, 0xC3, 0xF8, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xBC, 0x7E, 0x78, 0xF8,
  0x0F, 0xBC, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE1, 0xE1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0xDF, 0x01, 0xEF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0x07, 0xBC, 0x1F, 0x87, 0xDF, 0x0F,
  0xC3, 0xEF, 0x8F, 0xE1, 0xF7, 0xC7, 0xF0, 0xF1, 0xE3, 0xBC, 0xF8, 0xF1,
  0xDE, 0x7C, 0x7C, 0xE7, 0x3E, 0x3E, 0xF3, 0x9E, 0x0F, 0x79, 0xCF, 0x07,
  0xB8, 0xEF, 0x83, 0xDC, 0x7F, 0xC1, 0xEE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C,
  0x1F, 0x7C, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x3E, 0x7C, 0x3E, 0x7C,
  0x7C, 0x3E, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xBE, 0x0F, 0x9F, 0x07,
  0xCF, 0x83, 0xE3, 0xC1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0x7C, 0x1E,
  0x3C, 0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0xFC,
  0x1F, 0x87, 0xF0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF9, 0xFE, 0x3F, 0x87, 0xE0, 0xFF, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xF0,
  0x7E, 0x07, 0xC0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F,
  0x83, 0xF8, 0x7F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x0F, 0xE3, 0xF0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x7F,
  0x0F, 0xE1, 0xF8, 0x20, 0x00, 0x7E, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xD0, 0x02, 0x00,
};

const GFXglyph NotoSans_Condensed_Bold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 25, 9, 2, -25 },
  { 17, 12, 9, 16, 2, -25 },
  { 31, 17, 25, 19, 1, -25 },
  { 85, 15, 29, 17, 1, -27 },
  { 140, 26, 25, 28, 1, -25 },
  { 222, 21, 25, 21, 1, -25 },
  { 288, 5, 9, 9, 2, -25 },
  { 294, 9, 31, 11, 2, -25 },
  { 329, 9, 31, 11, 1, -25 },
  { 364, 15, 15, 17, 1, -27 },
  { 393, 15, 17, 17, 1, -21 },
  { 425, 6, 9, 9, 1, -4 },
  { 432, 9, 5, 11, 1, -12 },
  { 438, 5, 5, 9, 2, -5 },
  { 442, 14, 25, 14, 0, -25 },
  { 486, 15, 25, 17, 1, -25 },
  { 533, 11, 25, 17, 2, -25 },
  { 568, 15, 25, 17, 1, -25 },
  { 615, 15, 25, 17, 1, -25 },
  { 662, 16, 25, 17, 1, -25 },
  { 712, 14, 25, 17, 2, -25 },
  { 756, 15, 25, 17, 1, -25 },
  { 803, 15, 25, 17, 1, -25 },
  { 850, 15, 25, 17, 1, -25 },
  { 897, 15, 25, 17, 1, -25 },
  { 944, 5, 19, 9, 2, -19 },
  { 956, 6, 24, 9, 1, -19 },
  { 974, 15, 17, 17, 1, -21 },
  { 1006, 15, 11, 17, 1, -18 },
  { 1027, 15, 17, 17, 1, -21 },
  { 1059, 13, 25, 14, 0, -25 },
  { 1100, 25, 28, 27, 1, -25 },
  { 1188, 20, 25, 20, 0, -25 },
  { 1251, 16, 25, 20, 2, -25 },
  { 1301, 16, 25, 19, 2, -25 },
  { 1351, 18, 25, 21, 2, -25 },
  { 1408, 12, 25, 17, 3, -25 },
  { 1446, 12, 25, 16, 3, -25 },
  { 1484, 17, 25, 21, 2, -25 },
  { 1538, 17, 25, 22, 3, -25 },
  { 1592, 10, 25, 12, 1, -25 },
  { 1624, 10, 32, 10, -2, -25 },
  { 1664, 17, 25, 20, 3, -25 },
  { 1718, 13, 25, 16, 2, -25 },
  { 1759, 23, 25, 29, 3, -25 },
  { 1831, 18, 25, 24, 3, -25 },
  { 1888, 19, 25, 23, 2, -25 },
  { 1948, 15, 25, 19, 2, -25 },
  { 1995, 19, 31, 23, 2, -25 },
  { 2069, 17, 25, 19, 2, -25 },
  { 2123, 14, 25, 16, 1, -25 },
  { 2167, 15, 25, 17, 1, -25 },
  { 2214, 17, 25, 22, 2, -25 },
  { 2268, 19, 25, 19, 0, -25 },
  { 2328, 29, 25, 28, 0, -25 },
  { 2419, 19, 25, 19, 0, -25 },
  { 2479, 18, 25, 18, 0, -25 },
  { 2536, 15, 25, 16, 1, -25 },
  { 2583, 8, 31, 11, 2, -25 },
  { 2614, 14, 25, 14, 0, -25 },
  { 2658, 8, 31, 11, 1, -25 },
  { 2689, 17, 16, 19, 1, -25 },
  { 2723, 14, 2, 14, 0, 3 },
  { 2727, 9, 6, 11, 1, -27 },
  { 2734, 15, 20, 18, 1, -20 },
  { 2772, 16, 27, 19, 2, -27 },
  { 2826, 13, 20, 15, 1, -20 },
  { 2859, 16, 27, 19, 1, -27 },
  { 2913, 15, 19, 17, 1, -19 },
  { 2949, 13, 27, 11, 0, -27 },
  { 2993, 16, 28, 19, 1, -20 },
  { 3049, 15, 27, 19, 2, -27 },
  { 3100, 5, 27, 9, 2, -27 },
  { 3117, 8, 35, 9, -1, -27 },
  { 3152, 16, 27, 18, 2, -27 },
  { 3206, 5, 27, 9, 2, -27 },
  { 3223, 24, 20, 29, 2, -20 },
  { 3283, 15, 20, 19, 2, -20 },
  { 3321, 16, 20, 19, 1, -20 },
  { 3361, 16, 28, 19, 2, -20 },
  { 3417, 16, 28, 19, 1, -20 },
  { 3473, 11, 20, 13, 2, -20 },
  { 3501, 12, 20, 14, 1, -20 },
  { 3531, 11, 23, 13, 1, -23 },
  { 3563, 15, 19, 19, 2, -19 },
  { 3599, 17, 19, 17, 0, -19 },
  { 3640, 25, 19, 26, 0, -19 },
  { 3700, 16, 19, 16, 0, -19 },
  { 3738, 17, 27, 17, 0, -19 },
  { 3796, 12, 19, 14, 1, -19 },
  { 3825, 11, 31, 13, 0, -25 },
  { 3868, 4, 35, 17, 6, -27 },
  { 3886, 11, 31, 13, 1, -25 },
  { 3929, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_Bold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_BOLD35PT7B_H_
