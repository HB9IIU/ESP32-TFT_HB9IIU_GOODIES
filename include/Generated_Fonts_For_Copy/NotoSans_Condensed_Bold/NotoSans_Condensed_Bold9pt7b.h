#ifndef _NOTOSANS_CONDENSED_BOLD9PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xF6, 0x37, 0xD5, 0xF6, 0x30, 0x27, 0xE6, 0x3B, 0x62,
  0x45, 0x52, 0xA5, 0xB5, 0xA5, 0x49, 0x80, 0x21, 0xC5, 0x18, 0xEB, 0x67,
  0xC0, 0xD0, 0x6B, 0x6C, 0x98, 0xC9, 0x34, 0xB0, 0x2F, 0x67, 0x2F, 0x22,
  0x60, 0xE0, 0xC0, 0x32, 0x44, 0x48, 0x27, 0xDD, 0xDD, 0x70, 0x7C, 0x92,
  0x40, 0x2F, 0x13, 0x24, 0xF0, 0x2F, 0x16, 0x11, 0xF0, 0x37, 0x7B, 0xF3,
  0x74, 0x71, 0x1F, 0x27, 0xCF, 0xDD, 0x70, 0xF1, 0x22, 0x64, 0x27, 0xD6,
  0xD9, 0x70, 0x2F, 0x9D, 0x71, 0x60, 0xD0, 0xC0, 0xC0, 0x70, 0x3C, 0x61,
  0xF0, 0xF0, 0xC3, 0x68, 0x5C, 0xB4, 0x10, 0x7C, 0xBA, 0xAD, 0x5B, 0xC8,
  0x0E, 0x00, 0x32, 0x94, 0xED, 0xC4, 0xEB, 0xEB, 0xBE, 0x1B, 0x91, 0x8C,
  0x21, 0xC0, 0xE9, 0x99, 0xBE, 0xF3, 0xC9, 0xC0, 0xF3, 0xC9, 0x00, 0x13,
  0xD1, 0xBC, 0xA5, 0xE0, 0x99, 0xF9, 0x99, 0xE9, 0x25, 0xC0, 0x24, 0x92,
  0x4E, 0xBE, 0xCE, 0xAB, 0x92, 0x49, 0xC0, 0xCF, 0x5D, 0x75, 0xB6, 0x90,
  0xDD, 0xFB, 0xB9, 0x23, 0xD3, 0x9C, 0xA5, 0xE0, 0xF6, 0xE9, 0x00, 0x23,
  0xD3, 0x9C, 0xA5, 0xE3, 0x08, 0xEB, 0xEE, 0xAB, 0x27, 0xC6, 0x39, 0xE0,
  0xF6, 0x66, 0x66, 0x99, 0x99, 0x9E, 0x9A, 0x94, 0xA5, 0x10, 0x93, 0xB5,
  0xAB, 0x76, 0xCD, 0x80, 0xDB, 0x88, 0xC5, 0x6C, 0xDA, 0x98, 0x42, 0x10,
  0xF2, 0x24, 0xCF, 0xEA, 0xAC, 0xC4, 0x42, 0x23, 0xD5, 0x5C, 0x22, 0x95,
  0x10, 0xF0, 0xC4, 0x71, 0x7D, 0x70, 0x88, 0xEA, 0xBA, 0xE0, 0x7C, 0xCC,
  0x70, 0x11, 0x7D, 0xDD, 0x70, 0x7D, 0xFC, 0x70, 0x6B, 0xA4, 0x90, 0x7D,
  0xDD, 0x71, 0x70, 0x93, 0xDB, 0x68, 0xC5, 0x54, 0xC5, 0x55, 0xC0, 0x88,
  0xBE, 0xCA, 0xB0, 0xFE, 0xFE, 0x9A, 0x69, 0xA4, 0xF6, 0xDA, 0x7D, 0xDD,
  0x70, 0xEA, 0xBA, 0xE8, 0x80, 0x7D, 0xDD, 0x71, 0x10, 0xEA, 0x80, 0x79,
  0x9E, 0x5D, 0x24, 0xC0, 0xB6, 0xDE, 0x9D, 0x76, 0x60, 0x97, 0xE9, 0xB3,
  0x66, 0x80, 0xD6, 0x66, 0xD0, 0x9D, 0x76, 0x66, 0xC0, 0xE5, 0x2E, 0x69,
  0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF9,
};

const GFXglyph NotoSans_Condensed_Bold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 4, 0, -7 },
  { 12, 7, 7, 7, 0, -7 },
  { 19, 6, 7, 6, 0, -7 },
  { 25, 2, 2, 2, 0, -6 },
  { 26, 3, 7, 3, 0, -6 },
  { 29, 3, 7, 3, 0, -6 },
  { 32, 4, 4, 4, 0, -7 },
  { 34, 4, 4, 4, 0, -5 },
  { 36, 2, 2, 2, 0, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 2, 1, 2, 0, -1 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 3, 6, 4, 0, -6 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 4, 7, 4, 0, -7 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 4, 6, 4, 0, -6 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 4, 7, 4, 0, -7 },
  { 78, 2, 5, 2, 0, -5 },
  { 80, 2, 6, 2, 0, -5 },
  { 82, 4, 4, 4, 0, -5 },
  { 84, 4, 3, 4, 0, -5 },
  { 86, 4, 4, 4, 0, -5 },
  { 88, 3, 7, 4, 0, -7 },
  { 91, 7, 7, 7, 0, -6 },
  { 98, 5, 6, 5, 0, -6 },
  { 102, 4, 6, 5, 1, -6 },
  { 105, 5, 7, 5, 0, -7 },
  { 110, 4, 6, 6, 1, -6 },
  { 113, 3, 6, 4, 1, -6 },
  { 116, 3, 6, 4, 1, -6 },
  { 119, 5, 7, 6, 0, -7 },
  { 124, 4, 6, 6, 1, -6 },
  { 127, 3, 6, 3, 0, -6 },
  { 130, 3, 8, 3, -1, -6 },
  { 133, 4, 6, 5, 1, -6 },
  { 136, 3, 6, 4, 1, -6 },
  { 139, 6, 6, 7, 1, -6 },
  { 144, 4, 6, 6, 1, -6 },
  { 147, 5, 7, 6, 0, -7 },
  { 152, 3, 6, 5, 1, -6 },
  { 155, 5, 9, 6, 0, -7 },
  { 161, 4, 6, 5, 1, -6 },
  { 164, 4, 7, 4, 0, -7 },
  { 168, 4, 6, 4, 0, -6 },
  { 171, 4, 6, 6, 1, -6 },
  { 174, 5, 6, 5, 0, -6 },
  { 178, 7, 6, 7, 0, -6 },
  { 184, 5, 6, 5, 0, -6 },
  { 188, 5, 6, 5, 0, -6 },
  { 192, 4, 6, 4, 0, -6 },
  { 195, 2, 7, 3, 1, -6 },
  { 197, 4, 6, 4, 0, -6 },
  { 200, 2, 7, 3, 0, -6 },
  { 202, 5, 4, 5, 0, -6 },
  { 205, 4, 1, 4, 0, 1 },
  { 206, 3, 2, 3, 0, -7 },
  { 207, 4, 5, 5, 0, -5 },
  { 210, 4, 7, 5, 1, -7 },
  { 214, 4, 5, 4, 0, -5 },
  { 217, 4, 7, 5, 0, -7 },
  { 221, 4, 5, 4, 0, -5 },
  { 224, 3, 7, 3, 0, -7 },
  { 227, 4, 7, 5, 0, -5 },
  { 231, 3, 7, 5, 1, -7 },
  { 234, 2, 7, 2, 0, -7 },
  { 236, 2, 9, 2, 0, -7 },
  { 239, 4, 7, 5, 1, -7 },
  { 243, 1, 7, 2, 1, -7 },
  { 244, 6, 5, 7, 1, -5 },
  { 248, 3, 5, 5, 1, -5 },
  { 250, 4, 5, 5, 0, -5 },
  { 253, 4, 7, 5, 1, -5 },
  { 257, 4, 7, 5, 0, -5 },
  { 261, 2, 5, 3, 1, -5 },
  { 263, 3, 5, 4, 0, -5 },
  { 265, 3, 6, 3, 0, -6 },
  { 268, 3, 5, 5, 1, -5 },
  { 270, 4, 5, 4, 0, -5 },
  { 273, 7, 5, 7, 0, -5 },
  { 278, 4, 5, 4, 0, -5 },
  { 281, 4, 7, 4, 0, -5 },
  { 285, 3, 5, 4, 0, -5 },
  { 287, 3, 7, 3, 0, -6 },
  { 290, 1, 9, 4, 2, -7 },
  { 292, 3, 7, 3, 0, -6 },
  { 295, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_Bold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_BOLD9PT7B_H_
