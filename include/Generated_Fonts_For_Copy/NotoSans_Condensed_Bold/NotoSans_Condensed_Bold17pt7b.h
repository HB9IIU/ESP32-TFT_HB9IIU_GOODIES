#ifndef _NOTOSANS_CONDENSED_BOLD17PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x6D, 0xB6, 0x0B, 0xE0, 0xDF, 0x3C, 0xF3, 0x1B, 0x0D, 0x86,
  0x8F, 0xF7, 0xF9, 0xB0, 0xD9, 0xFF, 0xFF, 0x92, 0x09, 0x0D, 0x80, 0x10,
  0x73, 0xFE, 0xAD, 0x1E, 0x1E, 0x0E, 0x1F, 0x2F, 0xF7, 0xE1, 0x02, 0x00,
  0xF1, 0x8F, 0x18, 0x9B, 0x09, 0xB0, 0x9A, 0x0F, 0x6F, 0xF7, 0xB0, 0xDB,
  0x0D, 0xB1, 0x9B, 0x18, 0xB3, 0x0E, 0x3E, 0x0F, 0x87, 0x61, 0xD8, 0x3E,
  0x0F, 0x07, 0xDD, 0xBF, 0xE7, 0x98, 0xE7, 0xF8, 0xFF, 0xFF, 0x36, 0x6C,
  0xCC, 0xCC, 0xCC, 0xCE, 0x66, 0x30, 0xE3, 0x0C, 0x63, 0x0C, 0x63, 0x19,
  0xCC, 0x63, 0x33, 0x00, 0x18, 0x18, 0x7E, 0xFF, 0x3C, 0x3C, 0x66, 0x30,
  0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0xFB, 0x60, 0xFF, 0xFE, 0x5F, 0x00,
  0x0E, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0xC1, 0x86, 0x00, 0x79,
  0xFB, 0x36, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9B, 0xF3, 0xC0, 0x19, 0xDF,
  0xB5, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0xF9, 0xFA, 0x30, 0x70, 0xC3, 0x86,
  0x18, 0x71, 0xC3, 0xFF, 0xF0, 0xFD, 0xFA, 0x30, 0x61, 0xCF, 0x1F, 0x07,
  0x0F, 0x1F, 0xF7, 0xC0, 0x0E, 0x0E, 0x1E, 0x16, 0x36, 0x26, 0x66, 0xC6,
  0xFF, 0xFF, 0x06, 0x06, 0xFD, 0xFB, 0x06, 0x0F, 0x9F, 0xA3, 0x87, 0x0F,
  0x1B, 0xF7, 0xC0, 0x3C, 0xFB, 0x86, 0x0D, 0x9F, 0xB3, 0xE3, 0xC7, 0x9F,
  0xF3, 0xC0, 0xFF, 0xFF, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0x38, 0x30, 0x7D, 0xFB, 0x3E, 0x6F, 0xCF, 0x3F, 0x67, 0xC7, 0x8F, 0xF3,
  0xE0, 0x3C, 0x7E, 0x66, 0xE7, 0xE7, 0x67, 0x7F, 0x3B, 0x06, 0x06, 0x7C,
  0x78, 0xFC, 0x00, 0x17, 0xC0, 0xFC, 0x00, 0x07, 0xDB, 0x00, 0x06, 0x3D,
  0xE7, 0x0E, 0x07, 0x83, 0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81,
  0xC1, 0xE0, 0xF1, 0xEF, 0x38, 0x40, 0xFD, 0xFA, 0x38, 0x61, 0xC3, 0x0C,
  0x18, 0x00, 0x60, 0xC1, 0x80, 0x1F, 0x86, 0x19, 0x81, 0xE7, 0xBD, 0x93,
  0xB6, 0x64, 0xCC, 0xD9, 0xDB, 0x79, 0xFB, 0x00, 0x38, 0x43, 0xF8, 0x1E,
  0x07, 0x81, 0xE0, 0xF8, 0x37, 0x0C, 0xC3, 0x31, 0xFE, 0x7F, 0x98, 0x6E,
  0x1B, 0x87, 0xFE, 0xFE, 0xE7, 0xE7, 0xE6, 0xFC, 0xFE, 0xE7, 0xE7, 0xE7,
  0xFE, 0xFC, 0x3F, 0x7E, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE1,
  0x7E, 0x3E, 0xFC, 0x7F, 0x39, 0xDC, 0x6E, 0x3F, 0x1F, 0x8F, 0xC6, 0xE3,
  0x73, 0xBF, 0x9F, 0x80, 0xFF, 0xFE, 0x38, 0xE3, 0xFF, 0xF8, 0xE3, 0x8F,
  0xFF, 0xFF, 0xFE, 0x38, 0xE3, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0x3F, 0x7F,
  0x60, 0xE0, 0xC0, 0xCF, 0xCF, 0xC3, 0xE3, 0xE3, 0x7F, 0x3F, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70,
  0xFB, 0xCC, 0x63, 0x18, 0xC6, 0x31, 0x9F, 0xF0, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0xFB, 0xD8, 0xE3, 0xF3, 0xBB, 0x9D, 0x8F, 0xC7,
  0xC3, 0xF1, 0xD8, 0xEE, 0x73, 0x39, 0xDC, 0x70, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFD, 0x9B, 0xD9,
  0xFD, 0x9F, 0xD9, 0x7C, 0xF7, 0xCF, 0x7C, 0xF7, 0xCE, 0x7C, 0x67, 0xE1,
  0xF8, 0xFC, 0x7B, 0x3D, 0x9E, 0xEF, 0x37, 0x9F, 0xC7, 0xE3, 0xF0, 0xF8,
  0x70, 0x3E, 0x3F, 0xB8, 0xFC, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE3, 0xF1,
  0xDF, 0xC7, 0xC0, 0xFD, 0xFF, 0x9F, 0x3E, 0x7D, 0xFF, 0xFC, 0xE1, 0xC3,
  0x87, 0x00, 0x3E, 0x3F, 0xB8, 0xFC, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE3,
  0xF1, 0xDF, 0xC7, 0xC0, 0x70, 0x38, 0x0E, 0xFC, 0xFE, 0xE6, 0xE7, 0xE6,
  0xFE, 0xFC, 0xEC, 0xEE, 0xE6, 0xE7, 0xE3, 0x7F, 0xFC, 0x70, 0xE1, 0xE3,
  0xC7, 0x0E, 0x3F, 0xFE, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0x7F, 0x3E, 0xC1, 0xF0, 0xD8, 0xEC, 0x66, 0x31, 0x98, 0xD8,
  0x6C, 0x36, 0x0F, 0x07, 0x03, 0x80, 0xC3, 0x1F, 0x8C, 0x7E, 0x79, 0x99,
  0xE6, 0x67, 0x99, 0x9E, 0xE6, 0xDB, 0x9F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0x8F, 0x0E, 0x18, 0xE3, 0xBB, 0x8D, 0x86, 0xC3, 0xE0, 0xE0, 0x70, 0x7C,
  0x36, 0x3B, 0x98, 0xDC, 0x70, 0xE3, 0xB1, 0x9D, 0xC6, 0xC3, 0x61, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xFE, 0xFE, 0x06, 0x0C, 0x1C,
  0x18, 0x38, 0x30, 0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCF, 0xF0, 0xC0, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x18,
  0x30, 0x70, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x08, 0x0E,
  0x07, 0x06, 0xC3, 0x63, 0x1B, 0x8E, 0xFF, 0xFC, 0xE6, 0x30, 0xFC, 0x98,
  0x3B, 0xFF, 0xF9, 0xF3, 0xFF, 0xF6, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xFE,
  0xE6, 0xC6, 0xC7, 0xC6, 0xE6, 0xFE, 0xDC, 0x7F, 0xAC, 0x30, 0xC3, 0x0C,
  0x3F, 0x7C, 0x06, 0x0C, 0x18, 0x37, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F,
  0xF7, 0x60, 0x7D, 0xDB, 0x1F, 0xFF, 0xF8, 0x30, 0x7E, 0x7C, 0x3C, 0xF7,
  0x1C, 0xFB, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x7F, 0xDF, 0x1E, 0x3C,
  0x78, 0xF1, 0xFF, 0x76, 0x0E, 0x3F, 0xEF, 0x80, 0xC1, 0x83, 0x06, 0x0D,
  0xFF, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x60, 0xF4, 0xFF, 0xFF, 0xC0,
  0x33, 0x10, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC1, 0xC6, 0xCC, 0xDC, 0xD8, 0xF8, 0xEC, 0xCE, 0xC6, 0xC7, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xEF, 0xFF, 0xE6, 0x7C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x30, 0xDF, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6,
  0x7D, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0x7C, 0xDE, 0xEE, 0xE6, 0xC6,
  0xC7, 0xC6, 0xE6, 0xFE, 0xDC, 0xC0, 0xC0, 0xC0, 0xC0, 0x7F, 0xDF, 0x1E,
  0x3C, 0x78, 0xF1, 0xFF, 0x76, 0x0C, 0x18, 0x30, 0x60, 0xDF, 0xF9, 0x8C,
  0x63, 0x18, 0xC0, 0xFE, 0x71, 0xE7, 0x8E, 0x7F, 0xF8, 0x31, 0xCF, 0xFF,
  0x71, 0xC7, 0x1C, 0x71, 0xF3, 0xC0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF9,
  0xFF, 0x7E, 0xE3, 0x67, 0x66, 0x66, 0x76, 0x3C, 0x3C, 0x3C, 0x18, 0xE7,
  0x36, 0x73, 0x6F, 0x76, 0xD6, 0x6D, 0x67, 0x9E, 0x39, 0xE3, 0x9C, 0x39,
  0xC0, 0xE7, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7E, 0x66, 0xE7, 0xE3, 0x67,
  0x66, 0x66, 0x36, 0x3C, 0x3C, 0x1C, 0x18, 0x18, 0x38, 0x70, 0x70, 0x7D,
  0xF1, 0xC6, 0x38, 0xC6, 0x3F, 0xFC, 0x19, 0xCC, 0x63, 0x1B, 0xDC, 0x31,
  0x8C, 0x63, 0x1C, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7, 0x18, 0xC6,
  0x31, 0xE7, 0x73, 0x18, 0xC6, 0x73, 0x00, 0xF3, 0x7C,
};

const GFXglyph NotoSans_Condensed_Bold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 12, 4, 1, -12 },
  { 6, 6, 4, 8, 1, -12 },
  { 9, 9, 12, 9, 0, -12 },
  { 23, 7, 14, 8, 1, -13 },
  { 36, 12, 12, 14, 1, -12 },
  { 54, 10, 12, 10, 0, -12 },
  { 69, 2, 4, 4, 1, -12 },
  { 70, 4, 15, 5, 1, -12 },
  { 78, 5, 15, 5, 0, -12 },
  { 88, 8, 7, 8, 0, -13 },
  { 95, 7, 8, 8, 1, -10 },
  { 102, 3, 4, 4, 1, -2 },
  { 104, 5, 3, 5, 0, -6 },
  { 106, 3, 3, 4, 1, -3 },
  { 108, 7, 12, 7, 0, -12 },
  { 119, 7, 12, 8, 1, -12 },
  { 130, 5, 12, 8, 1, -12 },
  { 138, 7, 12, 8, 1, -12 },
  { 149, 7, 12, 8, 1, -12 },
  { 160, 8, 12, 8, 0, -12 },
  { 172, 7, 12, 8, 1, -12 },
  { 183, 7, 12, 8, 1, -12 },
  { 194, 8, 12, 8, 0, -12 },
  { 206, 7, 12, 8, 1, -12 },
  { 217, 8, 12, 8, 0, -12 },
  { 229, 3, 9, 5, 1, -9 },
  { 233, 3, 11, 5, 1, -9 },
  { 238, 7, 8, 8, 1, -10 },
  { 245, 7, 6, 8, 1, -9 },
  { 251, 7, 8, 8, 1, -10 },
  { 258, 7, 12, 7, 0, -12 },
  { 269, 11, 13, 13, 1, -12 },
  { 287, 10, 12, 10, 0, -12 },
  { 302, 8, 12, 10, 1, -12 },
  { 314, 8, 12, 9, 1, -12 },
  { 326, 9, 12, 10, 1, -12 },
  { 340, 6, 12, 8, 1, -12 },
  { 349, 6, 12, 8, 1, -12 },
  { 358, 8, 12, 10, 1, -12 },
  { 370, 9, 12, 11, 1, -12 },
  { 384, 5, 12, 6, 0, -12 },
  { 392, 5, 16, 5, -1, -12 },
  { 402, 9, 12, 10, 1, -12 },
  { 416, 6, 12, 8, 1, -12 },
  { 425, 12, 12, 14, 1, -12 },
  { 443, 9, 12, 12, 1, -12 },
  { 457, 9, 12, 11, 1, -12 },
  { 471, 7, 12, 9, 1, -12 },
  { 482, 9, 15, 11, 1, -12 },
  { 499, 8, 12, 9, 1, -12 },
  { 511, 6, 12, 8, 1, -12 },
  { 520, 8, 12, 8, 0, -12 },
  { 532, 8, 12, 11, 1, -12 },
  { 544, 9, 12, 9, 0, -12 },
  { 558, 14, 12, 14, 0, -12 },
  { 579, 9, 12, 9, 0, -12 },
  { 593, 9, 12, 9, 0, -12 },
  { 607, 8, 12, 8, 0, -12 },
  { 619, 4, 15, 5, 1, -12 },
  { 627, 7, 12, 7, 0, -12 },
  { 638, 4, 15, 5, 0, -12 },
  { 646, 9, 7, 9, 0, -12 },
  { 654, 7, 2, 7, 0, 1 },
  { 656, 4, 3, 6, 1, -13 },
  { 658, 7, 9, 9, 1, -9 },
  { 666, 8, 13, 9, 1, -13 },
  { 679, 6, 9, 7, 1, -9 },
  { 686, 7, 13, 9, 1, -13 },
  { 698, 7, 9, 8, 1, -9 },
  { 706, 6, 13, 6, 0, -13 },
  { 716, 7, 13, 9, 1, -9 },
  { 728, 7, 13, 9, 1, -13 },
  { 740, 2, 13, 4, 1, -13 },
  { 744, 4, 17, 4, -1, -13 },
  { 753, 8, 13, 9, 1, -13 },
  { 766, 2, 13, 4, 1, -13 },
  { 770, 12, 9, 14, 1, -9 },
  { 784, 7, 9, 9, 1, -9 },
  { 792, 7, 9, 9, 1, -9 },
  { 800, 8, 13, 9, 1, -9 },
  { 813, 7, 13, 9, 1, -9 },
  { 825, 5, 9, 6, 1, -9 },
  { 831, 5, 9, 7, 1, -9 },
  { 837, 6, 11, 6, 0, -11 },
  { 846, 7, 9, 9, 1, -9 },
  { 854, 8, 9, 8, 0, -9 },
  { 863, 12, 9, 12, 0, -9 },
  { 877, 8, 9, 8, 0, -9 },
  { 886, 8, 13, 8, 0, -9 },
  { 899, 6, 9, 7, 0, -9 },
  { 906, 5, 15, 6, 0, -12 },
  { 916, 2, 17, 8, 3, -13 },
  { 921, 5, 15, 6, 1, -12 },
  { 931, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Bold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_BOLD17PT7B_H_
