#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_Condensed_Bold
// Headers: 67

#include "NotoSans_Condensed_Bold6pt7b.h"
#include "NotoSans_Condensed_Bold7pt7b.h"
#include "NotoSans_Condensed_Bold8pt7b.h"
#include "NotoSans_Condensed_Bold9pt7b.h"
#include "NotoSans_Condensed_Bold10pt7b.h"
#include "NotoSans_Condensed_Bold11pt7b.h"
#include "NotoSans_Condensed_Bold12pt7b.h"
#include "NotoSans_Condensed_Bold13pt7b.h"
#include "NotoSans_Condensed_Bold14pt7b.h"
#include "NotoSans_Condensed_Bold15pt7b.h"
#include "NotoSans_Condensed_Bold16pt7b.h"
#include "NotoSans_Condensed_Bold17pt7b.h"
#include "NotoSans_Condensed_Bold18pt7b.h"
#include "NotoSans_Condensed_Bold19pt7b.h"
#include "NotoSans_Condensed_Bold20pt7b.h"
#include "NotoSans_Condensed_Bold21pt7b.h"
#include "NotoSans_Condensed_Bold22pt7b.h"
#include "NotoSans_Condensed_Bold23pt7b.h"
#include "NotoSans_Condensed_Bold24pt7b.h"
#include "NotoSans_Condensed_Bold25pt7b.h"
#include "NotoSans_Condensed_Bold26pt7b.h"
#include "NotoSans_Condensed_Bold27pt7b.h"
#include "NotoSans_Condensed_Bold28pt7b.h"
#include "NotoSans_Condensed_Bold29pt7b.h"
#include "NotoSans_Condensed_Bold30pt7b.h"
#include "NotoSans_Condensed_Bold31pt7b.h"
#include "NotoSans_Condensed_Bold32pt7b.h"
#include "NotoSans_Condensed_Bold33pt7b.h"
#include "NotoSans_Condensed_Bold34pt7b.h"
#include "NotoSans_Condensed_Bold35pt7b.h"
#include "NotoSans_Condensed_Bold36pt7b.h"
#include "NotoSans_Condensed_Bold37pt7b.h"
#include "NotoSans_Condensed_Bold38pt7b.h"
#include "NotoSans_Condensed_Bold39pt7b.h"
#include "NotoSans_Condensed_Bold40pt7b.h"
#include "NotoSans_Condensed_Bold41pt7b.h"
#include "NotoSans_Condensed_Bold42pt7b.h"
#include "NotoSans_Condensed_Bold43pt7b.h"
#include "NotoSans_Condensed_Bold44pt7b.h"
#include "NotoSans_Condensed_Bold45pt7b.h"
#include "NotoSans_Condensed_Bold46pt7b.h"
#include "NotoSans_Condensed_Bold47pt7b.h"
#include "NotoSans_Condensed_Bold48pt7b.h"
#include "NotoSans_Condensed_Bold49pt7b.h"
#include "NotoSans_Condensed_Bold50pt7b.h"
#include "NotoSans_Condensed_Bold51pt7b.h"
#include "NotoSans_Condensed_Bold52pt7b.h"
#include "NotoSans_Condensed_Bold53pt7b.h"
#include "NotoSans_Condensed_Bold54pt7b.h"
#include "NotoSans_Condensed_Bold55pt7b.h"
#include "NotoSans_Condensed_Bold56pt7b.h"
#include "NotoSans_Condensed_Bold57pt7b.h"
#include "NotoSans_Condensed_Bold58pt7b.h"
#include "NotoSans_Condensed_Bold59pt7b.h"
#include "NotoSans_Condensed_Bold60pt7b.h"
#include "NotoSans_Condensed_Bold61pt7b.h"
#include "NotoSans_Condensed_Bold62pt7b.h"
#include "NotoSans_Condensed_Bold63pt7b.h"
#include "NotoSans_Condensed_Bold64pt7b.h"
#include "NotoSans_Condensed_Bold65pt7b.h"
#include "NotoSans_Condensed_Bold66pt7b.h"
#include "NotoSans_Condensed_Bold67pt7b.h"
#include "NotoSans_Condensed_Bold68pt7b.h"
#include "NotoSans_Condensed_Bold69pt7b.h"
#include "NotoSans_Condensed_Bold70pt7b.h"
#include "NotoSans_Condensed_Bold71pt7b.h"
#include "NotoSans_Condensed_Bold72pt7b.h"
