#ifndef _NOTOSANS_CONDENSED_BOLD16PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xDE, 0xF7, 0xB0, 0x1A, 0x12, 0x16, 0x7F, 0x36,
  0x36, 0xFF, 0xFF, 0x2C, 0x2C, 0x6C, 0x11, 0xFF, 0xF4, 0xD3, 0xC3, 0x87,
  0x1F, 0x7F, 0x84, 0x10, 0x20, 0x47, 0x88, 0x59, 0x8C, 0x98, 0x4B, 0x05,
  0xB6, 0x7A, 0xF2, 0x69, 0x04, 0x90, 0xC9, 0x08, 0xF1, 0x87, 0x18, 0x0F,
  0x87, 0x61, 0x98, 0x3C, 0x0F, 0x07, 0x9D, 0xB6, 0xE7, 0xB9, 0xC7, 0xF8,
  0xF7, 0xFF, 0x76, 0xCC, 0xCC, 0xCC, 0xCC, 0xC6, 0x63, 0xE6, 0x33, 0x33,
  0x33, 0x33, 0x36, 0x6C, 0x19, 0x35, 0xFD, 0xE3, 0xCD, 0xCA, 0x00, 0x30,
  0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0x6D, 0xE0, 0xFF, 0xC0, 0xF0, 0x0C, 0x30,
  0xC6, 0x18, 0x63, 0x0C, 0x61, 0x86, 0x30, 0x31, 0xED, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3F, 0xDE, 0x3B, 0xFE, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x33,
  0xED, 0xC3, 0x0C, 0x71, 0x8C, 0x63, 0x8F, 0xFF, 0x33, 0xF9, 0xC3, 0x0D,
  0xE7, 0x83, 0x0C, 0x3F, 0xFE, 0x0E, 0x1E, 0x1E, 0x3E, 0x2E, 0x6E, 0x4E,
  0xFF, 0xFF, 0x0E, 0x0E, 0xFF, 0xFC, 0x30, 0xFB, 0xF0, 0xC3, 0x0F, 0xFF,
  0x80, 0x0C, 0x7D, 0xC3, 0x06, 0x0F, 0xDD, 0xF3, 0x66, 0xCD, 0xF9, 0xE0,
  0xFF, 0xFC, 0x18, 0x70, 0xC1, 0x86, 0x0C, 0x38, 0x61, 0xC0, 0x18, 0xFD,
  0x9B, 0x36, 0x67, 0x8F, 0x37, 0x67, 0xCD, 0xF9, 0xE0, 0x10, 0xF9, 0xBB,
  0x3E, 0x6C, 0xDF, 0x9F, 0x06, 0x0D, 0xF3, 0xC0, 0xFC, 0x03, 0xC0, 0xFC,
  0x03, 0xF8, 0x02, 0x0C, 0x7B, 0xCE, 0x07, 0x83, 0x81, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x83, 0x0F, 0x0F, 0x0D, 0xEE, 0x20, 0x33, 0xF4, 0xC3, 0x0C,
  0x63, 0x0C, 0x00, 0x07, 0x0C, 0x04, 0x07, 0xF1, 0x83, 0x23, 0x2D, 0xF7,
  0x26, 0xE4, 0xDD, 0x9B, 0x93, 0x5B, 0xBB, 0x00, 0x30, 0x83, 0xF0, 0x1C,
  0x0F, 0x0D, 0x86, 0xC3, 0x61, 0x99, 0xFC, 0xFE, 0x63, 0xF1, 0xF8, 0x60,
  0xFD, 0x9F, 0x1E, 0x3F, 0xDF, 0xF1, 0xE3, 0xC7, 0xFF, 0xF0, 0x18, 0xFD,
  0xDF, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0xF9, 0xF0, 0xFC, 0xFE, 0xC7,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xFE, 0xF8, 0xFF, 0x0C, 0x30, 0xFF,
  0xFC, 0x30, 0xC3, 0xFF, 0xC0, 0xFF, 0x0C, 0x30, 0xC3, 0xEC, 0x30, 0xC3,
  0x0C, 0x00, 0x0C, 0x3F, 0x72, 0xE0, 0xC0, 0xC0, 0xCF, 0xCF, 0xC7, 0xE7,
  0x7F, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xBE, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xFF, 0xC7, 0xCE, 0xCC, 0xDC, 0xD8, 0xF8, 0xFC, 0xCC, 0xCE,
  0xC6, 0xC7, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xF0,
  0xFE, 0x3F, 0xC7, 0xE8, 0xFD, 0xB7, 0xB6, 0xF6, 0xDE, 0x53, 0xCE, 0x79,
  0xCF, 0x39, 0x80, 0xE1, 0xF8, 0xFC, 0x7B, 0x3D, 0x9E, 0xEF, 0x37, 0x9F,
  0xC7, 0xE3, 0xF0, 0xE0, 0x18, 0x3F, 0x1D, 0xDC, 0x6C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0x71, 0x9F, 0xC7, 0xC0, 0xFD, 0xBF, 0x1E, 0x3C, 0xFF, 0xBE,
  0x60, 0xC1, 0x83, 0x00, 0x18, 0x3F, 0x1D, 0xDC, 0x6C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0x71, 0x9F, 0xC7, 0xC0, 0x60, 0x38, 0x0E, 0xFC, 0xCE, 0xC6,
  0xC6, 0xCE, 0xFC, 0xFC, 0xCC, 0xCE, 0xC6, 0xC7, 0x33, 0xFE, 0xB0, 0xC3,
  0xC7, 0x87, 0x0E, 0x3F, 0xBE, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7,
  0x7E, 0x3C, 0xC3, 0xB1, 0x98, 0xCC, 0x66, 0x61, 0xB0, 0xD8, 0x6C, 0x3C,
  0x0E, 0x07, 0x00, 0xC7, 0x1E, 0x38, 0xF9, 0xCE, 0xCA, 0x66, 0xDB, 0x36,
  0xD9, 0xB6, 0xC7, 0xBC, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0xE7, 0x66, 0x36,
  0x3C, 0x1C, 0x1C, 0x3C, 0x3E, 0x76, 0x67, 0xE3, 0xE3, 0x66, 0x76, 0x3E,
  0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFE, 0x0C, 0x30, 0xE1, 0x87,
  0x0C, 0x38, 0x61, 0xFF, 0xF8, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF,
  0xC3, 0x06, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x60, 0xC3, 0xF3, 0x33, 0x33,
  0x33, 0x33, 0x33, 0xFF, 0x18, 0x1C, 0x3C, 0x36, 0x66, 0x63, 0xC3, 0xFF,
  0xFC, 0xE7, 0x7B, 0xF0, 0xC3, 0xFF, 0x3C, 0xFF, 0xFC, 0xC1, 0x83, 0x06,
  0xEF, 0xD9, 0xF1, 0xE3, 0xC7, 0x8F, 0xFE, 0xE0, 0x3F, 0xEC, 0x30, 0xC3,
  0x0C, 0x3E, 0x78, 0x0E, 0x1C, 0x3B, 0xFF, 0xF9, 0xF3, 0xE3, 0xCF, 0x9F,
  0xFB, 0xB0, 0x7B, 0xFC, 0xF3, 0xFF, 0x0C, 0x3F, 0x7C, 0x3D, 0xE6, 0x1E,
  0xF9, 0x86, 0x18, 0x61, 0x86, 0x18, 0x77, 0xFF, 0x3E, 0x7C, 0x79, 0xF3,
  0xFF, 0x7E, 0x1E, 0x37, 0xE7, 0x80, 0xC1, 0x83, 0x06, 0xEF, 0xDD, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0xF3, 0xFF, 0xFF, 0x33, 0x03, 0x33, 0x33,
  0x33, 0x33, 0x33, 0xFE, 0xC1, 0x83, 0x06, 0x3C, 0xDB, 0xB6, 0x7C, 0xF9,
  0x9B, 0x3E, 0x30, 0xFF, 0xFF, 0xFF, 0xDD, 0xDF, 0xFF, 0xB9, 0xE7, 0x3C,
  0xE7, 0x9C, 0xF3, 0x9E, 0x73, 0xCE, 0x60, 0xDD, 0xFB, 0xBE, 0x3C, 0x78,
  0xF1, 0xE3, 0xC6, 0x79, 0xFB, 0x3E, 0x3C, 0x78, 0xF3, 0xFE, 0x78, 0xDD,
  0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xFF, 0xDD, 0x83, 0x06, 0x0C, 0x00, 0x77,
  0xFF, 0x3E, 0x7C, 0x79, 0xF3, 0xFF, 0x76, 0x1C, 0x38, 0x70, 0xE0, 0xDF,
  0xF9, 0x8C, 0x63, 0x18, 0xC0, 0x77, 0xF1, 0xCF, 0x1C, 0x7F, 0xF0, 0x21,
  0x1F, 0xF6, 0x31, 0x8C, 0x63, 0xCE, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3,
  0xFF, 0x76, 0xC7, 0xE6, 0x66, 0x66, 0x6C, 0x3C, 0x3C, 0x38, 0x18, 0xC6,
  0x7E, 0xE6, 0x6F, 0x66, 0xF6, 0x6B, 0x66, 0x9C, 0x29, 0xC3, 0x9C, 0x39,
  0xC0, 0xE6, 0xDD, 0xF1, 0xE3, 0x87, 0x9F, 0x37, 0xE6, 0xC7, 0xE6, 0x66,
  0x66, 0x6C, 0x3C, 0x3C, 0x38, 0x18, 0x18, 0x38, 0x70, 0x60, 0x7D, 0xF1,
  0x86, 0x30, 0xC6, 0x3F, 0xFC, 0x39, 0x8C, 0x63, 0x3B, 0x0E, 0x31, 0x8C,
  0x63, 0x84, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0x18, 0xC6, 0x30, 0xEE, 0x63,
  0x18, 0xCE, 0x40, 0x73, 0xFE, 0x18,
};

const GFXglyph NotoSans_Condensed_Bold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 8, 11, 9, 0, -11 },
  { 18, 6, 13, 8, 1, -12 },
  { 28, 12, 12, 13, 0, -12 },
  { 46, 10, 12, 10, 0, -12 },
  { 61, 2, 4, 4, 1, -11 },
  { 62, 4, 14, 5, 1, -11 },
  { 69, 4, 14, 5, 0, -11 },
  { 76, 7, 7, 8, 0, -12 },
  { 83, 6, 8, 8, 1, -10 },
  { 89, 3, 4, 4, 0, -2 },
  { 91, 5, 2, 5, 0, -5 },
  { 93, 2, 2, 4, 1, -2 },
  { 94, 6, 12, 7, 0, -12 },
  { 103, 6, 12, 8, 1, -12 },
  { 112, 5, 11, 8, 1, -11 },
  { 119, 6, 12, 8, 1, -12 },
  { 128, 6, 12, 8, 1, -12 },
  { 137, 8, 11, 8, 0, -11 },
  { 148, 6, 11, 8, 1, -11 },
  { 157, 7, 12, 8, 0, -12 },
  { 168, 7, 11, 8, 0, -11 },
  { 178, 7, 12, 8, 0, -12 },
  { 189, 7, 12, 8, 0, -12 },
  { 200, 2, 9, 4, 1, -9 },
  { 203, 2, 11, 4, 1, -9 },
  { 206, 7, 8, 8, 0, -10 },
  { 213, 7, 5, 8, 0, -8 },
  { 218, 6, 8, 8, 1, -10 },
  { 224, 6, 12, 6, 0, -12 },
  { 233, 11, 13, 12, 1, -12 },
  { 251, 9, 11, 9, 0, -11 },
  { 264, 7, 11, 9, 1, -11 },
  { 274, 7, 12, 9, 1, -12 },
  { 285, 8, 11, 10, 1, -11 },
  { 296, 6, 11, 8, 1, -11 },
  { 305, 6, 11, 7, 1, -11 },
  { 314, 8, 12, 10, 1, -12 },
  { 326, 8, 11, 10, 1, -11 },
  { 337, 5, 11, 5, 0, -11 },
  { 344, 4, 14, 5, -1, -11 },
  { 351, 8, 11, 9, 1, -11 },
  { 362, 6, 11, 7, 1, -11 },
  { 371, 11, 11, 13, 1, -11 },
  { 387, 9, 11, 11, 1, -11 },
  { 400, 9, 12, 10, 1, -12 },
  { 414, 7, 11, 8, 1, -11 },
  { 424, 9, 15, 10, 1, -12 },
  { 441, 8, 11, 9, 1, -11 },
  { 452, 6, 12, 7, 1, -12 },
  { 461, 7, 11, 8, 0, -11 },
  { 471, 8, 11, 10, 1, -11 },
  { 482, 9, 11, 9, 0, -11 },
  { 495, 13, 11, 13, 0, -11 },
  { 513, 8, 11, 9, 0, -11 },
  { 524, 8, 11, 8, 0, -11 },
  { 535, 7, 11, 7, 0, -11 },
  { 545, 4, 14, 5, 1, -11 },
  { 552, 6, 12, 7, 0, -12 },
  { 561, 4, 14, 5, 0, -11 },
  { 568, 8, 7, 9, 0, -11 },
  { 575, 7, 2, 7, 0, 1 },
  { 577, 4, 2, 5, 1, -12 },
  { 578, 6, 9, 8, 1, -9 },
  { 585, 7, 12, 9, 1, -12 },
  { 596, 6, 9, 7, 1, -9 },
  { 603, 7, 12, 9, 1, -12 },
  { 614, 6, 9, 8, 1, -9 },
  { 621, 6, 12, 5, 0, -12 },
  { 630, 7, 13, 9, 1, -9 },
  { 642, 7, 12, 9, 1, -12 },
  { 653, 2, 12, 4, 1, -12 },
  { 656, 4, 16, 4, -1, -12 },
  { 664, 7, 12, 8, 1, -12 },
  { 675, 2, 12, 4, 1, -12 },
  { 678, 11, 9, 13, 1, -9 },
  { 691, 7, 9, 9, 1, -9 },
  { 699, 7, 9, 8, 1, -9 },
  { 707, 7, 13, 9, 1, -9 },
  { 719, 7, 13, 9, 1, -9 },
  { 731, 5, 9, 6, 1, -9 },
  { 737, 5, 9, 7, 1, -9 },
  { 743, 5, 11, 6, 0, -11 },
  { 750, 7, 9, 9, 1, -9 },
  { 758, 8, 9, 8, 0, -9 },
  { 767, 12, 9, 12, 0, -9 },
  { 781, 7, 9, 8, 0, -9 },
  { 789, 8, 13, 8, 0, -9 },
  { 802, 6, 9, 6, 0, -9 },
  { 809, 5, 14, 6, 0, -11 },
  { 818, 2, 16, 8, 3, -12 },
  { 822, 5, 14, 6, 1, -11 },
  { 831, 7, 3, 8, 0, -7 },
};

const GFXfont NotoSans_Condensed_Bold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_BOLD16PT7B_H_
