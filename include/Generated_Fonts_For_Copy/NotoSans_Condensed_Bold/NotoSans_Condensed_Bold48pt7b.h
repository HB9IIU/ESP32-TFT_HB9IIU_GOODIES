#ifndef _NOTOSANS_CONDENSED_BOLD48PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x08,
  0xFE, 0x3F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0,
  0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF,
  0x83, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xE3, 0xE0, 0x03,
  0xE3, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x07,
  0xC3, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x0F, 0x87, 0xC0, 0x0F, 0x87, 0x80, 0x0F, 0x8F, 0x80, 0x0F,
  0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x1F,
  0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xEF, 0xCF, 0xE6, 0x0C, 0xFE, 0x60, 0x0F,
  0xC6, 0x00, 0xFE, 0x60, 0x0F, 0xE6, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x6F, 0xE0, 0x06, 0x7F, 0x00, 0x63, 0xF0, 0x06,
  0x3F, 0x80, 0x63, 0xFE, 0x06, 0x7F, 0xFC, 0x6F, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x03,
  0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0x07, 0xC7, 0xC0, 0x7C,
  0x00, 0x7C, 0x7C, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0xF8, 0x00, 0x7C, 0x3E,
  0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x1F, 0x00, 0x0F,
  0xC3, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE3, 0xE0,
  0x00, 0x7C, 0x3E, 0x7C, 0x3F, 0x07, 0xC7, 0xC7, 0xC7, 0xF8, 0x7C, 0x7C,
  0xFC, 0xFF, 0xC3, 0xFF, 0xCF, 0x9F, 0xFE, 0x3F, 0xF8, 0xF9, 0xFF, 0xE1,
  0xFF, 0x9F, 0x1F, 0x1F, 0x0F, 0xF1, 0xF3, 0xE1, 0xF0, 0x38, 0x3E, 0x3E,
  0x1F, 0x00, 0x03, 0xE3, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x07,
  0xC3, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE1, 0xF0,
  0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x1F,
  0x1F, 0x00, 0x3E, 0x01, 0xF3, 0xF0, 0x03, 0xE0, 0x1F, 0xFE, 0x00, 0x7E,
  0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x3F, 0x87, 0xFF, 0x83, 0xF8, 0x7F, 0xFE, 0x1F,
  0xC7, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F, 0xE7, 0xE1, 0xFC, 0x7F, 0x7F, 0x1F,
  0xC1, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0x87, 0xF0, 0x3F, 0xFC, 0x3F, 0x80,
  0xFF, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xE3, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFE, 0x7F, 0x01, 0xFF, 0xC3, 0xFE, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xE0, 0x03, 0xF8, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x09, 0xC3, 0xE3,
  0xCF, 0xDF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x1F,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFB, 0xF0,
  0x1F, 0x9F, 0xC1, 0xFC, 0x7F, 0x03, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x20,
  0x40, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E,
  0x3F, 0x1F, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x08, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x7E, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07,
  0xEF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7E, 0xFE, 0x07, 0xE7, 0xE0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF9, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0x3E, 0x7F, 0x18,
  0x7F, 0x10, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xF0, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x7E, 0x1F, 0xE3, 0x80, 0xFE, 0x30, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x78, 0x1F, 0xE3, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xEF, 0x03, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0xFC, 0x00,
  0xFB, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xC3,
  0xF0, 0x1F, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xF0,
  0x7C, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x10, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xEC, 0x01,
  0xFE, 0xF8, 0x3F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x1F, 0xC1, 0xFB, 0xFF, 0x0F, 0xDF, 0xFC, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xBF, 0xF1, 0xFD, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xE7, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xEF, 0xF8, 0xFC, 0x1F,
  0xCF, 0xE0, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E,
  0x0F, 0xE3, 0xF8, 0x7E, 0x0F, 0xEF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFD,
  0xFE, 0x1F, 0xC7, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0, 0x7F, 0x7E, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x81,
  0xFD, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFE, 0x3F, 0x8F, 0xE0, 0xFE, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0xBF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7F, 0x07, 0xFB, 0xFE,
  0x7F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xDF, 0x87, 0xFC, 0xFC,
  0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x10, 0x1F, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x11, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0x80, 0x1C,
  0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF3, 0xC1, 0xFC, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x7C, 0x0F, 0x8F, 0x81, 0xFF, 0xC7, 0xC7, 0xC1, 0xFF, 0xE1, 0xE7, 0xC1,
  0xFF, 0xF0, 0xFB, 0xE1, 0xF8, 0xF8, 0x7D, 0xF0, 0xF8, 0x7C, 0x3F, 0xF0,
  0xF8, 0x3E, 0x1F, 0xF8, 0x7C, 0x1F, 0x0F, 0xFC, 0x3E, 0x0F, 0x87, 0xFE,
  0x1F, 0x07, 0xC3, 0xFF, 0x1F, 0x03, 0xE1, 0xFF, 0x8F, 0x81, 0xF0, 0xFF,
  0xC7, 0xC0, 0xF8, 0x7F, 0xE1, 0xF0, 0x7C, 0x3F, 0xF0, 0xF8, 0x7E, 0x1E,
  0xF8, 0x7C, 0x3F, 0x1F, 0x7C, 0x3F, 0xFF, 0xDF, 0x9F, 0x0F, 0xFD, 0xFF,
  0x8F, 0x83, 0xFE, 0x7F, 0x87, 0xC0, 0xFE, 0x3F, 0x83, 0xF0, 0x08, 0x02,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x60, 0x01, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFB, 0xF8, 0x3F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE,
  0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x07,
  0xFB, 0xF8, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0x81, 0xFE, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0x07, 0x8F, 0xF0, 0x04, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x08, 0x7F, 0xF3, 0xE1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xFC, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x0F, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x1E, 0x1F, 0xE0, 0x04, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0x7F, 0x07, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x7F, 0x1F, 0xF8, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFF, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFB, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F, 0xCF, 0xC0, 0x7F, 0x1F,
  0x81, 0xFC, 0x3F, 0x07, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0xC1, 0xF8,
  0xFF, 0x03, 0xF1, 0xFC, 0x07, 0xE7, 0xF8, 0x0F, 0xCF, 0xE0, 0x1F, 0xBF,
  0x80, 0x3F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xC7, 0xF0,
  0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0xC3,
  0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFF, 0x3F,
  0x00, 0xFE, 0x7E, 0x01, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFC, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFB, 0xE0, 0x0F, 0xFF, 0xFB, 0xE0, 0x0F, 0xBF, 0xFF, 0xF0, 0x0F, 0xBF,
  0xFD, 0xF0, 0x1F, 0xBF, 0xFD, 0xF0, 0x1F, 0x3F, 0xFD, 0xF8, 0x1F, 0x3F,
  0xFD, 0xF8, 0x3F, 0x3F, 0xFC, 0xF8, 0x3E, 0x3F, 0xFC, 0xF8, 0x3E, 0x3F,
  0xFC, 0xFC, 0x3E, 0x3F, 0xFC, 0xFC, 0x7E, 0x3F, 0xFC, 0x7C, 0x7C, 0x3F,
  0xFC, 0x7C, 0x7C, 0x3F, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x7E, 0xF8, 0x3F,
  0xFC, 0x3E, 0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F,
  0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFD, 0xF8, 0x0F, 0xFE, 0xFE, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0xDF, 0xC1,
  0xFF, 0xE7, 0xE0, 0xFF, 0xF3, 0xF8, 0x7F, 0xF9, 0xFC, 0x3F, 0xFC, 0x7F,
  0x1F, 0xFE, 0x3F, 0x8F, 0xFF, 0x0F, 0xE7, 0xFF, 0x87, 0xF3, 0xFF, 0xC1,
  0xFD, 0xFF, 0xE0, 0xFE, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0x3F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFE,
  0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x3F, 0xF7, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x1F, 0xFB, 0xF8, 0x1F,
  0xDF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xDF, 0xC1, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xE1,
  0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x07, 0xF8, 0x3F, 0xF7, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE, 0x07, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0xFF,
  0xE0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xE7,
  0xE7, 0xF0, 0x0C, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x40, 0x07, 0xEF, 0x01, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F,
  0x80, 0xFE, 0x7F, 0xE7, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x1F,
  0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x80,
  0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xCF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xE0, 0x0F, 0xCF,
  0xC0, 0x3F, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF,
  0x80, 0xFE, 0x7F, 0x01, 0xFF, 0x01, 0xFC, 0x7E, 0x07, 0xDF, 0x03, 0xF0,
  0xFC, 0x0F, 0xBE, 0x07, 0xE1, 0xFC, 0x1F, 0x7C, 0x1F, 0xC3, 0xF8, 0x3E,
  0xF8, 0x3F, 0x83, 0xF0, 0x7D, 0xF0, 0x7E, 0x07, 0xE1, 0xFB, 0xF0, 0xFC,
  0x0F, 0xC3, 0xE7, 0xE1, 0xF8, 0x1F, 0xC7, 0xC7, 0xC7, 0xF0, 0x3F, 0x8F,
  0x8F, 0x8F, 0xE0, 0x3F, 0x3F, 0x1F, 0x1F, 0x80, 0x7E, 0x7E, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x7E, 0x7E, 0x01, 0xF9, 0xF0, 0x7D, 0xFC, 0x03, 0xFB,
  0xE0, 0xFB, 0xF8, 0x03, 0xF7, 0xC1, 0xF7, 0xE0, 0x07, 0xFF, 0x83, 0xEF,
  0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3,
  0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x07, 0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0xFF, 0x00,
  0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xC3, 0xF8,
  0x07, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7,
  0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0x7F, 0xC6, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x7F, 0xFB, 0xE7, 0xFE, 0x7C, 0x7F, 0x0F, 0x80, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0xE0, 0x3F, 0x1F,
  0xE1, 0xF9, 0xFF, 0x8F, 0xDF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF,
  0xE1, 0xFE, 0xFF, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0x7F, 0x83, 0xFB, 0xFE, 0x3F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xEF,
  0xFE, 0x3F, 0x3F, 0xF1, 0xF0, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF8, 0x31, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x9F, 0xE0, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x1E, 0x1F, 0xC3, 0xFC,
  0xFE, 0x3F, 0xF3, 0xF3, 0xFF, 0xDF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xE0, 0xFF, 0x7F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xBF, 0x83, 0xFD, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xEF, 0xC7, 0xFE, 0x7E, 0x0F, 0xE1, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFC, 0xFE, 0x7F, 0x07,
  0xE7, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x27,
  0xF8, 0x06, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x7F, 0x8F, 0xC7, 0xFE,
  0x7E, 0x7F, 0xFB, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFC, 0x1F, 0xEF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF7, 0xF0, 0x7F,
  0xBF, 0xC7, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFD, 0xF8, 0xFF,
  0xDF, 0xC1, 0xFC, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE8, 0x00, 0xFE, 0x78, 0x0F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC1,
  0xE0, 0xFC, 0x7F, 0x8F, 0xDF, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x11, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x08, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0xF0, 0x18, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xFF,
  0x80, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0x83, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0x3F, 0x80,
  0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF3, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x7C, 0x7F, 0xC1, 0xFE,
  0x3E, 0x7F, 0xF1, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF1, 0xFF, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0x81, 0xFC,
  0x07, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF0, 0x3F,
  0x80, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFE, 0x07,
  0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xC0,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xF8,
  0x1F, 0xC0, 0x7F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF,
  0x03, 0xF8, 0x0F, 0xFF, 0x81, 0xFC, 0x07, 0xE0, 0x00, 0x1E, 0x0F, 0x8F,
  0xF8, 0xF9, 0xFF, 0xCF, 0xDF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0x3F,
  0xC3, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x1E, 0x07, 0xC3, 0xFC, 0x3F, 0x3F, 0xF1, 0xFB,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xEF, 0xF0, 0x7F, 0x7F, 0xC7,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFD, 0xFF, 0xC7, 0xE7, 0xFE, 0x3F,
  0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0x8F, 0xC7, 0xFE, 0x7E, 0x7F, 0xFB, 0xF3, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xF7, 0xF0, 0x7F, 0xBF, 0xC7, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFD, 0xF8, 0xFF, 0xCF, 0xC1, 0xFC, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xF0, 0xFF, 0xE3, 0xF7, 0xEF,
  0xEF, 0xDF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0xFC,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0xFC, 0x04, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0x7F, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x08, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x83, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0x9F, 0x3F, 0xF9, 0xF0, 0xFE, 0x1F, 0xFE, 0x00, 0xFE, 0xFC, 0x01,
  0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0,
  0x7F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x01,
  0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F,
  0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x81, 0xF9, 0xF8, 0x1F, 0xF0, 0x3F, 0x3F,
  0x83, 0xFE, 0x07, 0xE7, 0xF0, 0x7F, 0xC1, 0xFC, 0x7E, 0x0F, 0x78, 0x3F,
  0x0F, 0xC1, 0xEF, 0x87, 0xE1, 0xFC, 0x7D, 0xF0, 0xFC, 0x3F, 0x8F, 0xBE,
  0x3F, 0x83, 0xF1, 0xF3, 0xC7, 0xE0, 0x7E, 0x3C, 0x78, 0xFC, 0x0F, 0xC7,
  0x8F, 0x9F, 0x81, 0xFD, 0xF1, 0xF3, 0xF0, 0x1F, 0xBE, 0x3E, 0xFE, 0x03,
  0xF7, 0xC3, 0xDF, 0x80, 0x7E, 0xF0, 0x7B, 0xF0, 0x0F, 0xDE, 0x0F, 0x7E,
  0x00, 0xFB, 0xC1, 0xEF, 0xC0, 0x1F, 0x78, 0x3D, 0xF0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x01,
  0xFF, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xFC, 0x03,
  0xF3, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0,
  0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF8, 0x03,
  0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x83,
  0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xC0,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFC,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0x80, 0x00, 0x0F, 0x80,
  0x09, 0xFF, 0x00, 0x5F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x00, 0xFF, 0xD0, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_Bold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 35, 13, 2, -34 },
  { 36, 17, 12, 22, 2, -34 },
  { 62, 24, 34, 26, 1, -34 },
  { 164, 20, 39, 24, 2, -36 },
  { 262, 36, 35, 39, 1, -35 },
  { 420, 29, 35, 29, 1, -35 },
  { 547, 7, 12, 12, 2, -34 },
  { 558, 13, 42, 15, 2, -34 },
  { 627, 12, 42, 15, 1, -34 },
  { 690, 21, 21, 23, 1, -37 },
  { 746, 20, 24, 24, 2, -29 },
  { 806, 9, 12, 12, 1, -6 },
  { 820, 12, 6, 15, 1, -16 },
  { 829, 8, 8, 13, 2, -7 },
  { 837, 19, 35, 20, 0, -35 },
  { 921, 20, 35, 24, 2, -35 },
  { 1009, 16, 34, 24, 2, -34 },
  { 1077, 20, 35, 24, 2, -35 },
  { 1165, 20, 35, 24, 2, -35 },
  { 1253, 22, 34, 24, 1, -34 },
  { 1347, 20, 34, 24, 2, -34 },
  { 1432, 21, 35, 24, 1, -35 },
  { 1524, 21, 34, 24, 1, -34 },
  { 1614, 21, 35, 24, 1, -35 },
  { 1706, 21, 35, 24, 1, -35 },
  { 1798, 7, 28, 13, 3, -27 },
  { 1823, 8, 33, 13, 2, -27 },
  { 1856, 21, 24, 24, 1, -29 },
  { 1919, 21, 14, 24, 1, -24 },
  { 1956, 20, 24, 24, 2, -29 },
  { 2016, 18, 36, 19, 0, -35 },
  { 2097, 33, 39, 37, 2, -35 },
  { 2258, 28, 34, 28, 0, -34 },
  { 2377, 22, 34, 27, 3, -34 },
  { 2471, 22, 35, 25, 2, -35 },
  { 2568, 24, 34, 29, 3, -34 },
  { 2670, 16, 34, 23, 4, -34 },
  { 2738, 16, 34, 22, 4, -34 },
  { 2806, 24, 35, 29, 2, -35 },
  { 2911, 23, 34, 31, 4, -34 },
  { 3009, 14, 34, 16, 1, -34 },
  { 3069, 13, 44, 14, -3, -34 },
  { 3141, 23, 34, 27, 4, -34 },
  { 3239, 18, 34, 22, 3, -34 },
  { 3316, 32, 34, 40, 4, -34 },
  { 3452, 25, 34, 33, 4, -34 },
  { 3559, 27, 35, 31, 2, -35 },
  { 3678, 21, 34, 25, 3, -34 },
  { 3768, 27, 43, 31, 2, -35 },
  { 3914, 24, 34, 27, 3, -34 },
  { 4016, 19, 35, 22, 2, -35 },
  { 4100, 21, 34, 23, 1, -34 },
  { 4190, 24, 34, 30, 3, -34 },
  { 4292, 26, 34, 26, 0, -34 },
  { 4403, 39, 34, 39, 0, -34 },
  { 4569, 25, 34, 26, 0, -34 },
  { 4676, 25, 34, 25, 0, -34 },
  { 4783, 20, 34, 22, 1, -34 },
  { 4868, 11, 42, 15, 3, -34 },
  { 4926, 19, 35, 20, 0, -35 },
  { 5010, 11, 42, 15, 1, -34 },
  { 5068, 24, 21, 26, 1, -34 },
  { 5131, 20, 3, 20, 0, 4 },
  { 5139, 12, 8, 16, 2, -37 },
  { 5151, 19, 27, 24, 2, -27 },
  { 5216, 21, 36, 26, 3, -36 },
  { 5311, 18, 27, 21, 2, -27 },
  { 5372, 21, 36, 26, 2, -36 },
  { 5467, 20, 27, 24, 2, -27 },
  { 5535, 16, 37, 16, 1, -37 },
  { 5609, 21, 39, 26, 2, -27 },
  { 5712, 20, 36, 26, 3, -36 },
  { 5802, 7, 37, 12, 3, -37 },
  { 5835, 12, 49, 12, -2, -37 },
  { 5909, 22, 36, 25, 3, -36 },
  { 6008, 7, 36, 12, 3, -36 },
  { 6040, 33, 27, 39, 3, -27 },
  { 6152, 20, 27, 26, 3, -27 },
  { 6220, 21, 27, 25, 2, -27 },
  { 6291, 21, 39, 26, 3, -27 },
  { 6394, 21, 39, 26, 2, -27 },
  { 6497, 15, 27, 18, 3, -27 },
  { 6548, 16, 27, 20, 2, -27 },
  { 6602, 15, 32, 17, 1, -32 },
  { 6662, 20, 26, 26, 3, -26 },
  { 6727, 23, 26, 23, 0, -26 },
  { 6802, 35, 26, 35, 0, -26 },
  { 6916, 22, 26, 23, 0, -26 },
  { 6988, 23, 38, 23, 0, -26 },
  { 7098, 17, 26, 19, 1, -26 },
  { 7154, 15, 42, 17, 1, -34 },
  { 7233, 5, 48, 23, 9, -37 },
  { 7263, 15, 42, 17, 2, -34 },
  { 7342, 21, 8, 24, 1, -21 },
};

const GFXfont NotoSans_Condensed_Bold48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_BOLD48PT7B_H_
