#ifndef _NOTOSANS_CONDENSED_BOLD49PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x00,
  0x00, 0x87, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0x80, 0xFF, 0x1F, 0xDF,
  0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE0, 0xF9, 0xF8, 0x3E,
  0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x1F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x03, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xF7, 0x1C, 0xFE, 0x70, 0x4F, 0xE7, 0x00, 0xFE,
  0x70, 0x0F, 0xE7, 0x00, 0x7F, 0x70, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x77, 0xF0, 0x07, 0x3F, 0x00, 0x73,
  0xFC, 0x07, 0x3F, 0xF0, 0x77, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x7F,
  0xF8, 0x07, 0xC0, 0x07, 0xE7, 0xC0, 0x3E, 0x00, 0x3E, 0x3F, 0x03, 0xF0,
  0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0xF8, 0x00, 0x7C, 0x3E,
  0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0x87, 0xC0, 0x01,
  0xF8, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x1F,
  0x02, 0x01, 0xF0, 0xF8, 0xF8, 0xFE, 0x0F, 0x8F, 0xCF, 0x8F, 0xFC, 0x7E,
  0x7C, 0x7C, 0xFF, 0xE1, 0xFF, 0xE7, 0xC7, 0xFF, 0x8F, 0xFE, 0x3E, 0x7E,
  0x7C, 0x3F, 0xF3, 0xE3, 0xE3, 0xF0, 0xFE, 0x1F, 0x1F, 0x0F, 0x80, 0x01,
  0xF8, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x87, 0xC0, 0x03, 0xE0,
  0x7C, 0x3E, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x1F, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0xFC, 0x00, 0x7C, 0x07, 0xE7, 0xC0, 0x07, 0xC0, 0x1F,
  0xFE, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xF0, 0x3F, 0x87, 0xFF, 0xC1, 0xFC,
  0x7F, 0xFF, 0x1F, 0xC7, 0xFB, 0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC,
  0x7F, 0xFF, 0x1F, 0xC1, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xC7, 0xF0, 0x1F,
  0xFC, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xF7, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x7F, 0x80, 0xFF, 0xC1, 0xFE, 0xFF, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x01,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x30, 0x7C, 0x19, 0xF3,
  0xE7, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7E, 0x01, 0xFB,
  0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0x03, 0xC1, 0xE0, 0x06, 0x04, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0xFE, 0xFC, 0xFC, 0xF8,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08,
  0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x08, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xDF, 0xE7, 0xF0, 0xFE, 0x7F, 0x07, 0xEF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07,
  0xE7, 0xF0, 0xFE, 0x7F, 0x9F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF,
  0xFF, 0x3F, 0x7E, 0x7F, 0x3C, 0x7F, 0x18, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF3, 0xFE, 0x7C, 0x0F, 0xE3, 0x00, 0x7F,
  0x10, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE3, 0xFE, 0x30,
  0x0F, 0xE2, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x83, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0x7F, 0x00, 0x3E,
  0xFE, 0x00, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xC7, 0xF0, 0x1F, 0x0F,
  0xE0, 0x3E, 0x1F, 0xC0, 0xF8, 0x3F, 0x81, 0xF0, 0x7F, 0x07, 0xC0, 0xFE,
  0x0F, 0x81, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x3E, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xEF, 0xC7, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF8,
  0x10, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xE0, 0x7E, 0x7F, 0xC3, 0xF7, 0xFF,
  0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xC3, 0xFD, 0xFC,
  0x0F, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0,
  0x7F, 0x3F, 0xCF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0,
  0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F,
  0x0F, 0xE1, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xCF, 0xF0, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E,
  0x7E, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x7F,
  0x01, 0xF9, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0x7F, 0xC7,
  0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7E, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0,
  0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xF7, 0xE0, 0x3F,
  0xDF, 0xC0, 0xFF, 0x7F, 0x07, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x1F, 0xFD, 0xF8, 0x3F, 0xE7, 0xE0, 0x3E, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x81, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x87, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0x80, 0x3E, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x7F, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0xFC, 0xFC, 0xFC, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7C, 0x7F, 0xCC, 0x03, 0xF9,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x0F,
  0xC0, 0xFF, 0x83, 0xE3, 0xE0, 0x7F, 0xF8, 0xF8, 0xF8, 0x7F, 0xFE, 0x3E,
  0x7C, 0x1F, 0xFF, 0x87, 0xDF, 0x0F, 0xC3, 0xE1, 0xF7, 0xC3, 0xE0, 0xF8,
  0x7F, 0xE1, 0xF8, 0x3E, 0x1F, 0xF8, 0x7C, 0x0F, 0x87, 0xFE, 0x1F, 0x03,
  0xE1, 0xFF, 0x87, 0xC1, 0xF8, 0x7F, 0xE1, 0xF0, 0x7E, 0x1F, 0xF8, 0x7C,
  0x1F, 0x07, 0xFE, 0x1F, 0x07, 0xC1, 0xFF, 0x87, 0xC1, 0xF0, 0x7B, 0xE1,
  0xF0, 0x7C, 0x3E, 0xF8, 0x7E, 0x3F, 0x8F, 0xBE, 0x0F, 0xFF, 0xFF, 0xC7,
  0xC3, 0xFF, 0xBF, 0xF1, 0xF0, 0x7F, 0xCF, 0xF8, 0x7E, 0x0F, 0xE1, 0xFC,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x38, 0x00, 0x7F, 0xE0,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFD, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x9F,
  0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xBF, 0x80, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFD,
  0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F,
  0xC0, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0x07, 0xF8, 0x06, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xF1, 0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFE,
  0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0xCF,
  0xE0, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF3, 0xF0, 0x7F,
  0xC0, 0x18, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xF0, 0x7F, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xFE, 0x03, 0xF8, 0xFF,
  0xE7, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8,
  0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x80,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00,
  0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xBE, 0x01, 0xF7, 0xFF, 0xDF, 0x00, 0xFB, 0xFF, 0xEF, 0xC0,
  0xFD, 0xFF, 0xF7, 0xE0, 0x7E, 0xFF, 0xF9, 0xF0, 0x3E, 0x7F, 0xFC, 0xFC,
  0x3F, 0x3F, 0xFE, 0x7E, 0x1F, 0x9F, 0xFF, 0x3F, 0x0F, 0x8F, 0xFF, 0x8F,
  0x87, 0xC7, 0xFF, 0xC7, 0xE7, 0xE3, 0xFF, 0xE3, 0xF3, 0xF1, 0xFF, 0xF0,
  0xF9, 0xF0, 0xFF, 0xF8, 0x7D, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0xF8, 0x1F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFE, 0x07, 0xF0, 0x1F,
  0xFF, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xF7, 0xE0, 0x3F, 0xFD, 0xFC, 0x0F, 0xFF,
  0x7F, 0x03, 0xFF, 0xCF, 0xE0, 0xFF, 0xF3, 0xF8, 0x3F, 0xFC, 0x7F, 0x0F,
  0xFF, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0xFF, 0xF0, 0xFE, 0x3F, 0xFC, 0x1F,
  0xCF, 0xFF, 0x07, 0xF3, 0xFF, 0xC0, 0xFE, 0xFF, 0xF0, 0x3F, 0xBF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x80,
  0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0x01,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFC,
  0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE3,
  0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE,
  0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xC0,
  0xE7, 0xF0, 0x04, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x3F, 0xF7, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00,
  0xFE, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x7F,
  0x01, 0xFF, 0x80, 0xFE, 0x7F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xFF,
  0x81, 0xFC, 0x3F, 0x01, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xFF, 0x81, 0xFC,
  0x3F, 0x83, 0xEF, 0xC1, 0xFC, 0x3F, 0x83, 0xEF, 0xC1, 0xF8, 0x1F, 0x83,
  0xE7, 0xC1, 0xF8, 0x1F, 0x87, 0xE7, 0xC3, 0xF8, 0x1F, 0xC7, 0xE7, 0xC3,
  0xF8, 0x1F, 0xC7, 0xE7, 0xE3, 0xF0, 0x0F, 0xC7, 0xC7, 0xE3, 0xF0, 0x0F,
  0xC7, 0xC3, 0xE3, 0xF0, 0x0F, 0xCF, 0xC3, 0xE7, 0xF0, 0x0F, 0xCF, 0xC3,
  0xE7, 0xF0, 0x0F, 0xEF, 0xC3, 0xF7, 0xE0, 0x07, 0xEF, 0x83, 0xF7, 0xE0,
  0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x9F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF3, 0xF8,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0,
  0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xF0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC1, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xFC, 0x3F,
  0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xE0, 0xFE, 0x08, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFB, 0xF3, 0xFF, 0x3F, 0x1F, 0xE1, 0xF0, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE3, 0xF0, 0x3F, 0xBF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0x8F, 0xFF,
  0xFF, 0x3F, 0xF3, 0xFC, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F,
  0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF,
  0x80, 0x7F, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0, 0x7F, 0xBF, 0xE3, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xDF, 0xFE, 0x3F, 0x3F, 0xF0, 0xF8,
  0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xF3, 0xE7, 0xF8, 0x09, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0xDF, 0xF0, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x7E, 0x1F, 0xF3, 0xF1, 0xFF,
  0xDF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFB, 0xFF, 0x7F, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC, 0x0F,
  0xEF, 0xF0, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0x7E, 0x3F,
  0xF9, 0xF0, 0x7F, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC3, 0xF9, 0xFC, 0x0F, 0xCF,
  0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01,
  0x3F, 0xC0, 0x30, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0x10, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xBF, 0xE7, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0xC7, 0xFD, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x1F, 0xFD, 0xF8, 0xFF, 0xCF, 0xC1, 0xFC, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE8, 0x00, 0x7F, 0x78,
  0x0F, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x8F, 0xE1, 0xFD,
  0xFF, 0x8F, 0xDF, 0xFE, 0x7E, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xFF, 0xFE, 0xFF,
  0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0x3C, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F,
  0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF9,
  0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0xFE,
  0x07, 0xF9, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x3F, 0xF1, 0xFF, 0xCF,
  0xDF, 0xFE, 0x7F, 0xF3, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xFC, 0x1F, 0xE0,
  0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0x81, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x80,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xFE,
  0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x01, 0xFF,
  0xF8, 0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xF0,
  0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x01, 0xFC, 0xF8, 0x3F,
  0x87, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0x3F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xF8, 0x3F, 0x03, 0xF3, 0xFF, 0x0F, 0xDF, 0xFE, 0x3F, 0x7F, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFE, 0x3F, 0xCF, 0xF0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFF, 0x07, 0xFB, 0xFE, 0x3F,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFB, 0xFF, 0x0F,
  0xE7, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xBF, 0xE7, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0xC7, 0xFD, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x1F, 0xFD, 0xF8, 0xFF, 0xCF, 0xC1, 0xFC, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xC0, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x1F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xF0, 0x73, 0xF0,
  0x09, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x83, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFC, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0xC3, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFD, 0xF9, 0xFF, 0xCF, 0xC3, 0xFC, 0x7E, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x1F,
  0x83, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC7, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07,
  0xEF, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0xF7, 0xE0, 0x3F, 0xC0, 0x7E, 0x7E, 0x03, 0xFC, 0x07, 0xE7, 0xF0, 0x3F,
  0xC0, 0xFE, 0x7F, 0x07, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F, 0xE0, 0xFC, 0x3F,
  0x07, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0xE1, 0xFC, 0x3F, 0x87, 0x9E, 0x1F,
  0xC1, 0xF8, 0xF9, 0xF1, 0xF8, 0x1F, 0x8F, 0x9F, 0x1F, 0x81, 0xF8, 0xF9,
  0xF3, 0xF8, 0x1F, 0xCF, 0x9F, 0x3F, 0x81, 0xFC, 0xF0, 0xF3, 0xF0, 0x0F,
  0xDF, 0x0F, 0x3F, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF,
  0x00, 0xFD, 0xF0, 0xFF, 0xE0, 0x07, 0xDE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x01,
  0xFE, 0xFE, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F,
  0x03, 0xF8, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7F, 0x00, 0xFC, 0x7E, 0x03, 0xF8,
  0xFE, 0x07, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xFC, 0xFE, 0x03,
  0xFB, 0xFC, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x78, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x83, 0xFF, 0x0F, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03,
  0xE0, 0x00, 0x1F, 0xC0, 0x05, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0x20, 0x00, 0x70,
};

const GFXglyph NotoSans_Condensed_Bold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 36, 13, 3, -35 },
  { 33, 18, 13, 22, 2, -35 },
  { 63, 25, 35, 27, 1, -35 },
  { 173, 20, 40, 24, 2, -37 },
  { 273, 37, 35, 40, 1, -35 },
  { 435, 29, 35, 30, 1, -35 },
  { 562, 8, 13, 12, 2, -35 },
  { 575, 13, 43, 16, 2, -35 },
  { 645, 13, 43, 16, 1, -35 },
  { 715, 21, 20, 23, 1, -37 },
  { 768, 21, 23, 24, 2, -29 },
  { 829, 8, 12, 13, 2, -6 },
  { 841, 13, 6, 15, 1, -16 },
  { 851, 8, 9, 13, 2, -8 },
  { 860, 20, 35, 20, 0, -35 },
  { 948, 20, 36, 24, 2, -36 },
  { 1038, 16, 35, 24, 2, -35 },
  { 1108, 20, 35, 24, 2, -35 },
  { 1196, 20, 35, 24, 2, -35 },
  { 1284, 23, 35, 24, 1, -35 },
  { 1385, 20, 35, 24, 2, -35 },
  { 1473, 21, 35, 24, 2, -35 },
  { 1565, 22, 35, 24, 1, -35 },
  { 1662, 22, 35, 24, 1, -35 },
  { 1759, 22, 35, 24, 1, -35 },
  { 1856, 7, 28, 13, 3, -27 },
  { 1881, 8, 33, 13, 2, -27 },
  { 1914, 22, 24, 24, 1, -30 },
  { 1980, 21, 15, 24, 2, -25 },
  { 2020, 21, 24, 24, 2, -30 },
  { 2083, 19, 36, 20, 0, -35 },
  { 2169, 34, 39, 38, 2, -35 },
  { 2335, 28, 35, 28, 0, -35 },
  { 2458, 23, 35, 28, 3, -35 },
  { 2559, 23, 35, 26, 2, -35 },
  { 2660, 25, 35, 30, 3, -35 },
  { 2770, 17, 35, 23, 4, -35 },
  { 2845, 17, 35, 23, 4, -35 },
  { 2920, 25, 35, 30, 2, -35 },
  { 3030, 24, 35, 31, 4, -35 },
  { 3135, 14, 35, 17, 1, -35 },
  { 3197, 14, 45, 14, -3, -35 },
  { 3276, 24, 35, 27, 4, -35 },
  { 3381, 18, 35, 22, 3, -35 },
  { 3460, 33, 35, 40, 4, -35 },
  { 3605, 26, 35, 34, 4, -35 },
  { 3719, 28, 36, 32, 2, -36 },
  { 3845, 21, 35, 26, 3, -35 },
  { 3937, 28, 44, 32, 2, -36 },
  { 4091, 24, 35, 27, 3, -35 },
  { 4196, 19, 35, 23, 2, -35 },
  { 4280, 21, 35, 23, 1, -35 },
  { 4372, 24, 35, 31, 3, -35 },
  { 4477, 27, 35, 27, 0, -35 },
  { 4596, 40, 35, 40, 0, -35 },
  { 4771, 26, 35, 26, 0, -35 },
  { 4885, 25, 35, 25, 0, -35 },
  { 4995, 21, 35, 23, 1, -35 },
  { 5087, 11, 43, 16, 3, -35 },
  { 5147, 20, 35, 20, 0, -35 },
  { 5235, 12, 43, 16, 1, -35 },
  { 5300, 24, 22, 27, 1, -35 },
  { 5366, 20, 4, 20, 0, 4 },
  { 5376, 12, 8, 16, 2, -38 },
  { 5388, 20, 27, 25, 2, -27 },
  { 5456, 22, 37, 26, 3, -37 },
  { 5558, 18, 27, 21, 2, -27 },
  { 5619, 21, 37, 26, 2, -37 },
  { 5717, 21, 27, 24, 2, -27 },
  { 5788, 17, 37, 16, 1, -37 },
  { 5867, 21, 39, 26, 2, -27 },
  { 5970, 21, 37, 27, 3, -37 },
  { 6068, 7, 37, 13, 3, -37 },
  { 6101, 12, 49, 13, -2, -37 },
  { 6175, 23, 37, 26, 3, -37 },
  { 6282, 7, 37, 13, 3, -37 },
  { 6315, 34, 27, 40, 3, -27 },
  { 6430, 21, 27, 27, 3, -27 },
  { 6501, 22, 27, 26, 2, -27 },
  { 6576, 22, 39, 26, 3, -27 },
  { 6684, 21, 39, 26, 2, -27 },
  { 6787, 15, 27, 18, 3, -27 },
  { 6838, 17, 27, 20, 2, -27 },
  { 6896, 16, 32, 18, 1, -32 },
  { 6960, 21, 27, 27, 3, -27 },
  { 7031, 24, 27, 24, 0, -27 },
  { 7112, 36, 27, 36, 0, -27 },
  { 7234, 23, 27, 23, 0, -27 },
  { 7312, 24, 39, 24, 0, -27 },
  { 7429, 18, 27, 20, 1, -27 },
  { 7490, 15, 43, 18, 1, -35 },
  { 7571, 5, 48, 23, 9, -37 },
  { 7601, 15, 43, 18, 2, -35 },
  { 7682, 22, 8, 24, 1, -21 },
};

const GFXfont NotoSans_Condensed_Bold49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_BOLD49PT7B_H_
