#ifndef _NOTOSANS_CONDENSED_BOLD30PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x6F, 0xFF, 0xF0,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3C, 0x07, 0x38, 0x1C,
  0x70, 0x38, 0xC0, 0x73, 0x80, 0xE7, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1C, 0x70, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x1C, 0x70, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C,
  0x00, 0x02, 0x00, 0x10, 0x01, 0xE0, 0x3F, 0xE7, 0xFF, 0x3F, 0xFB, 0xE8,
  0x9E, 0x40, 0xF2, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x0F, 0xC0, 0x4F, 0x02, 0x7E, 0x13, 0xFF, 0xFD, 0xFF, 0xE7, 0xFC, 0x03,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x01, 0xF8, 0x0E, 0x07,
  0xF0, 0x78, 0x3D, 0xC1, 0xC0, 0xE3, 0x8F, 0x03, 0x8E, 0x38, 0x0E, 0x38,
  0xE0, 0x38, 0xE7, 0x00, 0xE3, 0x9C, 0x03, 0x8E, 0xE3, 0xCF, 0x73, 0x9F,
  0x9F, 0xDE, 0xFF, 0x3E, 0x73, 0x9C, 0x61, 0xCE, 0x70, 0x0E, 0x79, 0xC0,
  0x39, 0xE7, 0x01, 0xC7, 0x9C, 0x07, 0x0E, 0x70, 0x3C, 0x39, 0xC0, 0xE0,
  0xFF, 0x07, 0x81, 0xF8, 0x1C, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFE, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xE3, 0xC0, 0x7B, 0xC0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF1, 0xF7, 0xFC, 0xF7, 0xDF,
  0x7B, 0xC7, 0xFD, 0xE1, 0xFC, 0xF0, 0xFE, 0x7C, 0x3E, 0x3F, 0x3F, 0x8F,
  0xFF, 0xC7, 0xFF, 0xF0, 0xFE, 0x7C, 0xFF, 0xFF, 0xEE, 0xE0, 0x0F, 0x1E,
  0x1C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F,
  0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x38, 0x70, 0xE1,
  0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x9E, 0x38, 0xF1, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xC1, 0x0E, 0x2F, 0x6F, 0x7F, 0xFB, 0xFF, 0xE1, 0xE0,
  0x1F, 0x81, 0xFE, 0x1E, 0x78, 0x73, 0x81, 0x08, 0x00, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x7B, 0xDE,
  0xEF, 0x7B, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x07, 0x00, 0xFE, 0x0F, 0xF8,
  0xFF, 0xC7, 0x8F, 0x3C, 0x7B, 0xC3, 0xDE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1E, 0xF8, 0xF3, 0xC7,
  0x9F, 0x7C, 0x7F, 0xC3, 0xFE, 0x0F, 0xC0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F,
  0x7F, 0xFE, 0xF7, 0x3C, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x07, 0x01,
  0xFE, 0x1F, 0xF9, 0xFF, 0xE7, 0x0F, 0x10, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE6, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0xFC, 0x07, 0xF8, 0x7D, 0xFF, 0xEF, 0xFE, 0x3F, 0xC0, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xEF, 0x03, 0xBC,
  0x1C, 0xF0, 0x73, 0xC3, 0x8F, 0x0E, 0x3C, 0x70, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xE0,
  0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x80, 0xF7, 0x9F, 0xBF, 0xF9, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xE0,
  0x7F, 0x87, 0xFC, 0x7F, 0xE7, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF3,
  0xC7, 0xBF, 0x3F, 0xFD, 0xFB, 0xEF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7B, 0xC7, 0xDF, 0x3C, 0xFF, 0xE3, 0xFE, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xFE,
  0x1F, 0xF8, 0xFF, 0xE7, 0x8F, 0x78, 0x79, 0xC3, 0xCF, 0x1E, 0x7D, 0xF1,
  0xFF, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x3C, 0xFB, 0xC3, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFE, 0x3E, 0xFF, 0xE7, 0xFE, 0x0F, 0xE0, 0x07, 0x01, 0xFE,
  0x1F, 0xF8, 0xFF, 0xCF, 0x8F, 0x78, 0x7B, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F,
  0x87, 0xFE, 0x3F, 0xFF, 0xF7, 0xFF, 0x9F, 0xBC, 0x31, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0x80, 0x6F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x6F, 0xFF, 0xF0, 0x33, 0xDE, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xEF, 0x7B, 0xBD, 0xEE, 0x00, 0x00, 0x08, 0x01, 0xC0,
  0x3E, 0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xF0, 0x07, 0x80, 0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x03, 0xF8, 0xFF, 0x1F, 0xE1, 0xF8, 0x0F, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x0E, 0x07, 0xFC, 0xFF, 0xE7, 0xFE, 0x61, 0xE0, 0x1F, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1E, 0x07, 0x81, 0xC0, 0x0E, 0x1E,
  0x00, 0x38, 0xE1, 0xF9, 0xCE, 0x3F, 0xC7, 0x71, 0xEE, 0x3B, 0x9C, 0x71,
  0xF8, 0xE3, 0x8F, 0xC7, 0x1C, 0x7E, 0x38, 0xE3, 0xF1, 0xC7, 0x1F, 0x8E,
  0x38, 0xFC, 0x73, 0xCE, 0x73, 0xFF, 0xF3, 0x8F, 0x9F, 0x1C, 0x18, 0x60,
  0x70, 0x00, 0x03, 0xC0, 0x08, 0x0F, 0x83, 0xC0, 0x3F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x80,
  0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0xC3, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x7C,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x78, 0xFF, 0xE3,
  0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x3E,
  0xFF, 0xF3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0x7B, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC7, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x01,
  0xE0, 0x1F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3E, 0x09, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x13, 0xF3, 0x87, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xEF, 0x07, 0xDE,
  0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x78, 0x3E, 0xF0, 0xFD, 0xFF, 0xF3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0xFB, 0xFF, 0x7F, 0xEF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF3,
  0xF0, 0x47, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE3,
  0xFF, 0xC7, 0xF7, 0x8F, 0xEF, 0x1F, 0xDE, 0x07, 0xBC, 0x0F, 0x7C, 0x1E,
  0x78, 0x3C, 0xFC, 0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xE0, 0xFF, 0xFF, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xBF, 0xFF,
  0xFE, 0xFC, 0xF0, 0x3F, 0xE0, 0xFB, 0xC3, 0xE7, 0x87, 0x8F, 0x1F, 0x1E,
  0x7C, 0x3C, 0xF8, 0x7B, 0xE0, 0xF7, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x0F, 0xFE, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF9, 0xE0, 0xF3,
  0xC1, 0xF7, 0x81, 0xEF, 0x03, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xF0, 0x77, 0xFF, 0x07, 0x7F, 0x70, 0xF7, 0xF7, 0x0E, 0xFF, 0x78, 0xEF,
  0xF3, 0x8E, 0xFF, 0x39, 0xEF, 0xF3, 0xDC, 0xFF, 0x3D, 0xCF, 0xF1, 0xFC,
  0xFF, 0x1F, 0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF0, 0xF8, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xF0, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0xF7, 0x8F, 0xF7, 0xCF, 0xF3, 0xCF,
  0xF3, 0xEF, 0xF1, 0xEF, 0xF1, 0xE7, 0xF0, 0xF7, 0xF0, 0xF7, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0,
  0x3E, 0xF0, 0x1F, 0x78, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E, 0xF0, 0x1F, 0x7C, 0x0F, 0x3E, 0x0F,
  0x8F, 0xDF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xC7, 0xFF,
  0x3F, 0xFD, 0xE3, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF,
  0x8F, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3E, 0xF0,
  0x1F, 0x78, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x3E, 0xF0, 0x1F, 0x7C, 0x0F, 0x3E, 0x0F, 0x8F, 0xDF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xC7,
  0x8F, 0xCF, 0x0F, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x7C, 0xF0, 0xF9, 0xFF,
  0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1E, 0x7C, 0x3C, 0x78, 0x78, 0xF8,
  0xF0, 0xF1, 0xE1, 0xF3, 0xC1, 0xE7, 0x83, 0xEF, 0x03, 0xE0, 0x07, 0x03,
  0xFE, 0x7F, 0xF7, 0xFE, 0xF8, 0x6F, 0x80, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xFC,
  0x1F, 0xFB, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3C, 0xFD, 0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFE, 0x00,
  0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78,
  0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07,
  0xBC, 0x0F, 0x83, 0xCF, 0x0F, 0xC1, 0xE7, 0x87, 0xE1, 0xF3, 0xC3, 0xF0,
  0xF1, 0xE1, 0xFC, 0x78, 0xF0, 0xFE, 0x3C, 0x3C, 0xF7, 0x1E, 0x1E, 0x7B,
  0x9F, 0x0F, 0x39, 0xCF, 0x07, 0x9C, 0xF7, 0x81, 0xDE, 0x7B, 0xC0, 0xFF,
  0x1D, 0xE0, 0x7F, 0x8E, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x07,
  0xE1, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x3C,
  0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x3E, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC, 0xF0, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xDC, 0x07, 0x38, 0x1E, 0x78, 0x38, 0x70, 0xF0, 0xF1, 0xC0, 0xE7,
  0x81, 0xEE, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x07, 0xFE, 0x3F, 0xF3, 0xFF, 0x20, 0xF0, 0x0F, 0x00, 0xF1, 0xFF,
  0x7F, 0xF7, 0xEF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xF7, 0xF7,
  0x3E, 0x70, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xCE, 0x1E, 0xFC, 0xFF, 0xF7, 0xFF, 0xBE, 0x3D, 0xE1, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xF1, 0xEF, 0xFF,
  0x7F, 0xF3, 0x9F, 0x00, 0x07, 0x83, 0xFC, 0xFF, 0xBF, 0xF7, 0xC2, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0xDF,
  0xF9, 0xFF, 0x1F, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x39, 0xE7, 0xEF, 0x3F, 0xFB, 0xFF, 0xDE, 0x3F, 0xF0, 0xFF,
  0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xDE, 0x1E, 0xF9,
  0xF7, 0xFF, 0x9F, 0xDC, 0x7C, 0xE0, 0x07, 0x00, 0xFE, 0x0F, 0xF8, 0xFB,
  0xE7, 0x87, 0x3C, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x08, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0x07, 0xC3,
  0xFC, 0x7F, 0x0F, 0xE3, 0xE0, 0x7C, 0x0F, 0x03, 0xFE, 0xFF, 0xDF, 0xF8,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x0E, 0x01, 0xF9, 0xCF, 0xEE, 0xFF,
  0xF7, 0x8F, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xF0, 0xF7, 0x87, 0xBE, 0x7D, 0xFF, 0xE7, 0xFF, 0x1F, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF7, 0x1F, 0xBF, 0xF9, 0xFF, 0x87, 0xF8, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC6, 0x1E, 0xFC, 0xFF, 0xF7,
  0xFF, 0xBE, 0x3D, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xE0, 0x6F,
  0xFF, 0x40, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C,
  0x3C, 0x78, 0xF0, 0x80, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0xFF, 0xFF,
  0xDF, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x1E, 0xF0, 0xF3, 0xC7, 0x8F, 0x3E, 0x3C, 0xF0, 0xF7,
  0x83, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFB, 0xC3, 0xCF, 0x8F, 0x1E, 0x3C,
  0x7C, 0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x81, 0x87, 0x3F, 0x3F,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x8F, 0x8F, 0xF8, 0x7C, 0x7F, 0xC3,
  0xC1, 0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F,
  0xE1, 0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E,
  0x0F, 0xF0, 0xF0, 0x78, 0x01, 0x87, 0x3F, 0x3B, 0xFD, 0xFF, 0xEF, 0x8F,
  0x78, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF8, 0x07, 0x80, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0x78, 0x79, 0xE1, 0xEF, 0x87, 0xBC, 0x1F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x07, 0xFE, 0x1E, 0x78, 0x79, 0xF3, 0xE3, 0xFF, 0x0F, 0xFC,
  0x0F, 0xC0, 0x03, 0x87, 0x3F, 0x3F, 0xFD, 0xFF, 0xEF, 0x8F, 0x78, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xFC,
  0xFB, 0xFF, 0xDF, 0xFC, 0xF7, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x01, 0xF9, 0xCF, 0xEE, 0xFF, 0xF7,
  0x8F, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0,
  0xF7, 0x87, 0xBE, 0x7D, 0xFF, 0xE7, 0xFF, 0x1F, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x03, 0xF3, 0xFB, 0xFF,
  0xFF, 0xFF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x00, 0x0E, 0x1F, 0xF7, 0xFF, 0xEF, 0xF0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x7F, 0x87, 0xF0, 0x7C, 0x0F, 0x03, 0xF0, 0xFF, 0xFF, 0xFE,
  0xFF, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x7F, 0xFF, 0xFF, 0xFC, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x47,
  0xF1, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x9F,
  0xFF, 0xFD, 0xFD, 0xE7, 0xCF, 0xF8, 0x3D, 0xE0, 0xF7, 0x87, 0xDE, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x0F, 0x3C, 0x1E, 0xF0, 0x7B, 0x81, 0xFE,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0xF0, 0x78, 0x3D,
  0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0x78, 0xF3,
  0x33, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xF0, 0x77, 0x3B,
  0x81, 0xD8, 0x6E, 0x07, 0x61, 0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0xF8, 0x7D, 0xF3, 0xE3, 0xCF, 0x0F, 0xBC,
  0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xFE,
  0x0F, 0xFC, 0x3C, 0xF1, 0xF3, 0xE7, 0x87, 0xBE, 0x1F, 0xF8, 0x3D, 0xE0,
  0xF7, 0x87, 0xDE, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x07, 0x3C, 0x1E,
  0xF0, 0x7B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x17, 0xC0, 0x7F, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xC3,
  0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE3,
  0xF8, 0xF8, 0x3F, 0x03, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xC0, 0xF8, 0x3F, 0x0F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7E,
  0x3F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xF0,
  0x78, 0xFC, 0x7C, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF1,
  0xF8, 0xF8, 0x70, 0x00, 0x7C, 0x0F, 0xFC, 0xFF, 0xFF, 0x8F, 0xF8, 0x1E,
  0x00,
};

const GFXglyph NotoSans_Condensed_Bold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 10, 7, 14, 2, -21 },
  { 21, 15, 21, 16, 1, -21 },
  { 61, 13, 25, 15, 1, -23 },
  { 102, 22, 22, 24, 1, -22 },
  { 163, 17, 22, 18, 1, -22 },
  { 210, 4, 7, 7, 2, -21 },
  { 214, 8, 26, 10, 1, -21 },
  { 240, 7, 26, 10, 1, -21 },
  { 263, 13, 13, 14, 1, -23 },
  { 285, 13, 15, 15, 1, -18 },
  { 310, 5, 7, 8, 1, -3 },
  { 315, 7, 4, 9, 1, -10 },
  { 319, 4, 5, 8, 2, -5 },
  { 322, 12, 22, 12, 0, -22 },
  { 355, 13, 22, 15, 1, -22 },
  { 391, 10, 21, 15, 1, -21 },
  { 418, 13, 22, 15, 1, -22 },
  { 454, 13, 22, 15, 1, -22 },
  { 490, 14, 21, 15, 0, -21 },
  { 527, 13, 21, 15, 1, -21 },
  { 562, 13, 22, 15, 1, -22 },
  { 598, 13, 21, 15, 1, -21 },
  { 633, 13, 22, 15, 1, -22 },
  { 669, 13, 22, 15, 1, -22 },
  { 705, 4, 17, 8, 2, -17 },
  { 714, 5, 21, 8, 1, -17 },
  { 728, 13, 15, 15, 1, -18 },
  { 753, 13, 9, 15, 1, -15 },
  { 768, 13, 15, 15, 1, -18 },
  { 793, 12, 22, 12, 0, -22 },
  { 826, 21, 24, 23, 1, -22 },
  { 889, 17, 21, 17, 0, -21 },
  { 934, 14, 21, 17, 2, -21 },
  { 971, 14, 22, 16, 1, -22 },
  { 1010, 15, 21, 18, 2, -21 },
  { 1050, 11, 21, 14, 2, -21 },
  { 1079, 11, 21, 14, 2, -21 },
  { 1108, 15, 22, 18, 1, -22 },
  { 1150, 15, 21, 19, 2, -21 },
  { 1190, 8, 21, 10, 1, -21 },
  { 1211, 8, 27, 9, -2, -21 },
  { 1238, 15, 21, 17, 2, -21 },
  { 1278, 11, 21, 14, 2, -21 },
  { 1307, 20, 21, 25, 2, -21 },
  { 1360, 16, 21, 21, 2, -21 },
  { 1402, 17, 22, 20, 1, -22 },
  { 1449, 13, 21, 16, 2, -21 },
  { 1484, 17, 27, 20, 1, -22 },
  { 1542, 15, 21, 17, 2, -21 },
  { 1582, 12, 22, 14, 1, -22 },
  { 1615, 14, 21, 14, 0, -21 },
  { 1652, 15, 21, 19, 2, -21 },
  { 1692, 16, 21, 16, 0, -21 },
  { 1734, 25, 21, 24, 0, -21 },
  { 1800, 16, 21, 16, 0, -21 },
  { 1842, 16, 21, 16, 0, -21 },
  { 1884, 12, 21, 14, 1, -21 },
  { 1916, 7, 26, 10, 2, -21 },
  { 1939, 12, 22, 12, 0, -22 },
  { 1972, 7, 26, 10, 1, -21 },
  { 1995, 15, 13, 16, 1, -21 },
  { 2020, 12, 2, 12, 0, 3 },
  { 2023, 8, 5, 10, 1, -23 },
  { 2028, 12, 17, 15, 1, -17 },
  { 2054, 13, 23, 16, 2, -23 },
  { 2092, 11, 17, 13, 1, -17 },
  { 2116, 13, 23, 16, 1, -23 },
  { 2154, 13, 17, 15, 1, -17 },
  { 2182, 11, 23, 10, 0, -23 },
  { 2214, 13, 24, 16, 1, -17 },
  { 2253, 13, 23, 16, 2, -23 },
  { 2291, 4, 23, 8, 2, -23 },
  { 2303, 7, 30, 8, -1, -23 },
  { 2330, 14, 23, 16, 2, -23 },
  { 2371, 4, 23, 8, 2, -23 },
  { 2383, 21, 17, 24, 2, -17 },
  { 2428, 13, 17, 16, 2, -17 },
  { 2456, 14, 17, 16, 1, -17 },
  { 2486, 13, 24, 16, 2, -17 },
  { 2525, 13, 24, 16, 1, -17 },
  { 2564, 9, 17, 11, 2, -17 },
  { 2584, 10, 17, 12, 1, -17 },
  { 2606, 10, 20, 11, 0, -20 },
  { 2631, 13, 16, 16, 2, -16 },
  { 2657, 14, 16, 14, 0, -16 },
  { 2685, 22, 16, 22, 0, -16 },
  { 2729, 14, 16, 14, 0, -16 },
  { 2757, 14, 23, 14, 0, -16 },
  { 2798, 10, 16, 12, 1, -16 },
  { 2818, 10, 26, 11, 0, -21 },
  { 2851, 4, 30, 14, 5, -23 },
  { 2866, 9, 26, 11, 1, -21 },
  { 2896, 13, 5, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_Bold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_BOLD30PT7B_H_
