#ifndef _NOTOSANS_CONDENSED_BOLD13PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE3, 0xC0, 0xF9, 0x90, 0x34, 0x79, 0xFB, 0xF2, 0x9F, 0xDA,
  0x34, 0x58, 0x23, 0xFF, 0x4E, 0x38, 0xF7, 0xF1, 0x08, 0x73, 0x34, 0x8D,
  0x63, 0x56, 0x77, 0xC2, 0xD0, 0xB4, 0x6D, 0x11, 0xC0, 0x78, 0x6C, 0x68,
  0x38, 0x73, 0xDE, 0xCE, 0x6E, 0x7B, 0xE8, 0x7B, 0x49, 0x24, 0xC9, 0x80,
  0xC6, 0x22, 0x33, 0x32, 0x26, 0xC0, 0x32, 0xDF, 0xCC, 0x78, 0xA0, 0x10,
  0x41, 0x3F, 0x10, 0x41, 0x00, 0x6D, 0x60, 0xF0, 0xF0, 0x18, 0xC4, 0x62,
  0x31, 0x88, 0xC0, 0x79, 0xB4, 0xF3, 0xCF, 0x34, 0xDB, 0x38, 0x3F, 0xB3,
  0x33, 0x33, 0x30, 0xF9, 0x30, 0xC2, 0x18, 0xC6, 0x1F, 0xFC, 0xF9, 0x30,
  0xCE, 0x38, 0x30, 0xF7, 0xF8, 0x18, 0x62, 0x9A, 0x4B, 0x2F, 0xC2, 0x08,
  0xF6, 0x31, 0xEF, 0x8C, 0x77, 0xF0, 0x39, 0x84, 0x3E, 0xEF, 0x34, 0xDB,
  0x38, 0xFC, 0x30, 0x86, 0x18, 0x43, 0x0C, 0x60, 0x79, 0x34, 0xDE, 0x79,
  0x3C, 0xD3, 0x78, 0x79, 0x3C, 0xF3, 0x7D, 0xF0, 0xE6, 0x70, 0xF0, 0x3C,
  0x6C, 0x00, 0xDA, 0xC0, 0x04, 0x77, 0x38, 0x38, 0x30, 0x40, 0xFF, 0xF0,
  0x3F, 0x83, 0x83, 0x83, 0x3B, 0x88, 0x00, 0xFC, 0xC6, 0x63, 0x30, 0x0C,
  0x60, 0x3E, 0x21, 0xA7, 0x56, 0xBA, 0x5D, 0x2A, 0xFD, 0x24, 0xC2, 0x1F,
  0x00, 0x38, 0x70, 0xB1, 0x66, 0xCF, 0xDF, 0xE3, 0xC6, 0xFB, 0x7C, 0xFE,
  0xFB, 0x3C, 0xFF, 0xF8, 0x7F, 0x2C, 0x30, 0xC3, 0x0C, 0x3A, 0x78, 0xFB,
  0x7C, 0xF3, 0xCF, 0x3C, 0xFE, 0xF0, 0xFC, 0xCF, 0xFC, 0xCF, 0xF0, 0xFC,
  0xCC, 0xFC, 0xCC, 0xC0, 0x7F, 0x9C, 0x30, 0xDF, 0x3C, 0xFB, 0x7C, 0xC7,
  0x1C, 0x7F, 0xFF, 0x1C, 0x71, 0xC4, 0xF6, 0x66, 0x66, 0x66, 0xF0, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xEE, 0xCF, 0x6D, 0xBC, 0xF3, 0x6D, 0xB3, 0xCC,
  0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xE3, 0xF1, 0xF9, 0xFE, 0xFF, 0x5E,
  0xAF, 0x77, 0xB3, 0xD9, 0x80, 0xE7, 0xCF, 0x9F, 0xBD, 0x7B, 0xF3, 0xE7,
  0xC6, 0x7D, 0x9B, 0x1E, 0x3C, 0x78, 0xF1, 0xF6, 0x78, 0xFE, 0xF3, 0xBF,
  0xFB, 0x18, 0xC0, 0x7D, 0x9B, 0x1E, 0x3C, 0x78, 0xF1, 0xF6, 0x78, 0x18,
  0x38, 0xFB, 0x6C, 0xF6, 0xFB, 0x4D, 0xB6, 0xCC, 0x7D, 0xA4, 0x18, 0x38,
  0x60, 0xFE, 0xF8, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xFB, 0x78, 0xC7, 0x8D, 0x13, 0x66, 0xC5, 0x8A, 0x1C,
  0x38, 0xCC, 0x79, 0x8B, 0x3B, 0x27, 0x67, 0xAC, 0xF5, 0x1C, 0xA1, 0x9C,
  0x31, 0x80, 0xCE, 0xD8, 0xA1, 0xC3, 0x87, 0x1B, 0x36, 0xC6, 0xC6, 0xD9,
  0xB1, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xFC, 0x21, 0x84, 0x31, 0x86, 0x3F,
  0xFC, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x18, 0x42, 0x18, 0x43, 0x18,
  0xE4, 0x92, 0x49, 0x27, 0x80, 0x10, 0x70, 0xA3, 0x6C, 0x60, 0xF8, 0xCC,
  0x79, 0x30, 0xDF, 0xCF, 0x37, 0xC0, 0xC3, 0x0C, 0x3E, 0xDB, 0x2C, 0xF2,
  0xDA, 0xE0, 0x7D, 0x88, 0x8D, 0x70, 0x0C, 0x30, 0xDF, 0x6D, 0x3C, 0xD3,
  0x6D, 0xD0, 0xF6, 0xE7, 0xF8, 0x65, 0xE0, 0x3B, 0x99, 0xE6, 0x31, 0x8C,
  0x63, 0x00, 0x75, 0xB4, 0xF3, 0x4D, 0xB7, 0xC3, 0x4D, 0xE0, 0xC6, 0x31,
  0x7D, 0xE7, 0x39, 0xCE, 0x40, 0xF3, 0xFF, 0xF0, 0x6C, 0x36, 0xDB, 0x6D,
  0xFC, 0xC3, 0x0C, 0x37, 0xDB, 0xCF, 0x34, 0xDB, 0x30, 0xFF, 0xFF, 0xF0,
  0xBF, 0x6E, 0xF6, 0x7B, 0x3D, 0x9E, 0xCF, 0x66, 0xBE, 0xF3, 0x9C, 0xE7,
  0x20, 0x79, 0xB4, 0x71, 0x4D, 0xB3, 0x80, 0xBB, 0x6C, 0xB3, 0xCB, 0x6F,
  0xB0, 0xC3, 0x00, 0x75, 0xB4, 0xF3, 0x4D, 0xB7, 0xC3, 0x0C, 0x30, 0xBF,
  0xCC, 0xCC, 0xC0, 0x7E, 0x58, 0xE1, 0xCF, 0xC0, 0x26, 0xF6, 0x66, 0x67,
  0x70, 0xCE, 0x73, 0x9D, 0xEF, 0xA0, 0xCD, 0x36, 0x9E, 0x78, 0xE3, 0x00,
  0xCC, 0xEE, 0xD7, 0x6E, 0xB7, 0x73, 0x98, 0xCC, 0xCD, 0xE7, 0x8C, 0x79,
  0xEC, 0xC0, 0xCD, 0x36, 0x9E, 0x38, 0xE3, 0x0C, 0x33, 0x80, 0xF8, 0xCC,
  0x46, 0x23, 0xE0, 0x32, 0x22, 0x6C, 0x62, 0x22, 0x30, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE3, 0x18, 0xC3, 0x1C, 0x8C, 0x63, 0x38, 0x67, 0xF8, 0x00,
};

const GFXglyph NotoSans_Condensed_Bold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 3, 6, 1, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 5, 11, 6, 1, -10 },
  { 21, 10, 9, 11, 0, -9 },
  { 33, 8, 9, 8, 0, -9 },
  { 42, 2, 3, 3, 1, -9 },
  { 43, 3, 11, 4, 1, -9 },
  { 48, 4, 11, 4, 0, -9 },
  { 54, 6, 6, 6, 0, -10 },
  { 59, 6, 7, 6, 0, -8 },
  { 65, 3, 4, 3, 0, -2 },
  { 67, 4, 1, 4, 0, -4 },
  { 68, 2, 2, 3, 1, -2 },
  { 69, 5, 9, 5, 0, -9 },
  { 75, 6, 9, 6, 0, -9 },
  { 82, 4, 9, 6, 1, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 5, 9, 6, 1, -9 },
  { 114, 6, 9, 6, 0, -9 },
  { 121, 6, 9, 6, 0, -9 },
  { 128, 6, 9, 6, 0, -9 },
  { 135, 6, 9, 6, 0, -9 },
  { 142, 2, 7, 3, 1, -7 },
  { 144, 3, 9, 3, 0, -7 },
  { 148, 6, 7, 6, 0, -8 },
  { 154, 6, 4, 6, 0, -7 },
  { 157, 6, 7, 6, 0, -8 },
  { 163, 5, 9, 5, 0, -9 },
  { 169, 9, 10, 10, 1, -9 },
  { 181, 7, 9, 7, 0, -9 },
  { 189, 6, 9, 7, 1, -9 },
  { 196, 6, 9, 7, 1, -9 },
  { 203, 6, 9, 8, 1, -9 },
  { 210, 4, 9, 6, 1, -9 },
  { 215, 4, 9, 6, 1, -9 },
  { 220, 6, 9, 8, 1, -9 },
  { 227, 6, 9, 8, 1, -9 },
  { 234, 4, 9, 4, 0, -9 },
  { 239, 4, 12, 4, -1, -9 },
  { 245, 6, 9, 7, 1, -9 },
  { 252, 5, 9, 6, 1, -9 },
  { 258, 9, 9, 11, 1, -9 },
  { 269, 7, 9, 9, 1, -9 },
  { 277, 7, 9, 8, 1, -9 },
  { 285, 5, 9, 7, 1, -9 },
  { 291, 7, 11, 8, 1, -9 },
  { 301, 6, 9, 7, 1, -9 },
  { 308, 6, 9, 6, 0, -9 },
  { 315, 6, 9, 6, 0, -9 },
  { 322, 6, 9, 8, 1, -9 },
  { 329, 7, 9, 7, 0, -9 },
  { 337, 11, 9, 11, 0, -9 },
  { 350, 7, 9, 7, 0, -9 },
  { 358, 7, 9, 7, 0, -9 },
  { 366, 6, 9, 6, 0, -9 },
  { 373, 3, 11, 4, 1, -9 },
  { 378, 5, 9, 5, 0, -9 },
  { 384, 3, 11, 4, 0, -9 },
  { 389, 7, 5, 7, 0, -9 },
  { 394, 5, 1, 5, 0, 1 },
  { 395, 3, 2, 4, 1, -10 },
  { 396, 6, 7, 7, 0, -7 },
  { 402, 6, 10, 7, 1, -10 },
  { 410, 4, 7, 6, 1, -7 },
  { 414, 6, 10, 7, 0, -10 },
  { 422, 5, 7, 6, 1, -7 },
  { 427, 5, 10, 4, 0, -10 },
  { 434, 6, 10, 7, 0, -7 },
  { 442, 5, 10, 7, 1, -10 },
  { 449, 2, 10, 3, 1, -10 },
  { 452, 3, 13, 3, 0, -10 },
  { 457, 6, 10, 7, 1, -10 },
  { 465, 2, 10, 3, 1, -10 },
  { 468, 9, 7, 11, 1, -7 },
  { 476, 5, 7, 7, 1, -7 },
  { 481, 6, 7, 7, 0, -7 },
  { 487, 6, 10, 7, 1, -7 },
  { 495, 6, 10, 7, 0, -7 },
  { 503, 4, 7, 5, 1, -7 },
  { 507, 5, 7, 5, 0, -7 },
  { 512, 4, 9, 5, 0, -9 },
  { 517, 5, 7, 7, 1, -7 },
  { 522, 6, 7, 6, 0, -7 },
  { 528, 9, 7, 10, 0, -7 },
  { 536, 6, 7, 6, 0, -7 },
  { 542, 6, 10, 6, 0, -7 },
  { 550, 5, 7, 5, 0, -7 },
  { 555, 4, 11, 5, 0, -9 },
  { 561, 2, 13, 6, 2, -10 },
  { 565, 5, 11, 5, 0, -9 },
  { 572, 6, 3, 6, 0, -6 },
};

const GFXfont NotoSans_Condensed_Bold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_BOLD13PT7B_H_
