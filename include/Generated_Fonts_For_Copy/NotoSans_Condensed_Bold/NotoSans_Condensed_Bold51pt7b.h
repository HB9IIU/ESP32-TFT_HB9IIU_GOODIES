#ifndef _NOTOSANS_CONDENSED_BOLD51PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x18, 0xFE, 0x3F, 0xFF, 0x8F, 0xEF, 0xE3, 0xFB, 0xF8, 0x7E, 0xFE,
  0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07,
  0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF8,
  0xF8, 0x00, 0x7C, 0x3E, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE3, 0xE0, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x7C, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xDC, 0x39, 0xFC, 0xE0,
  0x4F, 0xE7, 0x00, 0x7F, 0x38, 0x03, 0xF9, 0xC0, 0x0F, 0xEE, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0x9F, 0xC0, 0x1C, 0xFE, 0x00, 0xE3, 0xF8, 0x07, 0x1F, 0xF0, 0x39, 0xFF,
  0xE1, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xFE,
  0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x03, 0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0x80,
  0x0F, 0xC7, 0xC0, 0x7E, 0x00, 0x3E, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x7E,
  0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0xF8, 0x00,
  0x3E, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x7E, 0x1F, 0x00, 0x03, 0xE1, 0xF8,
  0xFC, 0x00, 0x0F, 0x87, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x9F, 0x87, 0xE0,
  0xFC, 0x7C, 0x7C, 0x7F, 0xE3, 0xF3, 0xF3, 0xF3, 0xFF, 0xC7, 0xFF, 0xCF,
  0x8F, 0xFF, 0x1F, 0xFE, 0x3E, 0x7F, 0xFE, 0x3F, 0xF1, 0xF9, 0xF8, 0xF8,
  0x7F, 0x87, 0xC7, 0xC3, 0xE0, 0x7C, 0x3F, 0x1F, 0x0F, 0xC0, 0x00, 0xF8,
  0x7C, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC3, 0xF0,
  0x00, 0x7C, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x3F, 0x00, 0x0F, 0x81,
  0xF0, 0xFC, 0x00, 0x7E, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0x1F, 0x0F, 0x80,
  0x0F, 0xC0, 0x7E, 0x3E, 0x00, 0x3E, 0x00, 0xFD, 0xF8, 0x01, 0xF8, 0x03,
  0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFC,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x3F, 0x87, 0xFF, 0xC0, 0xFE, 0x3F, 0xFF, 0x87, 0xF8, 0xFF,
  0xFF, 0x1F, 0xC7, 0xF9, 0xFE, 0x7F, 0x1F, 0xC3, 0xFB, 0xFC, 0x7F, 0x0F,
  0xFF, 0xE3, 0xFC, 0x1F, 0xFF, 0x8F, 0xF0, 0x3F, 0xFC, 0x3F, 0xC0, 0x7F,
  0xF0, 0xFF, 0x01, 0xFF, 0x81, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0x83, 0xFC, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xE7, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x27,
  0x07, 0xC3, 0x9F, 0x9E, 0x7E, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x83, 0xF8, 0x7F, 0x03,
  0xE1, 0xF0, 0x03, 0x03, 0x80, 0x04, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x3F, 0x9F, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0xFE,
  0x7E, 0x3F, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8,
  0x1F, 0xBF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xF7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFE, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFE,
  0x7F, 0x7C, 0x7F, 0x30, 0x7F, 0x10, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFC, 0x3F, 0xC7, 0x80, 0xFE,
  0x30, 0x07, 0xF0, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xF0, 0x3F, 0xC6,
  0x00, 0xFE, 0x20, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3E, 0x7F, 0x00, 0xFC,
  0xFE, 0x01, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0x87, 0xF0, 0x3E, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC1, 0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0x80, 0xFE,
  0x3F, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x20, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x70, 0x07, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0x01, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x70, 0x0F, 0xC7, 0xF8,
  0x3F, 0x3F, 0xF0, 0xFD, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xE1, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFE,
  0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF8, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0x1F, 0x80, 0xFE, 0xFE, 0x03,
  0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFC, 0x7F, 0x07, 0xF0,
  0xFE, 0x3F, 0xC3, 0xFD, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F,
  0x87, 0xF8, 0xFF, 0x3F, 0xC1, 0xFE, 0xFE, 0x03, 0xFB, 0xF0, 0x0F, 0xEF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xE0,
  0x3F, 0xBF, 0xC1, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x7F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x07,
  0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFE, 0x0F, 0xF7, 0xFE,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFB, 0xF0, 0xFF, 0xCF,
  0xC1, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x0C, 0x1F,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x3F,
  0x3F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x3F, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3E, 0x1F, 0xE3, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8,
  0xFC, 0x07, 0xFE, 0x1F, 0x1F, 0x03, 0xFF, 0xE3, 0xE3, 0xE0, 0xFF, 0xFC,
  0x3E, 0xFC, 0x3F, 0xFF, 0x87, 0xDF, 0x07, 0xE1, 0xF0, 0xFB, 0xE1, 0xF8,
  0x3E, 0x1F, 0x7C, 0x3E, 0x07, 0xC3, 0xFF, 0x87, 0xC1, 0xF8, 0x7F, 0xE1,
  0xF8, 0x3F, 0x0F, 0xFC, 0x3F, 0x07, 0xE1, 0xFF, 0x87, 0xC0, 0xFC, 0x3F,
  0xF0, 0xF8, 0x1F, 0x87, 0xFE, 0x1F, 0x03, 0xF0, 0xFF, 0xC3, 0xF0, 0x7E,
  0x1F, 0xF8, 0x7E, 0x0F, 0x83, 0xFF, 0x07, 0xC3, 0xF8, 0xFB, 0xF0, 0xFC,
  0x7F, 0x3F, 0x3E, 0x1F, 0xFF, 0xFF, 0xC7, 0xC1, 0xFF, 0x9F, 0xF8, 0xFC,
  0x1F, 0xF3, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x40, 0x07, 0xF8, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE,
  0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xC3, 0xFF, 0xBF, 0x80, 0xFF, 0x7F,
  0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0,
  0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xCF, 0xE0, 0x7F, 0xDF, 0xC0, 0x7F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xDF, 0xC0, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x7C, 0x1F, 0xF0, 0x0C, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x02, 0x1F, 0xF0, 0x0E, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3,
  0xF8, 0x1F, 0xF9, 0xFC, 0x07, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F,
  0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0x7F, 0xBF, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x3F, 0xC7,
  0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0xF8, 0x7F, 0xC0, 0x0C, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xF8, 0x03, 0xFB, 0xFE, 0x01, 0xFC, 0xFF, 0x80, 0xFE, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x81, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x3F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xE3, 0xFF, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0,
  0x3F, 0xC3, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF8, 0x07,
  0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFD, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F,
  0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0,
  0x7F, 0x87, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0xFE,
  0x01, 0xFE, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xF0,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFB, 0xFF, 0xDF, 0x80, 0x7E, 0xFF, 0xF7, 0xE0, 0x1F, 0xBF,
  0xFD, 0xF8, 0x07, 0xDF, 0xFF, 0x3E, 0x03, 0xF7, 0xFF, 0xCF, 0xC0, 0xFD,
  0xFF, 0xF3, 0xF0, 0x3E, 0x7F, 0xFC, 0xFC, 0x1F, 0x9F, 0xFF, 0x1F, 0x07,
  0xE7, 0xFF, 0xC7, 0xE1, 0xF9, 0xFF, 0xF1, 0xF8, 0x7C, 0x7F, 0xFC, 0x7E,
  0x3F, 0x1F, 0xFF, 0x0F, 0xCF, 0xC7, 0xFF, 0xC3, 0xF3, 0xE1, 0xFF, 0xF0,
  0xFD, 0xF8, 0x7F, 0xFC, 0x1F, 0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xE0,
  0x7F, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFE, 0x07, 0xFF, 0xDF,
  0xE0, 0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0x3F, 0xC3, 0xFF, 0xE3, 0xF8, 0x7F,
  0xFC, 0x7F, 0x8F, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE, 0x0F,
  0xE3, 0xFF, 0xC1, 0xFC, 0x7F, 0xF8, 0x1F, 0xCF, 0xFF, 0x03, 0xF9, 0xFF,
  0xE0, 0x3F, 0xBF, 0xFC, 0x07, 0xF7, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFD, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x00,
  0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x83,
  0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE3, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F,
  0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xF8, 0xFE, 0x07, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xF0, 0x1C, 0xFF, 0x00, 0x4F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E,
  0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x9F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF8, 0x07, 0xF1,
  0xFC, 0x03, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0x0F, 0xE0,
  0x7F, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xDF,
  0x03, 0xF8, 0x3F, 0x81, 0xF7, 0xE0, 0xFE, 0x07, 0xE0, 0x7D, 0xF8, 0x3F,
  0x81, 0xFC, 0x3F, 0x7E, 0x0F, 0xE0, 0x7F, 0x0F, 0xCF, 0x83, 0xF0, 0x1F,
  0xC3, 0xF3, 0xE1, 0xFC, 0x07, 0xF0, 0xF8, 0xFC, 0x7F, 0x00, 0xFC, 0x7E,
  0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x8F, 0xC7, 0xF0, 0x0F, 0xE7, 0xE1, 0xF1,
  0xF8, 0x03, 0xF9, 0xF8, 0x7E, 0xFE, 0x00, 0xFE, 0x7C, 0x1F, 0xBF, 0x80,
  0x1F, 0xBF, 0x07, 0xEF, 0xE0, 0x07, 0xEF, 0xC1, 0xFB, 0xF8, 0x01, 0xFB,
  0xF0, 0x3E, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xBF, 0x00, 0x0F, 0xFE, 0x03,
  0xEF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC7,
  0xF0, 0x07, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x0F,
  0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x8F,
  0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xCF, 0xC0,
  0x07, 0xE7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xFF, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x87, 0xF8,
  0x20, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFD, 0xFB, 0xFF, 0xCF, 0xCF, 0xFC, 0x7E, 0x3F, 0xC3, 0xF0, 0x30, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x0F,
  0xE7, 0xFE, 0x1F, 0xDF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0xEF, 0xF9, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x0F, 0xEF, 0xE0,
  0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F,
  0xDF, 0xC0, 0x3F, 0xBF, 0xC0, 0x7F, 0x7F, 0x81, 0xFE, 0xFF, 0x83, 0xFD,
  0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0x9F, 0xFC, 0x3F, 0x0F, 0xE0, 0x00, 0x02, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xE0,
  0x23, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x9F, 0xF8, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x01, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC1,
  0xFC, 0x7F, 0x0F, 0xFC, 0xFC, 0x7F, 0xFB, 0xF3, 0xFF, 0xEF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFE, 0x0F, 0xF7, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x83, 0xFD,
  0xFF, 0x3F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFE, 0xFC, 0x3F,
  0xF3, 0xF0, 0x7F, 0x87, 0xC0, 0x30, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7,
  0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x43, 0xFC, 0x07, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0x84, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0xFC, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF, 0xCF, 0xFF,
  0xBF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xF8, 0x3F, 0xDF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD,
  0xFE, 0x0F, 0xF7, 0xFC, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFE, 0xFC, 0x7F,
  0xFB, 0xF0, 0xFF, 0xDF, 0xC1, 0xFE, 0x7F, 0x00, 0x81, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x40, 0x03, 0xFD, 0xC0, 0x1F, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x8F,
  0xF0, 0xFE, 0x7F, 0xE3, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xC0, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9C, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE,
  0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xC0, 0xFF,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE,
  0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xCF, 0xFE, 0x3F,
  0xF8, 0xFD, 0xFF, 0xF3, 0xFF, 0xCF, 0xDF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x87, 0xFE, 0x1F, 0xEF,
  0xF0, 0x3F, 0xC0, 0xFE, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0,
  0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80,
  0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80,
  0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFC, 0x3F,
  0xC3, 0xF3, 0xFF, 0x8F, 0xCF, 0xFF, 0x3F, 0x7F, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x0F,
  0xE7, 0xF0, 0x1F, 0xCF, 0xF0, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0xFF, 0xC3, 0xF3, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF, 0x3F, 0xE0, 0xFF, 0x7F,
  0x81, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0,
  0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0xFF, 0x00,
  0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF8, 0x0F,
  0xEF, 0xF0, 0x3F, 0xDF, 0xF0, 0x7F, 0xBF, 0xFB, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFD, 0xFF, 0xE3, 0xF9, 0xFF, 0x87, 0xF1, 0xFC, 0x0F,
  0xE0, 0x40, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0xFC, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF, 0xCF, 0xFF, 0xBF, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xF8, 0x3F, 0xDF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFE, 0x0F, 0xF7, 0xFC,
  0x7F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFE, 0xFC, 0x7F, 0xFB, 0xF0, 0xFF, 0xCF,
  0xC1, 0xFE, 0x7F, 0x00, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFD, 0xFE, 0xFD, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF0, 0x7B, 0xF0, 0x09, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE3, 0x1F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x20, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xF3, 0xF1, 0xFF, 0xCF, 0xC3, 0xFC,
  0x3F, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE3,
  0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xF7, 0xE0, 0x03, 0xF7,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFB, 0xF0, 0x0F, 0xF0,
  0x1F, 0xDF, 0xC0, 0xFF, 0x80, 0xFC, 0xFE, 0x07, 0xFC, 0x0F, 0xE7, 0xF0,
  0x3F, 0xE0, 0x7F, 0x1F, 0x81, 0xFF, 0x83, 0xF8, 0xFE, 0x0F, 0x7C, 0x1F,
  0xC7, 0xF0, 0xFB, 0xE0, 0xFC, 0x3F, 0x87, 0xDF, 0x0F, 0xE0, 0xFC, 0x3E,
  0xF8, 0x7F, 0x07, 0xF1, 0xF3, 0xE3, 0xF8, 0x3F, 0x9F, 0x1F, 0x1F, 0x81,
  0xFC, 0xF8, 0xF9, 0xFC, 0x07, 0xE7, 0xC7, 0xCF, 0xE0, 0x3F, 0x3E, 0x1E,
  0x7F, 0x01, 0xF9, 0xF0, 0xF3, 0xF0, 0x0F, 0xEF, 0x07, 0xDF, 0x80, 0x7F,
  0x78, 0x3E, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F,
  0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x0F,
  0xC3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07,
  0xF7, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x03, 0xFF, 0xA0, 0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_Bold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 37, 13, 3, -36 },
  { 38, 18, 13, 23, 3, -36 },
  { 68, 26, 36, 28, 1, -36 },
  { 185, 21, 42, 25, 2, -39 },
  { 296, 38, 37, 41, 2, -37 },
  { 472, 30, 38, 31, 1, -37 },
  { 615, 7, 13, 12, 3, -36 },
  { 627, 13, 45, 16, 2, -37 },
  { 701, 13, 45, 16, 1, -37 },
  { 775, 22, 22, 24, 1, -39 },
  { 836, 22, 24, 25, 2, -30 },
  { 902, 9, 13, 13, 2, -6 },
  { 917, 13, 7, 16, 1, -17 },
  { 929, 8, 9, 13, 3, -8 },
  { 938, 20, 37, 21, 0, -37 },
  { 1031, 21, 38, 25, 2, -37 },
  { 1131, 16, 36, 25, 3, -36 },
  { 1203, 21, 37, 25, 2, -37 },
  { 1301, 21, 38, 25, 2, -37 },
  { 1401, 23, 36, 25, 1, -36 },
  { 1505, 21, 37, 25, 2, -36 },
  { 1603, 22, 38, 25, 2, -37 },
  { 1708, 23, 36, 25, 1, -36 },
  { 1812, 22, 38, 25, 2, -37 },
  { 1917, 22, 38, 25, 1, -37 },
  { 2022, 8, 29, 14, 3, -28 },
  { 2051, 9, 35, 14, 2, -28 },
  { 2091, 22, 25, 25, 2, -31 },
  { 2160, 22, 16, 25, 2, -26 },
  { 2204, 22, 25, 25, 2, -31 },
  { 2273, 20, 38, 21, 0, -37 },
  { 2368, 35, 41, 40, 2, -37 },
  { 2548, 29, 36, 29, 0, -36 },
  { 2679, 23, 36, 29, 4, -36 },
  { 2783, 24, 38, 27, 2, -37 },
  { 2897, 25, 36, 31, 4, -36 },
  { 3010, 17, 36, 24, 4, -36 },
  { 3087, 17, 36, 24, 4, -36 },
  { 3164, 25, 38, 31, 3, -37 },
  { 3283, 25, 36, 33, 4, -36 },
  { 3396, 15, 36, 17, 1, -36 },
  { 3464, 14, 47, 15, -3, -36 },
  { 3547, 25, 36, 29, 4, -36 },
  { 3660, 18, 36, 23, 4, -36 },
  { 3741, 34, 36, 42, 4, -36 },
  { 3894, 27, 36, 35, 4, -36 },
  { 4016, 29, 38, 33, 2, -37 },
  { 4154, 21, 36, 27, 4, -36 },
  { 4249, 29, 46, 33, 2, -37 },
  { 4416, 24, 36, 28, 4, -36 },
  { 4524, 20, 38, 24, 2, -37 },
  { 4619, 22, 36, 24, 1, -36 },
  { 4718, 24, 37, 32, 4, -36 },
  { 4829, 28, 36, 28, 0, -36 },
  { 4955, 42, 36, 41, 0, -36 },
  { 5144, 27, 36, 27, 0, -36 },
  { 5266, 26, 36, 26, 0, -36 },
  { 5383, 22, 36, 24, 1, -36 },
  { 5482, 12, 45, 16, 3, -37 },
  { 5550, 20, 37, 21, 0, -37 },
  { 5643, 12, 45, 16, 1, -37 },
  { 5711, 25, 22, 28, 1, -36 },
  { 5780, 21, 4, 21, 0, 4 },
  { 5791, 13, 8, 17, 2, -39 },
  { 5804, 21, 29, 26, 2, -28 },
  { 5881, 23, 40, 27, 3, -39 },
  { 5996, 19, 29, 22, 2, -28 },
  { 6065, 22, 40, 27, 2, -39 },
  { 6175, 22, 29, 25, 2, -28 },
  { 6255, 17, 39, 17, 1, -39 },
  { 6338, 22, 40, 27, 2, -28 },
  { 6448, 22, 39, 28, 3, -39 },
  { 6556, 7, 39, 13, 3, -39 },
  { 6591, 12, 51, 13, -2, -39 },
  { 6668, 24, 39, 27, 3, -39 },
  { 6785, 7, 39, 13, 3, -39 },
  { 6820, 36, 28, 42, 3, -28 },
  { 6946, 22, 28, 28, 3, -28 },
  { 7023, 23, 29, 27, 2, -28 },
  { 7107, 23, 40, 27, 3, -28 },
  { 7222, 22, 40, 27, 2, -28 },
  { 7332, 16, 28, 19, 3, -28 },
  { 7388, 17, 29, 21, 2, -28 },
  { 7450, 16, 35, 18, 1, -34 },
  { 7520, 22, 29, 28, 3, -28 },
  { 7600, 24, 28, 25, 0, -28 },
  { 7684, 37, 28, 37, 0, -28 },
  { 7814, 24, 28, 24, 0, -28 },
  { 7898, 24, 40, 25, 0, -28 },
  { 8018, 18, 28, 20, 1, -28 },
  { 8081, 15, 44, 18, 1, -36 },
  { 8164, 6, 51, 24, 9, -39 },
  { 8203, 16, 44, 18, 2, -36 },
  { 8291, 22, 8, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_Bold51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_BOLD51PT7B_H_
