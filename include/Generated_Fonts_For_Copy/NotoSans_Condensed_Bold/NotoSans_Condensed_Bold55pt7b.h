#ifndef _NOTOSANS_CONDENSED_BOLD55PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0xFF, 0x7F, 0xBF, 0xFF, 0xFF, 0xF7, 0xF9, 0xF8, 0x10, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F,
  0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x03, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x07, 0xE1,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC,
  0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xEF, 0xE3, 0xFD, 0xC1, 0xC7,
  0xF3, 0x80, 0x9F, 0xE7, 0x00, 0x3F, 0xCE, 0x00, 0x3F, 0x9C, 0x00, 0x7F,
  0xB8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xEF, 0xF8, 0x01, 0xCF, 0xF0, 0x03, 0x8F,
  0xE0, 0x07, 0x1F, 0xE0, 0x0E, 0x3F, 0xE0, 0x1C, 0x7F, 0xF8, 0x39, 0xFF,
  0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xC0,
  0x03, 0xF7, 0xF0, 0x07, 0xE0, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x1F, 0x81,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x1F,
  0x87, 0xF0, 0x7E, 0x1F, 0x8F, 0x87, 0xFC, 0x3F, 0x0F, 0x8F, 0xC7, 0xFF,
  0x0F, 0xCF, 0xC7, 0xC7, 0xFF, 0xC7, 0xFF, 0xE7, 0xE3, 0xFF, 0xE1, 0xFF,
  0xE3, 0xF3, 0xF1, 0xF8, 0x7F, 0xE3, 0xF1, 0xF8, 0xFC, 0x1F, 0xE1, 0xF8,
  0xFC, 0x3E, 0x03, 0xC1, 0xF8, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x0F,
  0xC0, 0x00, 0x7C, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0x07, 0xC0, 0x3F, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0x03,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x01, 0xFE, 0x1F, 0xFF, 0x01, 0xFC, 0x3F, 0xFF, 0x83, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFC, 0x7F, 0xBF, 0xC3, 0xFC, 0xFF, 0x9F, 0xE7, 0xF8, 0xFF, 0x0F,
  0xF7, 0xF8, 0xFF, 0x0F, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0x03,
  0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE3, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x10,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x20, 0x7E, 0x06, 0x7C, 0x7E, 0x3E, 0x7F, 0xBD,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xC3,
  0xF0, 0x07, 0x81, 0xE0, 0x01, 0x81, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E,
  0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x7F, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x83, 0xFC, 0xFF, 0x03, 0xF9,
  0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F,
  0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF,
  0xBF, 0xDF, 0xFF, 0xCF, 0xEF, 0xC7, 0xF3, 0xC3, 0xF8, 0xC1, 0xFC, 0x40,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0x83, 0xFE, 0x3C, 0x03, 0xFC, 0x30, 0x07, 0xF8, 0x40, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1E, 0x03, 0xFE, 0x10, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x1F,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x7F, 0x00, 0x1F,
  0xBF, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xC7, 0xF0, 0x07,
  0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3E, 0x7F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xA0, 0x03, 0xFE, 0xF0, 0x1F, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0x80, 0x7F, 0x1F, 0xE0, 0xFE,
  0x7F, 0xF1, 0xFD, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0xFF, 0x7F, 0x81, 0xFE,
  0x7F, 0x87, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x9F, 0xF1, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03,
  0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xF0, 0x7F,
  0x8F, 0xF1, 0xFE, 0x1F, 0xF7, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x1F, 0xF7, 0xFC, 0x7F, 0x87, 0xFC, 0xFE, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xBF,
  0xFB, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xC3, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFB, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x3F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xFF, 0x7F, 0x1F, 0xFC, 0xFE, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x7E, 0x7F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF9, 0xFE, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xF0, 0x30, 0x3F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF3, 0xF8,
  0xFC, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE3,
  0xF8, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF0,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0x80, 0xFF, 0x30, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x3F, 0xF8, 0x7E, 0x3F, 0x03, 0xFF, 0xF0,
  0xF8, 0xFC, 0x1F, 0xFF, 0xC3, 0xF3, 0xE0, 0xFF, 0xFF, 0x0F, 0xDF, 0x83,
  0xF8, 0xFC, 0x1F, 0x7E, 0x1F, 0xC3, 0xF0, 0x7D, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF7, 0xC1, 0xF0, 0x3F, 0x07, 0xDF, 0x0F, 0xC0, 0xFC, 0x1F, 0xFC, 0x3F,
  0x03, 0xF0, 0x7F, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x3F, 0x07,
  0xFF, 0x0F, 0xC0, 0xFC, 0x1F, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0xF0, 0xFC,
  0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0x7F, 0x0F, 0xBF, 0x0F, 0xC1, 0xFC, 0x3E,
  0x7C, 0x1F, 0x8F, 0xF1, 0xF9, 0xF0, 0x7F, 0xFF, 0xFF, 0xC7, 0xE0, 0xFF,
  0xEF, 0xFF, 0x1F, 0x83, 0xFF, 0x9F, 0xF8, 0x3E, 0x03, 0xFC, 0x3F, 0xC0,
  0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00,
  0x7F, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFC,
  0x0F, 0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF,
  0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x0F, 0xF3,
  0xFC, 0x07, 0xF9, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xFC, 0x07, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x0F, 0xFF, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xF0, 0x3C, 0x3F, 0xE0, 0x06, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x02, 0x1F, 0xFE, 0x0F, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x02, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xC7, 0xFF, 0xC7, 0xF8, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x0F,
  0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xF0, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xE7,
  0xF8, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x1C,
  0x3F, 0xF0, 0x00, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xDF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x1F,
  0xE7, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF4, 0x3F, 0xEF, 0xFF, 0xDF, 0xFF,
  0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x80, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xCF,
  0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0x8F, 0xF8, 0x0F, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xF0,
  0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0xE1,
  0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xCF,
  0xF0, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF8, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFD, 0xF8, 0x03, 0xF7, 0xFF, 0xEF, 0xC0, 0x1F, 0xBF,
  0xFF, 0x7E, 0x00, 0xFD, 0xFF, 0xFB, 0xF8, 0x0F, 0xCF, 0xFF, 0xCF, 0xC0,
  0x7E, 0x7F, 0xFE, 0x7E, 0x03, 0xF3, 0xFF, 0xF3, 0xF8, 0x3F, 0x9F, 0xFF,
  0x9F, 0xC1, 0xF8, 0xFF, 0xFC, 0x7E, 0x0F, 0xC7, 0xFF, 0xE3, 0xF0, 0x7E,
  0x3F, 0xFF, 0x1F, 0xC7, 0xE1, 0xFF, 0xF8, 0x7E, 0x3F, 0x0F, 0xFF, 0xC3,
  0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0x9F, 0xC3, 0xFF, 0xF0, 0xFE, 0xFC, 0x1F,
  0xFF, 0x83, 0xF7, 0xE0, 0xFF, 0xFC, 0x1F, 0xBF, 0x07, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x0F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0xFE,
  0x03, 0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0x9F, 0xE0,
  0xFF, 0xFE, 0x3F, 0x83, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xE1, 0xFC, 0x3F,
  0xFF, 0x87, 0xF8, 0xFF, 0xFE, 0x0F, 0xE3, 0xFF, 0xF8, 0x3F, 0xC7, 0xFF,
  0xE0, 0x7F, 0x1F, 0xFF, 0x81, 0xFE, 0x7F, 0xFE, 0x07, 0xF9, 0xFF, 0xF8,
  0x0F, 0xF7, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01,
  0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x02,
  0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0x7F, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFB, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xE3, 0xFC, 0x0F,
  0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC,
  0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC7, 0xFF, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0,
  0x7F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xCF, 0xF8, 0x7E, 0x7F, 0x80, 0x67, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF3,
  0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xF0,
  0x07, 0xF8, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE3, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7E, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFB, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xEF, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0xBF, 0x07, 0xF8, 0x0F, 0xE0, 0xFC, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC3, 0xF3, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC7, 0xE1, 0xFC, 0x01, 0xFC,
  0x3F, 0x1F, 0x87, 0xF0, 0x07, 0xF1, 0xFC, 0x7E, 0x3F, 0xC0, 0x1F, 0xC7,
  0xF1, 0xF8, 0xFE, 0x00, 0x7F, 0x9F, 0x87, 0xF3, 0xF8, 0x00, 0xFE, 0x7E,
  0x0F, 0xCF, 0xE0, 0x03, 0xF9, 0xF8, 0x3F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0,
  0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x03, 0xF7, 0xF0, 0x00, 0xFE, 0xFC, 0x0F,
  0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFB,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00,
  0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFB,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0x9F,
  0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00,
  0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xF8, 0x7F, 0xC3, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0x7F, 0xFC, 0xFC, 0xFF, 0xE1, 0xF1,
  0xFF, 0x07, 0xC0, 0x40, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x60, 0x0F, 0xF1, 0xFE, 0x07, 0xF9, 0xFF,
  0x83, 0xFD, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xF0, 0x7F, 0x9F, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xF8,
  0x07, 0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F,
  0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7,
  0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF,
  0x7F, 0xC0, 0x7F, 0xBF, 0xE0, 0x7F, 0xDF, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFD, 0xFF, 0xF0, 0xFE, 0x7F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x87, 0xFC, 0x0C, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x02, 0x7F,
  0xE0, 0x71, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x60, 0x7F, 0x03, 0xFC, 0x7F, 0x0F,
  0xFE, 0x7F, 0x1F, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0x3F, 0x0F, 0xFE, 0x3F, 0x03,
  0xFC, 0x3F, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xF8,
  0xFF, 0x1F, 0xC0, 0xFE, 0x7F, 0x80, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x02, 0x3F, 0xC0, 0x0C, 0x7F, 0xF1, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x0A,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFC, 0x60, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFC, 0x3F, 0x0F,
  0xFE, 0x3F, 0x1F, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0x0F, 0xFE, 0x7F, 0x03,
  0xFC, 0x7F, 0x00, 0x40, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x20, 0x01, 0xFE, 0x3E, 0x07, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x07, 0x00, 0xFF, 0x1F, 0xF0, 0xFF, 0x7F, 0xF8, 0xFF,
  0x7F, 0xFC, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xC1, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x8F,
  0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x07,
  0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC3,
  0xFC, 0x0F, 0xE3, 0xFC, 0x07, 0xF3, 0xFC, 0x03, 0xF9, 0xFE, 0x01, 0xFD,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0x7F, 0x01,
  0xFE, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFE,
  0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x07,
  0xF9, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x0F, 0x01, 0xF8, 0x7F,
  0xE0, 0x7F, 0xC3, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xF7, 0xFF, 0xEF, 0xFF,
  0xCF, 0xEF, 0xFF, 0xDF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xE1, 0xFF, 0xC3, 0xFE, 0xFF, 0x81, 0xFF, 0x83,
  0xFD, 0xFF, 0x03, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xF8,
  0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF,
  0x00, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF8,
  0x07, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x7F,
  0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0x00, 0x07, 0x80, 0xFC, 0x1F, 0xF0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF,
  0xFC, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1,
  0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x7F,
  0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01,
  0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0x8F, 0xFC, 0x1F,
  0xCF, 0xFF, 0x0F, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0x83, 0xFC, 0xFF, 0x80, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xC0, 0x3F,
  0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01,
  0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xBF, 0xC0,
  0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFE,
  0x03, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0xC1, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0x87, 0xF9, 0xFF, 0x83,
  0xFC, 0x7F, 0x81, 0xFE, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xFC, 0x3F, 0x0F, 0xFE, 0x3F, 0x1F, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F,
  0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC1, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0x0F,
  0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x00, 0x40, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x7E, 0x0F,
  0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xC3, 0xE7, 0xF0, 0x0C, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFE, 0x1F, 0xFF, 0x00, 0x14, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xF9, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x11, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFE, 0x00, 0x10, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0x7F, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0x7F, 0x3F, 0xFF, 0x7F, 0x1F, 0xFE, 0x7F, 0x07, 0xF8, 0x3F,
  0x00, 0x40, 0x00, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03,
  0xFD, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x7F, 0x00,
  0xFF, 0x80, 0xFF, 0x7F, 0x01, 0xFF, 0x80, 0xFE, 0x7F, 0x81, 0xFF, 0x80,
  0xFE, 0x7F, 0x81, 0xFF, 0x80, 0xFE, 0x3F, 0x81, 0xFF, 0x81, 0xFE, 0x3F,
  0x81, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xFF, 0xC1, 0xFC, 0x3F, 0xC3, 0xF7,
  0xC1, 0xFC, 0x1F, 0xC3, 0xE7, 0xC3, 0xFC, 0x1F, 0xC3, 0xE7, 0xC3, 0xF8,
  0x1F, 0xC3, 0xE7, 0xE3, 0xF8, 0x1F, 0xE7, 0xE3, 0xE3, 0xF8, 0x0F, 0xE7,
  0xE3, 0xE3, 0xF8, 0x0F, 0xE7, 0xC3, 0xE7, 0xF0, 0x0F, 0xE7, 0xC3, 0xE7,
  0xF0, 0x0F, 0xE7, 0xC3, 0xE7, 0xF0, 0x07, 0xE7, 0xC1, 0xF7, 0xF0, 0x07,
  0xEF, 0xC1, 0xF7, 0xE0, 0x07, 0xFF, 0x81, 0xF7, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0xFF,
  0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F,
  0xF0, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x27, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0x7F, 0xF0, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFE, 0x80, 0x1F, 0xFC, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_Bold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 40, 15, 3, -39 },
  { 46, 19, 14, 25, 3, -39 },
  { 80, 28, 39, 30, 1, -39 },
  { 217, 23, 45, 27, 2, -42 },
  { 347, 41, 41, 45, 2, -40 },
  { 558, 32, 41, 34, 2, -40 },
  { 722, 8, 14, 13, 3, -39 },
  { 736, 15, 48, 18, 2, -39 },
  { 826, 14, 48, 18, 1, -39 },
  { 910, 24, 23, 26, 1, -42 },
  { 979, 23, 27, 27, 2, -33 },
  { 1057, 10, 13, 14, 2, -6 },
  { 1074, 13, 7, 17, 2, -18 },
  { 1086, 9, 9, 14, 3, -8 },
  { 1097, 22, 40, 22, 0, -40 },
  { 1207, 23, 41, 27, 2, -40 },
  { 1325, 17, 39, 27, 3, -39 },
  { 1408, 23, 40, 27, 2, -40 },
  { 1523, 23, 41, 27, 2, -40 },
  { 1641, 25, 39, 27, 1, -39 },
  { 1763, 22, 40, 27, 3, -39 },
  { 1873, 23, 41, 27, 2, -40 },
  { 1991, 24, 39, 27, 1, -39 },
  { 2108, 23, 41, 27, 2, -40 },
  { 2226, 23, 41, 27, 2, -40 },
  { 2344, 9, 31, 15, 3, -30 },
  { 2379, 10, 37, 15, 2, -30 },
  { 2426, 24, 27, 27, 2, -33 },
  { 2507, 24, 17, 27, 2, -28 },
  { 2558, 24, 27, 27, 2, -33 },
  { 2639, 21, 41, 22, 0, -40 },
  { 2747, 38, 44, 43, 2, -40 },
  { 2956, 32, 39, 32, 0, -39 },
  { 3112, 25, 39, 31, 4, -39 },
  { 3234, 25, 41, 29, 3, -40 },
  { 3363, 27, 39, 34, 4, -39 },
  { 3495, 19, 39, 26, 4, -39 },
  { 3588, 19, 39, 26, 4, -39 },
  { 3681, 27, 41, 34, 3, -40 },
  { 3820, 27, 39, 35, 4, -39 },
  { 3952, 16, 39, 19, 1, -39 },
  { 4030, 15, 51, 16, -3, -39 },
  { 4126, 27, 39, 31, 4, -39 },
  { 4258, 20, 39, 25, 4, -39 },
  { 4356, 37, 39, 45, 4, -39 },
  { 4537, 30, 39, 38, 4, -39 },
  { 4684, 30, 41, 36, 3, -40 },
  { 4838, 23, 39, 29, 4, -39 },
  { 4951, 30, 49, 36, 3, -40 },
  { 5135, 26, 39, 31, 4, -39 },
  { 5262, 21, 41, 25, 2, -40 },
  { 5370, 24, 39, 26, 1, -39 },
  { 5487, 27, 40, 34, 4, -39 },
  { 5622, 30, 39, 30, 0, -39 },
  { 5769, 46, 39, 45, -1, -39 },
  { 5994, 29, 39, 29, 0, -39 },
  { 6136, 29, 39, 29, 0, -39 },
  { 6278, 23, 39, 25, 1, -39 },
  { 6391, 13, 48, 17, 3, -39 },
  { 6469, 22, 40, 22, 0, -40 },
  { 6579, 13, 48, 17, 1, -39 },
  { 6657, 28, 24, 30, 1, -39 },
  { 6741, 23, 4, 23, 0, 5 },
  { 6753, 14, 9, 18, 2, -42 },
  { 6769, 22, 32, 28, 2, -31 },
  { 6857, 25, 43, 30, 3, -42 },
  { 6992, 21, 32, 24, 2, -31 },
  { 7076, 24, 43, 30, 2, -42 },
  { 7205, 23, 32, 27, 2, -31 },
  { 7297, 19, 42, 18, 1, -42 },
  { 7397, 24, 44, 30, 2, -31 },
  { 7529, 24, 42, 30, 3, -42 },
  { 7655, 8, 42, 14, 3, -42 },
  { 7697, 13, 55, 14, -2, -42 },
  { 7787, 25, 42, 29, 4, -42 },
  { 7919, 8, 42, 14, 3, -42 },
  { 7961, 39, 31, 45, 3, -31 },
  { 8113, 24, 31, 30, 3, -31 },
  { 8206, 25, 32, 29, 2, -31 },
  { 8306, 25, 44, 30, 3, -31 },
  { 8444, 24, 44, 30, 2, -31 },
  { 8576, 17, 31, 21, 3, -31 },
  { 8642, 19, 32, 23, 2, -31 },
  { 8718, 18, 37, 20, 1, -36 },
  { 8802, 24, 31, 30, 3, -30 },
  { 8895, 26, 30, 27, 0, -30 },
  { 8993, 40, 30, 40, 0, -30 },
  { 9143, 26, 30, 26, 0, -30 },
  { 9241, 26, 43, 27, 0, -30 },
  { 9381, 20, 30, 22, 1, -30 },
  { 9456, 17, 48, 20, 1, -39 },
  { 9558, 6, 55, 26, 10, -42 },
  { 9600, 17, 48, 20, 2, -39 },
  { 9702, 24, 9, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_Bold55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_BOLD55PT7B_H_
