#ifndef _NOTOSANS_CONDENSED_BOLD26PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x70, 0x07, 0xFF, 0x70, 0xF3,
  0xF9, 0xFC, 0xEE, 0x77, 0x3B, 0x9D, 0xCE, 0x0E, 0x60, 0x67, 0x03, 0x38,
  0x19, 0xC1, 0xCC, 0x0E, 0x63, 0xFF, 0xFF, 0xFF, 0x19, 0xC0, 0xCE, 0x0E,
  0x71, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0xCE, 0x06, 0x70, 0x33, 0x83, 0x98,
  0x1C, 0xC0, 0x04, 0x00, 0x80, 0x7E, 0x1F, 0xF7, 0xFD, 0xE9, 0xBD, 0x07,
  0xA0, 0x7C, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x0B, 0xE1, 0x7E, 0x2F,
  0xFF, 0xDF, 0xF0, 0x78, 0x02, 0x00, 0x40, 0x08, 0x00, 0x38, 0x0E, 0x0F,
  0x81, 0x83, 0xF8, 0x70, 0x73, 0x0E, 0x0E, 0x73, 0x81, 0xCE, 0x70, 0x39,
  0xCC, 0x07, 0x3B, 0x80, 0xE6, 0x67, 0xDF, 0xDD, 0xF9, 0xF3, 0xBB, 0x9C,
  0xE6, 0x70, 0x1D, 0xCE, 0x07, 0x39, 0xC0, 0xE3, 0x38, 0x18, 0x67, 0x07,
  0x0E, 0xE0, 0xC1, 0xF8, 0x38, 0x1F, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0xFF,
  0x03, 0xCE, 0x07, 0x1C, 0x0F, 0x38, 0x1E, 0xF0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7C, 0x39, 0xFC, 0xF7, 0xBD, 0xEF, 0x3F, 0x9C, 0x7F, 0x3C, 0x7E, 0x78,
  0x78, 0xFF, 0xF8, 0xFF, 0xF8, 0xFE, 0xF8, 0xFF, 0xF7, 0x77, 0x70, 0x0E,
  0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C,
  0x78, 0x70, 0xE1, 0xE1, 0xC3, 0x83, 0x87, 0x80, 0xF0, 0xE0, 0xE1, 0xC1,
  0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x38,
  0x71, 0xE3, 0x8F, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x66, 0x6F, 0xFD,
  0xFF, 0xC7, 0x81, 0xF8, 0x7B, 0x8E, 0x78, 0xC4, 0x00, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x77, 0x7F, 0xEE, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0x01, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xE0,
  0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0F, 0x00, 0x1E, 0x07,
  0xF1, 0xFF, 0x3D, 0xEF, 0x1D, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x73, 0x8E, 0x7F, 0xC7, 0xF0, 0x7C,
  0x00, 0x03, 0x83, 0xC7, 0xE7, 0xF7, 0xFF, 0xBD, 0x9E, 0x4F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1E,
  0x0F, 0xF3, 0xFF, 0x79, 0xE4, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1E, 0x1F, 0xF3, 0xFF, 0x31, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x3F, 0x87, 0xE0, 0xFF, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x1F,
  0xFF, 0xDF, 0xF3, 0xFC, 0x00, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0D, 0xE1, 0xDE, 0x19, 0xE3, 0x9E, 0x31, 0xE7, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0x00, 0xE0, 0x1C, 0x03, 0xF8, 0x7F, 0x9F, 0xF9,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x1E, 0xFF, 0xDF, 0xF1, 0xFC,
  0x00, 0x07, 0xC3, 0xF8, 0xFF, 0x3E, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x3C,
  0xEF, 0xDF, 0xFB, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xFC, 0x7B, 0x8F, 0x7F,
  0xC7, 0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0xF1, 0xFF, 0x78,
  0xEF, 0x1F, 0xE3, 0x9C, 0x73, 0xFE, 0x3F, 0x83, 0xE1, 0xFE, 0x3D, 0xEF,
  0x1F, 0xC1, 0xF8, 0x3F, 0x8F, 0xFF, 0xEF, 0xF8, 0xFE, 0x00, 0x1E, 0x07,
  0xF1, 0xFF, 0x79, 0xEF, 0x1D, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1, 0xFF, 0xFD,
  0xFB, 0xBF, 0x70, 0x9E, 0x03, 0x80, 0x70, 0x1E, 0x7F, 0x8F, 0xE1, 0xF8,
  0x00, 0x77, 0xFC, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xEF, 0xB8, 0x77, 0xDC,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x3B, 0xDC, 0xE0, 0x00, 0x20, 0x0C,
  0x07, 0x83, 0xF1, 0xF9, 0xF8, 0x3C, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x18, 0x03, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x78,
  0x3F, 0x1F, 0x8F, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x1E, 0x3F, 0xEF, 0xFD,
  0x9F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x70, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x3C, 0x0F, 0x81, 0xC0, 0x01, 0xF0, 0x01, 0xFF,
  0x01, 0xFB, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x9C, 0x3C, 0x67, 0x3F, 0x9D,
  0x9E, 0x67, 0xE7, 0x39, 0xF9, 0xCE, 0x7E, 0x63, 0x9F, 0x98, 0xE7, 0xE7,
  0x39, 0xF9, 0xCE, 0x6E, 0x7F, 0xF9, 0x8F, 0x3C, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xE0, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xB8, 0x0F, 0x78, 0x1C,
  0x70, 0x38, 0xE0, 0xF1, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x1F, 0xFF,
  0x3C, 0x1E, 0x78, 0x3D, 0xE0, 0x3F, 0xC0, 0x78, 0xFE, 0x0F, 0xFC, 0xFF,
  0xEF, 0x3E, 0xF1, 0xEF, 0x0E, 0xF1, 0xEF, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF,
  0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF,
  0x00, 0x07, 0xC1, 0xFF, 0x3F, 0xF3, 0xE6, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07,
  0xC1, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0xF8, 0x07, 0xFC, 0x3F, 0xF1, 0xFF,
  0xCF, 0x1F, 0x78, 0x7B, 0xC3, 0xDE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0x78, 0x7B, 0xC3, 0xDE, 0x7C, 0xFF, 0xE7, 0xFE, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0x7F,
  0xC7, 0xFE, 0x7C, 0x67, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x03, 0xBC, 0x1D, 0xE0, 0xEF, 0x87, 0x3F,
  0xF8, 0xFF, 0xC3, 0xFC, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xFF,
  0xFF, 0xF9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x7D, 0xFF, 0xF8, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0E, 0xFE, 0xFE, 0xFC, 0xF0, 0x7F, 0x87, 0xBC, 0x79, 0xE3, 0xCF, 0x3C,
  0x7B, 0xC3, 0xDE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F,
  0x78, 0x79, 0xE3, 0xCF, 0x1E, 0x3C, 0xF1, 0xE7, 0x87, 0xBC, 0x3E, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xB8, 0x7F,
  0xDC, 0x77, 0xEE, 0x3B, 0xF7, 0x1D, 0xF9, 0xCC, 0xFC, 0xEE, 0x7E, 0x77,
  0x3F, 0x3B, 0x9F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE3, 0xF0, 0xE1, 0xF8,
  0x70, 0xE0, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF8,
  0xFE, 0xE3, 0xFB, 0xCF, 0xE7, 0x3F, 0x9E, 0x7E, 0x79, 0xF8, 0xF7, 0xE3,
  0xDF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xC0,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE7, 0xC7, 0x83, 0xCF, 0x07, 0xBC,
  0x07, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xEF, 0x07, 0x9E, 0x0F, 0x3E, 0x3E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80,
  0xF8, 0x1F, 0xF3, 0xFF, 0x7F, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFF, 0xFB, 0xFF, 0x7F, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE7, 0xC7, 0x83,
  0xCF, 0x07, 0xBC, 0x07, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xEF, 0x07, 0x9E, 0x0F, 0x3E, 0x3E, 0x3F, 0xF8, 0x3F,
  0xE0, 0x3F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0xF8,
  0x0F, 0xF8, 0xFF, 0xCF, 0x7E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3,
  0xCF, 0xFC, 0xFF, 0x8F, 0xF8, 0xF7, 0x8F, 0x3C, 0xF3, 0xCF, 0x1E, 0xF1,
  0xEF, 0x0F, 0xF0, 0xF0, 0x1F, 0x0F, 0xF7, 0xFF, 0xEE, 0xF0, 0xBC, 0x0F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x3F, 0x0F,
  0xFF, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0x7F, 0xF7, 0xFE,
  0x1F, 0xC0, 0xF0, 0x1F, 0xC0, 0x77, 0x03, 0xDC, 0x0E, 0x78, 0x39, 0xE1,
  0xE3, 0x87, 0x8E, 0x1C, 0x3C, 0x70, 0xF3, 0xC1, 0xCF, 0x07, 0x38, 0x1E,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x00,
  0xE0, 0x70, 0x3F, 0x83, 0x83, 0xFC, 0x1E, 0x1F, 0xE1, 0xF0, 0xF7, 0x0F,
  0x87, 0x38, 0x7C, 0x39, 0xE3, 0x63, 0xCF, 0x3B, 0x9E, 0x39, 0xDC, 0xF1,
  0xCE, 0xE7, 0x0E, 0x77, 0x38, 0x73, 0x9D, 0xC3, 0xF8, 0xFE, 0x0F, 0xC7,
  0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03,
  0xC1, 0xE0, 0xF0, 0x79, 0xE1, 0xE7, 0x87, 0x0F, 0x3C, 0x3C, 0xE0, 0x77,
  0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x83, 0xCE, 0x0F, 0x3C, 0x78, 0x79, 0xE1, 0xEF, 0x03, 0xC0,
  0xF0, 0x3F, 0xC1, 0xE7, 0x87, 0x9E, 0x3C, 0x38, 0xF0, 0xF3, 0x81, 0xDE,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xFF, 0xC0, 0xE0, 0x1C, 0x07,
  0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0xFF, 0xFF, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x01, 0xF8, 0x0F,
  0xC0, 0xE7, 0x07, 0x38, 0x70, 0xE3, 0x87, 0x38, 0x1D, 0xC0, 0xF0, 0xFF,
  0xFF, 0xFC, 0xF1, 0xE3, 0xC7, 0x7F, 0x8F, 0xF8, 0xCF, 0x00, 0xE0, 0x1E,
  0x3F, 0xDF, 0xFF, 0xEF, 0xF1, 0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0xEE, 0xF9,
  0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xE7, 0xFE,
  0xFF, 0xDE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1,
  0xFF, 0xFB, 0xFF, 0x77, 0xC0, 0x1F, 0xCF, 0xE7, 0xF9, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x05, 0xFE, 0x3F, 0x87, 0xE0, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xCF, 0xBB, 0xFF, 0x7F, 0xFE,
  0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xEF, 0xFD,
  0xFF, 0x9F, 0x70, 0x3F, 0x8F, 0xF9, 0xEF, 0x78, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xC0, 0xBF, 0xE3, 0xFC, 0x3F, 0x80, 0x0F,
  0x8F, 0xCF, 0xE7, 0x83, 0xC1, 0xE1, 0xFD, 0xFE, 0xFF, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x3E, 0xEF,
  0xFD, 0xFF, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC7, 0xBF, 0xF7, 0xFE, 0x7D, 0xC0, 0x38, 0x07, 0x41, 0xEF, 0xFD, 0xFF,
  0x3F, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xE7,
  0xFE, 0xFF, 0xDE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xF0, 0x67, 0xF7, 0x00, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x18, 0x73, 0xC7, 0x00, 0x01, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xFF, 0xFB, 0xE0,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE1, 0xEE, 0x3C,
  0xE3, 0x8E, 0x78, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7, 0x8E, 0x78,
  0xE3, 0xCE, 0x3C, 0xE1, 0xEE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xEF, 0x9F, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xC7, 0x8F, 0xE1,
  0xE3, 0xF8, 0x70, 0xFE, 0x1C, 0x3F, 0x87, 0x0F, 0xE1, 0xC3, 0xF8, 0x70,
  0xFE, 0x1C, 0x3F, 0x87, 0x0F, 0xE1, 0xC3, 0xF8, 0x70, 0xF0, 0xEF, 0x9F,
  0xFB, 0xFF, 0x78, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xC0, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0x0E,
  0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0x71, 0xE7, 0xFE,
  0x3F, 0xC1, 0xF8, 0xEF, 0x9F, 0xFB, 0xEF, 0x78, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xFF, 0xEF, 0xFD, 0xDF, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x3E, 0xEF, 0xFD, 0xFF, 0xF8,
  0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xBF, 0xF7,
  0xFE, 0x7D, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xCF,
  0xFE, 0xFE, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x7F, 0xFF, 0xBC, 0xDC, 0x0F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0x83,
  0xE1, 0xFF, 0xFF, 0xF7, 0xF0, 0x18, 0x0C, 0x0E, 0x0F, 0xFF, 0xFF, 0xFC,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0xFE, 0x7F, 0x1F,
  0x80, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0xCF, 0xFF, 0xFF, 0xFE, 0xF9, 0xC0, 0xF0, 0x77, 0x0F,
  0x70, 0xF7, 0x8E, 0x78, 0xE3, 0x9E, 0x39, 0xC3, 0xDC, 0x1D, 0xC1, 0xFC,
  0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0xF1, 0xF1, 0xEE, 0x3E, 0x39, 0xC7,
  0xC7, 0x3C, 0xD8, 0xE7, 0x9B, 0x3C, 0x77, 0x77, 0x8E, 0xEE, 0xE1, 0xDC,
  0xDC, 0x3B, 0x1B, 0x87, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x3E, 0x00, 0xF0, 0xF7, 0x9E, 0x39, 0xE3, 0xFC, 0x1F, 0xC1,
  0xF8, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0xFC, 0x3D, 0xC7, 0x9E, 0x78, 0xEF,
  0x0F, 0xF0, 0x77, 0x0F, 0x78, 0xF7, 0x8E, 0x38, 0xE3, 0x9E, 0x3D, 0xC1,
  0xDC, 0x1D, 0xC1, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0,
  0xE0, 0xF0, 0x70, 0x78, 0x78, 0x3C, 0x3C, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0x0F, 0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFC, 0xF8, 0xFC,
  0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1F, 0x0F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0xF0, 0xF8, 0x78,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3F, 0x0F, 0x1F, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xF0, 0xFC, 0x3F, 0xFF, 0x7F, 0xC1,
  0xE0,
};

const GFXglyph NotoSans_Condensed_Bold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 19, 7, 1, -19 },
  { 11, 9, 7, 12, 1, -19 },
  { 19, 13, 19, 14, 1, -19 },
  { 50, 11, 22, 13, 1, -20 },
  { 81, 19, 19, 21, 1, -19 },
  { 127, 15, 19, 16, 1, -19 },
  { 163, 4, 7, 6, 1, -19 },
  { 167, 7, 23, 8, 1, -19 },
  { 188, 7, 23, 8, 0, -19 },
  { 209, 11, 11, 12, 1, -20 },
  { 225, 11, 12, 13, 1, -15 },
  { 242, 4, 6, 7, 1, -3 },
  { 245, 6, 4, 8, 1, -9 },
  { 248, 4, 4, 7, 1, -4 },
  { 250, 10, 19, 11, 0, -19 },
  { 274, 11, 19, 13, 1, -19 },
  { 301, 9, 19, 13, 1, -19 },
  { 323, 11, 19, 13, 1, -19 },
  { 350, 11, 19, 13, 1, -19 },
  { 377, 12, 19, 13, 0, -19 },
  { 406, 11, 19, 13, 1, -19 },
  { 433, 11, 19, 13, 1, -19 },
  { 460, 11, 19, 13, 1, -19 },
  { 487, 11, 19, 13, 1, -19 },
  { 514, 11, 19, 13, 1, -19 },
  { 541, 5, 14, 7, 1, -14 },
  { 550, 5, 17, 7, 1, -14 },
  { 561, 11, 13, 13, 1, -16 },
  { 579, 11, 8, 13, 1, -13 },
  { 590, 11, 13, 13, 1, -16 },
  { 608, 10, 19, 10, 0, -19 },
  { 632, 18, 21, 20, 1, -19 },
  { 680, 15, 19, 15, 0, -19 },
  { 716, 12, 19, 15, 2, -19 },
  { 745, 12, 19, 14, 1, -19 },
  { 774, 13, 19, 16, 2, -19 },
  { 805, 9, 19, 12, 2, -19 },
  { 827, 9, 19, 12, 2, -19 },
  { 849, 13, 19, 16, 1, -19 },
  { 880, 13, 19, 17, 2, -19 },
  { 911, 7, 19, 9, 1, -19 },
  { 928, 8, 24, 8, -2, -19 },
  { 952, 13, 19, 15, 2, -19 },
  { 983, 9, 19, 12, 2, -19 },
  { 1005, 17, 19, 21, 2, -19 },
  { 1046, 14, 19, 18, 2, -19 },
  { 1080, 15, 19, 17, 1, -19 },
  { 1116, 11, 19, 14, 2, -19 },
  { 1143, 15, 23, 17, 1, -19 },
  { 1187, 12, 19, 14, 2, -19 },
  { 1216, 10, 19, 12, 1, -19 },
  { 1240, 12, 19, 12, 0, -19 },
  { 1269, 12, 19, 16, 2, -19 },
  { 1298, 14, 19, 14, 0, -19 },
  { 1332, 21, 19, 21, 0, -19 },
  { 1382, 14, 19, 14, 0, -19 },
  { 1416, 14, 19, 14, 0, -19 },
  { 1450, 12, 19, 12, 0, -19 },
  { 1479, 6, 23, 8, 2, -19 },
  { 1497, 10, 19, 11, 0, -19 },
  { 1521, 6, 23, 8, 1, -19 },
  { 1539, 13, 12, 14, 1, -19 },
  { 1559, 11, 2, 11, 0, 2 },
  { 1562, 6, 4, 9, 1, -20 },
  { 1565, 11, 14, 13, 1, -14 },
  { 1585, 11, 20, 14, 2, -20 },
  { 1613, 10, 14, 11, 1, -14 },
  { 1631, 11, 20, 14, 1, -20 },
  { 1659, 11, 14, 13, 1, -14 },
  { 1679, 9, 20, 8, 0, -20 },
  { 1702, 11, 20, 14, 1, -14 },
  { 1730, 11, 20, 14, 2, -20 },
  { 1758, 4, 20, 7, 1, -20 },
  { 1768, 6, 26, 7, -1, -20 },
  { 1788, 12, 20, 14, 2, -20 },
  { 1818, 3, 20, 7, 2, -20 },
  { 1826, 18, 14, 21, 2, -14 },
  { 1858, 11, 14, 14, 2, -14 },
  { 1878, 12, 14, 14, 1, -14 },
  { 1899, 11, 20, 14, 2, -14 },
  { 1927, 11, 20, 14, 1, -14 },
  { 1955, 8, 14, 10, 2, -14 },
  { 1969, 9, 14, 11, 1, -14 },
  { 1985, 9, 17, 9, 0, -17 },
  { 2005, 11, 14, 14, 2, -14 },
  { 2025, 12, 14, 13, 0, -14 },
  { 2046, 19, 14, 19, 0, -14 },
  { 2080, 12, 14, 12, 0, -14 },
  { 2101, 12, 20, 13, 0, -14 },
  { 2131, 9, 14, 10, 1, -14 },
  { 2147, 8, 23, 9, 0, -19 },
  { 2170, 3, 26, 12, 5, -20 },
  { 2180, 8, 23, 9, 1, -19 },
  { 2203, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_Bold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_BOLD26PT7B_H_
