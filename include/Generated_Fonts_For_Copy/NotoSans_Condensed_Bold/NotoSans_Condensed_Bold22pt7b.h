#ifndef _NOTOSANS_CONDENSED_BOLD22PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xEE, 0xE6, 0x66, 0x60, 0x0E, 0xFE, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x66, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0D, 0xC7, 0xFF,
  0x7F, 0xF1, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xEF, 0xFE, 0x3B, 0x03, 0x30,
  0x33, 0x03, 0x30, 0x08, 0x04, 0x0F, 0xCF, 0xFF, 0xB7, 0x43, 0xA1, 0xF0,
  0x7C, 0x0F, 0x83, 0xE1, 0x78, 0xBF, 0x7F, 0xFC, 0xFC, 0x08, 0x04, 0x00,
  0x78, 0x30, 0xF8, 0x30, 0xCC, 0x70, 0xCC, 0x60, 0xCC, 0xE0, 0xCC, 0xC0,
  0xCD, 0xCC, 0xCD, 0xBE, 0xFD, 0xBF, 0x7B, 0x33, 0x03, 0x33, 0x07, 0x33,
  0x06, 0x33, 0x0E, 0x33, 0x0C, 0x3F, 0x1C, 0x1E, 0x1E, 0x01, 0xF8, 0x1F,
  0xC0, 0xE6, 0x07, 0x30, 0x3B, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x77, 0x73,
  0xB9, 0xF9, 0xCF, 0xCE, 0x3C, 0x7B, 0xE3, 0xFF, 0x8F, 0xCF, 0xFF, 0xFE,
  0xC0, 0x1C, 0xE3, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x86,
  0x1C, 0x70, 0xE3, 0xC0, 0xE1, 0xC3, 0x0E, 0x18, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xCF, 0x00, 0x1C, 0x0C, 0x06, 0x1F, 0x7F,
  0xF8, 0xE0, 0xF8, 0xEE, 0xE6, 0x12, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x8F,
  0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x7E, 0xEE, 0xEC, 0xFF,
  0xC0, 0xEF, 0xE0, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38,
  0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0x3C, 0x3F, 0x9F,
  0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3B,
  0xB9, 0xFC, 0x7C, 0x0E, 0x3C, 0xFB, 0xFF, 0xED, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x3C, 0x7F, 0xBF, 0xC8, 0xF0, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x7C,
  0x7F, 0xBF, 0xC8, 0x70, 0x38, 0x18, 0x3C, 0x78, 0x3F, 0x03, 0xC0, 0xE0,
  0x70, 0x3E, 0x7F, 0xFD, 0xFC, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x37, 0x06, 0xE1, 0x9C, 0x73, 0x8C, 0x73, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0xE0, 0x1C, 0x7F, 0x3F, 0x9F, 0xCC, 0x0E, 0x07, 0x03, 0xF9, 0xFE,
  0x7F, 0x81, 0xC0, 0xE0, 0x70, 0x3E, 0x7B, 0xFD, 0xFC, 0x0F, 0x1F, 0x9F,
  0xCE, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xF7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0xBD, 0xFC, 0x7C, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x03, 0x80, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x3E,
  0x3F, 0xBD, 0xFC, 0x7E, 0x3F, 0x39, 0xFC, 0x7C, 0x7E, 0x7B, 0xB8, 0xFC,
  0x7E, 0x3F, 0x1F, 0xFC, 0xFC, 0x3C, 0x3F, 0x3F, 0xDC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xCF, 0xFF, 0xBF, 0xC4, 0xE0, 0x70, 0x74, 0x7B, 0xF9, 0xF8, 0xEF,
  0xF0, 0x00, 0x00, 0x0E, 0xFE, 0x6F, 0xF0, 0x00, 0x00, 0x07, 0x7E, 0xEE,
  0xC0, 0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x80, 0x70, 0x3E,
  0x07, 0xC0, 0x78, 0x3C, 0x7C, 0xF8, 0xF0, 0x60, 0x00, 0x3C, 0xFF, 0x7F,
  0x47, 0x07, 0x07, 0x0F, 0x1E, 0x1C, 0x18, 0x18, 0x00, 0x00, 0x38, 0x3C,
  0x38, 0x07, 0xC0, 0x3F, 0xE0, 0xF0, 0xE1, 0x80, 0x66, 0x3C, 0xEC, 0xFC,
  0xFB, 0x99, 0xE6, 0x33, 0xCC, 0x67, 0x98, 0xCF, 0x33, 0x9E, 0x77, 0x6E,
  0x7B, 0xCC, 0x42, 0x1C, 0x00, 0x1C, 0x18, 0x1F, 0xF0, 0x0F, 0x80, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xD8, 0x0E, 0xE0, 0x77, 0x07, 0x38,
  0x38, 0xE1, 0xC7, 0x0F, 0xF8, 0xFF, 0xC7, 0x0F, 0x38, 0x3B, 0xC1, 0xDC,
  0x0F, 0xFC, 0x3F, 0xCF, 0xFB, 0x8E, 0xE3, 0xB8, 0xEE, 0x7B, 0xF8, 0xFF,
  0x38, 0xEE, 0x3B, 0x8F, 0xE3, 0xBF, 0xEF, 0xF3, 0xF8, 0x0F, 0x8F, 0xF3,
  0xFD, 0xE1, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0,
  0x70, 0x1F, 0x73, 0xFC, 0x7E, 0xFC, 0x3F, 0xCF, 0xFB, 0x8F, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xFF, 0xEF, 0xF3,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xC3, 0x87, 0x0E,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFF,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0x0F, 0xC3, 0xFC, 0xFF, 0x3C, 0x17, 0x01,
  0xE0, 0x38, 0x07, 0x1F, 0xE3, 0xFC, 0x7F, 0x83, 0xF8, 0x77, 0x0E, 0xFB,
  0xCF, 0xF8, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF,
  0xF7, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0xFF, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0xFF, 0xBE, 0xE0, 0xE1, 0xF8, 0xFE, 0x3B, 0x9C, 0xEF, 0x3B, 0x8F, 0xE3,
  0xF0, 0xFE, 0x3F, 0x8E, 0xF3, 0x9C, 0xE7, 0xB8, 0xEE, 0x3F, 0x87, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xD8, 0x6F,
  0x61, 0xBD, 0xCE, 0xF7, 0x3B, 0xEC, 0xCF, 0xB3, 0x3E, 0xFC, 0xFB, 0xE3,
  0xE7, 0x8F, 0x9E, 0x3E, 0x78, 0xF9, 0xC3, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC,
  0x3F, 0x87, 0xB8, 0xF7, 0x1E, 0x73, 0xCE, 0x78, 0xEF, 0x1D, 0xE1, 0xFC,
  0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0F, 0xF0,
  0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x70,
  0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0xFC, 0x7F, 0xBF, 0xDC, 0xFE, 0x3F, 0x1F,
  0x8F, 0xCF, 0xFF, 0x7F, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x0F,
  0x83, 0xFC, 0x7F, 0xE7, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xCF, 0xFB, 0x9E, 0xE3, 0xB8,
  0xEE, 0x3B, 0xFC, 0xFE, 0x3F, 0x8E, 0xE3, 0x9C, 0xE7, 0x38, 0xEE, 0x3B,
  0x8F, 0x3E, 0x7F, 0xFF, 0xE1, 0xE0, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07,
  0x07, 0x87, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFD, 0xF7, 0xF8, 0xFC, 0xE0, 0x7E, 0x07,
  0x70, 0x67, 0x0E, 0x70, 0xE7, 0x0E, 0x38, 0xC3, 0x9C, 0x39, 0xC1, 0x9C,
  0x1D, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0xE0, 0xC1, 0xF8,
  0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x8E, 0x71, 0xE3, 0x9C, 0xF8, 0xE7, 0x3F,
  0x39, 0xCD, 0xCE, 0x33, 0x37, 0x0E, 0xCD, 0xC3, 0xF3, 0x70, 0xFC, 0xFC,
  0x3E, 0x3E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0xF0, 0xE7, 0x1E,
  0x79, 0xC3, 0x9C, 0x3B, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x83, 0xB8, 0x39, 0xC7, 0x9C, 0x70, 0xEF, 0x0F, 0xE0, 0xEE, 0x1D,
  0xC7, 0x3C, 0xE3, 0x9C, 0x77, 0x07, 0xE0, 0xF8, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0xFF, 0xF0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0xFF, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0xF0, 0x06,
  0x00, 0xC0, 0x3C, 0x07, 0x81, 0xF8, 0x33, 0x0E, 0x71, 0x86, 0x70, 0xFC,
  0x0C, 0xFF, 0x80, 0xE3, 0x8E, 0x30, 0x7E, 0x3F, 0x99, 0xE0, 0x70, 0x3B,
  0xFF, 0xCF, 0xC7, 0xE3, 0xF3, 0xFF, 0xEF, 0x70, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3B, 0xCF, 0xFB, 0xCF, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xFC, 0x7F, 0x3B, 0xFE, 0xEF, 0x00, 0x3F, 0x7F, 0x72, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xF3, 0x7F, 0x3E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xCF, 0x77, 0xFF, 0xCF, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFF,
  0x3D, 0xFF, 0x3D, 0xC0, 0x3E, 0x3F, 0xBC, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF,
  0xC0, 0xE0, 0x38, 0xDF, 0xE7, 0xE0, 0x0F, 0x3F, 0x3E, 0x38, 0x38, 0x7E,
  0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3D,
  0xDF, 0xFF, 0x3F, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xFC, 0xF7,
  0xDC, 0xF7, 0x01, 0x80, 0xEC, 0x7B, 0xFC, 0xFE, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3B, 0xCF, 0xFB, 0xEF, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x6F, 0xE0, 0x0E, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xE0, 0x19, 0xCE, 0x00, 0x1C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC3, 0xB8, 0xE7, 0x3C, 0xE7, 0x1D, 0xC3, 0xF8, 0x7F, 0x0F, 0x71,
  0xCF, 0x38, 0xE7, 0x0E, 0xE1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xEF, 0x3C, 0xFF, 0xFE, 0xF3, 0xEE, 0xF3, 0xCF, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3,
  0xC7, 0xEF, 0x3F, 0xEF, 0x3F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0x3E, 0x1F, 0xEF, 0x3B, 0x8E, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE3, 0x9C, 0xE7, 0xF8, 0xF8, 0xEF, 0x3F, 0xEF, 0x3F, 0xC7,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0xEF, 0xFB, 0xBC, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x00, 0x3D, 0xDF, 0xFF, 0x3F, 0x8F, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE3, 0xFC, 0xF7, 0xDC, 0xF7, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xEF, 0xFF, 0xFF, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x00, 0x7F, 0xFF, 0x8F, 0x0F, 0x0F, 0x8F, 0x87, 0x0F, 0x1F, 0xFF,
  0xE0, 0x18, 0x70, 0xE3, 0xFF, 0xE7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0xA7, 0xC7, 0x80, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE3, 0xFD, 0xF7, 0xFC, 0xF7, 0xE1, 0xEE, 0x39, 0xC7, 0x38, 0xC7,
  0x38, 0x77, 0x0E, 0xE1, 0xD8, 0x1F, 0x03, 0xE0, 0x78, 0x07, 0x00, 0xE3,
  0xC7, 0xE3, 0xC7, 0x73, 0xCE, 0x73, 0xCE, 0x77, 0x6E, 0x76, 0x6E, 0x36,
  0x6C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x38, 0x1C, 0x38, 0xF1,
  0xDC, 0xE3, 0xB8, 0xFC, 0x1F, 0x07, 0x81, 0xE0, 0xFC, 0x3F, 0x1C, 0xE7,
  0x3B, 0xC7, 0xE1, 0xEE, 0x39, 0xC7, 0x38, 0xC3, 0x38, 0x77, 0x0E, 0xE1,
  0xD8, 0x1F, 0x03, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x03, 0xE0,
  0x78, 0x00, 0x7F, 0x7F, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x78, 0x70,
  0xFF, 0xFF, 0x06, 0x3C, 0x78, 0xC1, 0x83, 0x06, 0x0C, 0x39, 0xE3, 0xE1,
  0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x3C, 0x78, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC1, 0xE3, 0xC3, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x3C, 0xF9,
  0xC3, 0x06, 0x0C, 0x18, 0x71, 0xE3, 0xC4, 0x00, 0x20, 0xFE, 0x7F, 0xF1,
  0xF0,
};

const GFXglyph NotoSans_Condensed_Bold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 10, 1, -16 },
  { 15, 12, 16, 12, 0, -16 },
  { 39, 9, 18, 11, 1, -17 },
  { 60, 16, 16, 18, 1, -16 },
  { 92, 13, 16, 14, 1, -16 },
  { 118, 3, 6, 5, 1, -16 },
  { 121, 6, 19, 7, 1, -16 },
  { 136, 6, 19, 7, 0, -16 },
  { 151, 9, 10, 10, 1, -17 },
  { 163, 9, 11, 11, 1, -13 },
  { 176, 4, 6, 6, 1, -3 },
  { 179, 5, 2, 7, 1, -7 },
  { 181, 4, 3, 6, 1, -3 },
  { 183, 9, 16, 9, 0, -16 },
  { 201, 9, 16, 11, 1, -16 },
  { 219, 7, 16, 11, 1, -16 },
  { 233, 9, 16, 11, 1, -16 },
  { 251, 9, 16, 11, 1, -16 },
  { 269, 11, 16, 11, 0, -16 },
  { 291, 9, 16, 11, 1, -16 },
  { 309, 9, 16, 11, 1, -16 },
  { 327, 10, 16, 11, 0, -16 },
  { 347, 9, 16, 11, 1, -16 },
  { 365, 9, 16, 11, 1, -16 },
  { 383, 4, 12, 6, 1, -12 },
  { 389, 4, 15, 6, 1, -12 },
  { 397, 9, 10, 11, 1, -13 },
  { 409, 9, 7, 11, 1, -11 },
  { 417, 9, 10, 11, 1, -13 },
  { 429, 8, 16, 9, 0, -16 },
  { 445, 15, 18, 17, 1, -16 },
  { 479, 13, 16, 13, 0, -16 },
  { 505, 10, 16, 13, 2, -16 },
  { 525, 10, 16, 12, 1, -16 },
  { 545, 10, 16, 13, 2, -16 },
  { 565, 7, 16, 10, 2, -16 },
  { 579, 7, 16, 10, 2, -16 },
  { 593, 11, 16, 13, 1, -16 },
  { 615, 10, 16, 14, 2, -16 },
  { 635, 6, 16, 7, 1, -16 },
  { 647, 6, 21, 6, -1, -16 },
  { 663, 10, 16, 12, 2, -16 },
  { 683, 8, 16, 10, 2, -16 },
  { 699, 14, 16, 18, 2, -16 },
  { 727, 11, 16, 15, 2, -16 },
  { 749, 12, 16, 14, 1, -16 },
  { 773, 9, 16, 12, 2, -16 },
  { 791, 12, 20, 14, 1, -16 },
  { 821, 10, 16, 12, 2, -16 },
  { 841, 8, 16, 10, 1, -16 },
  { 857, 10, 16, 10, 0, -16 },
  { 877, 10, 16, 14, 2, -16 },
  { 897, 12, 16, 12, 0, -16 },
  { 921, 18, 16, 18, 0, -16 },
  { 957, 12, 16, 12, 0, -16 },
  { 981, 11, 16, 11, 0, -16 },
  { 1003, 10, 16, 10, 0, -16 },
  { 1023, 5, 20, 7, 1, -16 },
  { 1036, 9, 16, 9, 0, -16 },
  { 1054, 5, 20, 7, 1, -16 },
  { 1067, 11, 10, 12, 0, -16 },
  { 1081, 9, 1, 9, 0, 2 },
  { 1083, 5, 4, 7, 1, -17 },
  { 1086, 9, 12, 11, 1, -12 },
  { 1100, 10, 17, 12, 1, -17 },
  { 1122, 8, 12, 10, 1, -12 },
  { 1134, 10, 17, 12, 1, -17 },
  { 1156, 9, 12, 11, 1, -12 },
  { 1170, 8, 17, 7, 0, -17 },
  { 1187, 10, 17, 12, 1, -12 },
  { 1209, 10, 17, 12, 1, -17 },
  { 1231, 4, 17, 6, 1, -17 },
  { 1240, 5, 22, 6, -1, -17 },
  { 1254, 11, 17, 12, 1, -17 },
  { 1278, 3, 17, 6, 1, -17 },
  { 1285, 16, 12, 18, 1, -12 },
  { 1309, 10, 12, 12, 1, -12 },
  { 1324, 10, 12, 12, 1, -12 },
  { 1339, 10, 17, 12, 1, -12 },
  { 1361, 10, 17, 12, 1, -12 },
  { 1383, 7, 12, 8, 1, -12 },
  { 1394, 7, 12, 9, 1, -12 },
  { 1405, 7, 15, 8, 0, -15 },
  { 1419, 10, 12, 12, 1, -12 },
  { 1434, 11, 12, 11, 0, -12 },
  { 1451, 16, 12, 16, 0, -12 },
  { 1475, 10, 12, 10, 0, -12 },
  { 1490, 11, 17, 11, 0, -12 },
  { 1514, 8, 12, 9, 0, -12 },
  { 1526, 7, 20, 8, 0, -16 },
  { 1544, 2, 22, 10, 4, -17 },
  { 1550, 7, 20, 8, 1, -16 },
  { 1568, 9, 4, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_Bold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_BOLD22PT7B_H_
