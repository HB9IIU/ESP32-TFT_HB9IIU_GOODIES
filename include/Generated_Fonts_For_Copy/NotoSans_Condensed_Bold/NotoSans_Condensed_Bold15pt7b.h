#ifndef _NOTOSANS_CONDENSED_BOLD15PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDE, 0xF7, 0xB0, 0x16, 0x16, 0x16, 0x7F, 0x7F,
  0x34, 0x24, 0xFF, 0x2C, 0x6C, 0x68, 0x23, 0xFE, 0xB8, 0xE1, 0xE3, 0xCB,
  0xAF, 0xE2, 0x08, 0x30, 0x87, 0x98, 0x59, 0x0D, 0xB0, 0x5A, 0x47, 0xEE,
  0x35, 0xB0, 0xDB, 0x0D, 0xB0, 0x9A, 0x18, 0xE0, 0x38, 0x3E, 0x19, 0x0D,
  0x83, 0xC1, 0xCD, 0xF7, 0xDE, 0xE7, 0x3F, 0x9F, 0xE0, 0xFF, 0x36, 0x4C,
  0xCC, 0xCC, 0xCC, 0xC6, 0x70, 0xC6, 0x63, 0x33, 0x33, 0x33, 0x36, 0xE0,
  0x10, 0xAB, 0xF9, 0xC6, 0xC5, 0x00, 0x18, 0x30, 0x67, 0xFF, 0xE3, 0x06,
  0x00, 0x6D, 0xE0, 0xFF, 0xF0, 0x0C, 0x31, 0x86, 0x10, 0xC3, 0x18, 0x61,
  0x8C, 0x00, 0x73, 0xED, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xE7, 0x80, 0x19,
  0xDF, 0xB1, 0x9C, 0xE7, 0x39, 0xCE, 0x39, 0xF9, 0x38, 0x30, 0xC1, 0x86,
  0x18, 0x60, 0xFD, 0xF8, 0x39, 0xF9, 0x38, 0x30, 0xC7, 0x03, 0x03, 0x06,
  0xF9, 0xF0, 0x0C, 0x38, 0x71, 0xE2, 0xCD, 0x93, 0x7F, 0xFE, 0x18, 0x30,
  0xFB, 0xEC, 0x30, 0xF3, 0xE1, 0xC3, 0x0F, 0xEF, 0x00, 0x1C, 0x79, 0x83,
  0x05, 0xDF, 0xF9, 0xB3, 0x66, 0xFC, 0xF0, 0xFF, 0xFC, 0x18, 0x60, 0xC1,
  0x86, 0x0C, 0x30, 0x61, 0xC0, 0x38, 0xF9, 0x9B, 0x37, 0xC7, 0x1B, 0x33,
  0xC6, 0xDD, 0xF0, 0x38, 0xF9, 0xBE, 0x3E, 0x6D, 0xDF, 0x83, 0x0C, 0xF9,
  0xE0, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x78, 0x02, 0x1C, 0xE7, 0x07, 0x83,
  0xC1, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xC1, 0xE0, 0xF0, 0x71, 0xCE,
  0x30, 0x00, 0x7B, 0xF8, 0xC3, 0x18, 0xC3, 0x08, 0x01, 0xC7, 0x00, 0x1E,
  0x0C, 0xE4, 0x0B, 0x7B, 0x92, 0xEC, 0x9B, 0x2E, 0xDB, 0x9F, 0xB0, 0x06,
  0x10, 0xFC, 0x1C, 0x0E, 0x0F, 0x06, 0xC3, 0x61, 0xB1, 0x98, 0xFE, 0x63,
  0x71, 0xB0, 0xE0, 0xF9, 0xFB, 0x3E, 0x7C, 0xDF, 0x33, 0xE3, 0xC7, 0xFB,
  0xF0, 0x3E, 0xFB, 0x96, 0x0C, 0x18, 0x30, 0x60, 0xE0, 0xF8, 0xF0, 0xF9,
  0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0xFB, 0xE0, 0xFF, 0xF1, 0x8C,
  0x7F, 0x18, 0xC7, 0xFE, 0xFF, 0xF1, 0x8C, 0x7F, 0xF8, 0xC6, 0x30, 0x1E,
  0xFF, 0x8E, 0x0C, 0x19, 0xF3, 0xE3, 0xC6, 0xFC, 0xF8, 0xC7, 0x8F, 0x1E,
  0x3C, 0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xFB, 0xDC, 0xE7, 0x39, 0xCE,
  0x73, 0xBE, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC7, 0x9F, 0x36,
  0xCD, 0x9F, 0x3E, 0x6E, 0xCD, 0x9F, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC7, 0xFE, 0xE1, 0xF8, 0x7F, 0x1F, 0xCF, 0xF3, 0xF4, 0xFD, 0xAF, 0x7B,
  0xCE, 0xF3, 0x3C, 0xCC, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xCF,
  0xCF, 0xC7, 0xC7, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7,
  0x7E, 0x3C, 0xF3, 0xFC, 0xF3, 0xCF, 0xFF, 0xB0, 0xC3, 0x0C, 0x00, 0x3C,
  0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x3C, 0x0E, 0x06,
  0x07, 0xF1, 0xFB, 0x36, 0x7C, 0xDF, 0xBE, 0x6C, 0xCD, 0x9F, 0x18, 0x7F,
  0xF3, 0x8E, 0x38, 0xE3, 0x9F, 0xFC, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xFD, 0xF0, 0xC3, 0xC3, 0x63, 0x66, 0x66, 0x66, 0x36, 0x3C, 0x3C, 0x1C,
  0x18, 0xC6, 0x3C, 0x63, 0xC6, 0x36, 0xF3, 0x6F, 0x66, 0xF6, 0x6D, 0x66,
  0x9E, 0x29, 0xE3, 0x9C, 0x38, 0xC0, 0xE7, 0x66, 0x6E, 0x3C, 0x3C, 0x18,
  0x3C, 0x3C, 0x66, 0x66, 0xE7, 0xC7, 0x66, 0x66, 0x6C, 0x3C, 0x3C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFC, 0x30, 0x61, 0x87, 0x0C, 0x30, 0x61,
  0xFF, 0xF8, 0xFF, 0x6D, 0xB6, 0xDB, 0x6E, 0xC1, 0x06, 0x18, 0x30, 0xC3,
  0x06, 0x18, 0x20, 0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x18,
  0x18, 0x3C, 0x3C, 0x66, 0x66, 0xC3, 0xFC, 0xCC, 0x7C, 0x5C, 0x1B, 0xF6,
  0x7C, 0xDB, 0xBB, 0xC1, 0x83, 0x07, 0xEE, 0xD9, 0xB3, 0xE6, 0xCD, 0xFB,
  0xE0, 0x7F, 0x71, 0x8C, 0x63, 0xEF, 0x0C, 0x30, 0xFF, 0xDF, 0x3C, 0xF3,
  0xCF, 0xF7, 0xC0, 0x7B, 0x3C, 0xFF, 0xC3, 0x0E, 0xDF, 0x3B, 0x19, 0xF6,
  0x31, 0x8C, 0x63, 0x18, 0xFF, 0x7C, 0xF3, 0xCF, 0x3F, 0xDF, 0x0E, 0x3F,
  0x9C, 0xC3, 0x0C, 0x3F, 0xEF, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0xF3, 0xFF,
  0xFC, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x40, 0xC1, 0x83, 0x06,
  0x7D, 0xDB, 0x3C, 0x7C, 0xD9, 0x9B, 0x38, 0xFF, 0xFF, 0xFC, 0xFF, 0xFB,
  0xBC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xFF, 0xBC, 0xF3, 0xCF,
  0x3C, 0xF3, 0x7B, 0x3C, 0xF3, 0xCF, 0x3F, 0xDE, 0xFD, 0xDB, 0x36, 0x7C,
  0xD9, 0xBF, 0x7C, 0xC1, 0x83, 0x06, 0x00, 0xFF, 0x7C, 0xF3, 0xCF, 0x3F,
  0xDF, 0x0C, 0x30, 0xC3, 0xFF, 0xB1, 0x8C, 0x63, 0x18, 0x7F, 0xA6, 0x1E,
  0x38, 0x37, 0xDE, 0x23, 0x3E, 0xC6, 0x31, 0x8C, 0x79, 0xC0, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3F, 0xDD, 0xC6, 0xCD, 0xB3, 0x66, 0xC7, 0x0E, 0x1C, 0xCE,
  0x79, 0xC9, 0xAB, 0x35, 0x67, 0xBC, 0xF7, 0x8E, 0xE1, 0x8C, 0xEE, 0xD8,
  0xE1, 0xC3, 0x8D, 0x9B, 0x63, 0xC6, 0xCD, 0xB3, 0x62, 0xC7, 0x0E, 0x0C,
  0x38, 0x61, 0xC2, 0x00, 0x7C, 0x61, 0x8C, 0x31, 0x8F, 0xFF, 0x19, 0xCC,
  0x63, 0x1B, 0x9C, 0x31, 0x8C, 0x63, 0x80, 0xFF, 0xFC, 0x8C, 0x66, 0x66,
  0x77, 0x66, 0x66, 0xC0, 0x23, 0xFE, 0x38,
};

const GFXglyph NotoSans_Condensed_Bold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 8, 11, 8, 0, -11 },
  { 18, 6, 12, 7, 1, -11 },
  { 27, 12, 11, 12, 0, -11 },
  { 44, 9, 11, 9, 0, -11 },
  { 57, 2, 4, 4, 1, -11 },
  { 58, 4, 13, 5, 1, -11 },
  { 65, 4, 13, 5, 0, -11 },
  { 72, 7, 6, 7, 0, -11 },
  { 78, 7, 7, 7, 0, -9 },
  { 85, 3, 4, 4, 0, -2 },
  { 87, 4, 2, 5, 0, -5 },
  { 88, 2, 2, 4, 1, -2 },
  { 89, 6, 11, 6, 0, -11 },
  { 98, 6, 11, 7, 1, -11 },
  { 107, 5, 11, 7, 1, -11 },
  { 114, 7, 11, 7, 0, -11 },
  { 124, 7, 11, 7, 0, -11 },
  { 134, 7, 11, 7, 0, -11 },
  { 144, 6, 11, 7, 1, -11 },
  { 153, 7, 11, 7, 0, -11 },
  { 163, 7, 11, 7, 0, -11 },
  { 173, 7, 11, 7, 0, -11 },
  { 183, 7, 11, 7, 0, -11 },
  { 193, 2, 8, 4, 1, -8 },
  { 195, 3, 10, 4, 0, -8 },
  { 199, 7, 7, 7, 0, -9 },
  { 206, 7, 5, 7, 0, -8 },
  { 211, 7, 7, 7, 0, -9 },
  { 218, 6, 11, 6, 0, -11 },
  { 227, 10, 12, 12, 1, -11 },
  { 242, 9, 11, 9, 0, -11 },
  { 255, 7, 11, 9, 1, -11 },
  { 265, 7, 11, 8, 1, -11 },
  { 275, 7, 11, 9, 1, -11 },
  { 285, 5, 11, 7, 1, -11 },
  { 292, 5, 11, 7, 1, -11 },
  { 299, 7, 11, 9, 1, -11 },
  { 309, 7, 11, 10, 1, -11 },
  { 319, 5, 11, 5, 0, -11 },
  { 326, 4, 14, 4, -1, -11 },
  { 333, 7, 11, 8, 1, -11 },
  { 343, 5, 11, 7, 1, -11 },
  { 350, 10, 11, 12, 1, -11 },
  { 364, 8, 11, 10, 1, -11 },
  { 375, 8, 11, 10, 1, -11 },
  { 386, 6, 11, 8, 1, -11 },
  { 395, 8, 14, 10, 1, -11 },
  { 409, 7, 11, 8, 1, -11 },
  { 419, 5, 11, 7, 1, -11 },
  { 426, 7, 11, 7, 0, -11 },
  { 436, 7, 11, 9, 1, -11 },
  { 446, 8, 11, 8, 0, -11 },
  { 457, 12, 11, 12, 0, -11 },
  { 474, 8, 11, 8, 0, -11 },
  { 485, 8, 11, 8, 0, -11 },
  { 496, 7, 11, 7, 0, -11 },
  { 506, 3, 13, 5, 1, -11 },
  { 511, 6, 11, 6, 0, -11 },
  { 520, 4, 13, 5, 0, -11 },
  { 527, 8, 7, 8, 0, -11 },
  { 534, 6, 1, 6, 0, 1 },
  { 535, 3, 2, 5, 1, -11 },
  { 536, 7, 8, 8, 0, -8 },
  { 543, 7, 11, 8, 1, -11 },
  { 553, 5, 8, 7, 1, -8 },
  { 558, 6, 11, 8, 1, -11 },
  { 567, 6, 8, 7, 1, -8 },
  { 573, 5, 11, 5, 0, -11 },
  { 580, 6, 12, 8, 1, -8 },
  { 589, 6, 11, 8, 1, -11 },
  { 598, 2, 11, 4, 1, -11 },
  { 601, 4, 15, 4, -1, -11 },
  { 609, 7, 11, 8, 1, -11 },
  { 619, 2, 11, 4, 1, -11 },
  { 622, 10, 8, 12, 1, -8 },
  { 632, 6, 8, 8, 1, -8 },
  { 638, 6, 8, 8, 1, -8 },
  { 644, 7, 12, 8, 1, -8 },
  { 655, 6, 12, 8, 1, -8 },
  { 664, 5, 8, 6, 1, -8 },
  { 669, 6, 8, 6, 0, -8 },
  { 675, 5, 10, 5, 0, -10 },
  { 682, 6, 8, 8, 1, -8 },
  { 688, 7, 8, 7, 0, -8 },
  { 695, 11, 8, 11, 0, -8 },
  { 706, 7, 8, 7, 0, -8 },
  { 713, 7, 12, 7, 0, -8 },
  { 724, 6, 8, 6, 0, -8 },
  { 730, 5, 13, 5, 0, -11 },
  { 739, 1, 14, 7, 3, -11 },
  { 741, 4, 13, 5, 1, -11 },
  { 748, 7, 3, 7, 0, -7 },
};

const GFXfont NotoSans_Condensed_Bold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_BOLD15PT7B_H_
