#ifndef _NOTOSANS_CONDENSED_BOLD42PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x7D, 0xFF,
  0xFF, 0xFF, 0xEF, 0x80, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0xC7, 0xEF, 0x8F, 0xDF, 0x1F, 0x3E, 0x3E, 0x7C, 0x3C, 0xF0, 0x79, 0xE0,
  0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x78, 0xF8, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x3C,
  0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x7E, 0x01, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFD, 0xC7, 0x7E, 0xE0, 0x3E, 0x70, 0x1F, 0xB8, 0x0F, 0xDC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0E, 0xFC, 0x07, 0x3F, 0x03, 0x9F, 0xE1,
  0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0x80,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x0F,
  0x80, 0x3F, 0xE0, 0x0F, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x7F, 0xF0, 0x1E,
  0x00, 0x78, 0xF0, 0x3E, 0x00, 0x78, 0xF8, 0x3C, 0x00, 0xF8, 0xF8, 0x7C,
  0x00, 0xF8, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0xF0, 0x00, 0xF8, 0xF9, 0xF0, 0x00, 0x78, 0xF9, 0xE3,
  0xF8, 0x78, 0xF3, 0xE7, 0xFC, 0x7D, 0xF3, 0xCF, 0xFC, 0x3F, 0xF3, 0xCF,
  0xFE, 0x3F, 0xE7, 0xCF, 0x1E, 0x1F, 0xC7, 0x9F, 0x1E, 0x00, 0x0F, 0x9F,
  0x1F, 0x00, 0x0F, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x1E, 0x1F,
  0x1F, 0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x3C, 0x1F, 0x1F, 0x00, 0x3C, 0x1F,
  0x1E, 0x00, 0x7C, 0x0F, 0x1E, 0x00, 0x78, 0x0F, 0xFE, 0x00, 0xF8, 0x07,
  0xFC, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xF9, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x1F,
  0x80, 0x0F, 0x8F, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFC, 0x7F, 0xF0, 0x7E, 0x3F,
  0xFC, 0x7E, 0x3F, 0xFF, 0x3F, 0x1F, 0x9F, 0x9F, 0x9F, 0x87, 0xFF, 0x8F,
  0xC1, 0xFF, 0xC7, 0xE0, 0xFF, 0xC3, 0xF0, 0x3F, 0xE1, 0xFC, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xF7, 0xF0, 0x3F, 0xE1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7,
  0xDF, 0x7D, 0xE7, 0x80, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x41, 0xE0, 0x9C, 0x78, 0xE7,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x7F, 0x00, 0x1F,
  0xE0, 0x0F, 0xFC, 0x07, 0xCF, 0x83, 0xF3, 0xF0, 0xF8, 0x78, 0x0E, 0x1C,
  0x01, 0x02, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x8F, 0xC7, 0xE7, 0xE0, 0xF9, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF,
  0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F,
  0x7C, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3E, 0x3F, 0x1F, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF,
  0xBF, 0xFC, 0xFD, 0xE3, 0xF3, 0x0F, 0xC4, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0x07, 0xE1, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x8E,
  0x07, 0xE2, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0xFF, 0xE0, 0x1E, 0xFC, 0x07, 0x9F,
  0x80, 0xF3, 0xF0, 0x3C, 0x7E, 0x0F, 0x8F, 0xC1, 0xE1, 0xF8, 0x7C, 0x3F,
  0x0F, 0x07, 0xE3, 0xE0, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFB, 0x87,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC1,
  0x01, 0xF3, 0xF8, 0x7D, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0x7F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF,
  0x01, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7F, 0x0F, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFE, 0x7F, 0x1F, 0x9F, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F,
  0x9F, 0x83, 0xE3, 0xF1, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xF8, 0x3F, 0xFF, 0x0F, 0xCF, 0xE7, 0xE1, 0xFD, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xDF, 0xC7, 0xF7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0x87, 0xE7, 0xC0, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x83, 0xF7, 0xF3, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFD, 0xF0, 0xFE, 0x7C, 0x0C, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x0C, 0x7F, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x7D, 0xFF, 0xFF, 0xFF,
  0xEF, 0x86, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x3E, 0x3F, 0x7F, 0x7F, 0x3F, 0x3E, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0xFF, 0x30, 0x3F,
  0x20, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x78, 0x00,
  0x0F, 0x87, 0xC0, 0x20, 0x3C, 0x3C, 0x1F, 0xF9, 0xF3, 0xE1, 0xFF, 0xC7,
  0x9E, 0x1F, 0xFE, 0x3D, 0xF1, 0xF8, 0xF1, 0xFF, 0x8F, 0x87, 0x87, 0xF8,
  0x78, 0x3C, 0x3F, 0xC7, 0xC3, 0xE1, 0xFE, 0x3E, 0x1F, 0x0F, 0xF1, 0xF0,
  0xF8, 0x7F, 0x8F, 0x87, 0xC3, 0xFC, 0x7C, 0x3E, 0x3D, 0xE3, 0xE1, 0xF1,
  0xEF, 0x0F, 0x0F, 0x8F, 0x78, 0x7D, 0xFC, 0xF3, 0xE3, 0xFE, 0xFF, 0x9F,
  0x0F, 0xF3, 0xF8, 0x78, 0x3F, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x60, 0x07, 0xF8, 0x3F,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC1, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x3F, 0xBF, 0x03, 0xF7, 0xE0,
  0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0x83,
  0xFB, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x01, 0x8F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x1F, 0xF3, 0xF0, 0x3F,
  0x9F, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0,
  0x3F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFC, 0x3F, 0xC7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xE0, 0x10, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x3F, 0x81,
  0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x0F, 0xF3, 0xFB, 0xFF, 0x7F, 0xEF, 0xF9, 0xFE, 0x3F, 0x00,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1,
  0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07,
  0xE7, 0xF0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0x7F, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF,
  0xBE, 0x03, 0xDF, 0xFB, 0xE0, 0x7D, 0xFF, 0x9E, 0x07, 0xDF, 0xFD, 0xF0,
  0x79, 0xFF, 0xDF, 0x0F, 0x9F, 0xFD, 0xF0, 0xF9, 0xFF, 0xCF, 0x0F, 0x9F,
  0xFC, 0xF8, 0xF1, 0xFF, 0xCF, 0x9F, 0x1F, 0xFC, 0xF9, 0xF1, 0xFF, 0xC7,
  0x9E, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0xC7, 0xFE, 0x1F, 0xFC, 0x7F, 0xE1,
  0xFF, 0xC3, 0xFC, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xC3, 0xFC, 0x1F, 0xFC,
  0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF0,
  0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xF7, 0xE0, 0xFF, 0xEF, 0xC1, 0xFF, 0xCF, 0xC3, 0xFF,
  0x9F, 0x87, 0xFF, 0x1F, 0x8F, 0xFF, 0x3F, 0x1F, 0xFE, 0x3F, 0x3F, 0xFC,
  0x7E, 0x7F, 0xF8, 0x7E, 0xFF, 0xF0, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x3F, 0x80,
  0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0xBF, 0x0F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x3F, 0x80, 0xFE,
  0x3F, 0x83, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xC3, 0xFC, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC7,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFC,
  0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE,
  0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x0F, 0xF8, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFE, 0x0E, 0xFC, 0x02, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0x7E, 0x07, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x7F, 0xE0, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0x7C, 0x03, 0xF8, 0x0F, 0xDF, 0x81, 0xFE, 0x03, 0xE7, 0xE0, 0x7F, 0x81,
  0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x7E, 0x07, 0xF8, 0x1F, 0x8F, 0x83, 0xFF,
  0x07, 0xC3, 0xE0, 0xFF, 0xC1, 0xF0, 0xFC, 0x3E, 0xF0, 0xFC, 0x3F, 0x0F,
  0x3C, 0x3F, 0x07, 0xC3, 0xCF, 0x8F, 0xC1, 0xF1, 0xF3, 0xE3, 0xE0, 0x7C,
  0x7C, 0xF8, 0xF8, 0x1F, 0x9F, 0x3E, 0x7E, 0x07, 0xE7, 0x87, 0x9F, 0x80,
  0xFB, 0xE1, 0xF7, 0xE0, 0x3E, 0xF8, 0x7D, 0xF0, 0x0F, 0xBE, 0x1F, 0x7C,
  0x03, 0xEF, 0x83, 0xDF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFD, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xEF,
  0x80, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0,
  0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF8,
  0x03, 0xF0, 0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1E, 0x1F, 0x82,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC1, 0xFF, 0xF1, 0xFF,
  0xFC, 0xFF, 0xFF, 0x7F, 0xCF, 0xDF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x07, 0xF7, 0xE3, 0xFD, 0xFF, 0xFF, 0x7F, 0xF7, 0xCF,
  0xF9, 0xF1, 0xFC, 0x7C, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x3F, 0x0F, 0xBF, 0xE3, 0xEF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF,
  0xE1, 0xFB, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xFD, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xBF, 0xE3, 0xC7, 0xF0, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE7,
  0xFB, 0xCF, 0xC0, 0xBF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x05, 0xFE, 0xFB, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xC1, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC3, 0xF3, 0xF1, 0xFE,
  0xFC, 0xFF, 0xDF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE1,
  0xFD, 0xFC, 0xFF, 0x7F, 0xFF, 0xCF, 0xFD, 0xF3, 0xFF, 0x7C, 0x3F, 0x1F,
  0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x5F, 0xC1, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xF8, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC7, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0x7F, 0x7F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xF7, 0xF7, 0xFD, 0xFF, 0xFF, 0x3F, 0xF7,
  0xCF, 0xFB, 0xF0, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFD, 0x80, 0x7E, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0xFE, 0x3E, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0x38, 0xFB, 0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x00, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x03, 0x80, 0xF8, 0x3F, 0x87, 0xF0, 0x7C, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF,
  0x1F, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x01, 0xFF, 0xE0, 0x3F, 0x7C, 0x0F, 0xCF, 0x83, 0xF1, 0xF0, 0xFC, 0x3E,
  0x1F, 0x87, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xF7, 0xE0, 0xFC,
  0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7C, 0x1F, 0xCF, 0x81, 0xF9, 0xF0,
  0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0x9F, 0xF1, 0xFF, 0x3F, 0xFF, 0xDF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1F, 0xE1, 0xFF,
  0xF0, 0x7F, 0x07, 0xFF, 0x83, 0xF0, 0x3F, 0xFC, 0x1F, 0x81, 0xFF, 0xE0,
  0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0x03, 0xFF, 0x81, 0xF8,
  0x1F, 0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0x03, 0xF0, 0x3F,
  0xF8, 0x1F, 0x81, 0xFF, 0xC0, 0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xF0,
  0x3F, 0x03, 0xFF, 0x81, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E,
  0x07, 0xE0, 0xF1, 0xFC, 0x79, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3E, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC7, 0xF3, 0xF8, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07,
  0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xBF, 0x01, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC1, 0xF9, 0xFC, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0xF1, 0xFC,
  0x3E, 0xFF, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFF, 0x7F, 0xBF, 0x07, 0xEF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x07, 0xEF, 0xF7, 0xFB, 0xFF, 0xFC, 0xFB, 0xFF, 0x3E, 0xFF, 0x8F,
  0x9F, 0xC3, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC7, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xF7, 0xF3, 0xFD, 0xFF, 0xFF, 0x3F, 0xF7,
  0xCF, 0xFB, 0xF0, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0xF0, 0xFF, 0x1F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xE1,
  0xDF, 0x80, 0xBF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x80,
  0xFF, 0xE3, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x1F, 0xFC, 0x00, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xF3, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xDF,
  0x87, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFC, 0xF0, 0xFE,
  0x3C, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE3, 0xE0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1,
  0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0,
  0x0F, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFC,
  0x0F, 0xE0, 0x7D, 0xF0, 0x3F, 0x81, 0xF7, 0xC0, 0xFE, 0x0F, 0xDF, 0x87,
  0xF8, 0x3F, 0x7E, 0x1F, 0xE0, 0xF8, 0xF8, 0x7B, 0xC3, 0xE3, 0xE1, 0xEF,
  0x1F, 0x8F, 0xC7, 0xBC, 0x7E, 0x3F, 0x3E, 0xF1, 0xF0, 0x7C, 0xF3, 0xC7,
  0xC1, 0xF3, 0xC7, 0x9F, 0x07, 0xCF, 0x1E, 0xFC, 0x1F, 0xBC, 0x7B, 0xE0,
  0x7E, 0xF1, 0xEF, 0x80, 0xFF, 0x87, 0xBE, 0x03, 0xFE, 0x0E, 0xF8, 0x0F,
  0xF8, 0x3B, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xE7, 0xE0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x1F, 0x9F, 0x81, 0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xBF, 0x01, 0xF9, 0xF8, 0x3F,
  0x1F, 0x83, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0xFE, 0x07, 0xF0,
  0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF8,
  0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFD, 0xF0, 0x07,
  0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0xFF,
  0xC3, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x7E, 0x1F, 0xF1, 0xFF, 0x8F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x0E, 0x00, 0x00, 0x3F, 0x80,
  0x2F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF,
  0x20, 0x01, 0x80,
};

const GFXglyph NotoSans_Condensed_Bold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 30, 11, 2, -30 },
  { 28, 15, 11, 19, 2, -30 },
  { 49, 21, 30, 23, 1, -30 },
  { 128, 17, 34, 21, 2, -32 },
  { 201, 32, 30, 34, 1, -30 },
  { 321, 25, 30, 26, 1, -30 },
  { 415, 6, 11, 10, 2, -30 },
  { 424, 11, 37, 14, 2, -30 },
  { 475, 11, 37, 14, 1, -30 },
  { 526, 18, 18, 20, 1, -32 },
  { 567, 18, 20, 21, 1, -25 },
  { 612, 8, 10, 11, 1, -5 },
  { 622, 11, 5, 13, 1, -14 },
  { 629, 7, 6, 11, 2, -6 },
  { 635, 17, 30, 17, 0, -30 },
  { 699, 18, 30, 21, 1, -30 },
  { 767, 14, 30, 21, 2, -30 },
  { 820, 18, 30, 21, 1, -30 },
  { 888, 18, 30, 21, 1, -30 },
  { 956, 19, 30, 21, 1, -30 },
  { 1028, 17, 30, 21, 2, -30 },
  { 1092, 18, 30, 21, 1, -30 },
  { 1160, 18, 30, 21, 1, -30 },
  { 1228, 18, 30, 21, 1, -30 },
  { 1296, 18, 30, 21, 1, -30 },
  { 1364, 7, 23, 11, 2, -23 },
  { 1385, 8, 28, 11, 1, -23 },
  { 1413, 18, 20, 21, 1, -25 },
  { 1458, 18, 13, 21, 1, -21 },
  { 1488, 19, 20, 21, 1, -25 },
  { 1536, 16, 30, 17, 0, -30 },
  { 1596, 29, 33, 33, 2, -30 },
  { 1716, 24, 30, 24, 0, -30 },
  { 1806, 19, 30, 24, 3, -30 },
  { 1878, 19, 30, 22, 2, -30 },
  { 1950, 21, 30, 26, 3, -30 },
  { 2029, 15, 30, 20, 3, -30 },
  { 2086, 15, 30, 20, 3, -30 },
  { 2143, 21, 30, 26, 2, -30 },
  { 2222, 21, 30, 27, 3, -30 },
  { 2301, 12, 30, 14, 1, -30 },
  { 2346, 11, 39, 12, -2, -30 },
  { 2400, 21, 30, 23, 3, -30 },
  { 2479, 15, 30, 19, 3, -30 },
  { 2536, 28, 30, 35, 3, -30 },
  { 2641, 23, 30, 29, 3, -30 },
  { 2728, 23, 30, 27, 2, -30 },
  { 2815, 18, 30, 22, 3, -30 },
  { 2883, 23, 37, 27, 2, -30 },
  { 2990, 20, 30, 23, 3, -30 },
  { 3065, 16, 30, 19, 2, -30 },
  { 3125, 18, 30, 20, 1, -30 },
  { 3193, 20, 30, 26, 3, -30 },
  { 3268, 23, 30, 23, 0, -30 },
  { 3355, 34, 30, 34, 0, -30 },
  { 3483, 22, 30, 22, 0, -30 },
  { 3566, 22, 30, 22, 0, -30 },
  { 3649, 18, 30, 19, 1, -30 },
  { 3717, 9, 37, 13, 3, -30 },
  { 3759, 17, 30, 17, 0, -30 },
  { 3823, 10, 37, 13, 1, -30 },
  { 3870, 21, 19, 23, 1, -30 },
  { 3920, 17, 3, 17, 0, 4 },
  { 3927, 10, 7, 14, 2, -32 },
  { 3936, 18, 23, 21, 1, -23 },
  { 3988, 18, 32, 23, 3, -32 },
  { 4060, 15, 23, 18, 2, -23 },
  { 4104, 18, 32, 23, 2, -32 },
  { 4176, 17, 23, 21, 2, -23 },
  { 4225, 15, 32, 14, 0, -32 },
  { 4285, 18, 33, 23, 2, -23 },
  { 4360, 17, 32, 23, 3, -32 },
  { 4428, 7, 32, 11, 2, -32 },
  { 4456, 11, 42, 11, -2, -32 },
  { 4514, 19, 32, 22, 3, -32 },
  { 4590, 5, 32, 11, 3, -32 },
  { 4610, 29, 23, 34, 3, -23 },
  { 4694, 17, 23, 23, 3, -23 },
  { 4743, 19, 23, 22, 2, -23 },
  { 4798, 18, 33, 23, 3, -23 },
  { 4873, 18, 33, 23, 2, -23 },
  { 4948, 12, 23, 16, 3, -23 },
  { 4983, 15, 23, 17, 1, -23 },
  { 5027, 13, 28, 15, 1, -28 },
  { 5073, 18, 23, 23, 2, -23 },
  { 5125, 20, 23, 20, 0, -23 },
  { 5183, 30, 23, 31, 0, -23 },
  { 5270, 20, 23, 20, 0, -23 },
  { 5328, 20, 33, 20, 0, -23 },
  { 5411, 15, 23, 17, 1, -23 },
  { 5455, 14, 37, 15, 0, -30 },
  { 5520, 4, 42, 20, 8, -32 },
  { 5541, 13, 37, 15, 2, -30 },
  { 5602, 19, 7, 21, 1, -18 },
};

const GFXfont NotoSans_Condensed_Bold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_BOLD42PT7B_H_
