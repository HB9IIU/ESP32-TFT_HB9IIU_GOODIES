#ifndef _NOTOSANS_CONDENSED_BOLD50PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE,
  0x7C, 0x10, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xBF,
  0x07, 0xDF, 0x83, 0xEF, 0xC1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x07,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x81, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xBF, 0x3F, 0x9C, 0x19, 0xFC, 0xE0, 0x0F, 0xE7, 0x00, 0x7F, 0x38, 0x03,
  0xFD, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x77, 0xF0, 0x03, 0x9F, 0xC0, 0x1C, 0xFF, 0x00, 0xE7,
  0xFC, 0x07, 0x3F, 0xF8, 0x3B, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x1F,
  0x80, 0x0F, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0x01, 0xF9,
  0xF8, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0x1F, 0x0F, 0x81, 0xF0,
  0x00, 0x7C, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE3, 0xE0, 0xF8, 0x1F, 0x0F,
  0x8F, 0x8F, 0xF8, 0x7E, 0x7E, 0x7E, 0x7F, 0xF0, 0xFF, 0xF9, 0xF1, 0xFF,
  0xC3, 0xFF, 0xCF, 0xCF, 0xFF, 0x87, 0xFE, 0x3E, 0x3E, 0x3E, 0x0F, 0xF8,
  0xF9, 0xF8, 0xF8, 0x1F, 0x87, 0xC7, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x7C, 0x00, 0x1F,
  0x87, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x1F,
  0x00, 0x0F, 0x81, 0xF0, 0xFC, 0x00, 0x3E, 0x07, 0xE3, 0xF0, 0x01, 0xF0,
  0x0F, 0x8F, 0x80, 0x07, 0xC0, 0x3F, 0x7E, 0x00, 0x3F, 0x00, 0xFF, 0xF8,
  0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0,
  0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xE1, 0xFF, 0xF0,
  0x7F, 0x0F, 0xFF, 0xC1, 0xFC, 0x3F, 0xFF, 0x87, 0xF1, 0xFE, 0xFF, 0x1F,
  0xC7, 0xF1, 0xFE, 0xFE, 0x1F, 0xC3, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0xC3,
  0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F,
  0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC,
  0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xC0, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0x03,
  0xE0, 0x47, 0x87, 0x8F, 0x9F, 0xDF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x81, 0xFF, 0xE1, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xF7, 0xF0, 0x1F, 0xCF, 0xC0, 0xFE, 0x3F, 0x81, 0xF8,
  0x7C, 0x01, 0xC1, 0xE0, 0x01, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xBF,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x18, 0x7E, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0x10, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFE, 0x3F, 0x8F, 0xE0,
  0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xEF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xBF, 0x81, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x87, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F,
  0xFF, 0xBF, 0xDF, 0xFF, 0xCF, 0xE7, 0xC7, 0xF1, 0xC3, 0xF8, 0x41, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF1, 0xF8, 0x3F, 0xC7, 0x00, 0xFE, 0x10, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xE0, 0x3F, 0xC6, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x60, 0x07, 0xFB, 0xF1, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3E,
  0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0x87,
  0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E,
  0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x7E, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x30, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE8, 0x00, 0x7F,
  0x70, 0x07, 0xFB, 0xFB, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x83, 0xF3,
  0xFF, 0x1F, 0xBF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xF7, 0xFD,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x83, 0xF9, 0xFF, 0x7F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x1F, 0xE3, 0xF8, 0x3F, 0x9F, 0xC0,
  0x7E, 0x7F, 0x01, 0xF9, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0xC7, 0xF0, 0x7F, 0xBF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0xFF, 0x3F, 0xE7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFF, 0x7E, 0x01, 0xFD,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xFC,
  0x07, 0xF7, 0xF8, 0x3F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC7, 0xF8, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xF8, 0x07,
  0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7,
  0xE0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0x03, 0xFD, 0xFE, 0x1F, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFE, 0xFC, 0x7F, 0xF7, 0xF0, 0x7F, 0x9F,
  0x80, 0x38, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0x07, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x02, 0x00, 0x00, 0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x1C, 0x1F, 0x9F, 0xCF,
  0xF7, 0xFB, 0xFD, 0xFC, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x7F,
  0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCE, 0x03, 0xF9, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x1F, 0x01,
  0xF0, 0xFC, 0x0F, 0xFE, 0x3F, 0x1F, 0x07, 0xFF, 0xC3, 0xE7, 0xE1, 0xFF,
  0xF8, 0x7C, 0xF8, 0x3F, 0x9F, 0x0F, 0x9F, 0x0F, 0xC3, 0xE0, 0xF3, 0xE1,
  0xF0, 0x7C, 0x1F, 0xF8, 0x7E, 0x0F, 0x83, 0xFF, 0x0F, 0x81, 0xF0, 0x7F,
  0xE1, 0xF0, 0x3E, 0x0F, 0xFC, 0x3E, 0x07, 0xC1, 0xFF, 0x87, 0xC0, 0xF8,
  0x3F, 0xF0, 0xF8, 0x1F, 0x0F, 0xBE, 0x1F, 0x03, 0xE1, 0xF7, 0xC3, 0xE0,
  0xFC, 0x3E, 0xF8, 0x7E, 0x1F, 0x87, 0xDF, 0x07, 0xC7, 0xF1, 0xF1, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3E, 0x0F, 0xFD, 0xFF, 0x87, 0xC1, 0xFF, 0x1F, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x3F, 0xC0,
  0x01, 0x80, 0x03, 0xFF, 0x87, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF0,
  0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xF3,
  0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8,
  0x1F, 0xEF, 0xE1, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFE, 0x0F, 0xFB, 0xF8, 0x0F, 0xEF,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0x1F, 0xF0,
  0x04, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x23, 0xFE, 0x01, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFE, 0x3F, 0xFC, 0xFE, 0x07,
  0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03,
  0xFC, 0xFE, 0x07, 0xFC, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xE0, 0x3C, 0x3F, 0xE0, 0x04,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xE0,
  0xFF, 0xF7, 0xF0, 0x7F, 0xFB, 0xF8, 0x3F, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7,
  0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xC3, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFE, 0x03,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE,
  0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0x80, 0xFE,
  0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xF7, 0xFF, 0xBE, 0x00, 0xFB,
  0xFF, 0xDF, 0x80, 0xFD, 0xFF, 0xEF, 0xC0, 0x7E, 0xFF, 0xF7, 0xE0, 0x3E,
  0x7F, 0xF9, 0xF8, 0x3F, 0x3F, 0xFC, 0xFC, 0x1F, 0x9F, 0xFE, 0x7E, 0x0F,
  0x8F, 0xFF, 0x1F, 0x07, 0xC7, 0xFF, 0x8F, 0xC7, 0xE3, 0xFF, 0xC7, 0xE3,
  0xF1, 0xFF, 0xE3, 0xF1, 0xF0, 0xFF, 0xF0, 0xF9, 0xF8, 0x7F, 0xF8, 0x7E,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x1F, 0xFE, 0x1F, 0xBE, 0x0F, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xF8, 0x1F, 0xE0, 0x3F, 0xFC,
  0x0F, 0xF0, 0x1F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x01, 0xF8, 0x07, 0xFF,
  0x80, 0xFC, 0x03, 0xF0, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xF7, 0xF0, 0x3F, 0xFD, 0xFC, 0x0F, 0xFF, 0x7F,
  0x03, 0xFF, 0xCF, 0xE0, 0xFF, 0xF3, 0xF8, 0x3F, 0xFC, 0x7F, 0x0F, 0xFF,
  0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0xFF, 0xF0, 0xFE, 0x3F, 0xFC, 0x1F, 0xCF,
  0xFF, 0x07, 0xF3, 0xFF, 0xC0, 0xFE, 0xFF, 0xF0, 0x3F, 0xBF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x00, 0xFE,
  0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE3,
  0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xF8, 0xFF, 0xDF, 0xC1, 0xFE, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFE, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC,
  0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F,
  0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x05, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE, 0x07, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0x9F, 0xE1, 0xF7, 0xF8, 0x04, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x01,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F,
  0x83, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x80,
  0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF0,
  0x07, 0xF3, 0xF0, 0x07, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFF, 0x80, 0xFE, 0x1F, 0x80,
  0xFF, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0x87, 0xF0, 0x3E, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0x7C, 0x0F, 0xC1, 0xFC, 0x1F, 0xBE, 0x0F, 0xE0,
  0x7E, 0x0F, 0xDF, 0x07, 0xF0, 0x3F, 0x07, 0xCF, 0xC3, 0xF8, 0x1F, 0xC3,
  0xE7, 0xE1, 0xFC, 0x0F, 0xE3, 0xF3, 0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0xF8,
  0xFE, 0x01, 0xF8, 0xFC, 0x7E, 0x7F, 0x00, 0xFC, 0x7E, 0x3F, 0x3F, 0x80,
  0x7F, 0x3E, 0x1F, 0x9F, 0xC0, 0x3F, 0xBF, 0x0F, 0xCF, 0xC0, 0x0F, 0xDF,
  0x83, 0xE7, 0xE0, 0x07, 0xEF, 0xC1, 0xF7, 0xF0, 0x03, 0xF7, 0xC0, 0xFF,
  0xF8, 0x01, 0xFB, 0xE0, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF0,
  0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF1,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xDF, 0xC0,
  0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x07, 0xC7,
  0xE0, 0x03, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xFC, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1C,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFE, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x9F, 0x3F, 0xF1, 0xF1, 0xFE, 0x1F, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE1, 0xE0, 0x3F, 0x9F, 0xF0, 0xFE, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0x87, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0,
  0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xBF, 0xC0,
  0xFE, 0xFF, 0xCF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x7F, 0xF8,
  0xFC, 0xFF, 0xC3, 0xF1, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xF0, 0x63, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x9F, 0xF0, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFF, 0x01, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3E, 0x1F,
  0xC3, 0xFE, 0x7F, 0x1F, 0xFD, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x7F, 0x87, 0xFD, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F, 0xCF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0x0F, 0xFC, 0xFC,
  0x1F, 0xE3, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xEF, 0xF9, 0xFC, 0x1F,
  0xCF, 0xE0, 0x7E, 0x7E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x09, 0xFF, 0x01, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x01,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xE3, 0xF1, 0xFF, 0xCF, 0xC7, 0xFF, 0xBF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xF8, 0x7F, 0xDF, 0xC0, 0xFF, 0x7F, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xFC, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xF7, 0xF0, 0xFF, 0xDF, 0xC1, 0xFC,
  0x7F, 0x00, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x40, 0x03, 0xF9, 0xC0, 0x1F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x87, 0xC1, 0xFC, 0xFF, 0x8F, 0xEF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFC, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0x3F, 0x81, 0xFC, 0x7F, 0x07,
  0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF3, 0xF8,
  0x0F, 0xEF, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFD, 0xFC, 0x0F,
  0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x1F, 0x8F, 0xF8, 0x3F, 0xE3,
  0xF3, 0xFF, 0x9F, 0xFE, 0x7E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0x8F, 0xF7, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF8,
  0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF,
  0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0,
  0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF8, 0x0F,
  0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC,
  0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F,
  0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x07, 0xE3, 0xFE, 0x3F,
  0x3F, 0xF9, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xDF, 0x80, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x03, 0xF1, 0xFF, 0x0F, 0xCF, 0xFE,
  0x3F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xBF,
  0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xFC, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xEF, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x04, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xE3, 0xF1,
  0xFF, 0xCF, 0xC7, 0xFF, 0xBF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xF8,
  0x7F, 0xDF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xFC, 0x7F, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0x7F, 0xF7, 0xF0, 0xFF, 0xDF, 0xC1, 0xFC, 0x7F, 0x00,
  0x81, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x81, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFB, 0xF8, 0x19, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF,
  0x00, 0x30, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE3, 0x1F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x40, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xEF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFD, 0xF8, 0xFF, 0xC7, 0xC3, 0xFC, 0x3E, 0x02, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xE0, 0x7F, 0x7F, 0x03, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xE0, 0x7E, 0x7F, 0x03, 0xFE, 0x07, 0xE3, 0xF0, 0x7F, 0xE0,
  0xFE, 0x3F, 0x87, 0xDE, 0x0F, 0xE3, 0xF8, 0x7D, 0xF0, 0xFC, 0x3F, 0x87,
  0xDF, 0x0F, 0xC1, 0xF8, 0x79, 0xF1, 0xFC, 0x1F, 0xCF, 0x9F, 0x1F, 0xC1,
  0xFC, 0xF8, 0xF1, 0xF8, 0x1F, 0xCF, 0x8F, 0x9F, 0x80, 0xFC, 0xF8, 0xF9,
  0xF8, 0x0F, 0xCF, 0x0F, 0xBF, 0x80, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF,
  0x07, 0xBF, 0x00, 0x7F, 0xF0, 0x7B, 0xF0, 0x07, 0xFF, 0x07, 0xBF, 0x00,
  0x7F, 0xF0, 0x7B, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xC1,
  0xFC, 0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0x7F,
  0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x81, 0xFC,
  0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xF0,
  0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03,
  0xFC, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x04, 0xFF, 0xC0, 0x17, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Bold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 37, 13, 3, -36 },
  { 38, 17, 13, 23, 3, -36 },
  { 66, 25, 36, 27, 1, -36 },
  { 179, 21, 41, 25, 2, -38 },
  { 287, 38, 36, 41, 1, -36 },
  { 458, 30, 37, 31, 1, -36 },
  { 597, 7, 13, 12, 3, -36 },
  { 609, 13, 44, 16, 2, -36 },
  { 681, 13, 44, 16, 1, -36 },
  { 753, 22, 21, 24, 1, -38 },
  { 811, 21, 24, 25, 2, -30 },
  { 874, 9, 13, 13, 2, -6 },
  { 889, 13, 7, 15, 1, -17 },
  { 901, 8, 9, 13, 3, -8 },
  { 910, 20, 36, 20, 0, -36 },
  { 1000, 21, 37, 25, 2, -36 },
  { 1098, 17, 36, 25, 2, -36 },
  { 1175, 21, 36, 25, 2, -36 },
  { 1270, 21, 37, 25, 2, -36 },
  { 1368, 23, 36, 25, 1, -36 },
  { 1472, 21, 37, 25, 2, -36 },
  { 1570, 21, 37, 25, 2, -36 },
  { 1668, 22, 36, 25, 1, -36 },
  { 1767, 22, 37, 25, 1, -36 },
  { 1869, 22, 37, 25, 1, -36 },
  { 1971, 8, 29, 13, 3, -28 },
  { 2000, 9, 35, 13, 2, -28 },
  { 2040, 22, 24, 25, 1, -30 },
  { 2106, 21, 15, 25, 2, -25 },
  { 2146, 21, 24, 25, 2, -30 },
  { 2209, 19, 37, 20, 0, -36 },
  { 2297, 35, 40, 39, 2, -36 },
  { 2472, 29, 36, 29, 0, -36 },
  { 2603, 22, 36, 28, 4, -36 },
  { 2702, 23, 37, 27, 2, -36 },
  { 2809, 24, 36, 31, 4, -36 },
  { 2917, 17, 36, 24, 4, -36 },
  { 2994, 17, 36, 23, 4, -36 },
  { 3071, 25, 37, 31, 2, -36 },
  { 3187, 24, 36, 32, 4, -36 },
  { 3295, 15, 36, 17, 1, -36 },
  { 3363, 14, 47, 15, -3, -36 },
  { 3446, 24, 36, 28, 4, -36 },
  { 3554, 18, 36, 23, 4, -36 },
  { 3635, 33, 36, 41, 4, -36 },
  { 3784, 26, 36, 34, 4, -36 },
  { 3901, 28, 37, 33, 2, -36 },
  { 4031, 21, 36, 26, 4, -36 },
  { 4126, 28, 45, 33, 2, -36 },
  { 4284, 24, 36, 28, 4, -36 },
  { 4392, 19, 37, 23, 2, -36 },
  { 4480, 22, 36, 24, 1, -36 },
  { 4579, 24, 37, 31, 4, -36 },
  { 4690, 27, 36, 27, 0, -36 },
  { 4812, 41, 36, 41, 0, -36 },
  { 4997, 27, 36, 27, 0, -36 },
  { 5119, 26, 36, 26, 0, -36 },
  { 5236, 21, 36, 23, 1, -36 },
  { 5331, 12, 44, 16, 3, -36 },
  { 5397, 20, 36, 20, 0, -36 },
  { 5487, 12, 44, 16, 1, -36 },
  { 5553, 25, 23, 27, 1, -36 },
  { 5625, 21, 4, 20, 0, 4 },
  { 5636, 12, 8, 16, 2, -38 },
  { 5648, 20, 29, 25, 2, -28 },
  { 5721, 22, 39, 27, 3, -38 },
  { 5829, 19, 29, 22, 2, -28 },
  { 5898, 22, 39, 27, 2, -38 },
  { 6006, 21, 29, 25, 2, -28 },
  { 6083, 17, 38, 16, 1, -38 },
  { 6164, 22, 40, 27, 2, -28 },
  { 6274, 21, 38, 27, 3, -38 },
  { 6374, 7, 38, 13, 3, -38 },
  { 6408, 12, 50, 13, -2, -38 },
  { 6483, 23, 38, 26, 3, -38 },
  { 6593, 7, 38, 13, 3, -38 },
  { 6627, 35, 28, 41, 3, -28 },
  { 6750, 21, 28, 27, 3, -28 },
  { 6824, 22, 29, 26, 2, -28 },
  { 6904, 22, 40, 27, 3, -28 },
  { 7014, 22, 40, 27, 2, -28 },
  { 7124, 15, 28, 19, 3, -28 },
  { 7177, 17, 29, 21, 2, -28 },
  { 7239, 16, 34, 18, 1, -33 },
  { 7307, 21, 28, 27, 3, -27 },
  { 7381, 24, 27, 24, 0, -27 },
  { 7462, 36, 27, 37, 0, -27 },
  { 7584, 23, 27, 23, 0, -27 },
  { 7662, 24, 39, 24, 0, -27 },
  { 7779, 18, 27, 20, 1, -27 },
  { 7840, 15, 44, 18, 1, -36 },
  { 7923, 6, 50, 24, 9, -38 },
  { 7961, 15, 44, 18, 2, -36 },
  { 8044, 22, 9, 25, 1, -22 },
};

const GFXfont NotoSans_Condensed_Bold50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_BOLD50PT7B_H_
