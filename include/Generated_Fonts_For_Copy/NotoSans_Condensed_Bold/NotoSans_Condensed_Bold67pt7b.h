#ifndef _NOTOSANS_CONDENSED_BOLD67PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold67pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFE, 0xFF, 0xDF, 0xF1, 0xFC, 0x0E, 0x00, 0xFF, 0xC3, 0xFF,
  0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF,
  0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0x9E, 0x1F, 0x3F,
  0xE3, 0xC0, 0x67, 0xFC, 0x78, 0x00, 0xFF, 0x8F, 0x00, 0x1F, 0xF1, 0xE0,
  0x03, 0xFE, 0x3C, 0x00, 0x7F, 0xE7, 0x80, 0x07, 0xFE, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0x7F, 0xE0, 0x01, 0xE7, 0xFC, 0x00, 0x3C, 0xFF, 0x80, 0x07,
  0x8F, 0xF0, 0x00, 0xF1, 0xFF, 0x00, 0x1E, 0x3F, 0xF8, 0x03, 0xCF, 0xFF,
  0xC0, 0x79, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xFF, 0x07,
  0xF0, 0xFE, 0x1F, 0xC7, 0xFF, 0xE1, 0xFE, 0x3F, 0x8F, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0xFE, 0x3F, 0x87, 0xF0,
  0xFE, 0x0F, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x7F,
  0x07, 0xF0, 0x02, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xE3, 0xF8, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0xE0,
  0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0x8F, 0xFC, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFC, 0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFD, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0xFF, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x06, 0x01, 0xF8, 0x06, 0x7C, 0x1F, 0x83, 0xE7,
  0xF9, 0xF9, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xF1, 0xFF,
  0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x7E, 0x07, 0xE0, 0x03,
  0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F,
  0xE3, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF0, 0x7F,
  0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x87, 0xF9,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF8, 0x38,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC1, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE,
  0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F,
  0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFD, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F,
  0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7,
  0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC,
  0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFD, 0xFF,
  0x7F, 0xF7, 0xFF, 0xFF, 0x9F, 0xF7, 0xFC, 0x7F, 0xCF, 0xE1, 0xFF, 0x1E,
  0x07, 0xFC, 0x30, 0x1F, 0xF0, 0x40, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFB, 0xFF, 0xE1,
  0xFC, 0x03, 0xFF, 0x07, 0xC0, 0x0F, 0xF8, 0x1C, 0x00, 0x7F, 0xC0, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xE3, 0xFF, 0xE0, 0xF8, 0x03,
  0xFF, 0x03, 0x00, 0x0F, 0xF8, 0x10, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xD0, 0x00,
  0x0F, 0xFE, 0xF0, 0x00, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xDF,
  0xF0, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0xFE, 0x7F, 0xC0, 0x01, 0xFC, 0xFF,
  0x80, 0x07, 0xF1, 0xFF, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x3F, 0x87, 0xFC,
  0x00, 0x7F, 0x0F, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0,
  0x0F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x01,
  0xFC, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xE1, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0x80, 0x0F, 0xFE,
  0xFF, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x18,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x1F, 0xE3, 0xFF, 0x80, 0xFF, 0x3F, 0xFF, 0x0F, 0xFB, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xBF, 0xF8, 0x07, 0xFD, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xF0,
  0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F,
  0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFB, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1,
  0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x17, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x0F,
  0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0x81, 0xFF, 0xEF, 0xFE, 0x1F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xDF, 0xE0, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xC7, 0xF8, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x20, 0x0F,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x87, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xF3,
  0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF1, 0xFE, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF3, 0xFF, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87,
  0xF0, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xE7, 0xFF, 0x87, 0x80,
  0x7F, 0xF1, 0x80, 0x0F, 0xFC, 0x40, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0xFE, 0x0F, 0xC3, 0xF8, 0x07, 0xFF,
  0xFC, 0x3F, 0x8F, 0xE0, 0x3F, 0xFF, 0xF0, 0xFE, 0x3F, 0x81, 0xFF, 0xFF,
  0xC1, 0xF9, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xF7, 0xF0, 0x3F, 0xC1, 0xFC,
  0x1F, 0xDF, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x7E, 0x07, 0xF0, 0x1F, 0xC1,
  0xFF, 0xF8, 0x3F, 0xC0, 0x7E, 0x07, 0xFF, 0xE0, 0xFE, 0x01, 0xF8, 0x0F,
  0xFF, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFF,
  0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xFF,
  0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFF, 0xF8,
  0x3F, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xBF, 0x83,
  0xF8, 0x1F, 0xE0, 0x7E, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xFB, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xCF, 0xE0, 0x7F, 0x9F, 0xFC, 0x7F, 0x3F, 0x81, 0xFF,
  0xFD, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xF7, 0xFF, 0xE1, 0xFC, 0x0F, 0xFF,
  0x8F, 0xFF, 0x07, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x01,
  0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01,
  0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xFB, 0xFE, 0x00, 0xFF,
  0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFB,
  0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFE, 0xFF,
  0x80, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xFE, 0xFF, 0x80, 0x1F, 0xFB,
  0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE,
  0x01, 0xF0, 0x7F, 0xF8, 0x00, 0x40, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x04, 0x1F, 0xFF,
  0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0x1F, 0xF0,
  0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3F, 0xFB, 0xFE,
  0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xE7, 0xFC, 0x00,
  0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE0,
  0x07, 0x80, 0xFF, 0xF0, 0x00, 0x20, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xF0,
  0x1F, 0xFF, 0xF7, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x07,
  0xFF, 0xE3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x01, 0xFF,
  0x9F, 0xF0, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x1F,
  0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xCF,
  0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x1F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x01,
  0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3F, 0xFB, 0xFE, 0x00,
  0x0F, 0xFD, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0xFF, 0xBF, 0xC0, 0x07, 0xFB,
  0xFF, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xF0, 0x01, 0xFD, 0xFF,
  0xFF, 0x3F, 0x80, 0x0F, 0xEF, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0xFF,
  0xCF, 0xF0, 0x07, 0xF3, 0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0x9F, 0xFF, 0xF9,
  0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F,
  0x80, 0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0,
  0x7F, 0x8F, 0xFF, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x1F,
  0xC3, 0xFF, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0x07, 0xFF, 0xFE, 0x1F, 0xE7, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFD, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xEF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF7, 0xFE, 0x01, 0xFF,
  0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0xFF, 0x1F, 0xF0,
  0x1F, 0xFF, 0xF1, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8,
  0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF,
  0xFF, 0x83, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0x1F, 0xFF, 0xF8, 0x1F, 0xF1, 0xFF, 0xFF, 0x81, 0xFF, 0x9F, 0xFF, 0xF8,
  0x0F, 0xF9, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xFF, 0xF8, 0x07, 0xFD, 0xFF,
  0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x07, 0xFE, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x05, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xF0, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF,
  0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFE, 0x07, 0xF1, 0xFF, 0x80, 0x1C, 0x3F, 0xF0, 0x00, 0x87,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF7, 0xC0, 0x07, 0xFE, 0xFE, 0x01,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x07, 0xF7, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xE7, 0xF0,
  0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xE7, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F,
  0xE0, 0x03, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xC3,
  0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0xC0, 0x01, 0xFE,
  0x3F, 0xC1, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0xC0,
  0x01, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x81, 0xFE,
  0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0xFF, 0x80, 0x00,
  0xFF, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x80,
  0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F,
  0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x7C, 0x07, 0xFE, 0x07, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF8, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xF3, 0xFF,
  0xFC, 0xFF, 0x1F, 0xFF, 0xCF, 0xF0, 0xFF, 0xF8, 0x7F, 0x07, 0xFE, 0x07,
  0xF0, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x3F, 0xE3, 0xFF, 0xC0, 0xFF, 0x9F, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0x0F,
  0xFB, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0x3F, 0xF8, 0x07, 0xFC, 0xFF, 0xC0,
  0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF,
  0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0,
  0x1F, 0xFB, 0xFF, 0x80, 0x7F, 0xCF, 0xFE, 0x03, 0xFF, 0x3F, 0xFE, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xEF, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF, 0x83, 0xFC, 0x7F, 0xFC, 0x0F,
  0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFE, 0x7E, 0x7F, 0xF0, 0x0C, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0x7F, 0xF0, 0x03, 0x7F, 0xF8,
  0x1F, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xF1, 0xFF, 0x0F,
  0xFF, 0xCF, 0xF8, 0x7F, 0xFF, 0x7F, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFD, 0xFF, 0xC0, 0xFF,
  0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x0F,
  0xFE, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xE7, 0xF8, 0x3F,
  0xFE, 0x3F, 0xC0, 0x7F, 0xC0, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x1F,
  0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x43, 0xFF, 0x00, 0x3C, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xF1,
  0xFE, 0x1F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0x7F, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFB, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0xBF,
  0xF8, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xF3, 0xFE, 0x0F, 0xFF, 0x1F,
  0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0x1C, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0xC0, 0x00, 0x7F, 0xE7, 0xC0, 0x07, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF1, 0xFF,
  0xE0, 0xFF, 0x9F, 0xFF, 0x87, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xC0, 0xFF, 0xDF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF7, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x3E, 0x1F, 0xEF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x8F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF,
  0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF,
  0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xF8,
  0x00, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC,
  0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F,
  0xE0, 0x1F, 0xFC, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x01, 0xFF,
  0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x07, 0xFE,
  0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFD,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x81,
  0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xC3, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFD, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFB, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x7F, 0xF8, 0x3F, 0xC7, 0xFF, 0xE1, 0xFE, 0x7F, 0xFF, 0x8F, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF0, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFD,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F,
  0xC7, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB,
  0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x3F,
  0xE7, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x03, 0xFC, 0x3F, 0xFC, 0x0F, 0xF1, 0xFF, 0xF8, 0x3F, 0xCF, 0xFF,
  0xF0, 0xFF, 0xBF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x80, 0x7F, 0xCF,
  0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80,
  0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF,
  0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF,
  0xFC, 0x01, 0xFF, 0xBF, 0xF8, 0x07, 0xFC, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF,
  0xE1, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0xF8, 0x3F, 0xE3, 0xFF,
  0xC0, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xFC, 0x3F,
  0xC1, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0x7F, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F, 0xFF, 0x7F, 0xE0,
  0x3F, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFE,
  0x03, 0xFF, 0xBF, 0xF8, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xF3, 0xFE,
  0x0F, 0xFF, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0x18, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC7, 0xFD, 0xFE, 0x3F, 0xEF, 0xF3, 0xFF, 0x7F, 0xBF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xC0, 0x78, 0xFF, 0x80, 0x18, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0xE0, 0x03, 0xFE, 0xFC,
  0x07, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x0C, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xC7, 0xF0, 0xFF, 0xF8, 0x7F,
  0x07, 0xFF, 0x07, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0x9F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xE7,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xF0,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xFC, 0x07, 0xFC,
  0x3F, 0xE0, 0x3F, 0x7E, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xBF, 0x01, 0xFE,
  0x07, 0xFC, 0x1F, 0xDF, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF,
  0x81, 0xFF, 0x07, 0xF3, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xF1, 0xF8, 0x3F,
  0xC0, 0x3F, 0xE1, 0xF8, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F,
  0xF0, 0x0F, 0xF8, 0xFE, 0x3F, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0x0F, 0xC7,
  0xFC, 0x01, 0xFE, 0x3F, 0x07, 0xE3, 0xFC, 0x00, 0xFF, 0x9F, 0x83, 0xF3,
  0xFE, 0x00, 0x7F, 0xCF, 0xC1, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xE0, 0xFE,
  0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x3F, 0x7F, 0x80, 0x07, 0xFB, 0xF0, 0x1F,
  0xBF, 0xC0, 0x03, 0xFD, 0xF8, 0x0F, 0xDF, 0xE0, 0x01, 0xFE, 0xFC, 0x07,
  0xEF, 0xF0, 0x00, 0x7F, 0x7E, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F,
  0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF,
  0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F,
  0xC7, 0xFE, 0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0,
  0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0,
  0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE,
  0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x09, 0xFF, 0xF0, 0x00, 0xDF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF6, 0x00, 0x0F, 0xFF, 0x20, 0x00, 0x07,
  0xC0,
};

const GFXglyph NotoSans_Condensed_Bold67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 49, 18, 3, -48 },
  { 69, 24, 17, 30, 3, -48 },
  { 120, 34, 48, 37, 1, -48 },
  { 324, 27, 55, 33, 3, -51 },
  { 510, 50, 50, 54, 2, -49 },
  { 823, 39, 50, 41, 2, -49 },
  { 1067, 10, 17, 16, 3, -48 },
  { 1089, 17, 59, 22, 3, -48 },
  { 1215, 18, 59, 22, 1, -48 },
  { 1348, 28, 28, 32, 2, -51 },
  { 1446, 29, 32, 33, 2, -40 },
  { 1562, 12, 17, 17, 2, -8 },
  { 1588, 17, 8, 21, 2, -22 },
  { 1605, 11, 11, 18, 3, -10 },
  { 1621, 26, 48, 27, 1, -48 },
  { 1777, 29, 50, 33, 2, -49 },
  { 1959, 22, 48, 33, 3, -48 },
  { 2091, 29, 49, 33, 2, -49 },
  { 2269, 29, 50, 33, 2, -49 },
  { 2451, 31, 48, 33, 1, -48 },
  { 2637, 27, 49, 33, 3, -48 },
  { 2803, 29, 49, 33, 2, -48 },
  { 2981, 29, 48, 33, 2, -48 },
  { 3155, 29, 49, 33, 2, -48 },
  { 3333, 29, 49, 33, 2, -48 },
  { 3511, 10, 38, 18, 4, -37 },
  { 3559, 12, 46, 18, 2, -37 },
  { 3628, 29, 33, 33, 2, -41 },
  { 3748, 29, 20, 33, 2, -34 },
  { 3821, 29, 33, 33, 2, -41 },
  { 3941, 26, 50, 27, 0, -49 },
  { 4104, 46, 53, 52, 3, -48 },
  { 4409, 39, 48, 39, 0, -48 },
  { 4643, 30, 48, 38, 5, -48 },
  { 4823, 31, 50, 36, 3, -49 },
  { 5017, 33, 48, 41, 5, -48 },
  { 5215, 23, 48, 32, 5, -48 },
  { 5353, 23, 48, 31, 5, -48 },
  { 5491, 34, 50, 41, 3, -49 },
  { 5704, 33, 48, 43, 5, -48 },
  { 5902, 19, 48, 23, 2, -48 },
  { 6016, 18, 62, 20, -4, -48 },
  { 6156, 33, 48, 37, 5, -48 },
  { 6354, 24, 48, 30, 5, -48 },
  { 6498, 45, 48, 55, 5, -48 },
  { 6768, 36, 48, 46, 5, -48 },
  { 6984, 38, 50, 44, 3, -49 },
  { 7222, 28, 48, 35, 5, -48 },
  { 7390, 38, 60, 44, 3, -49 },
  { 7675, 32, 48, 37, 5, -48 },
  { 7867, 27, 50, 31, 2, -49 },
  { 8036, 30, 48, 32, 1, -48 },
  { 8216, 32, 49, 42, 5, -48 },
  { 8412, 37, 48, 37, 0, -48 },
  { 8634, 56, 48, 54, -1, -48 },
  { 8970, 36, 48, 36, 0, -48 },
  { 9186, 35, 48, 35, 0, -48 },
  { 9396, 29, 48, 31, 1, -48 },
  { 9570, 16, 59, 21, 4, -48 },
  { 9688, 27, 48, 27, 0, -48 },
  { 9850, 15, 59, 21, 2, -48 },
  { 9961, 33, 30, 36, 2, -48 },
  { 10085, 28, 4, 27, 0, 6 },
  { 10099, 16, 10, 22, 3, -51 },
  { 10119, 28, 38, 34, 2, -37 },
  { 10252, 30, 52, 36, 4, -51 },
  { 10447, 24, 38, 29, 3, -37 },
  { 10561, 29, 52, 36, 3, -51 },
  { 10750, 28, 38, 33, 3, -37 },
  { 10883, 23, 51, 22, 1, -51 },
  { 11030, 29, 53, 36, 3, -37 },
  { 11223, 29, 51, 37, 4, -51 },
  { 11408, 10, 51, 17, 4, -51 },
  { 11472, 16, 67, 17, -2, -51 },
  { 11606, 31, 51, 35, 4, -51 },
  { 11804, 9, 51, 17, 4, -51 },
  { 11862, 47, 37, 55, 4, -37 },
  { 12080, 29, 37, 37, 4, -37 },
  { 12215, 30, 38, 35, 3, -37 },
  { 12358, 30, 53, 36, 4, -37 },
  { 12557, 29, 53, 36, 3, -37 },
  { 12750, 21, 37, 25, 4, -37 },
  { 12848, 24, 38, 28, 2, -37 },
  { 12962, 22, 45, 24, 1, -44 },
  { 13086, 28, 38, 37, 4, -37 },
  { 13219, 32, 37, 32, 0, -37 },
  { 13367, 49, 37, 49, 0, -37 },
  { 13594, 31, 37, 31, 0, -37 },
  { 13738, 32, 53, 32, 0, -37 },
  { 13950, 23, 37, 27, 2, -37 },
  { 14057, 21, 59, 24, 1, -48 },
  { 14212, 8, 66, 32, 12, -51 },
  { 14278, 21, 59, 24, 2, -48 },
  { 14433, 29, 11, 33, 2, -29 },
};

const GFXfont NotoSans_Condensed_Bold67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_BOLD67PT7B_H_
