#ifndef _NOTOSANS_CONDENSED_BOLD38PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0x78,
  0x7B, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xE7,
  0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x03, 0xC7, 0x00, 0x78, 0xE0, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0xE3, 0xC0,
  0x1C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x7F, 0x83, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7E, 0xDE, 0xF9,
  0x85, 0xF3, 0x03, 0xE6, 0x07, 0xEC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0D, 0xF0, 0x1B, 0xF0,
  0x37, 0xF8, 0x6F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF0, 0xFF, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xE0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0xF0, 0x07, 0x9E, 0x07,
  0x80, 0x7C, 0xF0, 0x78, 0x03, 0xC7, 0x83, 0xC0, 0x1E, 0x3C, 0x3C, 0x00,
  0xF1, 0xF1, 0xE0, 0x07, 0x8F, 0x9F, 0x00, 0x3C, 0x7C, 0xF0, 0x01, 0xE3,
  0xC7, 0x8E, 0x07, 0x9E, 0x78, 0xFC, 0x3C, 0xF3, 0xCF, 0xF1, 0xFF, 0xBC,
  0xFF, 0xC7, 0xF9, 0xE7, 0x9E, 0x1F, 0x9E, 0x3C, 0xF0, 0x20, 0xF3, 0xC7,
  0x80, 0x07, 0x9E, 0x1E, 0x00, 0x78, 0xF0, 0xF0, 0x03, 0xC7, 0x87, 0x80,
  0x3C, 0x3C, 0x7C, 0x01, 0xE1, 0xE3, 0xC0, 0x1E, 0x07, 0x9E, 0x00, 0xF0,
  0x3C, 0xF0, 0x0F, 0x81, 0xFF, 0x80, 0x78, 0x07, 0xF8, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E,
  0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0x80, 0x11, 0xFE, 0x0F, 0x8F, 0xFC, 0x3E, 0x7F, 0xF9, 0xF9,
  0xF3, 0xF7, 0xEF, 0xC7, 0xFF, 0x3F, 0x0F, 0xFC, 0xF8, 0x3F, 0xE3, 0xF0,
  0x7F, 0x8F, 0xC0, 0xFC, 0x3F, 0x8F, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xDF, 0x83, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B,
  0xC0, 0x07, 0xC3, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x78,
  0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81,
  0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x43, 0xC2, 0x7B,
  0xDE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3E, 0x7C, 0x7E, 0x7E, 0x1C, 0x38, 0x0C, 0x30, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3E, 0x7D, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E,
  0x3E, 0x7C, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x3E, 0x3E,
  0x7E, 0x3F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x3F,
  0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0xDF, 0x79, 0xF3, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x00, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFE,
  0x7C, 0x7E, 0x30, 0x3F, 0x20, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x1F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x38, 0x7F, 0x20, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0xF8,
  0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xBE, 0x03, 0x9F, 0x03, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xE1,
  0xE1, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0x87, 0xFF, 0xCF, 0xFF, 0xDF, 0xFF, 0x88, 0x3F, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0x7F,
  0xFE, 0xFF, 0xF9, 0xFF, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC3, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x30, 0x3E, 0x7F, 0x1F, 0x7F, 0xCF, 0xFF, 0xE7, 0xFF,
  0xFB, 0xF8, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xEF,
  0x83, 0xF7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF8, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xC3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x3E, 0x1F, 0x3F,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x7E,
  0xFC, 0x7E, 0x3F, 0x3E, 0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0xFB, 0xF0, 0x7C, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xDF, 0x02,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0x78, 0x3C,
  0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0xFB, 0xF7, 0xCF, 0x9F, 0x3C, 0x79, 0xE0, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x7F, 0xE1,
  0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xCE, 0x0F, 0x88, 0x1F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0x01, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF9,
  0xE0, 0xFF, 0x9E, 0x78, 0x7F, 0xE7, 0xBC, 0x3F, 0xF8, 0xFF, 0x1F, 0x1E,
  0x3F, 0xC7, 0x87, 0x8F, 0xF1, 0xE1, 0xE3, 0xFC, 0xF0, 0x78, 0xFE, 0x3C,
  0x1E, 0x3F, 0x8F, 0x07, 0x8F, 0xE3, 0xC3, 0xE3, 0xF8, 0xF0, 0xF0, 0xEF,
  0x1E, 0x3E, 0x7B, 0xC7, 0xFF, 0xFE, 0xF1, 0xFE, 0xFF, 0x3C, 0x3F, 0x9F,
  0x87, 0x81, 0x83, 0x81, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x04, 0x01, 0xFC, 0x1F, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF3,
  0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x01, 0xFB,
  0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0x87, 0xF7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7C, 0x1F, 0xBE, 0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0xF9, 0xF0, 0x7E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE3, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x20, 0x01, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xF3, 0xFF, 0xF1, 0xFC, 0x39, 0xFC, 0x04, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x02, 0x7F, 0x0E, 0x3F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xF9, 0xFF, 0x3E, 0x0F, 0xEF, 0x81, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3E, 0xF8, 0x1F, 0xBE, 0x0F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFE, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x18, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x83, 0x8F,
  0xC0, 0x13, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF7, 0xC0, 0x7E, 0xFC,
  0x0F, 0xDF, 0x81, 0xF9, 0xFC, 0x3F, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xC0, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC3, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3,
  0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xCF, 0xC0, 0xF8, 0x0F, 0xFE, 0x03, 0xEF,
  0x81, 0xFB, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x8F, 0xC3, 0xE3,
  0xF0, 0xF9, 0xF8, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xF8, 0x3E, 0x3F, 0x0F,
  0x8F, 0xC3, 0xE1, 0xF8, 0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0,
  0x7E, 0xF8, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0xFC, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE,
  0xF0, 0x7B, 0xFF, 0x78, 0x3D, 0xFF, 0xBE, 0x3E, 0xFF, 0xDF, 0x1E, 0x7F,
  0xE7, 0x8F, 0x3F, 0xF3, 0xC7, 0x9F, 0xF9, 0xF7, 0xCF, 0xFC, 0x7B, 0xC7,
  0xFE, 0x3D, 0xE3, 0xFF, 0x1F, 0xF1, 0xFF, 0x8F, 0xF0, 0xFF, 0xC3, 0xF8,
  0x7F, 0xE1, 0xFC, 0x3F, 0xF0, 0xFE, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC, 0x1F,
  0x07, 0xFE, 0x0F, 0x83, 0xE0, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFF, 0xBE, 0x1F, 0xFB, 0xE1, 0xFF, 0xBF, 0x1F, 0xF9,
  0xF1, 0xFF, 0x9F, 0x9F, 0xF8, 0xF9, 0xFF, 0x8F, 0xDF, 0xF8, 0x7D, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03,
  0xF0, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x01,
  0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3F, 0x01, 0xF9, 0xF8,
  0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF9,
  0xFE, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3E, 0xF8, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC7,
  0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xF7, 0xC0, 0x1F, 0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0xC7, 0xF1, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xF8, 0xFE, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E,
  0x0F, 0xCF, 0x83, 0xF3, 0xE1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xF9, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x1F, 0xBE,
  0x07, 0xEF, 0x80, 0xFC, 0x00, 0x80, 0x1F, 0xF0, 0x7F, 0xF9, 0xFF, 0xF7,
  0xFF, 0xCF, 0xE7, 0x9F, 0x01, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xFE,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE3, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0x9F,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0,
  0x1F, 0x01, 0xFF, 0xE0, 0x7F, 0x03, 0xE7, 0xC0, 0xFE, 0x07, 0xCF, 0x81,
  0xFC, 0x0F, 0x9F, 0x03, 0xF8, 0x1F, 0x3E, 0x0F, 0xF0, 0x7E, 0x3E, 0x1E,
  0xF0, 0xF8, 0x7C, 0x3D, 0xE1, 0xF0, 0xF8, 0x7B, 0xC3, 0xE1, 0xF0, 0xF7,
  0x87, 0xC3, 0xE3, 0xEF, 0x1F, 0x83, 0xE7, 0x9F, 0x3E, 0x07, 0xCF, 0x1E,
  0x7C, 0x0F, 0x9E, 0x3C, 0xF8, 0x1F, 0x7C, 0x79, 0xF0, 0x3E, 0xF8, 0xF7,
  0xC0, 0x3D, 0xE1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00,
  0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F,
  0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFD, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00,
  0xF9, 0xF0, 0x1F, 0x9F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xE0, 0x7C,
  0x7E, 0x07, 0xE7, 0xE0, 0x3E, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF7, 0xC0,
  0x7E, 0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xE0,
  0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF8,
  0xF8, 0x0F, 0x1E, 0x01, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x07,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x18, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0x9F, 0x7C,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xCF, 0x1F, 0x8F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0xF8,
  0x7C, 0xFE, 0x3E, 0xFF, 0x9F, 0xFF, 0xEF, 0xE3, 0xF7, 0xE0, 0xFB, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0xFE, 0x3F, 0x7F, 0xFF,
  0xBF, 0xFF, 0x9F, 0x7F, 0xCF, 0x9F, 0x80, 0x07, 0xF0, 0x7F, 0xF3, 0xFF,
  0x9F, 0xFE, 0x7E, 0x33, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xFE,
  0x19, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x0F, 0xCF, 0x8F, 0xF7, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xF3, 0xFB,
  0xF0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xFC, 0x3F, 0x7E,
  0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFC, 0xF0, 0xFC, 0x78, 0x0F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E,
  0xF8, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x06, 0x7F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xFE, 0x0F, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F,
  0x98, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F,
  0xFC, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC7, 0x8F, 0xF3, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF7, 0xF3, 0xFB, 0xF0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x3E, 0xFC, 0x3F, 0x7E, 0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFD, 0xF0, 0xFC, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x40, 0x1F,
  0x9C, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0xF8, 0xFB, 0xFE, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7B, 0xFF, 0xFF,
  0xF8, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1,
  0xF0, 0x30, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x5F, 0xBF, 0xDF, 0xEF,
  0xE7, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0xBE,
  0x1F, 0x9F, 0x0F, 0x8F, 0x8F, 0xC7, 0xCF, 0xC3, 0xE7, 0xC1, 0xF7, 0xC0,
  0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3F, 0x3E, 0x0F, 0xDF,
  0x03, 0xEF, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0xF8, 0x3F, 0x1F, 0x7F, 0xCF, 0xF3, 0xFF, 0xFB, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xF7, 0xFC, 0xFD, 0xF8, 0x7F, 0x0F, 0xFF, 0x07,
  0xE1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x03, 0xFF, 0x83, 0xE0, 0x7F,
  0xF0, 0x7C, 0x0F, 0xFE, 0x0F, 0x81, 0xFF, 0xC1, 0xF0, 0x3F, 0xF8, 0x3E,
  0x07, 0xFF, 0x07, 0xC0, 0xFF, 0xE0, 0xF8, 0x1F, 0xFC, 0x1F, 0x03, 0xFF,
  0x83, 0xE0, 0x7F, 0xF0, 0x7C, 0x0F, 0xFE, 0x0F, 0x81, 0xFF, 0xC1, 0xF0,
  0x3E, 0xF0, 0xF8, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x1F, 0x1F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F,
  0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xF8, 0xF8, 0x7D, 0xFE, 0x3E,
  0xFF, 0x9F, 0xFF, 0xEF, 0xE3, 0xF7, 0xE0, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0xFE, 0x3F, 0x7F, 0xFF, 0xBE, 0xFF, 0x9F,
  0x7F, 0xCF, 0x9F, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07,
  0xC7, 0x8F, 0xF3, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xF3, 0xFB, 0xF0, 0xFD,
  0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xFC, 0x3F, 0x7E, 0x1F, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE3, 0xFD, 0xF0, 0xFC, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0xF0, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xE1, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xC3, 0x7C, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x00, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x13, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0xFF,
  0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0,
  0xFD, 0xF0, 0x3E, 0x7E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x81, 0xF7, 0xC1, 0xF8,
  0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xC3, 0xF8, 0x3E, 0x7C, 0x3F, 0xC3, 0xE7,
  0xE3, 0xFC, 0x7C, 0x3E, 0x3B, 0xC7, 0xC3, 0xE3, 0x9C, 0x7C, 0x3E, 0x79,
  0xC7, 0xC3, 0xE7, 0x9E, 0xF8, 0x1F, 0x79, 0xEF, 0x81, 0xF7, 0x1E, 0xF8,
  0x1F, 0x70, 0xEF, 0x81, 0xF7, 0x0E, 0xF0, 0x0F, 0xF0, 0xEF, 0x00, 0xFF,
  0x0E, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFE,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x9F, 0x87,
  0xE3, 0xE1, 0xF0, 0xF8, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7D, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F,
  0xC7, 0xE1, 0xF1, 0xF0, 0x7E, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xFF, 0x01,
  0xF7, 0xC0, 0xFD, 0xF0, 0x3E, 0x7E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x13, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0xFF, 0x8F, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7F,
  0x07, 0xF0, 0x3F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xF0, 0x7F,
  0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xF8, 0x00, 0x00, 0x00, 0xBF, 0xC0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFA, 0x00, 0xF0,
};

const GFXglyph NotoSans_Condensed_Bold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 27, 10, 2, -27 },
  { 22, 13, 10, 17, 2, -27 },
  { 39, 19, 27, 21, 1, -27 },
  { 104, 15, 31, 19, 2, -29 },
  { 163, 29, 28, 31, 1, -28 },
  { 265, 22, 28, 23, 1, -28 },
  { 342, 5, 10, 9, 2, -27 },
  { 349, 10, 33, 12, 2, -27 },
  { 391, 10, 33, 12, 1, -27 },
  { 433, 16, 16, 18, 1, -29 },
  { 465, 17, 19, 19, 1, -23 },
  { 506, 7, 9, 10, 1, -4 },
  { 514, 10, 5, 12, 1, -13 },
  { 521, 6, 6, 10, 2, -6 },
  { 526, 15, 27, 15, 0, -27 },
  { 577, 16, 28, 19, 1, -28 },
  { 633, 12, 27, 19, 2, -27 },
  { 674, 16, 28, 19, 1, -28 },
  { 730, 16, 28, 19, 1, -28 },
  { 786, 17, 27, 19, 1, -27 },
  { 844, 15, 27, 19, 2, -27 },
  { 895, 17, 27, 19, 1, -27 },
  { 953, 17, 27, 19, 1, -27 },
  { 1011, 17, 27, 19, 1, -27 },
  { 1069, 16, 27, 19, 1, -27 },
  { 1123, 6, 21, 10, 2, -21 },
  { 1139, 7, 26, 10, 1, -21 },
  { 1162, 17, 19, 19, 1, -23 },
  { 1203, 17, 11, 19, 1, -19 },
  { 1227, 17, 19, 19, 1, -23 },
  { 1268, 15, 28, 15, 0, -28 },
  { 1321, 26, 30, 29, 2, -27 },
  { 1419, 22, 27, 22, 0, -27 },
  { 1494, 17, 27, 22, 3, -27 },
  { 1552, 17, 28, 20, 2, -28 },
  { 1612, 18, 27, 23, 3, -27 },
  { 1673, 13, 27, 18, 3, -27 },
  { 1717, 13, 27, 18, 3, -27 },
  { 1761, 19, 28, 23, 2, -28 },
  { 1828, 19, 27, 24, 3, -27 },
  { 1893, 11, 27, 13, 1, -27 },
  { 1931, 10, 35, 11, -2, -27 },
  { 1975, 18, 27, 21, 3, -27 },
  { 2036, 13, 27, 17, 3, -27 },
  { 2080, 25, 27, 31, 3, -27 },
  { 2165, 20, 27, 26, 3, -27 },
  { 2233, 21, 28, 25, 2, -28 },
  { 2307, 16, 27, 20, 3, -27 },
  { 2361, 21, 34, 25, 2, -28 },
  { 2451, 18, 27, 21, 3, -27 },
  { 2512, 15, 28, 18, 1, -28 },
  { 2565, 16, 27, 18, 1, -27 },
  { 2619, 18, 27, 24, 3, -27 },
  { 2680, 21, 27, 21, 0, -27 },
  { 2751, 31, 27, 31, 0, -27 },
  { 2856, 20, 27, 20, 0, -27 },
  { 2924, 20, 27, 20, 0, -27 },
  { 2992, 16, 27, 18, 1, -27 },
  { 3046, 9, 33, 12, 2, -27 },
  { 3084, 15, 27, 15, 0, -27 },
  { 3135, 9, 33, 12, 1, -27 },
  { 3173, 19, 17, 21, 1, -27 },
  { 3214, 16, 3, 16, 0, 3 },
  { 3220, 9, 6, 12, 2, -29 },
  { 3227, 16, 21, 19, 1, -21 },
  { 3269, 17, 29, 20, 2, -29 },
  { 3331, 14, 21, 16, 2, -21 },
  { 3368, 17, 29, 20, 1, -29 },
  { 3430, 16, 21, 19, 2, -21 },
  { 3472, 14, 29, 12, 0, -29 },
  { 3523, 17, 30, 20, 1, -21 },
  { 3587, 16, 29, 21, 2, -29 },
  { 3645, 6, 29, 10, 2, -29 },
  { 3667, 9, 38, 10, -1, -29 },
  { 3710, 17, 29, 20, 3, -29 },
  { 3772, 6, 29, 10, 2, -29 },
  { 3794, 27, 21, 31, 2, -21 },
  { 3865, 16, 21, 21, 2, -21 },
  { 3907, 18, 21, 20, 1, -21 },
  { 3955, 17, 30, 20, 2, -21 },
  { 4019, 17, 30, 20, 1, -21 },
  { 4083, 12, 21, 14, 2, -21 },
  { 4115, 13, 21, 16, 1, -21 },
  { 4150, 12, 25, 14, 1, -25 },
  { 4188, 16, 21, 21, 2, -21 },
  { 4230, 18, 21, 18, 0, -21 },
  { 4278, 28, 21, 28, 0, -21 },
  { 4352, 18, 21, 18, 0, -21 },
  { 4400, 18, 30, 18, 0, -21 },
  { 4468, 13, 21, 15, 1, -21 },
  { 4503, 12, 33, 14, 0, -27 },
  { 4553, 4, 38, 18, 7, -29 },
  { 4572, 12, 33, 14, 1, -27 },
  { 4622, 17, 7, 19, 1, -17 },
};

const GFXfont NotoSans_Condensed_Bold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_BOLD38PT7B_H_
