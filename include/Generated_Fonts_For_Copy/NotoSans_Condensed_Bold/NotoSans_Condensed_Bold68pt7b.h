#ifndef _NOTOSANS_CONDENSED_BOLD68PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x87, 0x80, 0xFF, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x81,
  0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFE, 0xF1, 0xFC, 0xFF, 0xCF, 0x03, 0x8F, 0xF8, 0xF0, 0x08,
  0xFF, 0x8F, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0xFF, 0x8F, 0x00, 0x0F, 0xFC,
  0xF0, 0x00, 0x7F, 0xEF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xF7, 0xFF, 0x00, 0x0F, 0x3F, 0xF0, 0x00, 0xF1, 0xFF, 0x00, 0x0F,
  0x1F, 0xF0, 0x00, 0xF1, 0xFF, 0x80, 0x0F, 0x1F, 0xFF, 0x00, 0xF1, 0xFF,
  0xFC, 0x0F, 0x3F, 0xEF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xC1, 0xFC,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xF8,
  0x7F, 0x01, 0xF0, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC0, 0xFE, 0x0F,
  0xE3, 0xF8, 0x7F, 0xFC, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xFF, 0xC3, 0xFC,
  0xFF, 0x1F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF,
  0x07, 0xFF, 0xC3, 0xF8, 0xFF, 0x0F, 0xE0, 0x7F, 0xF0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00,
  0x01, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F,
  0xF7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF,
  0x9F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x9F, 0xFC, 0x03, 0xFF,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xFF, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE0,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x08, 0x03, 0xF0, 0x04, 0x78,
  0x1F, 0x81, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0xFF, 0xEF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFC,
  0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x3F, 0xC3, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x8F, 0xF9, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xE7, 0xF8, 0x3C, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE,
  0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFE, 0xFF, 0x80,
  0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0xC7, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xEF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0x9F, 0xF7, 0xFC, 0x7F, 0xCF, 0xE1,
  0xFF, 0x1F, 0x07, 0xFC, 0x38, 0x1F, 0xF0, 0x40, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xC0, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0x87, 0x80, 0x0F, 0xFC,
  0x18, 0x00, 0x7F, 0xE0, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F,
  0x80, 0xFF, 0xF0, 0xF0, 0x01, 0xFF, 0x82, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0xF0, 0x00, 0xFF, 0xF7, 0xF8,
  0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0xE0,
  0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x7F, 0x3F, 0xE0,
  0x00, 0x7F, 0x3F, 0xE0, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0xFE, 0x7F, 0xE0,
  0x01, 0xFC, 0x7F, 0xE0, 0x01, 0xFC, 0x7F, 0xE0, 0x03, 0xF8, 0x7F, 0xE0,
  0x07, 0xF8, 0x7F, 0xE0, 0x07, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x7F, 0xE0, 0x1F, 0xC0, 0x7F, 0xE0,
  0x3F, 0x80, 0x7F, 0xE0, 0x3F, 0x80, 0x7F, 0xE0, 0x7F, 0x00, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1C, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xEC, 0x00, 0x0F, 0xFE, 0xF0, 0x01, 0xFF, 0xCF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0x00,
  0x1F, 0xE1, 0xFF, 0x80, 0xFF, 0x1F, 0xFE, 0x07, 0xF9, 0xFF, 0xF8, 0x7F,
  0xDF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xC3, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xF0,
  0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x07,
  0xFD, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xFE,
  0x3F, 0xE0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF,
  0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80,
  0x7F, 0xC7, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xDF, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0x81, 0xFF, 0xCF,
  0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB,
  0xFF, 0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x0F,
  0xFD, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xEF, 0xF1, 0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0xE7, 0xFC, 0x1F, 0xFE,
  0x3F, 0xE0, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0C,
  0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF3,
  0xF8, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE1, 0xE0,
  0x03, 0x01, 0xFE, 0x1F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC,
  0x3F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x3F, 0x01, 0xFF, 0xC7, 0x00, 0x3F, 0xF1, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x01,
  0xFF, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC0, 0x3F,
  0xFF, 0xE0, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xC1, 0xFC, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xF9, 0xFC, 0x0F, 0xF8, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0xE0,
  0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0xFC, 0x1F, 0xC0, 0x3F,
  0x81, 0xFF, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xFF, 0xF0, 0x7F, 0x00, 0xFE,
  0x07, 0xFF, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0xC1, 0xFC, 0x07, 0xF8,
  0x1F, 0xBF, 0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0x7F, 0x07, 0xF0, 0x1F, 0xE0,
  0xFE, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFD, 0xFC, 0x1F, 0xE0, 0xFF, 0x83,
  0xF3, 0xF8, 0x1F, 0xC1, 0xFF, 0x0F, 0xE7, 0xF0, 0x3F, 0xEF, 0xFF, 0xFF,
  0xC7, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xFE, 0x7F, 0xFC,
  0x1F, 0xC0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0x00, 0x7F,
  0xF3, 0xFE, 0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF,
  0xDF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFC,
  0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0xC7,
  0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8,
  0x03, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0x7F, 0xC0,
  0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFE, 0xFF, 0x80, 0x3F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xF8, 0x3F, 0xFC, 0x00, 0x70, 0x7F,
  0xF0, 0x00, 0x20, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x06, 0x1F, 0xFF, 0x00, 0x3C, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xC0, 0x3F, 0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0xCF,
  0xF8, 0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0xFF, 0xEF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0xF3, 0xFE,
  0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0x03,
  0xFF, 0xE0, 0x01, 0xC1, 0xFF, 0xE0, 0x00, 0x10, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF,
  0xDF, 0xF0, 0x0F, 0xFF, 0xF7, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xCF, 0xFE,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0x1F,
  0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0xFB, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF0, 0xFF, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xA0, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x8F,
  0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x3F, 0xF7,
  0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xF8, 0x03,
  0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F,
  0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x00, 0x07, 0xFF,
  0xFF, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xF8, 0x00, 0x7F, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xFF, 0xBF, 0xC0, 0x0F, 0xF7, 0xFF,
  0xFE, 0xFF, 0x00, 0x3F, 0x9F, 0xFF, 0xFB, 0xFC, 0x00, 0xFE, 0x7F, 0xFF,
  0xE7, 0xF0, 0x07, 0xF9, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0xE7, 0xFF, 0xFE,
  0x7F, 0x80, 0x7F, 0x1F, 0xFF, 0xF9, 0xFE, 0x03, 0xFC, 0x7F, 0xFF, 0xE3,
  0xF8, 0x0F, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0x3F, 0x87, 0xFF, 0xFE, 0x3F,
  0xC0, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x07, 0xFF, 0xFE, 0x1F, 0xE3,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x3F,
  0x81, 0xFF, 0xFF, 0x83, 0xFC, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF7, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xDF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0x07, 0xFC, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF,
  0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0x00,
  0xFF, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0x8F,
  0xF8, 0x0F, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0x81,
  0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xCF, 0xFF,
  0xF8, 0x07, 0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0xF8, 0x03, 0xFE,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF,
  0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0x80,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xE8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF,
  0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0x7F,
  0xC0, 0x3F, 0xFB, 0xFE, 0x03, 0xFF, 0xDF, 0xF0, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF,
  0x87, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x3F,
  0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07,
  0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x07,
  0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFE,
  0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xFC,
  0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x0F,
  0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x7F,
  0x8F, 0xFE, 0x01, 0xF1, 0xFF, 0x80, 0x04, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF7, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFD, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFE, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x3F, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0x8F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xC7, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xF0, 0x01,
  0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x7F, 0x0F,
  0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFC,
  0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x0F, 0xF1, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0x03, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x01, 0xFC, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xBF, 0xC0,
  0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x3F, 0xDF, 0xF0, 0x00, 0x1F,
  0xEF, 0xF0, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF0, 0x07, 0xF7, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x00,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFE,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0x9F, 0xFE, 0x07, 0x80, 0x3F, 0xF0, 0x20, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7,
  0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0xEF,
  0xF1, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0x87, 0xF0, 0x7F, 0xE0, 0x7F, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x3F,
  0xE1, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0x0F, 0xFB,
  0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0x3F, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFB, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFE, 0x01, 0xFF, 0xBF, 0xFC, 0x0F, 0xFE,
  0xFF, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xC3, 0xFC, 0x7F, 0xFE, 0x0F, 0xF0,
  0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F,
  0xF8, 0x1E, 0x3F, 0xF8, 0x02, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x13, 0xFF, 0x80, 0x18, 0xFF, 0xF0, 0x7C, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xC0, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF,
  0x07, 0xFF, 0xCF, 0xFC, 0x3F, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF, 0x7F, 0xC7,
  0xFF, 0xFD, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x87, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x7F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0x9F, 0xF0, 0x7F, 0xFC, 0x3F, 0xC0,
  0x7F, 0xE0, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xCF, 0xFE, 0x3F,
  0xE0, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x06, 0x3F, 0xF8, 0x03, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xFE, 0x04, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xFC, 0x7F, 0xC3,
  0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xF7, 0xFC, 0x7F, 0xFF, 0xDF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFD, 0xFF, 0x80,
  0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x1F,
  0xFD, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x87, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFE, 0xFF, 0xC3,
  0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xCF, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x03,
  0x80, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x60, 0x00, 0x1F,
  0xF9, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x07, 0xE0, 0x1F, 0xF0, 0xFF, 0xE0, 0xFF, 0x8F, 0xFF,
  0x87, 0xFC, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x1E, 0x1F, 0xEF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF,
  0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF,
  0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB,
  0xFE, 0x00, 0x78, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x9F, 0xF8,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF3, 0xFE,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0x01, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC3, 0xFC, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC7, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xF3, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x3F, 0xF8, 0x3F,
  0xC7, 0xFF, 0xE1, 0xFE, 0x7F, 0xFF, 0x8F, 0xF3, 0xFF, 0xFE, 0x7F, 0xBF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE7,
  0xFE, 0x01, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF,
  0x80, 0x7F, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xF8,
  0x3F, 0xC7, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF3, 0xFF,
  0x80, 0x7F, 0xEF, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xE0,
  0x1F, 0xFB, 0xFF, 0xC0, 0xFF, 0xEF, 0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF, 0xFC,
  0x3F, 0xE7, 0xFF, 0xE0, 0xFF, 0x8F, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xFC, 0x7F, 0xC3,
  0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xF7, 0xFC, 0x7F, 0xFF, 0xDF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFD, 0xFF, 0x80,
  0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x1F,
  0xFD, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x87, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFE, 0xFF, 0xC3,
  0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xCF, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x03,
  0xC0, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xF1, 0xFC, 0xFF, 0xC0, 0x38, 0xFF, 0x80, 0x08, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x70, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0xF8, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF9, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF,
  0xF9, 0xFE, 0x1F, 0xFF, 0x8F, 0xF0, 0x3F, 0xF0, 0x3F, 0x80, 0x7C, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x1F,
  0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xDF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xF3, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xFE, 0x03, 0xFE, 0x3F,
  0xF0, 0x3F, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xBF, 0x81, 0xFF, 0x07,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xE7, 0xE0, 0x7F, 0xC1,
  0xFF, 0x07, 0xF3, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xF9, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE1, 0xF8, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFC, 0x3F, 0x0F, 0xF8,
  0x0F, 0xF8, 0xFE, 0x1F, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0x0F, 0xE7, 0xFC,
  0x01, 0xFF, 0x3F, 0x87, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0x83, 0xF9, 0xFF,
  0x00, 0x7F, 0xCF, 0xC0, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xE0, 0x7E, 0x7F,
  0x80, 0x0F, 0xF7, 0xF0, 0x3F, 0x3F, 0xC0, 0x07, 0xFB, 0xF8, 0x1F, 0xBF,
  0xE0, 0x03, 0xFD, 0xF8, 0x0F, 0xDF, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x04, 0x7F,
  0xE0, 0x00, 0x13, 0xFF, 0xF0, 0x01, 0xDF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFB, 0x00, 0x0F, 0xFF, 0xC8, 0x00, 0x0F, 0xFE,
  0x20, 0x00, 0x01, 0x80,
};

const GFXglyph NotoSans_Condensed_Bold68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 50, 18, 4, -49 },
  { 64, 24, 18, 31, 3, -49 },
  { 118, 35, 48, 37, 1, -48 },
  { 328, 28, 56, 34, 3, -52 },
  { 524, 51, 50, 55, 2, -49 },
  { 843, 40, 50, 42, 2, -49 },
  { 1093, 10, 18, 17, 3, -49 },
  { 1116, 18, 60, 22, 3, -49 },
  { 1251, 18, 60, 22, 1, -49 },
  { 1386, 29, 29, 32, 2, -52 },
  { 1492, 29, 32, 34, 2, -40 },
  { 1608, 12, 17, 18, 2, -8 },
  { 1634, 17, 8, 21, 2, -22 },
  { 1651, 11, 11, 18, 3, -10 },
  { 1667, 26, 49, 28, 1, -49 },
  { 1827, 29, 50, 34, 2, -49 },
  { 2009, 22, 49, 34, 3, -49 },
  { 2144, 29, 49, 34, 2, -49 },
  { 2322, 29, 50, 34, 2, -49 },
  { 2504, 32, 49, 34, 1, -49 },
  { 2700, 28, 50, 34, 3, -49 },
  { 2875, 29, 50, 34, 2, -49 },
  { 3057, 29, 49, 34, 2, -49 },
  { 3235, 29, 50, 34, 2, -49 },
  { 3417, 29, 50, 34, 2, -49 },
  { 3599, 10, 39, 18, 4, -38 },
  { 3648, 12, 47, 18, 2, -38 },
  { 3719, 30, 33, 34, 2, -41 },
  { 3843, 30, 20, 34, 2, -34 },
  { 3918, 30, 33, 34, 2, -41 },
  { 4042, 26, 50, 27, 0, -49 },
  { 4205, 47, 54, 53, 3, -49 },
  { 4523, 39, 49, 39, 0, -49 },
  { 4762, 31, 49, 39, 5, -49 },
  { 4952, 31, 50, 36, 3, -49 },
  { 5146, 33, 49, 42, 5, -49 },
  { 5349, 24, 49, 32, 5, -49 },
  { 5496, 23, 49, 32, 5, -49 },
  { 5637, 34, 50, 42, 3, -49 },
  { 5850, 33, 49, 44, 5, -49 },
  { 6053, 19, 49, 23, 2, -49 },
  { 6170, 19, 63, 20, -4, -49 },
  { 6320, 33, 49, 38, 5, -49 },
  { 6523, 24, 49, 31, 5, -49 },
  { 6670, 46, 49, 56, 5, -49 },
  { 6952, 36, 49, 47, 5, -49 },
  { 7173, 38, 50, 44, 3, -49 },
  { 7411, 29, 49, 36, 5, -49 },
  { 7589, 38, 61, 44, 3, -49 },
  { 7879, 33, 49, 38, 5, -49 },
  { 8082, 27, 50, 31, 2, -49 },
  { 8251, 30, 49, 32, 1, -49 },
  { 8435, 33, 50, 43, 5, -49 },
  { 8642, 37, 49, 37, 0, -49 },
  { 8869, 57, 49, 55, -1, -49 },
  { 9219, 36, 49, 36, 0, -49 },
  { 9440, 35, 49, 35, 0, -49 },
  { 9655, 29, 49, 31, 1, -49 },
  { 9833, 16, 60, 22, 4, -49 },
  { 9953, 27, 49, 28, 0, -49 },
  { 10119, 15, 60, 22, 2, -49 },
  { 10232, 33, 31, 37, 2, -49 },
  { 10360, 28, 5, 28, 0, 6 },
  { 10378, 17, 11, 22, 3, -52 },
  { 10402, 28, 39, 34, 2, -38 },
  { 10539, 30, 53, 37, 4, -52 },
  { 10738, 25, 39, 30, 3, -38 },
  { 10860, 30, 53, 37, 3, -52 },
  { 11059, 28, 39, 34, 3, -38 },
  { 11196, 24, 52, 22, 1, -52 },
  { 11352, 30, 54, 37, 3, -38 },
  { 11555, 29, 52, 37, 4, -52 },
  { 11744, 10, 52, 18, 4, -52 },
  { 11809, 16, 68, 18, -2, -52 },
  { 11945, 32, 52, 36, 4, -52 },
  { 12153, 9, 52, 18, 4, -52 },
  { 12212, 47, 38, 55, 4, -38 },
  { 12436, 29, 38, 37, 4, -38 },
  { 12574, 30, 39, 36, 3, -38 },
  { 12721, 30, 54, 37, 4, -38 },
  { 12924, 30, 54, 37, 3, -38 },
  { 13127, 21, 38, 26, 4, -38 },
  { 13227, 24, 39, 28, 2, -38 },
  { 13344, 22, 46, 25, 1, -45 },
  { 13471, 29, 38, 37, 4, -37 },
  { 13609, 33, 37, 33, 0, -37 },
  { 13762, 49, 37, 50, 0, -37 },
  { 13989, 32, 37, 32, 0, -37 },
  { 14137, 33, 53, 33, 0, -37 },
  { 14356, 24, 37, 27, 2, -37 },
  { 14467, 21, 60, 25, 1, -49 },
  { 14625, 8, 68, 32, 12, -52 },
  { 14693, 21, 60, 25, 3, -49 },
  { 14851, 30, 12, 34, 2, -30 },
};

const GFXfont NotoSans_Condensed_Bold68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_BOLD68PT7B_H_
