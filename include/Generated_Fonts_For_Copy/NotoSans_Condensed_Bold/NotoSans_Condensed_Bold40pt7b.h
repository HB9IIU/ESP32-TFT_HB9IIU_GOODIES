#ifndef _NOTOSANS_CONDENSED_BOLD40PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x7C, 0xFC,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDE,
  0x1F, 0x78, 0x7D, 0xE1, 0xE7, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x1E, 0x38,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x0F,
  0x1E, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x0F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFD, 0x8E,
  0xF9, 0x82, 0xF9, 0x80, 0xF9, 0x80, 0xFD, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xBF,
  0x01, 0x9F, 0x01, 0x9F, 0xC1, 0x9F, 0xF1, 0xBF, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xF8, 0x3F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFE, 0x03, 0xE0, 0x1F,
  0xF8, 0x0F, 0x00, 0x79, 0xF0, 0x3C, 0x03, 0xE3, 0xC1, 0xE0, 0x0F, 0x8F,
  0x07, 0x80, 0x3E, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0xF0, 0x03, 0xC3, 0xC7,
  0xC0, 0x0F, 0x8F, 0x1E, 0x00, 0x3E, 0x3C, 0xF8, 0x20, 0x78, 0xF3, 0xC7,
  0xE1, 0xE7, 0xCF, 0x3F, 0xC7, 0xFE, 0x79, 0xFF, 0x8F, 0xF9, 0xE7, 0x9E,
  0x1F, 0xCF, 0x1E, 0x7C, 0x3C, 0x3C, 0xF8, 0xF0, 0x01, 0xF3, 0xE3, 0xC0,
  0x07, 0x8F, 0x0F, 0x00, 0x1E, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0xF0, 0x03,
  0xC3, 0xE3, 0xC0, 0x1E, 0x0F, 0x8F, 0x00, 0x78, 0x1E, 0x7C, 0x03, 0xE0,
  0x7D, 0xE0, 0x0F, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFC, 0x01, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7E, 0x3F, 0xF8,
  0x7C, 0x7F, 0xF8, 0xFC, 0x7E, 0xFC, 0xFC, 0xFC, 0x7E, 0xF8, 0xFC, 0x3F,
  0xF8, 0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7F, 0xBF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE,
  0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0x9E, 0x79, 0xE7,
  0x80, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C,
  0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x06, 0x1C, 0x33, 0xEE, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xF8, 0x03, 0xFE, 0x03, 0xEF, 0x01, 0xF7, 0xC1, 0xF1, 0xF0, 0x78,
  0xF0, 0x18, 0x30, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3E, 0x7C,
  0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x79, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC3, 0xFF, 0xF1, 0xF1, 0xF9, 0xF8, 0x7C, 0xF8, 0x3F, 0x7C, 0x1F,
  0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x81, 0xF7,
  0xC0, 0xFB, 0xE0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3E, 0x3F, 0x7F, 0x1F, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0xFD, 0xFB, 0xCF, 0xCC,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xE1, 0xF8, 0xC0, 0x7E, 0x20, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0xC1, 0xF8, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0xF8, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0xFB, 0xE0,
  0x3C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xC3, 0xE0, 0xF0, 0xF8, 0x78,
  0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x7B,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xF1, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFF, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC2, 0x01, 0xF7, 0xF0, 0xFB, 0xFE, 0x3E, 0xFF, 0xCF, 0xFF,
  0xFB, 0xF8, 0x7E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F,
  0xFC, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3F, 0x3F, 0x8F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0x3F, 0x1F, 0x87, 0xE7, 0xC1, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x9F,
  0x87, 0xC3, 0xF3, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1, 0xFB, 0xF0, 0x3E,
  0xFC, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFB, 0xF0, 0x3E, 0x7E, 0x1F, 0x9F,
  0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFD, 0xFD, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xF7, 0xC3,
  0xF3, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x41, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x7B,
  0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B,
  0xFF, 0xFF, 0xFD, 0xF0, 0x3E, 0x7E, 0x7E, 0x7F, 0x7E, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E,
  0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0xF3, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xE6, 0x0F, 0xC8,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x7C, 0x1F,
  0xF3, 0xCF, 0x0F, 0xFE, 0x3D, 0xE3, 0xFF, 0xC7, 0xF8, 0x7C, 0x78, 0xFF,
  0x1F, 0x0F, 0x1F, 0xE3, 0xC1, 0xE3, 0xFC, 0x78, 0x3C, 0x7F, 0x8F, 0x07,
  0x8F, 0xF1, 0xE1, 0xF1, 0xFE, 0x3C, 0x3E, 0x3F, 0xC7, 0x87, 0xC7, 0xF8,
  0xF0, 0xF8, 0xFF, 0x1F, 0x3F, 0x3D, 0xE1, 0xFF, 0xFF, 0xBC, 0x3F, 0xDF,
  0xE3, 0xC3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x04, 0x00, 0xFE, 0x0F, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xE0,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xFC, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xC0,
  0x7E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF7, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBE, 0x0F, 0xEF, 0x81, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x7F, 0xBE, 0x07, 0xEF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xE0, 0xE7, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x02, 0x3F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x87, 0xFC, 0xF8, 0x1F,
  0xCF, 0x80, 0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF,
  0x80, 0xFC, 0xF8, 0x1F, 0xCF, 0x83, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFC, 0x0C, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF3,
  0xF0, 0x3F, 0x3F, 0xE7, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x7E, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0x8F, 0xE0, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F,
  0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFD, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xF0,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0x78, 0x0F,
  0x7F, 0xEF, 0x03, 0xEF, 0xFD, 0xF0, 0x7D, 0xFF, 0xBE, 0x0F, 0x3F, 0xF3,
  0xC3, 0xE7, 0xFE, 0x7C, 0x7C, 0xFF, 0xCF, 0x8F, 0x1F, 0xF9, 0xF1, 0xE3,
  0xFF, 0x1E, 0x7C, 0x7F, 0xE3, 0xEF, 0x0F, 0xFC, 0x7D, 0xE1, 0xFF, 0x87,
  0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xE0, 0xFF, 0xC3, 0xFC, 0x1F,
  0xF8, 0x3F, 0x83, 0xFF, 0x07, 0xE0, 0x7F, 0xE0, 0xFC, 0x0F, 0xFC, 0x1F,
  0x81, 0xFF, 0x81, 0xF0, 0x3E, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFE, 0xFC, 0x3F, 0xF7, 0xE1,
  0xFF, 0x9F, 0x8F, 0xFC, 0xFC, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x9F, 0xF8,
  0x7C, 0xFF, 0xC3, 0xF7, 0xFE, 0x0F, 0xBF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0x9F, 0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xC3, 0xFB, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xF7, 0xC3, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F,
  0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F,
  0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF0,
  0xFF, 0x3E, 0x07, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x9F, 0x03, 0xF3, 0xE0,
  0x7E, 0x7C, 0x0F, 0xCF, 0x83, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xE3, 0xF0, 0x7C, 0x7E, 0x0F, 0x87,
  0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x1F, 0x9F, 0x03,
  0xF3, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xFE,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7E, 0x1E, 0x7E, 0x02, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7F, 0xBF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x03, 0xCF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0xFC, 0x01, 0xF0, 0x0F, 0xFF, 0x01, 0xF8,
  0x07, 0xDF, 0x80, 0xFC, 0x03, 0xE7, 0xC0, 0x7F, 0x03, 0xF3, 0xE0, 0x3F,
  0x81, 0xF9, 0xF0, 0x3F, 0xC0, 0xFC, 0xFC, 0x1F, 0xE0, 0x7C, 0x7E, 0x0F,
  0xF0, 0x3E, 0x1F, 0x07, 0xFC, 0x3F, 0x0F, 0x83, 0xDE, 0x1F, 0x87, 0xC3,
  0xEF, 0x0F, 0x83, 0xF1, 0xF7, 0x87, 0xC1, 0xF8, 0xF3, 0xE3, 0xE0, 0x7C,
  0x79, 0xF3, 0xF0, 0x3E, 0x7C, 0xF9, 0xF8, 0x1F, 0x3E, 0x3C, 0xF8, 0x0F,
  0x9F, 0x1E, 0x7C, 0x03, 0xEF, 0x0F, 0xBE, 0x01, 0xF7, 0x87, 0xDF, 0x00,
  0xFB, 0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xF0,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0x7E, 0x0F, 0xC1,
  0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xC0, 0x7E,
  0x3F, 0x03, 0xF0, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0x80, 0xFC,
  0xFC, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x07, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7C, 0x1F,
  0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7B, 0xE0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0,
  0x0F, 0x1F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x83, 0xE0, 0x78, 0x3C, 0x07,
  0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xEF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0xF8, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xC3, 0xF0, 0x80, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0xFF, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xDF, 0xFF,
  0xEF, 0xFD, 0xF3, 0xFE, 0xF8, 0xFC, 0x3C, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0xFC, 0x3F, 0x7F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x3F,
  0xBF, 0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x1F, 0xBF, 0xC7, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xF9, 0xFE,
  0x3E, 0x3F, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0x7F, 0x3B,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x05, 0xFC, 0x77, 0xFF,
  0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F,
  0x8F, 0x9F, 0xF7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7, 0xF7, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF,
  0x1F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFE, 0xF8, 0xFE, 0x3C, 0x07, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE3, 0xF7, 0xE0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0x3F, 0x03,
  0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xE0, 0x1F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7E, 0x11, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7F, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xCF, 0x9F, 0xF7, 0xCF, 0xFB, 0xEF, 0xFF,
  0xF7, 0xE7, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x1F, 0xDF, 0xFF, 0xEF, 0xFD, 0xF3, 0xFE,
  0xF8, 0xFE, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xD8,
  0x0F, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x06, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0xFC, 0x7E, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7C, 0x7F, 0xFF, 0xFF, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xFF, 0xF7, 0xFB, 0xF0, 0xC0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x83,
  0xF3, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x9F, 0x83, 0xEF, 0xC0,
  0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xBE, 0x0F, 0xCF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0x83,
  0xF3, 0xE0, 0x7E, 0xF8, 0x1F, 0xBE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xFC, 0x1F, 0x8F, 0x9F,
  0xE3, 0xFE, 0xFB, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7,
  0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x1F, 0xC1, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC,
  0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8,
  0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF,
  0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F,
  0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F,
  0xF8, 0xFC, 0x7C, 0xFF, 0xBE, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7C, 0x07,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x3F, 0x3F, 0x07,
  0xEF, 0xC1, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xF0, 0x7E, 0xFC,
  0x1F, 0x9F, 0x8F, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFE,
  0x00, 0xF8, 0xFC, 0x3E, 0x7F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x3F,
  0xBF, 0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x1F, 0xBF, 0xCF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFD, 0xFE,
  0x3F, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x0F, 0xCF, 0x9F, 0xF7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7, 0xF7, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFF, 0x1F, 0xDF, 0xFF, 0xEF, 0xFD, 0xF3, 0xFE, 0xF8, 0xFE, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0xFF, 0xCF,
  0xFE, 0xFD, 0xF7, 0xEF, 0xFF, 0x7F, 0xC7, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xF0, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFE, 0xFC, 0x3B, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF1, 0x3F, 0xF1, 0xFF,
  0x1F, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xBF, 0x9F, 0xDF, 0xFF, 0xEF, 0xFE, 0xF3, 0xFE, 0x78,
  0xFE, 0x3C, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0x3F, 0x03, 0xE7,
  0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x1F, 0x83,
  0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0xFB, 0xE0,
  0xFE, 0x0F, 0xDF, 0x07, 0xF0, 0x7C, 0xF8, 0x3F, 0x83, 0xE7, 0xE1, 0xFE,
  0x1F, 0x1F, 0x0E, 0xF1, 0xF8, 0xF8, 0xF7, 0x8F, 0xC7, 0xC7, 0xBC, 0x7C,
  0x3F, 0x3D, 0xE3, 0xE1, 0xF9, 0xE7, 0x9F, 0x07, 0xCE, 0x3D, 0xF8, 0x3E,
  0xF1, 0xEF, 0x81, 0xF7, 0x8F, 0x7C, 0x0F, 0xBC, 0x7B, 0xE0, 0x3D, 0xE1,
  0xDF, 0x01, 0xFF, 0x0E, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC,
  0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xF8, 0x7E, 0x1F, 0x8F,
  0xC1, 0xF3, 0xF0, 0x3F, 0x7E, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBF, 0x07, 0xE3, 0xE0, 0xFC, 0x7E,
  0x3F, 0x07, 0xC7, 0xE0, 0xFD, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xEF, 0x80,
  0xFD, 0xF0, 0x1F, 0xBF, 0x03, 0xE7, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0xC3,
  0xE1, 0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7E, 0x7C, 0x07, 0xCF,
  0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0xFF, 0x87, 0xF0, 0x3F, 0xC1, 0xFF, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xF0, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x00, 0x3F, 0x80,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xA0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_Bold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 29, 11, 2, -29 },
  { 23, 14, 11, 18, 2, -29 },
  { 43, 20, 29, 22, 1, -29 },
  { 116, 16, 32, 20, 2, -30 },
  { 180, 30, 29, 32, 1, -29 },
  { 289, 24, 29, 25, 1, -29 },
  { 376, 6, 11, 10, 2, -29 },
  { 385, 10, 35, 13, 2, -29 },
  { 429, 10, 35, 13, 1, -29 },
  { 473, 17, 16, 19, 1, -30 },
  { 507, 18, 19, 20, 1, -24 },
  { 550, 7, 10, 10, 1, -5 },
  { 559, 10, 5, 12, 1, -13 },
  { 566, 6, 6, 11, 2, -6 },
  { 571, 16, 29, 16, 0, -29 },
  { 629, 17, 29, 20, 1, -29 },
  { 691, 13, 29, 20, 2, -29 },
  { 739, 17, 29, 20, 1, -29 },
  { 801, 17, 29, 20, 1, -29 },
  { 863, 18, 29, 20, 1, -29 },
  { 929, 16, 29, 20, 2, -29 },
  { 987, 18, 29, 20, 1, -29 },
  { 1053, 18, 29, 20, 1, -29 },
  { 1119, 18, 29, 20, 1, -29 },
  { 1185, 17, 29, 20, 1, -29 },
  { 1247, 6, 22, 11, 2, -22 },
  { 1264, 8, 27, 11, 1, -22 },
  { 1291, 18, 19, 20, 1, -24 },
  { 1334, 18, 12, 20, 1, -20 },
  { 1361, 18, 19, 20, 1, -24 },
  { 1404, 15, 29, 16, 0, -29 },
  { 1459, 27, 32, 31, 2, -29 },
  { 1567, 23, 29, 23, 0, -29 },
  { 1651, 18, 29, 23, 3, -29 },
  { 1717, 18, 29, 21, 2, -29 },
  { 1783, 20, 29, 24, 3, -29 },
  { 1856, 14, 29, 19, 3, -29 },
  { 1907, 14, 29, 19, 3, -29 },
  { 1958, 20, 29, 24, 2, -29 },
  { 2031, 20, 29, 26, 3, -29 },
  { 2104, 11, 29, 13, 1, -29 },
  { 2144, 11, 37, 12, -2, -29 },
  { 2195, 20, 29, 22, 3, -29 },
  { 2268, 14, 29, 18, 3, -29 },
  { 2319, 27, 29, 33, 3, -29 },
  { 2417, 21, 29, 27, 3, -29 },
  { 2494, 22, 29, 26, 2, -29 },
  { 2574, 17, 29, 21, 3, -29 },
  { 2636, 22, 36, 26, 2, -29 },
  { 2735, 19, 29, 22, 3, -29 },
  { 2804, 16, 29, 18, 1, -29 },
  { 2862, 17, 29, 19, 1, -29 },
  { 2924, 19, 29, 25, 3, -29 },
  { 2993, 22, 29, 22, 0, -29 },
  { 3073, 33, 29, 32, 0, -29 },
  { 3193, 21, 29, 21, 0, -29 },
  { 3270, 21, 29, 21, 0, -29 },
  { 3347, 17, 29, 18, 1, -29 },
  { 3409, 10, 35, 13, 2, -29 },
  { 3453, 16, 29, 16, 0, -29 },
  { 3511, 9, 35, 13, 1, -29 },
  { 3551, 20, 18, 22, 1, -29 },
  { 3596, 16, 2, 16, 0, 4 },
  { 3600, 9, 7, 13, 2, -31 },
  { 3608, 17, 22, 20, 1, -22 },
  { 3655, 18, 30, 22, 2, -30 },
  { 3723, 14, 22, 17, 2, -22 },
  { 3762, 17, 30, 22, 2, -30 },
  { 3826, 17, 22, 20, 2, -22 },
  { 3873, 14, 31, 13, 0, -31 },
  { 3928, 17, 32, 22, 2, -22 },
  { 3996, 17, 30, 22, 2, -30 },
  { 4060, 6, 30, 10, 2, -30 },
  { 4083, 9, 40, 10, -1, -30 },
  { 4128, 18, 30, 21, 3, -30 },
  { 4196, 6, 30, 10, 2, -30 },
  { 4219, 28, 22, 33, 2, -22 },
  { 4296, 17, 22, 22, 2, -22 },
  { 4343, 18, 22, 21, 2, -22 },
  { 4393, 18, 32, 22, 2, -22 },
  { 4465, 17, 32, 22, 2, -22 },
  { 4533, 13, 22, 15, 2, -22 },
  { 4569, 14, 22, 16, 1, -22 },
  { 4608, 12, 26, 14, 1, -26 },
  { 4647, 17, 22, 22, 2, -22 },
  { 4694, 19, 22, 19, 0, -22 },
  { 4747, 29, 22, 29, 0, -22 },
  { 4827, 19, 22, 19, 0, -22 },
  { 4880, 19, 32, 19, 0, -22 },
  { 4956, 14, 22, 16, 1, -22 },
  { 4995, 13, 35, 14, 0, -29 },
  { 5052, 5, 40, 19, 7, -31 },
  { 5077, 13, 35, 14, 1, -29 },
  { 5134, 18, 6, 20, 1, -17 },
};

const GFXfont NotoSans_Condensed_Bold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_BOLD40PT7B_H_
