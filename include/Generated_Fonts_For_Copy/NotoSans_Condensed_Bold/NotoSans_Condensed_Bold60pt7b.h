#ifndef _NOTOSANS_CONDENSED_BOLD60PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xEF, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE7, 0xF0, 0x30, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFD,
  0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xDF, 0xC1,
  0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF,
  0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xBC, 0x3C, 0xFF, 0x3C, 0x04, 0xFF, 0x3C, 0x00, 0xFF, 0x3C,
  0x00, 0xFF, 0x3C, 0x00, 0xFF, 0x3C, 0x00, 0xFF, 0xBC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3D, 0xFF, 0x00, 0x3C, 0xFF, 0x00, 0x3C,
  0xFF, 0x00, 0x3C, 0x7F, 0x80, 0x3C, 0x7F, 0xC0, 0x3C, 0xFF, 0xF0, 0x3C,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xC1, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0xC7, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x3F, 0x07, 0xF0, 0x3F, 0x87, 0xE3,
  0xF8, 0xFF, 0xE0, 0xFC, 0x3F, 0x1F, 0x87, 0xFF, 0x87, 0xF3, 0xF8, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x3F,
  0x9F, 0xC3, 0xFF, 0xC7, 0xF1, 0xF8, 0xFE, 0x0F, 0xFC, 0x3F, 0x1F, 0xC3,
  0xF0, 0x3F, 0xC3, 0xF8, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0xFE,
  0x00, 0x01, 0xFC, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x80,
  0x00, 0x7E, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x83, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0x00, 0xFF,
  0x07, 0xFF, 0xF0, 0x1F, 0xE1, 0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0x8F, 0xFB, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC3,
  0xFE, 0xFF, 0x8F, 0xF0, 0x3F, 0xFF, 0xE1, 0xFE, 0x03, 0xFF, 0xFC, 0x3F,
  0xC0, 0x7F, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFD, 0xFF, 0x80,
  0xFF, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x14, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xEF, 0xF7, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0xE0, 0xFC, 0x0E, 0x3F, 0x3F, 0x1F, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xCF, 0xF0, 0x0F, 0xF1,
  0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFE, 0x0F, 0xC0, 0x0F, 0x03, 0xE0, 0x01,
  0xC0, 0x60, 0x00, 0x10, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFE, 0x7F, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xFB, 0xFE,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x1F, 0xE7,
  0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F,
  0xE7, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xF9, 0xFE, 0xFE, 0x3F, 0xCF, 0x87,
  0xF8, 0xE0, 0xFF, 0x08, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7E, 0x03, 0xFE, 0x3E, 0x01, 0xFF,
  0x0E, 0x00, 0x7F, 0x82, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7C, 0x03, 0xFE,
  0x18, 0x01, 0xFF, 0x08, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFD, 0xFE, 0x00, 0x1F, 0x9F,
  0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x1F, 0xE0, 0x07, 0xF1, 0xFE, 0x00,
  0x7E, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x1F, 0x81,
  0xFE, 0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0,
  0x7E, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x10, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0xF0, 0x07, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xD0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x1F, 0xF8, 0x3F, 0xCF, 0xFF, 0x0F, 0xF7,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF,
  0xFE, 0x1F, 0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0x9F,
  0xE0, 0x1F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F, 0xF1,
  0xFF, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07,
  0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xC0,
  0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xB0, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF,
  0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xFB,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07,
  0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xBF, 0x87, 0xFF, 0xCF,
  0xE0, 0xFF, 0xE3, 0xF8, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x30, 0x3F, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x3F, 0x07, 0x80, 0x1F, 0x87, 0xF8, 0xFF, 0x3F, 0xF7,
  0xFE, 0xFF, 0xCF, 0xF9, 0xFE, 0x1F, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87,
  0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x01, 0xFF, 0x18,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF,
  0xC7, 0xF1, 0xF8, 0x1F, 0xFF, 0xE1, 0xF9, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7E, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xFE, 0x0F,
  0xE0, 0x7E, 0x0F, 0xFF, 0x07, 0xF0, 0x3F, 0x07, 0xFF, 0x83, 0xF0, 0x3F,
  0x83, 0xFF, 0xC3, 0xF8, 0x1F, 0xC1, 0xFF, 0xE1, 0xFC, 0x0F, 0xE0, 0xFF,
  0xF0, 0xFC, 0x07, 0xF0, 0x7F, 0xF8, 0x7E, 0x03, 0xF8, 0x3F, 0xFC, 0x3F,
  0x01, 0xF8, 0x1F, 0xFE, 0x1F, 0x80, 0xFC, 0x0F, 0xFF, 0x0F, 0xC0, 0x7E,
  0x07, 0xFF, 0x87, 0xF0, 0x3F, 0x07, 0xEF, 0xC3, 0xF8, 0x3F, 0x83, 0xF7,
  0xE0, 0xFC, 0x1F, 0xC1, 0xFB, 0xF0, 0x7F, 0x1F, 0xF1, 0xF9, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xBF, 0xFC, 0x7F, 0x03, 0xFF, 0x9F,
  0xFC, 0x1F, 0x80, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE,
  0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F,
  0xDF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFC, 0x0F,
  0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x0F,
  0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xDF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE0, 0x3C, 0x1F, 0xF8, 0x01, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0x0F, 0xFE,
  0x01, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xE3, 0xFF, 0xF8, 0xFF,
  0x80, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x01, 0xFF,
  0x8F, 0xF8, 0x0F, 0xFE, 0x3F, 0xE1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xC0, 0x3C, 0x1F, 0xFC, 0x00, 0x20, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFD,
  0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F,
  0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x7F, 0xC7, 0xFE,
  0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x3C, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0xCF, 0xF0,
  0x07, 0xFC, 0x7F, 0x80, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x01,
  0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x03, 0xFC,
  0xFF, 0xC0, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x7F, 0xE0, 0x07, 0xFB, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x01, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xF8,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F,
  0xC0, 0x7F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xFC, 0x7F, 0x80,
  0x3F, 0xE3, 0xFC, 0x01, 0xFF, 0x9F, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x3F,
  0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0xFE, 0xFE,
  0x00, 0xFE, 0xFF, 0xFE, 0x7E, 0x00, 0xFC, 0xFF, 0xFE, 0x7F, 0x01, 0xFC,
  0xFF, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0xFE, 0x7F, 0x01, 0xF8, 0xFF, 0xFE,
  0x3F, 0x83, 0xF8, 0xFF, 0xFE, 0x3F, 0x83, 0xF8, 0xFF, 0xFE, 0x3F, 0x83,
  0xF8, 0xFF, 0xFE, 0x3F, 0x83, 0xF0, 0xFF, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0xFE, 0x1F, 0xC7, 0xE0, 0xFF, 0xFE, 0x0F,
  0xCF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xEF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0xFF,
  0x00, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x7F, 0x80, 0xFF, 0xFE, 0x7F,
  0x80, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0xFE, 0x3F, 0xC0, 0xFF, 0xFE, 0x3F,
  0xE0, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0xFE, 0x07,
  0xFC, 0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFE, 0x01,
  0xFE, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F,
  0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0xFE, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x3F,
  0xEF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFE, 0xFF, 0x87, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xF0,
  0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF,
  0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01,
  0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF7,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xE0, 0xFC, 0x7F, 0xC0, 0x18, 0x7F, 0x80,
  0x08, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01,
  0xFE, 0xF0, 0x03, 0xFE, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0,
  0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xDF,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFD,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0x07, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFB,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xBF, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x80, 0xFF, 0x03,
  0xF3, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x7E, 0x0F, 0xF0, 0x07, 0xF8,
  0x7F, 0x1F, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x00, 0x7F,
  0x87, 0xF1, 0xFC, 0x7F, 0x80, 0x1F, 0xE1, 0xF8, 0x7F, 0x1F, 0xE0, 0x03,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0x83, 0xF1, 0xFE, 0x00,
  0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x3F, 0x9F, 0xC0,
  0x01, 0xFC, 0xFC, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x01, 0xFB, 0xFC,
  0x00, 0x1F, 0xDF, 0xC0, 0x7E, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xBF,
  0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x01,
  0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFC, 0xFE,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3E, 0x07, 0xFC,
  0x0C, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFC,
  0xFF, 0xFC, 0xFE, 0x3F, 0xFC, 0x7F, 0x0F, 0xF8, 0x1F, 0x80, 0x60, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x0F, 0xF3,
  0xFF, 0x83, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xBF, 0xE0, 0x3F,
  0xEF, 0xF8, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xBF, 0xE0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFF, 0x8F, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xEF, 0xFF, 0xE3, 0xF9, 0xFF, 0xF0,
  0xFE, 0x3F, 0xF8, 0x3F, 0x07, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x0C, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x04, 0x7F, 0xC0,
  0x18, 0xFF, 0xE1, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x3F, 0xC1,
  0xFF, 0xC7, 0xF8, 0x7F, 0xFC, 0xFF, 0x1F, 0xFF, 0xDF, 0xE3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xFE, 0xFF,
  0x80, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F,
  0xEF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0,
  0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x1F, 0xF9,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0x7F, 0x87, 0xFF, 0xEF, 0xF0, 0x7F, 0xF8, 0xFE, 0x07, 0xFC, 0x1F, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFE,
  0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xE7,
  0xF8, 0x03, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x43, 0xFF, 0x00, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0x04, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0xFF,
  0xE3, 0xFC, 0x3F, 0xFE, 0x7F, 0x87, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0x7F, 0xC0,
  0x7F, 0xEF, 0xF8, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF7,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F,
  0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFC, 0xFF,
  0xC7, 0xFF, 0x9F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xBF,
  0xC3, 0xFF, 0xE7, 0xF8, 0x3F, 0xF8, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x04,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x88, 0x00, 0x1F, 0xF1, 0xC0, 0x07, 0xFE, 0x3F, 0xEF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0xFF, 0xF1, 0xFE, 0xFF, 0xFC,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0x0C, 0x3F,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFC, 0x00, 0x60, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x3F, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x3F,
  0xEF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x7E, 0x1F, 0xFE, 0x1F, 0xFE,
  0x3F, 0x9F, 0xFF, 0x1F, 0xFF, 0x9F, 0xDF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF8,
  0x07, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0xFC, 0x1F, 0xF0, 0x7E, 0x1F, 0xFE, 0x3F, 0x9F,
  0xFF, 0x9F, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFE, 0x7F, 0xE1,
  0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xF8, 0x07, 0xF9, 0xFE, 0x00,
  0xFF, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F,
  0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0x8F,
  0xFE, 0x0F, 0xE7, 0xFF, 0xC3, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0x3F, 0xF3, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0xFF,
  0xBF, 0xE0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xFF, 0x3F, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0xC3,
  0xFC, 0xFF, 0xE0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC0, 0xE0, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0xFF, 0xE3, 0xFC, 0x3F,
  0xFE, 0x7F, 0x87, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8,
  0x07, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF7, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xF7,
  0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFE, 0x01,
  0xFF, 0x7F, 0xC0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xBF, 0xC3, 0xFF, 0xE7,
  0xF8, 0x3F, 0xF8, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x04, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFE, 0x0F, 0x9F, 0xE0, 0x0C, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x0C, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFC, 0xFF, 0xFC, 0xFE, 0x3F, 0xFC, 0x7F, 0x0F, 0xFC,
  0x1F, 0x80, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F,
  0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xFC, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF7, 0xF8,
  0x07, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07,
  0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xE3, 0xFC, 0x0F, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xBF, 0x07, 0xF8,
  0x1F, 0xE1, 0xF9, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0x9F, 0x87, 0xF8, 0x1F,
  0xE1, 0xF9, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0x9F, 0x87, 0xF0, 0x0F, 0xF3,
  0xF0, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0x0F, 0xCF, 0xF0, 0x0F, 0xF3, 0xF0,
  0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0, 0xFC,
  0xFE, 0x00, 0x7F, 0x3E, 0x07, 0xDF, 0xE0, 0x07, 0xFB, 0xE0, 0x7D, 0xFE,
  0x00, 0x7F, 0xFE, 0x07, 0xDF, 0xC0, 0x03, 0xFF, 0xE0, 0x7D, 0xFC, 0x00,
  0x3F, 0xFE, 0x07, 0xDF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F,
  0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xE0,
  0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0x80,
  0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F,
  0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0A, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x4F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFE, 0x80, 0x07, 0xFF, 0x20, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_Condensed_Bold60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 44, 16, 3, -43 },
  { 56, 21, 16, 27, 3, -43 },
  { 98, 31, 43, 33, 1, -43 },
  { 265, 24, 49, 30, 3, -46 },
  { 412, 45, 44, 49, 2, -43 },
  { 660, 35, 44, 37, 2, -43 },
  { 853, 9, 16, 15, 3, -43 },
  { 871, 15, 52, 19, 3, -43 },
  { 969, 16, 52, 19, 1, -43 },
  { 1073, 26, 26, 28, 1, -46 },
  { 1158, 26, 29, 30, 2, -36 },
  { 1253, 11, 15, 15, 2, -7 },
  { 1274, 15, 8, 19, 2, -20 },
  { 1289, 10, 10, 16, 3, -9 },
  { 1302, 23, 43, 24, 1, -43 },
  { 1426, 26, 45, 30, 2, -44 },
  { 1573, 19, 43, 30, 3, -43 },
  { 1676, 25, 43, 30, 2, -43 },
  { 1811, 25, 44, 30, 2, -43 },
  { 1949, 28, 43, 30, 1, -43 },
  { 2100, 24, 44, 30, 3, -43 },
  { 2232, 26, 44, 30, 2, -43 },
  { 2375, 27, 43, 30, 1, -43 },
  { 2521, 26, 44, 30, 2, -43 },
  { 2664, 26, 44, 30, 2, -43 },
  { 2807, 10, 34, 16, 3, -33 },
  { 2850, 11, 41, 16, 2, -33 },
  { 2907, 26, 29, 30, 2, -36 },
  { 3002, 26, 18, 30, 2, -30 },
  { 3061, 26, 29, 30, 2, -36 },
  { 3156, 23, 44, 24, 0, -43 },
  { 3283, 41, 48, 47, 3, -43 },
  { 3529, 35, 43, 35, 0, -43 },
  { 3718, 27, 43, 34, 4, -43 },
  { 3864, 27, 44, 32, 3, -43 },
  { 4013, 30, 43, 37, 4, -43 },
  { 4175, 20, 43, 28, 5, -43 },
  { 4283, 20, 43, 28, 5, -43 },
  { 4391, 30, 44, 37, 3, -43 },
  { 4556, 29, 43, 38, 5, -43 },
  { 4712, 17, 43, 20, 2, -43 },
  { 4804, 16, 56, 17, -3, -43 },
  { 4916, 29, 43, 34, 5, -43 },
  { 5072, 22, 43, 27, 4, -43 },
  { 5191, 40, 43, 49, 5, -43 },
  { 5406, 32, 43, 41, 5, -43 },
  { 5578, 33, 45, 39, 3, -44 },
  { 5764, 26, 43, 32, 4, -43 },
  { 5904, 33, 54, 39, 3, -44 },
  { 6127, 29, 43, 33, 4, -43 },
  { 6283, 24, 44, 28, 2, -43 },
  { 6415, 26, 43, 28, 1, -43 },
  { 6555, 29, 44, 38, 4, -43 },
  { 6715, 33, 43, 33, 0, -43 },
  { 6893, 50, 43, 49, -1, -43 },
  { 7162, 32, 43, 32, 0, -43 },
  { 7334, 31, 43, 31, 0, -43 },
  { 7501, 26, 43, 28, 1, -43 },
  { 7641, 14, 53, 19, 4, -43 },
  { 7734, 24, 43, 24, 0, -43 },
  { 7863, 14, 53, 19, 1, -43 },
  { 7956, 30, 27, 33, 1, -43 },
  { 8058, 25, 4, 25, 0, 5 },
  { 8071, 15, 10, 20, 2, -46 },
  { 8090, 25, 34, 30, 2, -33 },
  { 8197, 26, 47, 32, 4, -46 },
  { 8350, 23, 34, 26, 2, -33 },
  { 8448, 27, 47, 32, 2, -46 },
  { 8607, 26, 34, 30, 2, -33 },
  { 8718, 21, 46, 20, 1, -46 },
  { 8839, 27, 47, 32, 2, -33 },
  { 8998, 25, 46, 33, 4, -46 },
  { 9142, 9, 46, 16, 3, -46 },
  { 9194, 14, 60, 16, -2, -46 },
  { 9299, 28, 46, 31, 4, -46 },
  { 9460, 8, 46, 16, 4, -46 },
  { 9506, 41, 33, 49, 4, -33 },
  { 9676, 25, 33, 33, 4, -33 },
  { 9780, 27, 34, 32, 2, -33 },
  { 9895, 26, 47, 32, 4, -33 },
  { 10048, 27, 47, 32, 2, -33 },
  { 10207, 18, 33, 23, 4, -33 },
  { 10282, 21, 34, 25, 2, -33 },
  { 10372, 19, 41, 22, 1, -40 },
  { 10470, 25, 34, 33, 4, -33 },
  { 10577, 29, 33, 29, 0, -33 },
  { 10697, 44, 33, 44, 0, -33 },
  { 10879, 28, 33, 28, 0, -33 },
  { 10995, 29, 47, 29, 0, -33 },
  { 11166, 22, 33, 24, 1, -33 },
  { 11257, 18, 53, 22, 1, -43 },
  { 11377, 7, 60, 28, 11, -46 },
  { 11430, 19, 53, 22, 2, -43 },
  { 11556, 26, 10, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_Bold60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_BOLD60PT7B_H_
