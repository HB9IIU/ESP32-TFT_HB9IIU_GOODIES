#ifndef _NOTOSANS_CONDENSED_BOLD29PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x79, 0xEF, 0x3D, 0xC7, 0xB8, 0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x8E, 0x06,
  0x30, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x73, 0x81, 0xCE, 0x07, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCE, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x73, 0x80,
  0x02, 0x00, 0x20, 0x0F, 0xC3, 0xFF, 0x7F, 0xF7, 0xAE, 0xF2, 0x0F, 0x20,
  0xFA, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x02, 0xF0, 0x2F,
  0x82, 0xFF, 0x3F, 0xFF, 0xEF, 0xFC, 0x0F, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x3C, 0x03, 0x81, 0xF8, 0x1C, 0x07, 0xF0, 0x70, 0x39, 0xC3, 0x80, 0xE7,
  0x0E, 0x03, 0x9E, 0x70, 0x0E, 0x79, 0xC0, 0x39, 0xE7, 0x00, 0xE7, 0x38,
  0xC3, 0x9C, 0xEF, 0xC7, 0xF7, 0x3F, 0x9F, 0x9D, 0xCE, 0x3C, 0xE7, 0x38,
  0x03, 0x9C, 0xF0, 0x1E, 0x71, 0xC0, 0x71, 0xCF, 0x01, 0xC7, 0x3C, 0x0E,
  0x1C, 0xE0, 0x38, 0x3F, 0x81, 0xC0, 0xFE, 0x07, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0x8F, 0x03, 0xC7, 0x00, 0xE7,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC3, 0xCF, 0xF1, 0xEF,
  0xFD, 0xF7, 0x9F, 0xF3, 0xC7, 0xF9, 0xE1, 0xF8, 0xF0, 0x7C, 0x7C, 0x7E,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFC, 0xF8, 0x7B, 0xDC, 0xE7, 0x39, 0xCE,
  0x0F, 0x0E, 0x1C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E,
  0x0E, 0x0F, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x87, 0x0E, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x1E, 0x38, 0xF1,
  0xC0, 0x0F, 0x00, 0xF0, 0x0E, 0x0C, 0xE2, 0xFF, 0xFF, 0xFF, 0x7F, 0xE1,
  0xF8, 0x3F, 0x83, 0xBC, 0x79, 0xE1, 0x08, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x7B, 0xDE, 0xEF, 0x73, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xDE, 0xF0, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00,
  0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0xFE, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0x78, 0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x03, 0xC1, 0xF0, 0xFC,
  0x7F, 0x3F, 0xFE, 0xF7, 0x3C, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1F,
  0x87, 0xFC, 0xFF, 0xEF, 0xFE, 0x60, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x87, 0xFC, 0xFF, 0xE7,
  0xBF, 0x40, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0xE1, 0xF8, 0x1F, 0x81,
  0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFC, 0x1F, 0xFF, 0xEF,
  0xFC, 0xFF, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x6F, 0x03, 0xBC, 0x1C, 0xF0, 0x73, 0xC3, 0x8F, 0x0E, 0x3C,
  0x70, 0xF1, 0xC3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x7F, 0x87, 0xFE, 0x7F, 0xE2, 0x3F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFE, 0x3F, 0xFF, 0xEF, 0xFC, 0x7F, 0x80,
  0x03, 0xE0, 0xFE, 0x3F, 0xE3, 0xF2, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xF7, 0xCF, 0xFE, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF8, 0xF7, 0x9F, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF,
  0x0F, 0x70, 0xF7, 0x9E, 0x3F, 0xE3, 0xFC, 0x1F, 0x83, 0xFE, 0x79, 0xEF,
  0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0,
  0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xFF, 0xF7, 0xF7, 0x7F, 0x71, 0xEF, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0x3E, 0x7F, 0xC7, 0xF8, 0x7F, 0x00, 0xEF, 0xFF, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x7B, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3D, 0xEF, 0x77, 0xBD, 0xC0, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F,
  0xE3, 0xF8, 0xFE, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00,
  0xF0, 0x03, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x03, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x0F, 0x80, 0x60, 0x02, 0x00, 0x00, 0x1F, 0x0F, 0xFB, 0xFF, 0xBD,
  0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xE0, 0x3C, 0x3C, 0x00,
  0xE3, 0x81, 0x0E, 0x70, 0xFE, 0x77, 0x1F, 0xE7, 0x73, 0x8E, 0x7E, 0x38,
  0xE7, 0xE7, 0x0E, 0x7E, 0x70, 0xE7, 0xE7, 0x0E, 0x7E, 0x71, 0xE7, 0xE3,
  0x9E, 0x7E, 0x3F, 0xFE, 0x71, 0xF7, 0xC7, 0x0E, 0x38, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x07, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x3D,
  0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F, 0x1C, 0x07, 0x8F, 0x03, 0xC7, 0x83,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7C, 0x1E, 0x3C, 0x0F,
  0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x80, 0xF8, 0xFF, 0x07, 0xFF, 0x3F, 0xFD,
  0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x1E, 0xF1, 0xF7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x8F,
  0xFF, 0xFD, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFE, 0x3C, 0x09, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xFC, 0x63, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFF, 0x8F, 0xFF,
  0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0,
  0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xE0, 0x4F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xF7, 0x8F, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x7C, 0x1E, 0x7C, 0x3C,
  0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0xFF, 0xFE, 0xFE, 0xFC, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F,
  0xBC, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x3C, 0x3D, 0xF0, 0xF7, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xCF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF0,
  0xF3, 0xC3, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x3C, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xEF, 0xF7, 0x0E, 0xFF,
  0x71, 0xEF, 0xF7, 0x9C, 0xFF, 0x79, 0xCF, 0xF3, 0x9C, 0xFF, 0x3B, 0xCF,
  0xF3, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x0F, 0xF1, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0xF7, 0x8F,
  0xF7, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xEF, 0xF1, 0xEF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0,
  0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x7C, 0x1F,
  0x1F, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x0F, 0xFC,
  0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F,
  0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x7C, 0x1F, 0x1F, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0xF0, 0xF3, 0xC3, 0xCF,
  0x0F, 0xBC, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3,
  0xCF, 0x0F, 0x3E, 0x3C, 0x78, 0xF1, 0xF3, 0xC3, 0xCF, 0x0F, 0xBC, 0x1E,
  0xF0, 0x7C, 0x1F, 0x87, 0xFD, 0xFF, 0xBF, 0xFF, 0x85, 0xE0, 0x3C, 0x07,
  0xC0, 0x7C, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x78, 0x0F,
  0x81, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3D,
  0xF3, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF0, 0x0F, 0xF0, 0x0F, 0x70,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1E, 0xF0, 0x7C,
  0x1E, 0x78, 0x7C, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1C, 0x78, 0xFE,
  0x3C, 0x38, 0xEE, 0x3C, 0x3C, 0xEF, 0x3C, 0x3C, 0xEF, 0x3C, 0x3C, 0xE7,
  0x38, 0x3D, 0xE7, 0x78, 0x1D, 0xC7, 0x78, 0x1D, 0xC7, 0x78, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83,
  0xF0, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0xF0, 0x79, 0xF0, 0xF1, 0xE3, 0xC3,
  0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xBC, 0x0F, 0x7C, 0x3E, 0x78,
  0x78, 0xF9, 0xF0, 0xF3, 0xC1, 0xFF, 0x81, 0xE0, 0xF0, 0x1E, 0xF0, 0x7D,
  0xE0, 0xF3, 0xE1, 0xE3, 0xC7, 0x87, 0x8F, 0x07, 0xBC, 0x0F, 0x78, 0x0E,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC, 0xF0, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF,
  0xFF, 0xF0, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x7F,
  0x01, 0xDE, 0x0F, 0x38, 0x38, 0xF1, 0xE1, 0xC7, 0x07, 0xBC, 0x0E, 0xE0,
  0x3C, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF0, 0xF0, 0x1F, 0xC7, 0xFE, 0x3F,
  0xE3, 0x1F, 0x00, 0xF0, 0x0F, 0x0F, 0xF3, 0xFF, 0x7F, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0x7F, 0x73, 0xE7, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xDF, 0x1F, 0xFC, 0xFF, 0xE7, 0xCF,
  0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xFE, 0x1E, 0xF0, 0xF7,
  0x87, 0xBE, 0x7D, 0xFF, 0xCE, 0xFE, 0x73, 0xE0, 0x0F, 0xC7, 0xFC, 0xFF,
  0x3E, 0x27, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x07, 0xC6, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x79, 0xE7, 0xFF, 0x7F, 0xFB, 0xE7, 0xFE, 0x3F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xDE,
  0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0x9C, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x8F,
  0x70, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x17, 0xFF, 0x3F, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0x23,
  0xC0, 0x78, 0x0F, 0xE7, 0xFC, 0xFF, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x00, 0x1F, 0x79, 0xFF, 0xDF, 0xFE, 0xF9, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xF7, 0x8F, 0xBF, 0xFC,
  0xFF, 0xE3, 0xEF, 0x00, 0x78, 0x03, 0xE0, 0x3E, 0xE3, 0xE7, 0xFF, 0x3F,
  0xF0, 0xFE, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF7, 0xCF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0x3C, 0x78, 0xE0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0x7F, 0xF7, 0xEF,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC1,
  0xFE, 0x1E, 0xF1, 0xE7, 0x9F, 0x3C, 0xF1, 0xEF, 0x0F, 0xF0, 0x7F, 0x83,
  0xFE, 0x1F, 0xF8, 0xF3, 0xC7, 0x8F, 0x3C, 0x79, 0xE1, 0xEF, 0x0F, 0x78,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xC7, 0xCE, 0xFE, 0xFE, 0xFF, 0xFF, 0xEF, 0x9F, 0x9F, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x87,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xF0, 0xF7,
  0x8F, 0x3F, 0xF8, 0xFF, 0x81, 0xF8, 0xE7, 0xC7, 0x7F, 0x3F, 0xF9, 0xF3,
  0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xFF, 0x87, 0xBC, 0x3D,
  0xE1, 0xEF, 0x9F, 0x7F, 0xF3, 0xFF, 0x9E, 0xF8, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1F, 0x79, 0xFF, 0xDF,
  0xFE, 0xF9, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xF0, 0xF7, 0x8F, 0xBF, 0xFC, 0xFF, 0xE3, 0xEF, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0xE7, 0xF7,
  0xFB, 0xDF, 0xEF, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0x3F, 0x9F, 0xFF, 0xFB, 0xC2, 0xF0, 0x3E, 0x0F,
  0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x3C, 0x0F, 0xC3, 0xFF, 0xFF, 0xFB, 0xFC,
  0x1C, 0x07, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF3, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF1, 0x3F, 0xC7, 0xF0, 0xFC,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0x7F, 0x73, 0xE7,
  0xF0, 0x3F, 0xE1, 0xF7, 0x87, 0x9E, 0x1E, 0x78, 0x78, 0xF3, 0xC3, 0xCF,
  0x0F, 0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xE0, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xDE, 0x3E, 0x1C,
  0xF1, 0xF9, 0xE7, 0x8D, 0xCF, 0x3C, 0xEE, 0x78, 0xF7, 0x73, 0xC7, 0xBB,
  0x9C, 0x3D, 0xCD, 0xE1, 0xEC, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0, 0xF8, 0x79,
  0xE3, 0xE3, 0xCF, 0x0F, 0x7C, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x0F, 0x78, 0x3C, 0xF1, 0xF3, 0xC7, 0x87,
  0xBE, 0x1F, 0xF0, 0x3F, 0xE1, 0xF7, 0x87, 0x9E, 0x1E, 0x78, 0x78, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x1C, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0x87, 0xC3, 0xE1, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x9F, 0xCF, 0xC7, 0xE3, 0xF8, 0x3C, 0x1E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x3E, 0x1F, 0x0F, 0x80, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x7C, 0x3F, 0x0F,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xF0, 0xF8, 0x7C,
  0x7E, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE3, 0xF1, 0xF8, 0xF8,
  0x40, 0x00, 0x10, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_Bold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 11, 8, 13, 1, -21 },
  { 23, 14, 21, 16, 1, -21 },
  { 60, 12, 24, 14, 1, -22 },
  { 96, 22, 21, 24, 1, -21 },
  { 154, 17, 21, 18, 1, -21 },
  { 199, 5, 8, 7, 1, -21 },
  { 204, 8, 26, 9, 1, -21 },
  { 230, 7, 26, 9, 1, -21 },
  { 253, 12, 12, 14, 1, -22 },
  { 271, 12, 14, 14, 1, -17 },
  { 292, 5, 7, 7, 1, -3 },
  { 297, 7, 4, 9, 1, -10 },
  { 301, 5, 4, 8, 1, -4 },
  { 304, 12, 21, 12, 0, -21 },
  { 336, 12, 21, 14, 1, -21 },
  { 368, 10, 21, 14, 1, -21 },
  { 395, 12, 21, 14, 1, -21 },
  { 427, 12, 21, 14, 1, -21 },
  { 459, 14, 21, 14, 0, -21 },
  { 496, 12, 21, 14, 1, -21 },
  { 528, 12, 21, 14, 1, -21 },
  { 560, 12, 21, 14, 1, -21 },
  { 592, 12, 21, 14, 1, -21 },
  { 624, 12, 21, 14, 1, -21 },
  { 656, 4, 16, 8, 2, -16 },
  { 664, 5, 20, 8, 1, -16 },
  { 677, 12, 15, 14, 1, -18 },
  { 700, 12, 9, 14, 1, -15 },
  { 714, 13, 15, 14, 1, -18 },
  { 739, 11, 21, 12, 0, -21 },
  { 768, 20, 23, 22, 1, -21 },
  { 826, 17, 21, 17, 0, -21 },
  { 871, 13, 21, 16, 2, -21 },
  { 906, 14, 21, 15, 1, -21 },
  { 943, 14, 21, 18, 2, -21 },
  { 980, 10, 21, 14, 2, -21 },
  { 1007, 10, 21, 14, 2, -21 },
  { 1034, 15, 21, 18, 1, -21 },
  { 1074, 14, 21, 19, 2, -21 },
  { 1111, 8, 21, 10, 1, -21 },
  { 1132, 8, 27, 8, -2, -21 },
  { 1159, 14, 21, 16, 2, -21 },
  { 1196, 11, 21, 13, 2, -21 },
  { 1225, 20, 21, 24, 2, -21 },
  { 1278, 16, 21, 20, 2, -21 },
  { 1320, 17, 21, 19, 1, -21 },
  { 1365, 12, 21, 15, 2, -21 },
  { 1397, 17, 26, 19, 1, -21 },
  { 1453, 14, 21, 16, 2, -21 },
  { 1490, 11, 21, 13, 1, -21 },
  { 1519, 13, 21, 14, 0, -21 },
  { 1554, 14, 21, 18, 2, -21 },
  { 1591, 16, 21, 16, 0, -21 },
  { 1633, 24, 21, 24, 0, -21 },
  { 1696, 15, 21, 15, 0, -21 },
  { 1736, 15, 21, 15, 0, -21 },
  { 1776, 13, 21, 13, 0, -21 },
  { 1811, 7, 26, 9, 2, -21 },
  { 1834, 12, 21, 12, 0, -21 },
  { 1866, 6, 26, 9, 1, -21 },
  { 1886, 14, 13, 16, 1, -21 },
  { 1909, 12, 2, 12, 0, 3 },
  { 1912, 7, 4, 9, 1, -22 },
  { 1916, 12, 16, 15, 1, -16 },
  { 1940, 13, 22, 16, 2, -22 },
  { 1976, 11, 16, 13, 1, -16 },
  { 1998, 13, 22, 16, 1, -22 },
  { 2034, 12, 16, 14, 1, -16 },
  { 2058, 11, 22, 9, 0, -22 },
  { 2089, 13, 23, 16, 1, -16 },
  { 2127, 12, 22, 16, 2, -22 },
  { 2160, 4, 22, 8, 2, -22 },
  { 2171, 7, 29, 8, -1, -22 },
  { 2197, 13, 22, 15, 2, -22 },
  { 2233, 4, 22, 8, 2, -22 },
  { 2244, 20, 16, 24, 2, -16 },
  { 2284, 12, 16, 16, 2, -16 },
  { 2308, 13, 16, 15, 1, -16 },
  { 2334, 13, 23, 16, 2, -16 },
  { 2372, 13, 23, 16, 1, -16 },
  { 2410, 9, 16, 11, 2, -16 },
  { 2428, 10, 16, 12, 1, -16 },
  { 2448, 10, 19, 10, 0, -19 },
  { 2472, 12, 16, 16, 2, -16 },
  { 2496, 14, 16, 14, 0, -16 },
  { 2524, 21, 16, 21, 0, -16 },
  { 2566, 14, 16, 14, 0, -16 },
  { 2594, 14, 23, 14, 0, -16 },
  { 2635, 10, 16, 12, 1, -16 },
  { 2655, 9, 26, 10, 0, -21 },
  { 2685, 3, 29, 14, 5, -22 },
  { 2696, 9, 26, 10, 1, -21 },
  { 2726, 13, 5, 14, 1, -13 },
};

const GFXfont NotoSans_Condensed_Bold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_BOLD29PT7B_H_
