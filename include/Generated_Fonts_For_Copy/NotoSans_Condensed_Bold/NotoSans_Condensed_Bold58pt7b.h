#ifndef _NOTOSANS_CONDENSED_BOLD58PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x06,
  0x00, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7,
  0xF0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xDC,
  0x3C, 0x7F, 0x9C, 0x04, 0x7F, 0x1C, 0x00, 0x7F, 0x1C, 0x00, 0x7F, 0x1C,
  0x00, 0x7F, 0x9C, 0x00, 0x7F, 0xDC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1C, 0xFF, 0x00, 0x1C, 0xFF, 0x00, 0x1C, 0x7F, 0x00, 0x1C,
  0x7F, 0xC0, 0x1C, 0x7F, 0xF0, 0x1C, 0xFF, 0xFE, 0x1D, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x40, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x07,
  0xF1, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x83, 0xF8,
  0xFE, 0x3F, 0x1F, 0xFC, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xC7, 0xF7, 0xF1,
  0xF8, 0xFF, 0xF8, 0xFF, 0xFE, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0x8F, 0xC7,
  0xE3, 0xF0, 0xFF, 0xE3, 0xF9, 0xFC, 0x7E, 0x0F, 0xF8, 0x7E, 0x3F, 0x07,
  0xE0, 0x7C, 0x0F, 0xC7, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x81,
  0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC7, 0xF0,
  0x00, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xC3,
  0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0x87, 0xFC, 0x7F, 0xDF, 0xE1, 0xFE,
  0x1F, 0xE7, 0xFC, 0x7F, 0x8F, 0xF8, 0xFF, 0xBF, 0xE3, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F,
  0xFF, 0x83, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0x00, 0xFF, 0xF0, 0x3F,
  0xF0, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0xC0, 0xFC, 0x0C, 0xFC, 0x7C, 0x3E, 0x7F, 0xFE, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x03, 0xFB, 0xF8, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x7E, 0x0F, 0xC0, 0x0F, 0x03, 0xC0, 0x03, 0x01, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F,
  0xC7, 0xF3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB,
  0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xBF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF3, 0xF8,
  0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFE, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x3F, 0xFF, 0xEF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xF7,
  0xE1, 0xFE, 0x78, 0x3F, 0xC6, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0x83, 0xFE, 0x3E, 0x01, 0xFE,
  0x18, 0x01, 0xFF, 0x10, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3E, 0x03, 0xFE, 0x18, 0x01, 0xFE, 0x10, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x0F, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF7,
  0xF8, 0x00, 0x7E, 0xFF, 0x00, 0x0F, 0xDF, 0xE0, 0x03, 0xF3, 0xFC, 0x00,
  0x7E, 0x7F, 0x80, 0x1F, 0x8F, 0xF0, 0x03, 0xF1, 0xFE, 0x00, 0xFC, 0x3F,
  0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xE0, 0xFF, 0x01, 0xF8, 0x1F, 0xE0, 0x3F,
  0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x0F, 0xF0, 0x7E, 0x01, 0xFE,
  0x0F, 0xC0, 0x3F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xC7, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFB, 0xF8, 0xFF, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0x80, 0xFF, 0x3F,
  0xF0, 0x7F, 0x3F, 0xFC, 0x3F, 0xBF, 0xFF, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0x07, 0xFD, 0xFF, 0x01, 0xFE, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xF0, 0x7F, 0xC7, 0xFC, 0x7F,
  0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xF8, 0xFF,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF,
  0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0xC7, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xE0,
  0x7F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x3F, 0xDF, 0xF0, 0x3F, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0x87, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0xBF,
  0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0x7F, 0x0F, 0xFF,
  0x3F, 0x81, 0xFF, 0x1F, 0xC0, 0x1E, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x04, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x0C, 0x00, 0x1F, 0x0F, 0xF3,
  0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFC, 0xFF, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xF9,
  0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3, 0xF0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0x81, 0xFF, 0x38,
  0x03, 0xFC, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x07, 0xFC,
  0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xC7, 0xE1, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFC, 0x7E, 0x0F, 0xFF, 0xF8, 0x7E, 0x7E, 0x0F,
  0xE0, 0xFC, 0x3F, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x9F, 0x87, 0xF0, 0x3F,
  0x07, 0xCF, 0xC3, 0xF0, 0x1F, 0x83, 0xF7, 0xE1, 0xF8, 0x0F, 0xC1, 0xFB,
  0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0xF8, 0x3F,
  0x03, 0xF0, 0x3E, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x7E, 0x0F, 0xC0, 0xFC,
  0x0F, 0xBF, 0x07, 0xE0, 0x7E, 0x0F, 0xDF, 0x83, 0xF0, 0x3F, 0x07, 0xE7,
  0xC1, 0xF8, 0x3F, 0x83, 0xE3, 0xF0, 0xFE, 0x1F, 0xE3, 0xF1, 0xF8, 0x3F,
  0xFF, 0xFB, 0xF8, 0xFC, 0x1F, 0xFF, 0x7F, 0xF8, 0x7E, 0x07, 0xFF, 0x3F,
  0xF8, 0x1F, 0x81, 0xFF, 0x8F, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x02,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x07,
  0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xF0,
  0x3F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x3C, 0x3F, 0xF0, 0x03, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x23, 0xFF, 0x80, 0x38, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xE0, 0x3F, 0xF8, 0xFF, 0x00, 0x7F, 0xE7, 0xF8, 0x01,
  0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF,
  0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF,
  0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0x7F, 0x80,
  0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xFC, 0xFF, 0x00, 0xFF,
  0xC7, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xC0,
  0x7C, 0x1F, 0xF8, 0x00, 0x41, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x3F,
  0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF,
  0xFC, 0x03, 0xFE, 0x3F, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0,
  0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x7F,
  0xC3, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF1,
  0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xFC,
  0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xF0, 0x07, 0xFC, 0x7F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0xFF,
  0x9F, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFB, 0xF0, 0x01,
  0xFF, 0xFF, 0xF7, 0xF0, 0x03, 0xF7, 0xFF, 0xFF, 0xE0, 0x0F, 0xEF, 0xFF,
  0xEF, 0xC0, 0x1F, 0xDF, 0xFF, 0xDF, 0xC0, 0x3F, 0x3F, 0xFF, 0xBF, 0x80,
  0x7E, 0x7F, 0xFF, 0x7F, 0x01, 0xFC, 0xFF, 0xFE, 0x7E, 0x03, 0xF9, 0xFF,
  0xFC, 0xFE, 0x07, 0xE3, 0xFF, 0xF9, 0xFC, 0x1F, 0xC7, 0xFF, 0xF1, 0xF8,
  0x3F, 0x8F, 0xFF, 0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0xC7, 0xF0, 0xFC, 0x3F,
  0xFF, 0x8F, 0xE3, 0xF8, 0x7F, 0xFF, 0x0F, 0xC7, 0xF0, 0xFF, 0xFE, 0x1F,
  0xCF, 0xC1, 0xFF, 0xFC, 0x3F, 0xBF, 0x83, 0xFF, 0xF8, 0x7F, 0x7F, 0x07,
  0xFF, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF7,
  0xF8, 0x07, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xDF,
  0xE0, 0x3F, 0xFF, 0x9F, 0xE0, 0x7F, 0xFF, 0x3F, 0xC0, 0xFF, 0xFE, 0x3F,
  0xC1, 0xFF, 0xFC, 0x7F, 0x83, 0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0x1F, 0xFF, 0xC1, 0xFE, 0x3F, 0xFF, 0x83, 0xFE,
  0x7F, 0xFF, 0x03, 0xFC, 0xFF, 0xFE, 0x07, 0xFD, 0xFF, 0xFC, 0x07, 0xFB,
  0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFC, 0x7F, 0xFD, 0xFE, 0x03, 0xFE,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0xFF, 0xDF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF,
  0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07,
  0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07,
  0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xF1, 0xFC, 0x7F,
  0xC0, 0x38, 0xFF, 0x00, 0x13, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFB, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80,
  0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xBF,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xCF,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF1,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF7, 0xE0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFB, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFD, 0xF8, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x7F, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0x9F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0x8F, 0xC1,
  0xFE, 0x00, 0xFE, 0x0F, 0xC7, 0xE0, 0xFE, 0x00, 0x7F, 0x8F, 0xE3, 0xF8,
  0xFF, 0x00, 0x3F, 0xC7, 0xF1, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0xFE,
  0x3F, 0xC0, 0x07, 0xF1, 0xF8, 0x3F, 0x1F, 0xE0, 0x03, 0xF8, 0xFC, 0x1F,
  0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x07,
  0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0x81, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0x80,
  0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x7E, 0xFE, 0x00, 0x07, 0xF7, 0xE0,
  0x3F, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xBF, 0x80, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0x8F,
  0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFE,
  0x3F, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD,
  0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE,
  0xFF, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0x83, 0xFE, 0x04, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7F, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F,
  0x3F, 0xFE, 0x7F, 0x1F, 0xFC, 0x3F, 0x0F, 0xF8, 0x3F, 0x01, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE1, 0xFE, 0x07, 0xF1, 0xFF, 0x83, 0xF9, 0xFF, 0xE1, 0xFD,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xF9, 0xFF, 0xDF,
  0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFE, 0x1F, 0xFB, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0x7F, 0xFC, 0x3F,
  0x1F, 0xFC, 0x1F, 0x87, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0x9F, 0x0F, 0xF8, 0x0C, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x08, 0xFF, 0xC1, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x3F, 0xC1, 0xFF,
  0xCF, 0xF0, 0xFF, 0xFB, 0xFC, 0x7F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0x3F, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0x7F,
  0xDF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE, 0x01,
  0xFF, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xE7, 0xF0, 0x7F, 0xF1, 0xFC,
  0x0F, 0xF8, 0x7F, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x81, 0xFE, 0x7F, 0x80, 0x7F, 0x3F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x02, 0x1F, 0xF0, 0x07, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFC, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC1, 0xFF, 0xC7, 0xF0,
  0xFF, 0xF9, 0xFC, 0x7F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0x3F, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0,
  0x1F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0x7F,
  0xC0, 0xFF, 0xCF, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xBF, 0xC3, 0xFF, 0xEF, 0xF0, 0x7F, 0xF3, 0xFC, 0x0F, 0xF8,
  0xFF, 0x00, 0x20, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x88, 0x00, 0x3F, 0xE3, 0xC0, 0x1F, 0xF8,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xE0, 0xFE, 0x3F, 0xF8, 0xFE, 0x7F, 0xFC, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE0, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x3F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF,
  0xFF, 0x3F, 0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F,
  0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0,
  0x07, 0xF3, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xDF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x1F, 0xE1,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0xFF, 0x00,
  0xFF, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF8, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xE0, 0xFC, 0x7F,
  0xF8, 0xFC, 0xFF, 0xFC, 0xFC, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x7F,
  0x9F, 0xE0, 0x1F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x7E, 0x1F,
  0xF8, 0x3F, 0x9F, 0xFE, 0x1F, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF3, 0xFF, 0x8F, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x7F,
  0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x81,
  0xFF, 0x7F, 0xE1, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xEF,
  0xFF, 0xC7, 0xF7, 0xFF, 0xC3, 0xF9, 0xFF, 0xC1, 0xFC, 0x3F, 0xC0, 0xFE,
  0x02, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC1, 0xFF,
  0xC7, 0xF0, 0xFF, 0xF9, 0xFC, 0x7F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0x3F, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0x7F,
  0xDF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFE, 0x01,
  0xFF, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0xC3, 0xFF, 0xEF, 0xF0, 0x7F, 0xF3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x00, 0x20, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0x03, 0xCF, 0xF0, 0x0C, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x83,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0x80, 0x04, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0xC1, 0xFF, 0xBF,
  0xF3, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFB, 0xF8,
  0xFF, 0xFD, 0xFC, 0x3F, 0xFC, 0x7E, 0x0F, 0xF8, 0x3F, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFE,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xF9, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xDF, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF7, 0xF8, 0x0F, 0xFC, 0x03, 0xFD, 0xFE, 0x03, 0xFF,
  0x00, 0xFE, 0x7F, 0x80, 0xFF, 0xE0, 0x7F, 0x8F, 0xE0, 0x3F, 0xF8, 0x1F,
  0xE3, 0xFC, 0x0F, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xFF, 0x81, 0xFC, 0x3F,
  0xC1, 0xFB, 0xE0, 0x7F, 0x07, 0xF0, 0x7E, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F,
  0x3F, 0x0F, 0xF0, 0x7F, 0x87, 0xCF, 0xC3, 0xF8, 0x1F, 0xE3, 0xF3, 0xF0,
  0xFE, 0x03, 0xF8, 0xFC, 0x7C, 0x7F, 0x80, 0xFE, 0x3F, 0x1F, 0x1F, 0xE0,
  0x3F, 0xCF, 0x87, 0xE7, 0xF0, 0x0F, 0xF3, 0xE1, 0xF9, 0xFC, 0x03, 0xFD,
  0xF8, 0x7E, 0x7F, 0x00, 0x7F, 0x7E, 0x0F, 0xBF, 0xC0, 0x1F, 0xDF, 0x83,
  0xEF, 0xE0, 0x07, 0xF7, 0xC0, 0xFB, 0xF8, 0x01, 0xFD, 0xF0, 0x3E, 0xFE,
  0x00, 0x3F, 0x7C, 0x0F, 0xBF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xF8,
  0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xFB, 0xFC, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F,
  0xDF, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x9F, 0xE0,
  0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x8F,
  0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0x3F, 0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x80,
  0x03, 0xFC, 0x00,
};

const GFXglyph NotoSans_Condensed_Bold58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 42, 15, 3, -41 },
  { 49, 20, 15, 26, 3, -41 },
  { 87, 30, 41, 32, 1, -41 },
  { 241, 24, 47, 29, 2, -44 },
  { 382, 43, 43, 47, 2, -42 },
  { 614, 34, 43, 36, 2, -42 },
  { 797, 8, 15, 14, 3, -41 },
  { 812, 15, 51, 19, 3, -42 },
  { 908, 15, 51, 19, 1, -42 },
  { 1004, 25, 24, 27, 1, -44 },
  { 1079, 25, 27, 29, 2, -34 },
  { 1164, 10, 15, 15, 2, -7 },
  { 1183, 14, 7, 18, 2, -19 },
  { 1196, 9, 10, 15, 3, -9 },
  { 1208, 22, 42, 24, 1, -42 },
  { 1324, 25, 43, 29, 2, -42 },
  { 1459, 19, 41, 29, 3, -41 },
  { 1557, 24, 42, 29, 2, -42 },
  { 1683, 24, 43, 29, 2, -42 },
  { 1812, 27, 41, 29, 1, -41 },
  { 1951, 23, 42, 29, 3, -41 },
  { 2072, 25, 43, 29, 2, -42 },
  { 2207, 26, 41, 29, 1, -41 },
  { 2341, 25, 43, 29, 2, -42 },
  { 2476, 25, 43, 29, 2, -42 },
  { 2611, 9, 33, 15, 3, -32 },
  { 2649, 10, 40, 15, 2, -32 },
  { 2699, 25, 28, 29, 2, -35 },
  { 2787, 25, 17, 29, 2, -29 },
  { 2841, 25, 28, 29, 2, -35 },
  { 2929, 22, 43, 23, 0, -42 },
  { 3048, 41, 47, 45, 2, -42 },
  { 3289, 33, 41, 33, 0, -41 },
  { 3459, 26, 41, 33, 4, -41 },
  { 3593, 26, 43, 31, 3, -42 },
  { 3733, 29, 41, 35, 4, -41 },
  { 3882, 20, 41, 27, 4, -41 },
  { 3985, 20, 41, 27, 4, -41 },
  { 4088, 29, 43, 35, 3, -42 },
  { 4244, 29, 41, 37, 4, -41 },
  { 4393, 16, 41, 20, 2, -41 },
  { 4475, 15, 53, 17, -3, -41 },
  { 4575, 29, 41, 32, 4, -41 },
  { 4724, 21, 41, 26, 4, -41 },
  { 4832, 39, 41, 48, 4, -41 },
  { 5032, 31, 41, 40, 4, -41 },
  { 5191, 32, 43, 38, 3, -42 },
  { 5363, 25, 41, 31, 4, -41 },
  { 5492, 32, 52, 38, 3, -42 },
  { 5700, 28, 41, 32, 4, -41 },
  { 5844, 23, 43, 27, 2, -42 },
  { 5968, 26, 41, 27, 1, -41 },
  { 6102, 28, 42, 36, 4, -41 },
  { 6249, 32, 41, 32, 0, -41 },
  { 6413, 49, 41, 47, -1, -41 },
  { 6665, 31, 41, 31, 0, -41 },
  { 6824, 30, 41, 30, 0, -41 },
  { 6978, 25, 41, 27, 1, -41 },
  { 7107, 13, 51, 18, 4, -42 },
  { 7190, 23, 42, 24, 0, -42 },
  { 7311, 14, 51, 18, 1, -42 },
  { 7401, 29, 25, 32, 1, -41 },
  { 7492, 24, 4, 24, 0, 5 },
  { 7504, 15, 9, 19, 2, -44 },
  { 7521, 24, 33, 29, 2, -32 },
  { 7620, 25, 45, 31, 4, -44 },
  { 7761, 22, 33, 25, 2, -32 },
  { 7852, 26, 45, 31, 2, -44 },
  { 7999, 25, 33, 29, 2, -32 },
  { 8103, 20, 44, 19, 1, -44 },
  { 8213, 26, 46, 31, 2, -32 },
  { 8363, 24, 44, 32, 4, -44 },
  { 8495, 9, 44, 15, 3, -44 },
  { 8545, 14, 58, 15, -2, -44 },
  { 8647, 27, 44, 30, 4, -44 },
  { 8796, 7, 44, 15, 4, -44 },
  { 8835, 40, 32, 47, 4, -32 },
  { 8995, 24, 32, 32, 4, -32 },
  { 9091, 26, 33, 31, 2, -32 },
  { 9199, 25, 46, 31, 4, -32 },
  { 9343, 26, 46, 31, 2, -32 },
  { 9493, 17, 32, 22, 4, -32 },
  { 9561, 20, 33, 24, 2, -32 },
  { 9644, 19, 39, 21, 1, -38 },
  { 9737, 25, 33, 32, 3, -32 },
  { 9841, 28, 32, 28, 0, -32 },
  { 9953, 42, 32, 42, 0, -32 },
  { 10121, 27, 32, 27, 0, -32 },
  { 10229, 28, 46, 28, 0, -32 },
  { 10390, 21, 32, 23, 1, -32 },
  { 10474, 18, 50, 21, 1, -41 },
  { 10587, 7, 57, 27, 10, -44 },
  { 10637, 18, 50, 21, 2, -41 },
  { 10750, 25, 9, 29, 2, -25 },
};

const GFXfont NotoSans_Condensed_Bold58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_BOLD58PT7B_H_
