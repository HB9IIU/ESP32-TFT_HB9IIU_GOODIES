#ifndef _NOTOSANS_CONDENSED_BOLD44PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x38, 0xFF,
  0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00,
  0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3C, 0x00, 0xF8,
  0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x1E, 0x3E, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE0, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1F, 0x00,
  0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0xF8, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x1F, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFE,
  0xC3, 0x3F, 0x30, 0x0F, 0xCC, 0x03, 0xF3, 0x00, 0xFE, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x33, 0xF0, 0x0C, 0xFC, 0x03, 0x3F, 0x80,
  0xCF, 0xFC, 0x33, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x1F, 0xFF,
  0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xE0, 0x0F, 0xFC,
  0x01, 0xE0, 0x07, 0xFE, 0x01, 0xF0, 0x07, 0xCF, 0x80, 0xF0, 0x03, 0xE7,
  0xC0, 0xF8, 0x01, 0xE1, 0xE0, 0x78, 0x01, 0xF0, 0xF0, 0x7C, 0x00, 0xF8,
  0x78, 0x3C, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x1F,
  0x0F, 0x8F, 0x00, 0x0F, 0x87, 0x8F, 0x80, 0x03, 0xC3, 0xC7, 0x87, 0xE1,
  0xF3, 0xE7, 0xCF, 0xF8, 0xF9, 0xF3, 0xC7, 0xFE, 0x3F, 0xF3, 0xE7, 0xFF,
  0x1F, 0xF9, 0xF3, 0xE7, 0xC7, 0xF9, 0xF3, 0xE3, 0xE0, 0xF0, 0xF9, 0xF1,
  0xF0, 0x00, 0x78, 0xF8, 0x78, 0x00, 0x7C, 0x7C, 0x3C, 0x00, 0x3C, 0x3E,
  0x1E, 0x00, 0x3E, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x87, 0x80, 0x1F, 0x07,
  0xC7, 0xC0, 0x0F, 0x81, 0xE3, 0xE0, 0x07, 0x80, 0xF9, 0xF0, 0x07, 0xC0,
  0x7F, 0xF0, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x01, 0xE0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7E, 0x1F, 0xF8, 0x1F, 0x8F, 0xFF, 0x0F,
  0xE7, 0xFF, 0xE3, 0xF1, 0xFD, 0xFC, 0xFC, 0x7E, 0x3F, 0xFF, 0x3F, 0x87,
  0xFF, 0x8F, 0xE0, 0xFF, 0xE3, 0xF8, 0x3F, 0xF0, 0xFE, 0x07, 0xFC, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF3, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFB,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x03, 0xE0, 0x7C, 0x1F,
  0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0,
  0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF8, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83,
  0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x83, 0xE0, 0x9E, 0x78,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0x7C, 0x07, 0xEF, 0xC1, 0xF8, 0xF8, 0x3F, 0x1F,
  0x81, 0xC1, 0xC0, 0x18, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x7F,
  0x7F, 0x0F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC0, 0xFD, 0xF8,
  0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0,
  0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x7F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFE, 0xFD, 0xF3, 0xF3, 0x8F, 0xC4, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0,
  0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFE, 0x7F,
  0x8F, 0x03, 0xF0, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7C, 0x7F, 0x86, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xDF, 0x80, 0x3D, 0xF8, 0x07, 0xDF, 0x80, 0xF9, 0xF8,
  0x0F, 0x9F, 0x81, 0xF1, 0xF8, 0x1E, 0x1F, 0x83, 0xE1, 0xF8, 0x3C, 0x1F,
  0x87, 0xC1, 0xF8, 0x78, 0x1F, 0x8F, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFE,
  0x30, 0x7F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xB8, 0x0F, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xE0,
  0x87, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xCF, 0xE0, 0xFB, 0xFF, 0x1F, 0x7F, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xE0, 0xFC,
  0xFC, 0x3F, 0x9F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x3F, 0x7E,
  0x07, 0xEF, 0xC0, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFE,
  0xFE, 0x3F, 0x8F, 0xE7, 0xE0, 0xFE, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFD, 0xF8, 0x1F, 0xBF, 0xCF, 0xF7, 0xFF,
  0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0x7F, 0x9F, 0x83,
  0xF3, 0xF0, 0x7E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF8, 0xFF, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xEF, 0x8F, 0xFB, 0xF0, 0x7E, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x71, 0xFF, 0xFF, 0xFF, 0xDF, 0xBE, 0x3E, 0x3F, 0x7F,
  0x7F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xE3, 0xFC, 0xC0,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x80, 0xF8, 0xF0, 0x3F, 0xF1, 0xE7, 0xC1, 0xFF, 0xC7, 0xDE,
  0x0F, 0xFF, 0x1F, 0x78, 0x7C, 0x3C, 0x3F, 0xE3, 0xE1, 0xF0, 0xFF, 0x8F,
  0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0x0F, 0xF0, 0xF0, 0x7C, 0x3F, 0xC3, 0xC1,
  0xF0, 0xFF, 0x0F, 0x07, 0xC3, 0xFC, 0x3C, 0x1F, 0x0F, 0xF0, 0xF0, 0x7C,
  0x3F, 0xC3, 0xE1, 0xF1, 0xEF, 0x8F, 0x8F, 0xC7, 0xBE, 0x3F, 0xFF, 0xFE,
  0xF8, 0x7F, 0xDF, 0xF1, 0xE0, 0xFE, 0x3F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x30, 0x03, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF9,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7F,
  0x1F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0xFE, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xC0, 0x63, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0x3F, 0xC0, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0,
  0x7F, 0xCF, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F,
  0xBF, 0x01, 0xFC, 0xFC, 0x0F, 0xF3, 0xF1, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xF7, 0xE3, 0xFE, 0x01, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x00, 0xFD, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF3,
  0xFC, 0x0F, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xF8, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE1, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x0F, 0xF9, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x8F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0,
  0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x7F, 0x03, 0xF1, 0xFC,
  0x0F, 0xCF, 0xE0, 0x3F, 0x7F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF7,
  0xF0, 0x3F, 0x9F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC,
  0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x3F,
  0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xC0, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xDF, 0x03, 0xEF, 0xFF, 0x7C, 0x0F, 0xBF, 0xFD, 0xF0,
  0x3E, 0xFF, 0xF7, 0xE1, 0xF3, 0xFF, 0xCF, 0x87, 0xCF, 0xFF, 0x3E, 0x1F,
  0x3F, 0xFC, 0xF8, 0x78, 0xFF, 0xF1, 0xF3, 0xE3, 0xFF, 0xC7, 0xCF, 0x8F,
  0xFF, 0x1F, 0x3E, 0x3F, 0xFC, 0x7D, 0xF0, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xE0, 0xFF, 0xF0,
  0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0x3F, 0xFC, 0x0F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xF8, 0x0F, 0xC0, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFD, 0xF8, 0x3F, 0xFD, 0xF8, 0x3F, 0xFC, 0xFC,
  0x3F, 0xFC, 0xFC, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x3F,
  0x3F, 0xFC, 0x3F, 0x3F, 0xFC, 0x1F, 0xBF, 0xFC, 0x1F, 0xBF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF,
  0xBF, 0xE0, 0xFE, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xF7, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8,
  0x3F, 0xBF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xBF, 0x1F, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF, 0xE0, 0xFE, 0x07, 0xF8, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xDF,
  0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xF9, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0,
  0x7F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7E, 0x0F, 0xF3, 0xF0, 0x3F, 0x9F, 0x81, 0xFC,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0,
  0xFC, 0x7E, 0x1F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x3F,
  0x03, 0xF9, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F,
  0xE0, 0x03, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7,
  0xFF, 0xFB, 0xF8, 0x19, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xFC, 0x1F, 0xDF, 0xFF,
  0xEF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0x7E, 0x03, 0xFB, 0xF8, 0x3F, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7E,
  0x7E, 0x03, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0xC0, 0x7E, 0x7E, 0x03, 0xFC,
  0x07, 0xE7, 0xE0, 0x7F, 0xC0, 0xFC, 0x3E, 0x07, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7F, 0xE0, 0xFC, 0x3F, 0x07, 0xBE, 0x0F, 0xC3, 0xF0, 0x7B, 0xE0, 0xFC,
  0x3F, 0x0F, 0x9E, 0x1F, 0x81, 0xF0, 0xF9, 0xF1, 0xF8, 0x1F, 0x8F, 0x9F,
  0x1F, 0x81, 0xF8, 0xF9, 0xF1, 0xF8, 0x1F, 0x9F, 0x9F, 0x1F, 0x81, 0xF9,
  0xF1, 0xF3, 0xF0, 0x0F, 0x9F, 0x0F, 0xBF, 0x00, 0xF9, 0xF0, 0xFB, 0xF0,
  0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0xFD, 0xE0, 0xFB, 0xE0, 0x07, 0xFE, 0x07,
  0xBE, 0x00, 0x7F, 0xE0, 0x7B, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xE0, 0xFC,
  0x1F, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xF3,
  0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFD, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3, 0xF8, 0x1F,
  0xC3, 0xF0, 0x3F, 0x07, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xE7, 0xF0,
  0x1F, 0xCF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0xFC,
  0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x83, 0xF0,
  0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3F, 0x0F,
  0x80, 0x7C, 0x7C, 0x01, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1E, 0x3F, 0x82, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xF7, 0xF3, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF,
  0x9F, 0x1F, 0xC3, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x9F, 0xC3, 0xF7, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xBF, 0x87, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7F, 0x0F, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x3E, 0xFF, 0xE7, 0xCF, 0xF8, 0xF8, 0xFE, 0x00, 0x00,
  0x60, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F,
  0x02, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x03, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0x07, 0xE1, 0xFC,
  0xFC, 0x7F, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0x9F, 0x0F, 0xE3, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0x1F, 0x9F, 0x83, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x09, 0xFF, 0x3E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFC, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFB, 0x87, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xE7, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x7C, 0x7F,
  0xCF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xBF, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0xC0, 0x1F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x10, 0x3F, 0x3F, 0x8F, 0xDF, 0xF3, 0xEF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x7C,
  0xFF, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0x07, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xFF, 0xF7, 0xFE, 0xFF,
  0xDF, 0xF3, 0xFC, 0x18, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC,
  0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F,
  0xDF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x01, 0x03, 0xE3, 0xF8, 0x3F,
  0x8F, 0xBF, 0xF1, 0xFF, 0x3E, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFC,
  0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03,
  0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC,
  0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03,
  0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF,
  0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC,
  0x0F, 0xC0, 0xFC, 0x00, 0x10, 0x3E, 0x3F, 0x8F, 0x9F, 0xF3, 0xEF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0,
  0x00, 0x40, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0x87, 0xFB, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x7E, 0x07, 0xE7,
  0xE0, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0x00, 0x10, 0x1F, 0x1F, 0xC3, 0xE7, 0xFC, 0x7D, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0x7F, 0xBF, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0x7F, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xEF, 0xF8,
  0xFC, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x7C, 0x7F, 0xCF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xBF, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x17, 0x87, 0xFE, 0x7F,
  0xF7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x80, 0x0F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x1C,
  0xFC, 0x04, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0x7F, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFD, 0xF3, 0xFF, 0x7C, 0x7F, 0x1F, 0xFC,
  0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC,
  0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xEF, 0xC0,
  0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x7E, 0x0F, 0xF0, 0x3F, 0x7E, 0x0F,
  0xF0, 0x3E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x3E, 0x0F,
  0xF8, 0x7E, 0x3F, 0x1F, 0xF8, 0x7C, 0x3F, 0x1F, 0x78, 0xFC, 0x3F, 0x1E,
  0x78, 0xFC, 0x1F, 0x1E, 0x78, 0xFC, 0x1F, 0x9E, 0x7C, 0xF8, 0x1F, 0xBE,
  0x3D, 0xF8, 0x1F, 0xBE, 0x3D, 0xF8, 0x0F, 0xBC, 0x3D, 0xF8, 0x0F, 0xBC,
  0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xFC,
  0x1D, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7E,
  0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x1F, 0x83, 0xF0, 0xFE, 0x3F, 0x83, 0xF1,
  0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83,
  0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC0, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xF0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7C, 0x00, 0x1F, 0x80, 0x17, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x80, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_Bold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 31, 12, 2, -31 },
  { 29, 16, 11, 20, 2, -31 },
  { 51, 22, 31, 24, 1, -31 },
  { 137, 18, 36, 22, 2, -33 },
  { 218, 33, 32, 36, 1, -32 },
  { 350, 26, 32, 27, 1, -32 },
  { 454, 7, 11, 11, 2, -31 },
  { 464, 11, 39, 14, 2, -32 },
  { 518, 11, 39, 14, 1, -32 },
  { 572, 19, 19, 21, 1, -34 },
  { 618, 19, 21, 22, 1, -26 },
  { 668, 8, 11, 11, 1, -5 },
  { 679, 11, 6, 14, 1, -15 },
  { 688, 7, 7, 12, 2, -7 },
  { 695, 18, 32, 18, 0, -32 },
  { 767, 19, 32, 22, 1, -32 },
  { 843, 14, 31, 22, 2, -31 },
  { 898, 19, 32, 22, 1, -32 },
  { 974, 19, 32, 22, 1, -32 },
  { 1050, 20, 31, 22, 1, -31 },
  { 1128, 18, 31, 22, 2, -31 },
  { 1198, 19, 32, 22, 1, -32 },
  { 1274, 19, 31, 22, 1, -31 },
  { 1348, 19, 32, 22, 1, -32 },
  { 1424, 19, 32, 22, 1, -32 },
  { 1500, 7, 24, 12, 2, -24 },
  { 1521, 8, 30, 12, 1, -24 },
  { 1551, 19, 22, 22, 1, -27 },
  { 1604, 19, 13, 22, 1, -22 },
  { 1635, 20, 22, 22, 1, -27 },
  { 1690, 17, 32, 18, 0, -32 },
  { 1758, 30, 35, 34, 2, -32 },
  { 1890, 25, 31, 25, 0, -31 },
  { 1987, 20, 31, 25, 3, -31 },
  { 2065, 20, 32, 23, 2, -32 },
  { 2145, 22, 31, 27, 3, -31 },
  { 2231, 16, 31, 21, 3, -31 },
  { 2293, 15, 31, 21, 3, -31 },
  { 2352, 22, 32, 27, 2, -32 },
  { 2440, 22, 31, 28, 3, -31 },
  { 2526, 13, 31, 15, 1, -31 },
  { 2577, 12, 40, 13, -3, -31 },
  { 2637, 22, 31, 25, 3, -31 },
  { 2723, 16, 31, 20, 3, -31 },
  { 2785, 30, 31, 36, 3, -31 },
  { 2902, 24, 31, 30, 3, -31 },
  { 2995, 25, 32, 29, 2, -32 },
  { 3095, 19, 31, 23, 3, -31 },
  { 3169, 25, 39, 29, 2, -32 },
  { 3291, 21, 31, 24, 3, -31 },
  { 3373, 17, 32, 20, 2, -32 },
  { 3441, 19, 31, 21, 1, -31 },
  { 3515, 21, 31, 28, 3, -31 },
  { 3597, 24, 31, 24, 0, -31 },
  { 3690, 36, 31, 36, 0, -31 },
  { 3830, 23, 31, 23, 0, -31 },
  { 3920, 23, 31, 23, 0, -31 },
  { 4010, 19, 31, 20, 1, -31 },
  { 4084, 10, 39, 14, 3, -32 },
  { 4133, 18, 32, 18, 0, -32 },
  { 4205, 10, 39, 14, 1, -32 },
  { 4254, 22, 19, 24, 1, -31 },
  { 4307, 18, 3, 18, 0, 4 },
  { 4314, 11, 7, 14, 2, -34 },
  { 4324, 19, 25, 22, 1, -25 },
  { 4384, 19, 33, 24, 3, -33 },
  { 4463, 16, 25, 19, 2, -25 },
  { 4513, 19, 33, 24, 2, -33 },
  { 4592, 18, 24, 22, 2, -24 },
  { 4646, 15, 34, 14, 1, -34 },
  { 4710, 19, 36, 24, 2, -25 },
  { 4796, 18, 33, 24, 3, -33 },
  { 4871, 7, 33, 11, 2, -33 },
  { 4900, 11, 44, 11, -2, -33 },
  { 4961, 20, 33, 23, 3, -33 },
  { 5044, 6, 33, 11, 3, -33 },
  { 5069, 30, 25, 36, 3, -25 },
  { 5163, 18, 25, 24, 3, -25 },
  { 5220, 20, 25, 23, 2, -25 },
  { 5283, 19, 36, 24, 3, -25 },
  { 5369, 19, 36, 24, 2, -25 },
  { 5455, 13, 25, 17, 3, -25 },
  { 5496, 16, 25, 18, 1, -25 },
  { 5546, 14, 29, 16, 1, -29 },
  { 5597, 18, 24, 24, 3, -24 },
  { 5651, 21, 24, 21, 0, -24 },
  { 5714, 32, 24, 32, 0, -24 },
  { 5810, 21, 24, 21, 0, -24 },
  { 5873, 21, 35, 21, 0, -24 },
  { 5965, 16, 24, 18, 1, -24 },
  { 6013, 14, 38, 16, 0, -31 },
  { 6080, 5, 44, 21, 8, -34 },
  { 6108, 13, 38, 16, 2, -31 },
  { 6170, 20, 7, 22, 1, -19 },
};

const GFXfont NotoSans_Condensed_Bold44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_BOLD44PT7B_H_
