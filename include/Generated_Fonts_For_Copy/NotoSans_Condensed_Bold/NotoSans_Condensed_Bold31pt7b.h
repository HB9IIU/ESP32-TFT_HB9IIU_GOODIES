#ifndef _NOTOSANS_CONDENSED_BOLD31PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x03,
  0x3D, 0xFF, 0x78, 0xF3, 0xFE, 0x7B, 0xCF, 0x79, 0xEF, 0x3D, 0xE7, 0xBC,
  0x77, 0x0E, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1C, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xCE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xE0, 0x71, 0xC0,
  0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x3F, 0xE3, 0xFF, 0xBF, 0xF9, 0xED, 0xDF, 0x60, 0xF3, 0x03, 0xD8,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0x7C,
  0x1B, 0xF0, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x3E, 0x03, 0xC0, 0xFE, 0x07, 0x01, 0xDE, 0x0E, 0x07,
  0x9C, 0x38, 0x0E, 0x38, 0x70, 0x1C, 0x71, 0xE0, 0x38, 0xE3, 0x80, 0x71,
  0xCF, 0x00, 0xE3, 0x9C, 0x31, 0xE7, 0x39, 0xF1, 0xDE, 0xE7, 0xF3, 0xF9,
  0xDE, 0xF3, 0xE7, 0x38, 0xE0, 0x0E, 0x71, 0xC0, 0x3C, 0xE3, 0x80, 0x71,
  0xC7, 0x01, 0xE3, 0x8E, 0x03, 0x87, 0x1C, 0x07, 0x0F, 0x78, 0x1C, 0x0F,
  0xE0, 0x38, 0x1F, 0xC0, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7,
  0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x79, 0xFF, 0x1E, 0x7F, 0xCF,
  0xBE, 0xFB, 0xEF, 0x1F, 0xF3, 0xC3, 0xFC, 0xF0, 0x7E, 0x3E, 0x0F, 0x8F,
  0xEF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x70,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x07, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1E,
  0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x0E, 0x73, 0x7F, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0x80, 0xFE, 0x0F,
  0x78, 0xF3, 0xE1, 0x8C, 0x00, 0x40, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x7D, 0xE7, 0x9E, 0x7B, 0xCF,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x67, 0xBF, 0xEF, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFB,
  0xE7, 0x8F, 0x7C, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0x78, 0xFB, 0xC7, 0x9F,
  0x7C, 0x7F, 0xE3, 0xFE, 0x07, 0xE0, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7D, 0x9F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x1F, 0xC3,
  0xFF, 0x3F, 0xFC, 0xF3, 0xE6, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC7,
  0xFF, 0x1F, 0xFC, 0xE3, 0xE4, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x07, 0xFC, 0x7F, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xEF, 0x01, 0xFE, 0x07,
  0x7C, 0x0E, 0xF8, 0x39, 0xF0, 0x73, 0xE1, 0xC7, 0xC7, 0x8F, 0x8E, 0x1F,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0xFC, 0x07, 0xFC, 0xFD, 0xFF,
  0xEF, 0xFE, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x87, 0xFC, 0x7E, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF7, 0xE7, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF,
  0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7B, 0xC3, 0xDF, 0x3E, 0x7F,
  0xE3, 0xFE, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0xC1, 0xFF, 0x9F, 0xFC, 0xF1, 0xF7, 0x87,
  0xBC, 0x3D, 0xE3, 0xEF, 0x9E, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0x7F, 0xC7,
  0xDF, 0x3C, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3E, 0xFF,
  0xF7, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xF3, 0xEF, 0x8F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFE, 0x7E, 0xFF, 0xF7,
  0xFF, 0x9F, 0xBC, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x91, 0xF8, 0xFF,
  0xC7, 0xFC, 0x3F, 0x80, 0xF7, 0xBF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x7B, 0xFF, 0xF0, 0x79, 0xF7, 0xDE, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF7, 0x9E, 0x79, 0xE7, 0x3C, 0xF0, 0x00, 0x08, 0x00, 0xC0, 0x1E,
  0x03, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0xC7, 0xF0, 0xFE, 0x0F, 0xC0, 0x78, 0x03,
  0x00, 0x00, 0x3F, 0xCF, 0xFE, 0x7F, 0xE7, 0x1F, 0x40, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFC, 0x3E, 0x07, 0x80, 0x3C, 0x3C, 0x00,
  0x70, 0xE0, 0x61, 0xE7, 0x8F, 0xF3, 0x9C, 0x7F, 0xCE, 0x71, 0xC7, 0x1D,
  0xCF, 0x1C, 0x7F, 0x38, 0x71, 0xF8, 0xE1, 0xC7, 0xE3, 0x8F, 0x1F, 0x8E,
  0x3C, 0xEE, 0x38, 0xF3, 0xBC, 0xF3, 0xCE, 0x71, 0xFB, 0xF1, 0xC7, 0xEF,
  0x87, 0x82, 0x08, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x7E, 0x0E, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x03, 0xE7, 0xC0, 0xF9,
  0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF,
  0xBE, 0x7F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0xFB, 0xFF,
  0xCF, 0xFE, 0x3F, 0xFE, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xFC, 0x7F, 0xF1, 0xF8, 0xE3, 0xE0, 0x4F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x08, 0xFE, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x7C, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xF3, 0xF8, 0xE7, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0xF8, 0x3D,
  0xFC, 0xF9, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x9F, 0xEF, 0xFF, 0xFC, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x9F, 0x7F, 0xBF, 0x9F,
  0x82, 0x00, 0xF8, 0x3F, 0xF0, 0x7B, 0xE1, 0xF7, 0xC7, 0xCF, 0x8F, 0x9F,
  0x3E, 0x3E, 0xF8, 0x7D, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x0F, 0xFE, 0x1F, 0x3C, 0x3E, 0x7C, 0x7C, 0x78, 0xF8, 0xF9, 0xF1, 0xF3,
  0xE1, 0xF7, 0xC3, 0xEF, 0x83, 0xFF, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xDC, 0x1F, 0xFE, 0xE0, 0xFF,
  0xF7, 0x87, 0x7F, 0xBC, 0x7B, 0xFC, 0xE3, 0xDF, 0xE7, 0x1C, 0xFF, 0x3C,
  0xE7, 0xF9, 0xEF, 0x3F, 0xC7, 0x71, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F,
  0x8F, 0xE3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x38,
  0x3C, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xEF, 0x0F, 0xF7, 0xC7, 0xF9, 0xE3, 0xFC, 0xF9,
  0xFE, 0x3C, 0xFF, 0x1F, 0x7F, 0x87, 0xBF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFC,
  0x07, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0xFC, 0xFC, 0x7E, 0x0F, 0x9F,
  0x03, 0xE7, 0xC0, 0x79, 0xE0, 0x1F, 0x78, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x1E,
  0x7C, 0x0F, 0x8F, 0x83, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F,
  0xE3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0xFC, 0xFC, 0x7E,
  0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0x79, 0xE0, 0x1F, 0x78, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7D,
  0xF0, 0x1E, 0x7C, 0x0F, 0x8F, 0x83, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0x8F,
  0x9F, 0x0F, 0x3E, 0x1F, 0x7C, 0x3C, 0xF8, 0x79, 0xF1, 0xF3, 0xFF, 0xC7,
  0xFF, 0x0F, 0xFC, 0x1F, 0x7C, 0x3E, 0x78, 0x7C, 0xF8, 0xF8, 0xF1, 0xF1,
  0xF3, 0xE1, 0xE7, 0xC3, 0xEF, 0x83, 0xDF, 0x07, 0xC0, 0x1F, 0xE3, 0xFF,
  0x7F, 0xF7, 0xFE, 0xF8, 0x2F, 0x80, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7D, 0xFF, 0xFB, 0xFF, 0xE3, 0xFF,
  0x81, 0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x07, 0xDE, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0xF0, 0x1E, 0x07, 0xF8, 0x1F, 0x03, 0xFE, 0x0F, 0x81, 0xEF,
  0x07, 0xC1, 0xF7, 0x83, 0xE0, 0xF3, 0xC3, 0xF8, 0x79, 0xE1, 0xFC, 0x3C,
  0xF8, 0xEE, 0x1E, 0x3C, 0x77, 0x1F, 0x1E, 0x3B, 0xCF, 0x0F, 0x3D, 0xE7,
  0x87, 0x9E, 0xF3, 0xC3, 0xCE, 0x39, 0xE0, 0xF7, 0x1D, 0xF0, 0x7B, 0x8F,
  0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x7C, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x1E, 0x7C, 0x1F, 0x78, 0x0F,
  0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C,
  0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C,
  0x3E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xFF, 0xFF, 0xF8, 0xF0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8,
  0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xDC, 0x07,
  0xBC, 0x0E, 0x38, 0x3C, 0x78, 0x70, 0xF1, 0xE0, 0xF3, 0x81, 0xEF, 0x01,
  0xFC, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x1F, 0xC3, 0xFF, 0x8F, 0xFC, 0x61, 0xF0, 0x0F, 0x80, 0x3C, 0x0F, 0xE7,
  0xFF, 0x7F, 0xFF, 0xE3, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF,
  0xEF, 0xEF, 0x3E, 0x38, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF8, 0xF7, 0xF3, 0xFF, 0xCF, 0xDF, 0xBE,
  0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x7B, 0xC1, 0xEF,
  0x07, 0xBE, 0x1E, 0xFC, 0xFB, 0xFF, 0xCF, 0xFF, 0x39, 0xF8, 0x0F, 0xE1,
  0xFF, 0x3F, 0xE7, 0xE6, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x78, 0x17, 0xC6, 0x3F, 0xE3, 0xFE, 0x0F, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC7, 0xCF, 0x3F, 0xBD, 0xFF, 0xF7, 0xCF, 0xDE, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xDE, 0x1F, 0x7C,
  0xFD, 0xFF, 0xF3, 0xFB, 0xC7, 0xCF, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0xF9,
  0xF7, 0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x0C, 0xFF, 0xE7, 0xFF, 0x0F, 0xF0, 0x03, 0xC1,
  0xFC, 0x7F, 0x8F, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xFE, 0xFF, 0xDF, 0xF8,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF,
  0xDF, 0x3F, 0x78, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x1F, 0x78, 0x7D, 0xF3, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x60, 0xF9, 0xFF, 0xE7, 0xFF, 0x1F,
  0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0xFC, 0xFF, 0xF7, 0xFF, 0xBF, 0x7F, 0xF1, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0x6F, 0xFF, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x3C, 0x78, 0xF0, 0xE0, 0x00, 0x0F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x79, 0xFF, 0xFF, 0xBE, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x1F, 0xF0, 0xFB,
  0xC3, 0xCF, 0x1F, 0x3C, 0xF8, 0xF3, 0xC3, 0xDE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0xC3, 0xEF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF0, 0xF3, 0xC3, 0xEF, 0x07,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xE3, 0xE7, 0xFF, 0xBF, 0xBF, 0xFF, 0xFF, 0xFB, 0xFD,
  0xFF, 0x8F, 0x87, 0xF8, 0x7C, 0x3F, 0xC1, 0xE1, 0xFE, 0x0F, 0x0F, 0xF0,
  0x78, 0x7F, 0x83, 0xC3, 0xFC, 0x1E, 0x1F, 0xE0, 0xF0, 0xFF, 0x07, 0x87,
  0xF8, 0x3C, 0x3F, 0xC1, 0xE1, 0xFE, 0x0F, 0x0F, 0xF0, 0x78, 0x78, 0xE7,
  0xE7, 0xFF, 0xBF, 0xFD, 0xFB, 0xFF, 0x8F, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x78, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x7F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xDE, 0x0F,
  0x78, 0x7D, 0xF3, 0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0xE3, 0xE3, 0xDF,
  0xCF, 0xFF, 0x3F, 0x3E, 0xF8, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0,
  0x7F, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF8, 0x7B, 0xF3, 0xEF, 0xFF, 0x3D,
  0xFC, 0xF7, 0xE3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0x3F, 0x78, 0x7F,
  0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F,
  0x78, 0x7D, 0xF3, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xE3, 0xF3, 0xFF,
  0xFF, 0xFF, 0xC7, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x3F, 0x8F, 0xFF, 0xFF, 0x78, 0x6F, 0x01,
  0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC7,
  0xFF, 0xF7, 0xFE, 0xFF, 0x80, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x3F, 0xFF,
  0xFF, 0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3E, 0x0F, 0x91, 0xFC, 0x7F, 0x0F, 0xC0, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F, 0x38,
  0xF8, 0x3F, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7, 0xC7, 0x8F, 0x0F,
  0x1E, 0x1E, 0x3C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0x77, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x7C, 0x3E, 0xF0,
  0xF8, 0x79, 0xE3, 0xF0, 0xF3, 0xC7, 0xE1, 0xE7, 0x8E, 0xE7, 0x8F, 0x9D,
  0xCF, 0x0F, 0x3B, 0x9E, 0x1E, 0xF7, 0x3C, 0x3D, 0xCE, 0xF0, 0x7B, 0x8D,
  0xE0, 0x77, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF0, 0xFC,
  0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xE0, 0xF8, 0x7D, 0xF1,
  0xF3, 0xC7, 0x8F, 0x3C, 0x1E, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x07,
  0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xFC, 0x3E, 0xF0, 0xF3, 0xE7, 0xC7, 0x9E,
  0x1F, 0xF8, 0x3C, 0xF8, 0x3E, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE3, 0xC7,
  0xC7, 0x8F, 0x0F, 0x1E, 0x1F, 0x3C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0,
  0x77, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xC3, 0xF0, 0xFC, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC1, 0xF0, 0xF8, 0xFE, 0x3E, 0x0F, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x3F,
  0x0F, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF1, 0xFC, 0x7C, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x00, 0x00, 0x0B, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x20,
};

const GFXglyph NotoSans_Condensed_Bold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 22, 8, 2, -22 },
  { 15, 11, 8, 14, 2, -22 },
  { 26, 15, 22, 17, 1, -22 },
  { 68, 13, 26, 15, 1, -24 },
  { 111, 23, 22, 25, 1, -22 },
  { 175, 18, 22, 19, 1, -22 },
  { 225, 4, 8, 8, 2, -22 },
  { 229, 8, 27, 10, 1, -22 },
  { 256, 8, 27, 10, 1, -22 },
  { 283, 13, 14, 15, 1, -24 },
  { 306, 13, 15, 15, 1, -18 },
  { 331, 6, 8, 8, 1, -4 },
  { 337, 8, 4, 10, 1, -10 },
  { 341, 5, 5, 8, 2, -5 },
  { 345, 12, 22, 13, 0, -22 },
  { 378, 13, 22, 15, 1, -22 },
  { 414, 10, 22, 15, 2, -22 },
  { 442, 13, 22, 15, 1, -22 },
  { 478, 13, 22, 15, 1, -22 },
  { 514, 15, 22, 15, 0, -22 },
  { 556, 13, 22, 15, 1, -22 },
  { 592, 13, 22, 15, 1, -22 },
  { 628, 13, 22, 15, 1, -22 },
  { 664, 13, 22, 15, 1, -22 },
  { 700, 13, 22, 15, 1, -22 },
  { 736, 5, 17, 8, 2, -17 },
  { 747, 6, 21, 8, 1, -17 },
  { 763, 13, 15, 15, 1, -19 },
  { 788, 13, 10, 15, 1, -16 },
  { 805, 13, 15, 15, 1, -19 },
  { 830, 12, 22, 12, 0, -22 },
  { 863, 22, 24, 24, 1, -22 },
  { 929, 18, 22, 18, 0, -22 },
  { 979, 14, 22, 18, 2, -22 },
  { 1018, 15, 22, 16, 1, -22 },
  { 1060, 16, 22, 19, 2, -22 },
  { 1104, 11, 22, 15, 2, -22 },
  { 1135, 11, 22, 14, 2, -22 },
  { 1166, 15, 22, 19, 2, -22 },
  { 1208, 16, 22, 20, 2, -22 },
  { 1252, 9, 22, 10, 1, -22 },
  { 1277, 9, 29, 9, -2, -22 },
  { 1310, 15, 22, 17, 2, -22 },
  { 1352, 11, 22, 14, 2, -22 },
  { 1383, 21, 22, 26, 2, -22 },
  { 1441, 17, 22, 21, 2, -22 },
  { 1488, 18, 22, 20, 1, -22 },
  { 1538, 13, 22, 16, 2, -22 },
  { 1574, 18, 27, 20, 1, -22 },
  { 1635, 15, 22, 17, 2, -22 },
  { 1677, 12, 22, 14, 1, -22 },
  { 1710, 14, 22, 15, 0, -22 },
  { 1749, 15, 22, 19, 2, -22 },
  { 1791, 17, 22, 17, 0, -22 },
  { 1838, 25, 22, 25, 0, -22 },
  { 1907, 16, 22, 16, 0, -22 },
  { 1951, 16, 22, 16, 0, -22 },
  { 1995, 13, 22, 14, 1, -22 },
  { 2031, 7, 27, 10, 2, -22 },
  { 2055, 12, 22, 13, 0, -22 },
  { 2088, 7, 27, 10, 1, -22 },
  { 2112, 15, 14, 17, 1, -22 },
  { 2139, 13, 2, 13, 0, 3 },
  { 2143, 8, 5, 10, 1, -24 },
  { 2148, 13, 17, 16, 1, -17 },
  { 2176, 14, 24, 17, 2, -24 },
  { 2218, 12, 17, 13, 1, -17 },
  { 2244, 14, 24, 17, 1, -24 },
  { 2286, 13, 17, 15, 1, -17 },
  { 2314, 11, 24, 10, 0, -24 },
  { 2347, 14, 24, 17, 1, -17 },
  { 2389, 13, 24, 17, 2, -24 },
  { 2428, 4, 24, 8, 2, -24 },
  { 2440, 7, 31, 8, -1, -24 },
  { 2468, 14, 24, 16, 2, -24 },
  { 2510, 4, 24, 8, 2, -24 },
  { 2522, 21, 17, 25, 2, -17 },
  { 2567, 13, 17, 17, 2, -17 },
  { 2595, 14, 17, 16, 1, -17 },
  { 2625, 14, 24, 17, 2, -17 },
  { 2667, 14, 24, 17, 1, -17 },
  { 2709, 9, 17, 12, 2, -17 },
  { 2729, 11, 17, 13, 1, -17 },
  { 2753, 10, 21, 11, 0, -21 },
  { 2780, 13, 17, 17, 2, -17 },
  { 2808, 15, 17, 15, 0, -17 },
  { 2840, 23, 17, 23, 0, -17 },
  { 2889, 14, 17, 15, 0, -17 },
  { 2919, 15, 24, 15, 0, -17 },
  { 2964, 11, 17, 12, 1, -17 },
  { 2988, 10, 27, 11, 0, -22 },
  { 3022, 3, 31, 15, 6, -24 },
  { 3034, 10, 27, 11, 1, -22 },
  { 3068, 13, 6, 15, 1, -14 },
};

const GFXfont NotoSans_Condensed_Bold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_BOLD31PT7B_H_
