#ifndef _NOTOSANS_CONDENSED_BOLD32PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x00,
  0x1D, 0xFF, 0xFF, 0xC0, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x77, 0x8E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x0F,
  0x38, 0x0F, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E,
  0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xE0, 0x39,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0xFE, 0x0F, 0xFE, 0x7F, 0xF9, 0xFF, 0xEF,
  0xB1, 0x3E, 0xC0, 0xFB, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xDE, 0x03, 0x7E, 0x0D, 0xFE, 0x37, 0xBF, 0xFE,
  0xFF, 0xF1, 0xFF, 0x80, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3E,
  0x01, 0xE0, 0x7F, 0x01, 0xC0, 0x7F, 0x83, 0xC0, 0xF3, 0x83, 0x80, 0xF3,
  0x87, 0x80, 0xE3, 0xC7, 0x00, 0xE3, 0xCF, 0x00, 0xE3, 0xCE, 0x00, 0xE3,
  0xCE, 0x00, 0xF3, 0x9E, 0x78, 0xF3, 0x9C, 0xFC, 0x7F, 0xBD, 0xFE, 0x7F,
  0x39, 0xCE, 0x3E, 0x79, 0xCF, 0x00, 0x73, 0xCF, 0x00, 0x73, 0xC7, 0x00,
  0xE3, 0xC7, 0x00, 0xE3, 0xCF, 0x01, 0xE1, 0xCF, 0x01, 0xC1, 0xCF, 0x03,
  0xC1, 0xFE, 0x03, 0x80, 0xFE, 0x07, 0x80, 0x7C, 0x0F, 0xC0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE7, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC3,
  0xE7, 0xFC, 0x7C, 0xFF, 0xCF, 0x3E, 0x7F, 0xE7, 0xC7, 0xFC, 0xF0, 0xFF,
  0x1F, 0x0F, 0xE3, 0xE0, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x07, 0xF9, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x87, 0x87, 0x83, 0xC3,
  0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E,
  0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC1,
  0x8E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC1, 0xEF, 0x1F,
  0x7C, 0x71, 0xC1, 0x8C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x7D, 0xF7, 0x9E, 0x79,
  0xCF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x78, 0xF9, 0xE1, 0xEF, 0x87,
  0xBE, 0x1E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0x79, 0xE1, 0xE7, 0x8F, 0x9F, 0xFC, 0x3F,
  0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDE,
  0xFF, 0xBD, 0xDF, 0x47, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xC0,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x70, 0xF8, 0x81, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x20, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF0,
  0x1F, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x0F,
  0xBC, 0xFE, 0xFF, 0xF3, 0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xDE, 0x03, 0xBC, 0x0E,
  0x78, 0x1C, 0xF0, 0x71, 0xE1, 0xE3, 0xC3, 0x87, 0x8F, 0x0F, 0x1C, 0x1E,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7B, 0x81, 0xFF, 0x87, 0xFF, 0x1F,
  0xFE, 0x21, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xE8,
  0x0F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0xE1, 0xFF, 0x8F, 0xFE, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF3,
  0xC3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7B, 0xE1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF,
  0x1F, 0x3E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x3E, 0x7D, 0xF0, 0xFF,
  0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0xF1, 0xF7, 0xEF, 0x8F, 0xBC, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x07, 0xFE, 0x3E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00,
  0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0xF8, 0xFB, 0xC1, 0xEF, 0x07,
  0xBC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xBC, 0xFE,
  0xF1, 0xF7, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x11, 0xFC, 0x7F,
  0xE1, 0xFF, 0x07, 0xF0, 0x00, 0x67, 0xFF, 0xFF, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x3B, 0xFF, 0xFF, 0x80, 0x39, 0xF7, 0xDF, 0x78, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xDF, 0x79, 0xE7, 0x9C, 0xF3, 0xC0, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x01, 0xFC, 0x1F,
  0xC1, 0xFC, 0x3F, 0xC0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x1F, 0x87,
  0xFE, 0xFF, 0xF7, 0xFF, 0x60, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x78, 0xF0,
  0x00, 0xE3, 0x87, 0xF3, 0xDE, 0x3F, 0xE7, 0x71, 0xFF, 0x9D, 0xC7, 0x1C,
  0x77, 0x3C, 0x71, 0xFC, 0xE1, 0xC7, 0xF3, 0x87, 0x1F, 0xCE, 0x1C, 0x7F,
  0x38, 0x71, 0xFC, 0xF3, 0xC7, 0x73, 0xCF, 0xB9, 0xC7, 0xFF, 0xE7, 0x0F,
  0x9F, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x01, 0x01, 0xF8, 0x3C,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xEF, 0x00, 0x7B,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x81, 0xF1, 0xE0, 0x7C, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xC0, 0xF9, 0xF0, 0x1E, 0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7C, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x07,
  0xBE, 0x0F, 0x7C, 0x1E, 0xF8, 0x7D, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0xDF, 0x0F, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1,
  0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xE3, 0xF0, 0x47, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x09, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F,
  0xF9, 0xFF, 0xF7, 0xE0, 0x4F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3D, 0xF0, 0x7B, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF,
  0xC3, 0xFF, 0x00, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xEF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xCF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xCF, 0xBF, 0xDF, 0xEF, 0xE3,
  0xC0, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0x70, 0x3F, 0xFD, 0xE0, 0xEF, 0xF7, 0x87, 0xBF, 0xDE,
  0x1E, 0xFF, 0xB8, 0x73, 0xFE, 0xF1, 0xCF, 0xFB, 0xCF, 0x3F, 0xEF, 0x3C,
  0xFF, 0x9C, 0xE3, 0xFE, 0x7F, 0x8F, 0xF9, 0xFE, 0x3F, 0xE3, 0xF0, 0xFF,
  0x8F, 0xC3, 0xFE, 0x3F, 0x0F, 0xF8, 0xF8, 0x3F, 0xE1, 0xE0, 0xFF, 0x87,
  0x83, 0xC0, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xEF, 0x0F, 0xF7, 0xC7, 0xF9, 0xE3, 0xFC,
  0xF9, 0xFE, 0x3C, 0xFF, 0x9F, 0x7F, 0xC7, 0xBF, 0xE3, 0xFF, 0xF0, 0xF7,
  0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3E, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3E, 0x0F, 0x9F, 0x01, 0xE7, 0xC0, 0x7D, 0xF0, 0x1F, 0x78, 0x07, 0xDE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80,
  0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x83, 0xFF, 0x8F, 0xFF,
  0xBF, 0xFE, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x8F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x0F, 0x9F,
  0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x78, 0x07, 0xDE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7D, 0xF0, 0x1F,
  0x7C, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xF8, 0xF8,
  0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFB,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xE0, 0xF9, 0xF0, 0xF8,
  0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0xF8, 0x7C, 0xF8, 0x3C, 0xF8, 0x3E, 0xF8,
  0x3F, 0x0F, 0xE1, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0x83, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x3D, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x07, 0xFE, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x3E, 0x78, 0x0F, 0x1F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C,
  0x3C, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF0, 0x1E,
  0x03, 0xFC, 0x07, 0x80, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0xFC, 0x1F, 0x78,
  0x3F, 0x07, 0x9E, 0x0F, 0xC1, 0xE7, 0x83, 0xF0, 0x79, 0xF1, 0xFE, 0x3E,
  0x3C, 0x7F, 0x8F, 0x0F, 0x1F, 0xE3, 0xC3, 0xC7, 0x38, 0xF0, 0xF1, 0xCE,
  0x3C, 0x3E, 0xF3, 0xDF, 0x07, 0xBC, 0xF7, 0x81, 0xEF, 0x3D, 0xE0, 0x7B,
  0x87, 0x78, 0x1E, 0xE1, 0xDE, 0x07, 0xF8, 0x77, 0x80, 0xFE, 0x1F, 0xC0,
  0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F,
  0x80, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x07, 0x87, 0xC7, 0xC1, 0xE3, 0xC0,
  0xFB, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1E, 0xF0, 0x1F,
  0x7C, 0x0F, 0x1E, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xC1, 0xF3, 0xE0, 0xFB,
  0xE0, 0x3E, 0xF8, 0x0F, 0xBC, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC3, 0xC3,
  0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3E, 0xF0, 0x0F, 0x78, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xF8, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x1E,
  0x70, 0x3C, 0x78, 0x3C, 0x38, 0x38, 0x3C, 0x78, 0x3C, 0x70, 0x1E, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x07,
  0xC1, 0xFF, 0x8F, 0xFC, 0x7F, 0xF1, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0xFF,
  0x3F, 0xFB, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x7F, 0xE3, 0xFF,
  0xFF, 0x7F, 0xB9, 0xF9, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x1C, 0x3D, 0xFC, 0xFF, 0xF3, 0xFF, 0xEF, 0x8F,
  0xBE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFB, 0xFF, 0xEF, 0x7F, 0x3C, 0xF8, 0x07,
  0xC1, 0xFF, 0x3F, 0xF3, 0xFE, 0x7C, 0x27, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC1, 0x7E, 0x73, 0xFF, 0x3F,
  0xF0, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0xF3, 0xC7, 0xEF, 0x3F, 0xFD, 0xFF, 0xF7, 0xC7, 0xDE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xDE,
  0x1F, 0x7E, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xE7, 0x07, 0x80, 0x7F, 0x83,
  0xFF, 0x1F, 0xFE, 0x78, 0x79, 0xE1, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xE1, 0x8F, 0xFE,
  0x1F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xF2, 0x1E, 0x01,
  0xE0, 0x1E, 0x07, 0xFC, 0xFF, 0xCF, 0xFC, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x1C, 0x7E, 0xF3, 0xFF, 0xDF, 0xFF, 0x7C,
  0x7D, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3D, 0xE1, 0xF7, 0xEF, 0xDF, 0xFF, 0x3F, 0xBC, 0x7C, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3D, 0x81, 0xF7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x1C, 0x3D, 0xFC, 0xFF, 0xFB, 0xFF, 0xEF, 0xCF, 0xBE, 0x1F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF7, 0xFF, 0xE0, 0x03,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x1E,
  0x1E, 0x1F, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3E, 0xFE, 0xFE, 0xFC, 0x70, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x3E, 0xF0, 0xF9,
  0xE1, 0xE3, 0xC7, 0xC7, 0x9F, 0x0F, 0x3C, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE1, 0xF3, 0xC3, 0xC7, 0xC7, 0x87, 0x8F, 0x0F, 0x9E, 0x0F,
  0x3C, 0x1F, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xC1, 0xE3, 0xDF, 0xCF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7F, 0xE1, 0xF0, 0xFF, 0x87, 0x83, 0xFC,
  0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E,
  0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F,
  0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF0, 0xE1, 0xC3, 0xDF, 0xCF, 0xFF, 0xBF,
  0xFE, 0xFC, 0xFB, 0xE1, 0xEF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xC7, 0xCF,
  0x07, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xE7, 0x83, 0xCF, 0x0F, 0x9F, 0x3F, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0,
  0xE1, 0xC3, 0xDF, 0xCF, 0x7F, 0xBF, 0xFE, 0xF8, 0x7B, 0xE1, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0xCF, 0xBF, 0xFE, 0xF7, 0xF3, 0xCF, 0x8F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x1C,
  0x7E, 0xF3, 0xFF, 0xDF, 0xFF, 0x7C, 0x7D, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3D, 0xE1, 0xF7, 0xEF,
  0xDF, 0xFF, 0x3F, 0xBC, 0x7C, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xE1, 0xFD, 0xFF, 0x7F,
  0xFE, 0xFF, 0xBF, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xFD, 0xFF, 0xFF,
  0xEF, 0x05, 0xE0, 0x3E, 0x03, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x81, 0xF0,
  0x1F, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xF9, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE4, 0x7F, 0x8F, 0xF0,
  0xFE, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x7F,
  0xF7, 0xEF, 0xFF, 0x7F, 0xB9, 0xF9, 0xC0, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0,
  0xFB, 0xC1, 0xE7, 0xC3, 0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x3E, 0x78,
  0x3D, 0xF0, 0x7B, 0xC0, 0xF7, 0x80, 0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x7C, 0x1E, 0xF0, 0xFC, 0x3D, 0xE1,
  0xF8, 0xFB, 0xC7, 0xF1, 0xE7, 0xCE, 0xE3, 0xC7, 0x9D, 0xC7, 0x8F, 0x3B,
  0xDF, 0x1E, 0x73, 0xBC, 0x3C, 0xE7, 0x78, 0x3F, 0x8E, 0xF0, 0x7F, 0x1D,
  0xE0, 0xFE, 0x3B, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0xFC, 0x3E, 0xF8, 0xF8, 0xF1, 0xE1,
  0xF7, 0xC1, 0xEF, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x1F,
  0xC0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0x87, 0x8F, 0x1F, 0x1F, 0x3E, 0x3E,
  0xF8, 0x3E, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xC1, 0xE7, 0xC3, 0xC7,
  0x87, 0x8F, 0x1F, 0x1F, 0x3C, 0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x81,
  0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0xFE, 0x3F, 0x0F, 0xC3, 0xF8,
  0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83,
  0xF0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x3F, 0x0F, 0xC3, 0xF8, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0xC3, 0xF0, 0x7C, 0x7F, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x7E, 0x3F, 0x0F,
  0xC3, 0xE0, 0x3C, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xF8,
};

const GFXglyph NotoSans_Condensed_Bold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 8, 2, -23 },
  { 16, 11, 8, 15, 2, -23 },
  { 27, 16, 23, 17, 1, -23 },
  { 73, 14, 26, 16, 1, -24 },
  { 119, 24, 23, 26, 1, -23 },
  { 188, 19, 23, 20, 1, -23 },
  { 243, 4, 8, 8, 2, -23 },
  { 247, 9, 28, 10, 1, -23 },
  { 279, 8, 28, 10, 1, -23 },
  { 307, 13, 13, 15, 1, -24 },
  { 329, 14, 15, 16, 1, -19 },
  { 356, 6, 8, 8, 1, -4 },
  { 362, 8, 4, 10, 1, -11 },
  { 366, 5, 5, 8, 2, -5 },
  { 370, 13, 23, 13, 0, -23 },
  { 408, 14, 23, 16, 1, -23 },
  { 449, 10, 23, 16, 2, -23 },
  { 478, 14, 23, 16, 1, -23 },
  { 519, 14, 23, 16, 1, -23 },
  { 560, 15, 23, 16, 0, -23 },
  { 604, 14, 23, 16, 1, -23 },
  { 645, 14, 23, 16, 1, -23 },
  { 686, 14, 23, 16, 1, -23 },
  { 727, 14, 23, 16, 1, -23 },
  { 768, 14, 23, 16, 1, -23 },
  { 809, 5, 18, 9, 2, -18 },
  { 821, 6, 22, 9, 1, -18 },
  { 838, 14, 15, 16, 1, -19 },
  { 865, 14, 10, 16, 1, -16 },
  { 883, 14, 15, 16, 1, -19 },
  { 910, 12, 23, 13, 0, -23 },
  { 945, 22, 26, 25, 1, -23 },
  { 1017, 18, 23, 18, 0, -23 },
  { 1069, 15, 23, 18, 2, -23 },
  { 1113, 15, 23, 17, 1, -23 },
  { 1157, 16, 23, 20, 2, -23 },
  { 1203, 11, 23, 15, 2, -23 },
  { 1235, 11, 23, 15, 2, -23 },
  { 1267, 15, 23, 20, 2, -23 },
  { 1311, 16, 23, 21, 2, -23 },
  { 1357, 9, 23, 11, 1, -23 },
  { 1383, 9, 30, 9, -2, -23 },
  { 1417, 16, 23, 18, 2, -23 },
  { 1463, 12, 23, 14, 2, -23 },
  { 1498, 22, 23, 26, 2, -23 },
  { 1562, 17, 23, 22, 2, -23 },
  { 1611, 18, 23, 21, 1, -23 },
  { 1663, 14, 23, 17, 2, -23 },
  { 1704, 18, 28, 21, 1, -23 },
  { 1767, 16, 23, 18, 2, -23 },
  { 1813, 13, 23, 15, 1, -23 },
  { 1851, 14, 23, 15, 1, -23 },
  { 1892, 16, 23, 20, 2, -23 },
  { 1938, 18, 23, 18, 0, -23 },
  { 1990, 26, 23, 26, 0, -23 },
  { 2065, 17, 23, 17, 0, -23 },
  { 2114, 17, 23, 17, 0, -23 },
  { 2163, 13, 23, 15, 1, -23 },
  { 2201, 7, 28, 10, 2, -23 },
  { 2226, 13, 23, 13, 0, -23 },
  { 2264, 7, 28, 10, 1, -23 },
  { 2289, 16, 14, 17, 1, -23 },
  { 2317, 13, 2, 13, 0, 3 },
  { 2321, 8, 6, 10, 1, -25 },
  { 2327, 13, 18, 16, 1, -18 },
  { 2357, 14, 24, 17, 2, -24 },
  { 2399, 12, 18, 14, 1, -18 },
  { 2426, 14, 24, 17, 1, -24 },
  { 2468, 14, 18, 16, 1, -18 },
  { 2500, 12, 24, 10, 0, -24 },
  { 2536, 14, 26, 17, 1, -18 },
  { 2582, 14, 24, 17, 2, -24 },
  { 2624, 5, 24, 8, 2, -24 },
  { 2639, 8, 32, 8, -1, -24 },
  { 2671, 15, 24, 17, 2, -24 },
  { 2716, 4, 24, 8, 2, -24 },
  { 2728, 22, 18, 26, 2, -18 },
  { 2778, 14, 18, 17, 2, -18 },
  { 2810, 15, 18, 17, 1, -18 },
  { 2844, 14, 26, 17, 2, -18 },
  { 2890, 14, 26, 17, 1, -18 },
  { 2936, 10, 18, 12, 2, -18 },
  { 2959, 11, 18, 13, 1, -18 },
  { 2984, 11, 21, 12, 0, -21 },
  { 3013, 13, 18, 17, 2, -18 },
  { 3043, 15, 18, 15, 0, -18 },
  { 3077, 23, 17, 23, 0, -17 },
  { 3126, 15, 17, 15, 0, -17 },
  { 3158, 15, 26, 15, 0, -18 },
  { 3207, 11, 18, 13, 1, -18 },
  { 3232, 10, 28, 12, 0, -23 },
  { 3267, 3, 31, 15, 6, -24 },
  { 3279, 10, 28, 12, 1, -23 },
  { 3314, 14, 5, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_Bold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_BOLD32PT7B_H_
