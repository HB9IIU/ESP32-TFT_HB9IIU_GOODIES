#ifndef _NOTOSANS_CONDENSED_BOLD10PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xB4, 0x29, 0xBE, 0xAF, 0xA9, 0x40, 0x23, 0xBC, 0xC3, 0x1F,
  0xC4, 0x20, 0x64, 0xA8, 0xA8, 0x7F, 0x15, 0x15, 0x26, 0x71, 0x47, 0x1B,
  0xDF, 0x67, 0xC0, 0xC0, 0x69, 0x6C, 0x92, 0x20, 0xC9, 0x92, 0xD2, 0x80,
  0x25, 0x7E, 0xE5, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x70, 0xE0, 0xC0, 0x12,
  0x26, 0x44, 0xC0, 0x72, 0xB7, 0xBD, 0xA9, 0xC0, 0x3F, 0x73, 0x33, 0x30,
  0xF2, 0x84, 0x62, 0x23, 0xE0, 0xF0, 0x84, 0xE1, 0xCF, 0xC0, 0x31, 0x94,
  0xAF, 0xFC, 0x40, 0x72, 0x18, 0xE1, 0xCB, 0xC0, 0x72, 0x3D, 0xAD, 0xAD,
  0xC0, 0xF8, 0x84, 0x62, 0x31, 0x80, 0x76, 0x94, 0xED, 0xED, 0xC0, 0x76,
  0xB6, 0xF5, 0x09, 0x80, 0xCC, 0x50, 0x1C, 0x09, 0xB0, 0x60, 0x80, 0xF8,
  0x3E, 0x83, 0x06, 0xC8, 0x00, 0xF1, 0x36, 0x44, 0x60, 0x3C, 0x85, 0x6D,
  0x5A, 0xAA, 0xD1, 0x1E, 0x30, 0xC7, 0x96, 0x7B, 0x2C, 0xC0, 0xF9, 0xBF,
  0x99, 0xF0, 0x7A, 0x11, 0x84, 0x34, 0xE0, 0xF4, 0xA7, 0x39, 0xDB, 0x80,
  0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0x3B, 0x11, 0xB4, 0xA4, 0xE0, 0x9C,
  0xE7, 0xF9, 0xCE, 0x60, 0xE9, 0x24, 0xB8, 0x24, 0x92, 0x49, 0xE0, 0x9D,
  0xB9, 0xCA, 0x5A, 0x60, 0x92, 0x49, 0x38, 0xCF, 0x3C, 0xEB, 0xB6, 0xDB,
  0x40, 0xCE, 0x7B, 0x5B, 0xCE, 0x60, 0x79, 0x34, 0x71, 0x4D, 0x33, 0x80,
  0xEB, 0x9F, 0x88, 0x80, 0x79, 0x34, 0x71, 0x4D, 0x33, 0x82, 0x0C, 0xF5,
  0xAD, 0xCA, 0x5A, 0x60, 0x7C, 0x47, 0x19, 0xF0, 0xF9, 0x08, 0x42, 0x10,
  0x80, 0x9C, 0xE7, 0x39, 0xCB, 0xC0, 0xCE, 0x56, 0xA7, 0x18, 0xC0, 0x99,
  0xDB, 0xDB, 0x5A, 0x76, 0x66, 0x66, 0xDA, 0x9C, 0x67, 0x2F, 0x20, 0xDA,
  0x94, 0x62, 0x10, 0x80, 0xF1, 0x22, 0x4C, 0xF0, 0xEA, 0xAA, 0xC0, 0xC4,
  0x46, 0x22, 0x10, 0xED, 0xB6, 0xDB, 0xE0, 0x21, 0x95, 0x90, 0xF0, 0xCC,
  0x27, 0x17, 0xD7, 0x88, 0xAF, 0x99, 0xBE, 0x27, 0xCC, 0x47, 0x18, 0xCE,
  0xFD, 0xED, 0x6D, 0x22, 0xB7, 0xF4, 0x38, 0x36, 0x4E, 0x44, 0x44, 0x23,
  0xF7, 0xB5, 0xBC, 0x6E, 0x88, 0xAF, 0xBB, 0xBB, 0xDF, 0x51, 0x55, 0x70,
  0x88, 0x8B, 0xEE, 0xA9, 0xFF, 0x25, 0xFA, 0xDD, 0xBB, 0x76, 0xC0, 0x2F,
  0xBB, 0xBB, 0x23, 0xF7, 0x95, 0xB8, 0x2F, 0x99, 0xBE, 0x88, 0x23, 0xF7,
  0xB5, 0xBC, 0x63, 0x3E, 0x49, 0x00, 0x2F, 0xC7, 0x3E, 0x4B, 0xA4, 0x98,
  0xBB, 0xBB, 0xD0, 0xDA, 0x94, 0xE2, 0x00, 0xDA, 0xDD, 0xBB, 0x66, 0xC0,
  0xDB, 0x98, 0xED, 0x80, 0xDA, 0x94, 0xE2, 0x13, 0x80, 0xF2, 0x64, 0xF0,
  0x69, 0x2C, 0x93, 0x20, 0xFF, 0xC0, 0xC9, 0x36, 0x92, 0x80, 0xF8,
};

const GFXglyph NotoSans_Condensed_Bold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 2, 5, 1, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 5, 9, 5, 0, -8 },
  { 14, 8, 7, 8, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 1, 2, 2, 1, -7 },
  { 28, 3, 9, 3, 0, -7 },
  { 32, 3, 9, 3, 0, -7 },
  { 36, 5, 5, 5, 0, -8 },
  { 40, 5, 5, 5, 0, -6 },
  { 44, 2, 2, 3, 0, -1 },
  { 45, 3, 1, 3, 0, -3 },
  { 46, 1, 2, 3, 1, -2 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 5, 7, 5, 0, -7 },
  { 56, 4, 7, 5, 0, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 5, 7, 5, 0, -7 },
  { 100, 1, 6, 3, 1, -6 },
  { 101, 2, 7, 3, 0, -6 },
  { 103, 5, 5, 5, 0, -6 },
  { 107, 5, 3, 5, 0, -5 },
  { 109, 5, 5, 5, 0, -6 },
  { 113, 4, 7, 4, 0, -7 },
  { 117, 7, 8, 8, 0, -7 },
  { 124, 6, 7, 6, 0, -7 },
  { 130, 4, 7, 6, 1, -7 },
  { 134, 5, 7, 5, 0, -7 },
  { 139, 5, 7, 6, 1, -7 },
  { 144, 3, 7, 5, 1, -7 },
  { 147, 3, 7, 5, 1, -7 },
  { 150, 5, 7, 6, 0, -7 },
  { 155, 5, 7, 6, 1, -7 },
  { 160, 3, 7, 3, 0, -7 },
  { 163, 3, 9, 3, -1, -7 },
  { 167, 5, 7, 6, 1, -7 },
  { 172, 3, 7, 5, 1, -7 },
  { 175, 6, 7, 8, 1, -7 },
  { 181, 5, 7, 7, 1, -7 },
  { 186, 6, 7, 7, 0, -7 },
  { 192, 4, 7, 5, 1, -7 },
  { 196, 6, 9, 7, 0, -7 },
  { 203, 5, 7, 6, 1, -7 },
  { 208, 4, 7, 5, 0, -7 },
  { 212, 5, 7, 5, 0, -7 },
  { 217, 5, 7, 6, 1, -7 },
  { 222, 5, 7, 5, 0, -7 },
  { 227, 8, 7, 8, 0, -7 },
  { 234, 5, 7, 5, 0, -7 },
  { 239, 5, 7, 5, 0, -7 },
  { 244, 4, 7, 5, 0, -7 },
  { 248, 2, 9, 3, 1, -7 },
  { 251, 4, 7, 4, 0, -7 },
  { 255, 3, 9, 3, 0, -7 },
  { 259, 5, 4, 5, 0, -7 },
  { 262, 4, 1, 4, 0, 1 },
  { 263, 3, 2, 3, 0, -8 },
  { 264, 4, 6, 5, 0, -6 },
  { 267, 4, 8, 5, 1, -8 },
  { 271, 4, 6, 4, 0, -6 },
  { 274, 5, 8, 5, 0, -8 },
  { 279, 5, 6, 5, 0, -6 },
  { 283, 4, 8, 3, 0, -8 },
  { 287, 5, 8, 5, 0, -6 },
  { 292, 4, 8, 5, 1, -8 },
  { 296, 1, 8, 3, 1, -8 },
  { 297, 2, 10, 3, 0, -8 },
  { 300, 4, 8, 5, 1, -8 },
  { 304, 1, 8, 3, 1, -8 },
  { 305, 7, 6, 8, 1, -6 },
  { 311, 4, 6, 5, 1, -6 },
  { 314, 5, 6, 5, 0, -6 },
  { 318, 4, 8, 5, 1, -6 },
  { 322, 5, 8, 5, 0, -6 },
  { 327, 3, 6, 4, 1, -6 },
  { 330, 4, 6, 4, 0, -6 },
  { 333, 3, 7, 4, 0, -7 },
  { 336, 4, 5, 5, 1, -5 },
  { 339, 5, 5, 5, 0, -5 },
  { 343, 7, 5, 7, 0, -5 },
  { 348, 5, 5, 5, 0, -5 },
  { 352, 5, 7, 5, 0, -5 },
  { 357, 4, 5, 4, 0, -5 },
  { 360, 3, 9, 4, 0, -7 },
  { 364, 1, 10, 5, 2, -8 },
  { 366, 3, 9, 4, 0, -7 },
  { 370, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_Bold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_BOLD10PT7B_H_
