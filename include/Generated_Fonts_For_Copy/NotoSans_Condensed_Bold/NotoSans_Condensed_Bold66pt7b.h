#ifndef _NOTOSANS_CONDENSED_BOLD66PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xF3, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0x78, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3,
  0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x0F, 0xC1, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFE,
  0xE3, 0xF9, 0xFF, 0x9C, 0x0E, 0x3F, 0xE3, 0x80, 0x47, 0xFC, 0x70, 0x00,
  0xFF, 0x8E, 0x00, 0x1F, 0xF1, 0xC0, 0x03, 0xFE, 0x38, 0x00, 0x7F, 0xE7,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x77, 0xFE, 0x00, 0x0E, 0x7F, 0xE0, 0x01, 0xC7,
  0xFC, 0x00, 0x38, 0xFF, 0x80, 0x07, 0x0F, 0xF8, 0x00, 0xE1, 0xFF, 0xC0,
  0x1C, 0x7F, 0xFE, 0x03, 0x8F, 0xFF, 0xF8, 0x77, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x7F,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFE, 0x3F, 0x81, 0xF8, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC3, 0xFF, 0x03, 0xF8, 0x7F, 0x1F, 0xC3, 0xFF, 0xE1,
  0xFC, 0x3F, 0x8F, 0xE3, 0xFF, 0xF8, 0xFF, 0x3F, 0xC7, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xF8, 0xFF, 0x3F,
  0x87, 0xFF, 0xE3, 0xF8, 0x7F, 0x1F, 0xC1, 0xFF, 0xE1, 0xFC, 0x7F, 0x07,
  0xF0, 0x7F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x0F, 0x80, 0xFE, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xF8,
  0x3F, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFC,
  0x3F, 0xF0, 0xFF, 0xCF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x80,
  0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xF8,
  0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF7,
  0xFD, 0xFF, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF8, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0x03, 0xF8, 0x0C, 0x7E, 0x1F, 0x87, 0xC7, 0xFD, 0xFB, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFB, 0xFE,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F,
  0xE0, 0x7E, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC7, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x07, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3,
  0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x1F, 0xF9,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0xEF, 0xFF, 0xFE, 0x7F, 0xBF, 0xE7, 0xFC, 0xFE, 0x3F, 0xE3, 0xE1, 0xFF,
  0x0E, 0x0F, 0xF8, 0x20, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xF0, 0x07, 0xFE, 0x1E, 0x00, 0x7F,
  0xE0, 0xC0, 0x03, 0xFE, 0x08, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x1F, 0x81, 0xFF, 0xE1, 0xE0, 0x07, 0xFE, 0x08, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x1F, 0xDF, 0xF0,
  0x00, 0x7F, 0x3F, 0xE0, 0x00, 0xFE, 0x7F, 0xC0, 0x03, 0xF8, 0xFF, 0x80,
  0x07, 0xF1, 0xFF, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x3F, 0x87, 0xFC, 0x00,
  0xFE, 0x0F, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x01, 0xFC,
  0x03, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFD, 0x00, 0x01,
  0xFF, 0xBC, 0x00, 0x7F, 0xF7, 0xF0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x40, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x0F, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x3F, 0xFE, 0x0F,
  0xFB, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xBF, 0xF8, 0x0F,
  0xFD, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x01,
  0xFF, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x07, 0xFC,
  0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x3F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE3, 0xFE, 0x01, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x1F, 0xF0, 0x7F,
  0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF7,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x03,
  0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x3F,
  0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0xFE, 0x0F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xF1, 0xFF, 0xFE, 0xFF,
  0x0F, 0xFF, 0xCF, 0xF0, 0x7F, 0xF8, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x03,
  0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x20, 0x0F, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFB,
  0xFF, 0x7F, 0xE7, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC3, 0xFC, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFD, 0xFF, 0xBF, 0xE3, 0xF8, 0x1C, 0x00, 0x02, 0x01, 0xFC, 0x3F, 0xE3,
  0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF1, 0xFE, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07,
  0xF0, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0x83,
  0xFF, 0x8E, 0x00, 0x7F, 0xC4, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF,
  0x03, 0xF8, 0xFE, 0x01, 0xFF, 0xFE, 0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xF0,
  0x7E, 0x3F, 0x81, 0xFF, 0xFF, 0x83, 0xFB, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F,
  0xDF, 0xC0, 0xFF, 0x0F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF7,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xFF, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0xF8,
  0x3F, 0x80, 0xFE, 0x07, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0xFE, 0x0F,
  0xE0, 0x3F, 0x81, 0xFF, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x03,
  0xF8, 0x1F, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x01, 0xFE,
  0x0F, 0xFF, 0x81, 0xFC, 0x0F, 0xF0, 0x7E, 0xFE, 0x0F, 0xE0, 0x7F, 0x83,
  0xF7, 0xF0, 0x7F, 0x07, 0xFC, 0x3F, 0xBF, 0x83, 0xFC, 0x7F, 0xF3, 0xF9,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F,
  0x81, 0xFF, 0xF3, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x08, 0x00, 0x10, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0x80,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xF3,
  0xFE, 0x00, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFE, 0xFF,
  0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF,
  0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F,
  0xEF, 0xF8, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0x7F, 0xF8, 0x01,
  0xC1, 0xFF, 0xC0, 0x01, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x87, 0xFF, 0x80, 0x1E, 0x0F, 0xFF, 0xE7, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0x80, 0x1F, 0xFC, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x7F, 0xF8, 0xFF,
  0x81, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0x80, 0x07,
  0x07, 0xFF, 0x80, 0x00, 0x83, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFB, 0xFE, 0x03, 0xFF, 0xFD, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE,
  0x3F, 0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80,
  0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x87,
  0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x9F,
  0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE7,
  0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x00, 0x0F, 0xEF, 0xFF, 0xF7,
  0xF0, 0x00, 0xFE, 0xFF, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xFF, 0xF7, 0xF8,
  0x01, 0xFE, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xCF, 0xFF, 0xF3, 0xF8, 0x01,
  0xFC, 0xFF, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xFF, 0xF3, 0xFC, 0x03, 0xF8,
  0xFF, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xFF, 0xF1, 0xFE, 0x07, 0xF8, 0xFF,
  0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0xF9, 0xFE, 0x07, 0xF0, 0xFF, 0xFF,
  0x8F, 0xE0, 0x7F, 0x0F, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x8F,
  0xF0, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x87, 0xF1,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x9F, 0xC0, 0xFF, 0xFF, 0x87, 0xF9, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0x9F, 0xC0, 0xFF, 0xFF, 0x83, 0xFB, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xDF, 0xF0, 0x07, 0xFF,
  0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xE7, 0xFC, 0x03,
  0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF,
  0x81, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xE0, 0xFF, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xC3, 0xFF,
  0xFC, 0x0F, 0xFC, 0x7F, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0xF9,
  0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0xF8, 0x03,
  0xFE, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0xDF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x74, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x80, 0xFF, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x1F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xDF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F,
  0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFC, 0x07, 0xC7, 0xFE, 0x00, 0x31, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xA0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFE,
  0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF7, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xDF, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x80, 0x3F,
  0xC0, 0xFF, 0x3F, 0x81, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x7F, 0x03, 0xFE,
  0x00, 0xFF, 0x83, 0xF8, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF1, 0xFE,
  0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC3, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x80, 0x0F,
  0xF8, 0xFE, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xF1, 0xFC, 0x1F, 0xE3, 0xFC,
  0x00, 0x1F, 0xE7, 0xF8, 0x1F, 0xCF, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x3F,
  0x9F, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x7F, 0x3F, 0xE0, 0x00, 0xFF, 0xBF,
  0x80, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x01, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFE, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0x8F, 0xFF, 0x07, 0x80, 0x7F, 0xE0,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xE3, 0xFE, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xDF, 0xFC,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFC,
  0xFF, 0xFE, 0x3F, 0x8F, 0xFF, 0x87, 0xF0, 0x7F, 0xE0, 0x7E, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x70, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF3, 0xFF, 0xE0,
  0xFF, 0x9F, 0xFF, 0x87, 0xFD, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x3F, 0xFB, 0xFF, 0x80,
  0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF7, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xDF,
  0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0xBF, 0xFC,
  0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFD, 0xFF, 0xFE, 0x1F, 0xE7, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0x07,
  0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1C, 0x7F, 0xE0,
  0x04, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0x7F, 0xE0, 0x06, 0x7F, 0xF8,
  0x1E, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x3C, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xF1, 0xFF, 0x0F,
  0xFF, 0xCF, 0xF8, 0xFF, 0xFF, 0x7F, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xFD, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x1F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xBF, 0xE1, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0x87, 0xF8, 0x1F,
  0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0,
  0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFE,
  0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x47,
  0xFF, 0x00, 0x3C, 0x3F, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0x0C, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xF8, 0x3F, 0xC1, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0x9F, 0xF1, 0xFF, 0xFE,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xF0, 0x7F, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xF7, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xF8, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF,
  0xF3, 0xFE, 0x0F, 0xFF, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0x18, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xC0, 0x00, 0x7F, 0xE7, 0xC0,
  0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0xFF, 0x8F, 0xFE,
  0x0F, 0xF9, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0x3F, 0x3F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xEF, 0xFB,
  0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF,
  0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF,
  0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xE0, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFC,
  0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x87,
  0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF,
  0x1F, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFB,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xBF, 0xE0, 0x0F, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF,
  0x0F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE,
  0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x0F, 0xE1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF3, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFB, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F,
  0xE0, 0xFE, 0x1F, 0xFF, 0x0F, 0xF3, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xCF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x7F,
  0xE3, 0xFF, 0x01, 0xFF, 0x9F, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xEF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x03,
  0xFF, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0xC7, 0xFF, 0xC1, 0xFE, 0x7F, 0xFF,
  0x0F, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xBF, 0xF0,
  0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFD,
  0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0x7F, 0xF8, 0x3F, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFD, 0xFF,
  0xFC, 0x3F, 0xEF, 0xFF, 0xE1, 0xFF, 0x3F, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0,
  0x7F, 0xC0, 0x70, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF,
  0x9F, 0xF1, 0xFF, 0xFE, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFB, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x3F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xF8, 0xFF,
  0xFF, 0x7F, 0xC3, 0xFF, 0xF3, 0xFE, 0x0F, 0xFF, 0x1F, 0xF0, 0x3F, 0xF0,
  0xFF, 0x80, 0x18, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xF0, 0xFC, 0xFF, 0x80, 0x39, 0xFF,
  0x00, 0x13, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0x3F, 0xFF, 0xEF, 0xF1, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0x87,
  0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFC,
  0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xFC,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xFE,
  0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xFE,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x7E, 0x07, 0xFC, 0x1F, 0xF0, 0x7E, 0x7E,
  0x07, 0xF8, 0x1F, 0xF0, 0x7E, 0x7F, 0x07, 0xF8, 0x1F, 0xF0, 0x7E, 0x7F,
  0x0F, 0xF8, 0x0F, 0xF0, 0xFE, 0x7F, 0x0F, 0xF8, 0x0F, 0xF8, 0xFE, 0x3F,
  0x0F, 0xF0, 0x0F, 0xF8, 0xFC, 0x3F, 0x0F, 0xF0, 0x0F, 0xF8, 0xFC, 0x3F,
  0x1F, 0xF0, 0x07, 0xF8, 0xFC, 0x3F, 0x9F, 0xF0, 0x07, 0xF9, 0xFC, 0x1F,
  0x9F, 0xE0, 0x07, 0xF9, 0xFC, 0x1F, 0x9F, 0xE0, 0x07, 0xFD, 0xF8, 0x1F,
  0x9F, 0xE0, 0x03, 0xFD, 0xF8, 0x1F, 0x9F, 0xE0, 0x03, 0xFD, 0xF8, 0x1F,
  0xBF, 0xC0, 0x03, 0xFD, 0xF8, 0x1F, 0xBF, 0xC0, 0x03, 0xFD, 0xF8, 0x0F,
  0xBF, 0xC0, 0x01, 0xFD, 0xF8, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xF0, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x80, 0x3F, 0xF7,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x08, 0xFF, 0xC0, 0x00, 0x5F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF6, 0x00, 0x1F, 0xFF, 0x20,
  0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_Condensed_Bold66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 48, 17, 3, -47 },
  { 67, 24, 17, 30, 3, -47 },
  { 118, 34, 47, 36, 1, -47 },
  { 318, 27, 54, 33, 3, -50 },
  { 501, 49, 49, 54, 2, -48 },
  { 802, 39, 49, 41, 2, -48 },
  { 1041, 10, 17, 16, 3, -47 },
  { 1063, 17, 57, 21, 3, -47 },
  { 1185, 17, 57, 21, 1, -47 },
  { 1307, 28, 28, 31, 2, -50 },
  { 1405, 29, 32, 33, 2, -39 },
  { 1521, 12, 17, 17, 2, -8 },
  { 1547, 17, 8, 20, 2, -22 },
  { 1564, 11, 11, 17, 3, -10 },
  { 1580, 25, 48, 27, 1, -48 },
  { 1730, 28, 49, 33, 2, -48 },
  { 1902, 21, 47, 33, 3, -47 },
  { 2026, 28, 48, 33, 2, -48 },
  { 2194, 28, 49, 33, 2, -48 },
  { 2366, 31, 47, 33, 1, -47 },
  { 2549, 27, 48, 33, 3, -47 },
  { 2711, 29, 49, 33, 2, -48 },
  { 2889, 29, 47, 33, 2, -47 },
  { 3060, 29, 49, 33, 2, -48 },
  { 3238, 28, 49, 33, 2, -48 },
  { 3410, 11, 38, 18, 3, -37 },
  { 3463, 12, 46, 18, 2, -37 },
  { 3532, 29, 32, 33, 2, -40 },
  { 3648, 29, 20, 33, 2, -33 },
  { 3721, 29, 32, 33, 2, -40 },
  { 3837, 25, 49, 27, 0, -48 },
  { 3991, 45, 53, 51, 3, -48 },
  { 4290, 38, 47, 38, 0, -47 },
  { 4514, 30, 47, 37, 5, -47 },
  { 4691, 30, 49, 35, 3, -48 },
  { 4875, 32, 47, 40, 5, -47 },
  { 5063, 23, 47, 31, 5, -47 },
  { 5199, 23, 47, 31, 5, -47 },
  { 5335, 33, 49, 40, 3, -48 },
  { 5538, 32, 47, 42, 5, -47 },
  { 5726, 18, 47, 22, 2, -47 },
  { 5832, 18, 61, 19, -4, -47 },
  { 5970, 32, 47, 37, 5, -47 },
  { 6158, 24, 47, 30, 5, -47 },
  { 6299, 44, 47, 54, 5, -47 },
  { 6558, 35, 47, 45, 5, -47 },
  { 6764, 37, 49, 43, 3, -48 },
  { 6991, 28, 47, 35, 5, -47 },
  { 7156, 37, 59, 43, 3, -48 },
  { 7429, 32, 47, 37, 5, -47 },
  { 7617, 26, 49, 30, 2, -48 },
  { 7777, 29, 47, 31, 1, -47 },
  { 7948, 32, 48, 41, 5, -47 },
  { 8140, 36, 47, 36, 0, -47 },
  { 8352, 55, 47, 54, -1, -47 },
  { 8676, 35, 47, 35, 0, -47 },
  { 8882, 34, 47, 34, 0, -47 },
  { 9082, 28, 47, 30, 1, -47 },
  { 9247, 15, 58, 21, 4, -47 },
  { 9356, 26, 48, 27, 0, -48 },
  { 9512, 15, 58, 21, 2, -47 },
  { 9621, 32, 29, 36, 2, -47 },
  { 9737, 27, 4, 27, 0, 6 },
  { 9751, 16, 11, 22, 3, -51 },
  { 9773, 27, 38, 33, 2, -37 },
  { 9902, 29, 51, 36, 4, -50 },
  { 10087, 24, 38, 29, 3, -37 },
  { 10201, 29, 51, 36, 3, -50 },
  { 10386, 28, 38, 33, 3, -37 },
  { 10519, 23, 50, 21, 1, -50 },
  { 10663, 29, 53, 36, 3, -37 },
  { 10856, 28, 50, 36, 4, -50 },
  { 11031, 10, 50, 17, 4, -50 },
  { 11094, 15, 66, 17, -2, -50 },
  { 11218, 31, 50, 35, 4, -50 },
  { 11412, 9, 50, 17, 4, -50 },
  { 11469, 46, 37, 54, 4, -37 },
  { 11682, 28, 37, 36, 4, -37 },
  { 11812, 29, 38, 35, 3, -37 },
  { 11950, 29, 53, 36, 4, -37 },
  { 12143, 29, 53, 36, 3, -37 },
  { 12336, 20, 37, 25, 4, -37 },
  { 12429, 23, 38, 27, 2, -37 },
  { 12539, 21, 45, 24, 1, -44 },
  { 12658, 28, 37, 36, 4, -36 },
  { 12788, 32, 36, 32, 0, -36 },
  { 12932, 48, 36, 48, 0, -36 },
  { 13148, 31, 36, 31, 0, -36 },
  { 13288, 32, 52, 32, 0, -36 },
  { 13496, 23, 36, 26, 2, -36 },
  { 13600, 20, 58, 24, 1, -47 },
  { 13745, 7, 65, 31, 12, -50 },
  { 13802, 21, 58, 24, 2, -47 },
  { 13955, 29, 11, 33, 2, -29 },
};

const GFXfont NotoSans_Condensed_Bold66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_BOLD66PT7B_H_
