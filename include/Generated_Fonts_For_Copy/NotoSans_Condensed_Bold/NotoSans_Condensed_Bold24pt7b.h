#ifndef _NOTOSANS_CONDENSED_BOLD24PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x70, 0x06, 0xFF, 0x70, 0xF7, 0xFB,
  0xF9, 0xDC, 0x66, 0x33, 0x18, 0x0C, 0xC1, 0xCC, 0x1D, 0xC1, 0x9C, 0x19,
  0x8F, 0xFF, 0xFF, 0xF3, 0x98, 0x3B, 0x83, 0xB8, 0xFF, 0xEF, 0xFE, 0x33,
  0x03, 0x30, 0x73, 0x07, 0x70, 0x67, 0x00, 0x0C, 0x03, 0x03, 0xFD, 0xFE,
  0xFD, 0xBB, 0x0E, 0xC3, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x3F, 0x0D, 0xE3,
  0x7F, 0xFB, 0xFE, 0x3E, 0x03, 0x00, 0xC0, 0x7C, 0x1C, 0x3F, 0x0E, 0x0E,
  0xE3, 0x83, 0x38, 0xC0, 0xCE, 0x70, 0x33, 0x98, 0x0C, 0xEE, 0x23, 0xBB,
  0x3C, 0xFD, 0xDF, 0x9F, 0x66, 0x60, 0x19, 0x9C, 0x0E, 0x67, 0x03, 0x19,
  0xC1, 0xC6, 0x70, 0x61, 0x98, 0x38, 0x7E, 0x0C, 0x0F, 0x00, 0x3F, 0x00,
  0xFE, 0x07, 0xB8, 0x1C, 0xE0, 0x73, 0x81, 0xDE, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x3B, 0xFD, 0xEE, 0x77, 0xB8, 0xFC, 0xE3, 0xF3, 0x87, 0x8F, 0xFF,
  0x1F, 0xFE, 0x3F, 0x3C, 0xFF, 0xEE, 0x66, 0x1C, 0xE3, 0x9C, 0x71, 0xCE,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0xF0,
  0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x87,
  0x0E, 0x1C, 0x70, 0xE3, 0x8E, 0x00, 0x1C, 0x07, 0x08, 0xCB, 0xFE, 0xFF,
  0xC7, 0x83, 0xE1, 0xDC, 0x73, 0x88, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x77, 0xFE, 0xEE,
  0xFF, 0xFF, 0xC0, 0x6F, 0xF7, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x00, 0x3F, 0x1F, 0xE7, 0xFB, 0xCE, 0xE3, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xFC, 0xE7, 0xF9, 0xFC, 0x3E,
  0x00, 0x0F, 0x1F, 0x3F, 0x7F, 0xF7, 0x67, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x7F, 0x3F, 0xEF, 0xF9, 0x0F, 0x03,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x3F, 0xE7, 0x79, 0x0F, 0x03, 0xC0, 0xE0,
  0x78, 0xFC, 0x3F, 0x0F, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0xFF, 0xFB, 0xFE,
  0xFE, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0D, 0xC1, 0xDC, 0x19,
  0xC3, 0xBC, 0x33, 0xC7, 0x3C, 0x63, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x1C, 0x0F,
  0xE3, 0xFE, 0xFF, 0x80, 0xF0, 0x3C, 0x07, 0x03, 0xE0, 0xFF, 0xFB, 0xFC,
  0xFE, 0x00, 0x1F, 0x8F, 0xE7, 0xE9, 0xC0, 0xE0, 0x38, 0x0E, 0xF3, 0xFE,
  0xFF, 0xFC, 0xFE, 0x1F, 0x87, 0xE1, 0xFC, 0xF7, 0xF9, 0xFE, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x00, 0x3F, 0x1F,
  0xEF, 0x3B, 0x8F, 0xE3, 0xFC, 0xE7, 0xF8, 0xFC, 0x3F, 0x1F, 0xEF, 0x3F,
  0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFE, 0x3F, 0x00, 0x3E, 0x1F, 0xEF, 0xFB,
  0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xFF, 0xDF, 0xF3, 0xDC, 0x07, 0x03,
  0x80, 0xE7, 0xF1, 0xFC, 0x7C, 0x00, 0x7F, 0xF2, 0x00, 0x00, 0x06, 0xFF,
  0x70, 0x7F, 0xF2, 0x00, 0x00, 0x00, 0x77, 0xFE, 0xEE, 0x00, 0x40, 0x30,
  0x3C, 0x3F, 0x3F, 0x3E, 0x0F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x30, 0x0F,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x3C, 0x3F, 0x3F, 0x3F, 0x0F, 0x02, 0x00,
  0x7F, 0x7F, 0xDF, 0xE8, 0x70, 0x38, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x06,
  0x00, 0x00, 0x00, 0x40, 0xF0, 0x78, 0x1C, 0x00, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0x03, 0x87, 0x00, 0xC7, 0x1E, 0x73, 0x1F, 0x9B, 0x9C, 0xCD, 0xDC,
  0x67, 0xCE, 0x33, 0xE7, 0x39, 0xF3, 0x9C, 0xDD, 0xCE, 0x6E, 0x7F, 0xF7,
  0x1E, 0xF1, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x18, 0x0F, 0xFC, 0x01, 0xFC,
  0x00, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x77, 0x81,
  0xCE, 0x07, 0x38, 0x3C, 0xE0, 0xE3, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF9,
  0xE1, 0xE7, 0x03, 0xBC, 0x0E, 0xF0, 0x3C, 0xFF, 0x1F, 0xF3, 0xFF, 0x71,
  0xEE, 0x1D, 0xC3, 0xB8, 0xF7, 0xFC, 0xFF, 0x9C, 0xFB, 0x87, 0x70, 0xFE,
  0x1F, 0xC3, 0xBF, 0xF7, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xFC, 0xFF, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xF0, 0x4F, 0xF9, 0xFF, 0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0xFF, 0xCE,
  0x1E, 0xE1, 0xEE, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE,
  0x0E, 0xE1, 0xEE, 0x3C, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0xF1, 0xFF, 0x3F, 0xE7,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x7F,
  0x07, 0x70, 0x77, 0x87, 0x3F, 0xF3, 0xFF, 0x0F, 0xE0, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0xFF,
  0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0xBF, 0xFC,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x73, 0xFF, 0xFB, 0xC0, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x78, 0xE7,
  0x8E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7, 0x0E, 0x78, 0xE3,
  0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x37,
  0xFC, 0x77, 0xEC, 0x77, 0xEE, 0x77, 0xEE, 0x67, 0xE6, 0xE7, 0xE7, 0xE7,
  0xE7, 0xC7, 0xE7, 0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xE3, 0x87, 0xF0, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xB8, 0xFD, 0xC7, 0xE7,
  0x3F, 0x39, 0xF8, 0xEF, 0xC7, 0x7E, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F,
  0xE0, 0xF8, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1E, 0x1E, 0x70, 0x7B, 0xC0,
  0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x0E, 0x70,
  0x79, 0xE1, 0xE3, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0xFF, 0x3F, 0xEF, 0xFB,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xBF, 0xCF, 0xE3, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1E,
  0x1E, 0x70, 0x7B, 0xC0, 0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xBC, 0x0E, 0x70, 0x79, 0xE1, 0xE3, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0xFF, 0x1F, 0xF3, 0xFF, 0x71,
  0xEE, 0x3D, 0xC3, 0xB8, 0xF7, 0x3C, 0xFF, 0x9F, 0xC3, 0xBC, 0x73, 0x8E,
  0x79, 0xC7, 0x38, 0xF7, 0x0F, 0xE1, 0xE0, 0x3F, 0xBF, 0xFF, 0xFE, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xE0, 0x70, 0x3C, 0x1F, 0xFF,
  0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE3, 0xFF, 0xFB,
  0xFE, 0x3F, 0x80, 0xE0, 0x3F, 0x81, 0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x1C,
  0x78, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xEF, 0x07, 0x70, 0x3B, 0x81, 0xDC,
  0x06, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0xE0, 0xE0, 0xFE, 0x0F, 0x0E,
  0xF0, 0xF0, 0xE7, 0x1F, 0x0E, 0x71, 0xF1, 0xE7, 0x1F, 0x1E, 0x71, 0xB9,
  0xC7, 0x9B, 0x9C, 0x3B, 0xB9, 0xC3, 0xB9, 0xBC, 0x3B, 0x9B, 0x83, 0xB9,
  0xF8, 0x1B, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1E,
  0x0F, 0x00, 0xF0, 0xF3, 0xC7, 0x8E, 0x38, 0x7B, 0xC1, 0xDC, 0x0F, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x3B, 0x83, 0xDC, 0x1C,
  0xF1, 0xE3, 0x8E, 0x1E, 0xF0, 0x78, 0xF0, 0x77, 0x0F, 0x78, 0xE3, 0x8E,
  0x39, 0xC3, 0xDC, 0x1F, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xCF, 0xF9, 0xFF,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xFC,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0xFF, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFF, 0x80,
  0x0E, 0x01, 0xC0, 0x7C, 0x0F, 0x83, 0xB8, 0x77, 0x1C, 0x63, 0x8E, 0xE0,
  0xDC, 0x1F, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0xF1, 0xE1, 0xC0, 0x7F, 0x1F,
  0xE2, 0x38, 0x0F, 0x03, 0xCF, 0xF7, 0xFF, 0xCF, 0xE3, 0xF8, 0xFF, 0x7F,
  0xF7, 0x7D, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xEF, 0x3F,
  0xF7, 0xFE, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F,
  0xFE, 0xFF, 0xDC, 0xF0, 0x3F, 0xBF, 0xDE, 0xDE, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x78, 0x1F, 0xEF, 0xF3, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x7B, 0xDF, 0xFB, 0xFF, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xFC, 0x7B, 0xFF, 0x7F, 0xE7, 0x9C, 0x3F, 0x1F, 0xE7, 0x3F,
  0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x99, 0xFE, 0x1F,
  0x80, 0x1F, 0x9F, 0x8F, 0x47, 0x03, 0x83, 0xFB, 0xFC, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x3C, 0xEF,
  0xFD, 0xFF, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3D,
  0xFF, 0xBF, 0xF3, 0xDE, 0x03, 0x80, 0x72, 0x1E, 0x7F, 0xCF, 0xF0, 0xF8,
  0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF, 0x3F, 0xF7, 0xFE,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3C, 0x7F, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0xF1, 0xC0, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3F, 0xEF, 0xB8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC7, 0xB8, 0xE7, 0x38, 0xEF, 0x1D, 0xC3, 0xF0, 0x7F, 0x0F, 0xE1, 0xCE,
  0x39, 0xE7, 0x1C, 0xE3, 0xDC, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0x9F, 0x77, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x7F,
  0x1E, 0x3F, 0x8E, 0x1F, 0xC7, 0x0F, 0xE3, 0x87, 0xF1, 0xC3, 0xF8, 0xE1,
  0xFC, 0x70, 0xFE, 0x38, 0x7F, 0x1C, 0x38, 0xEF, 0x9D, 0xFB, 0xFF, 0x78,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1E, 0x3F, 0x0F, 0xF1, 0xEF, 0x78, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFE, 0x39, 0xFF, 0x3F, 0xC1, 0xF0, 0xE7, 0x9F, 0xFB, 0xEF, 0x78,
  0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xFF, 0x7F, 0xEF,
  0x79, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0xEF,
  0xFD, 0xEF, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3D,
  0xFF, 0xBF, 0xF3, 0xDE, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xE7, 0xEF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x7F, 0xFF, 0xE2, 0xE0, 0xF0, 0xFC, 0x7E, 0x1F, 0x07, 0x87,
  0xFF, 0xFF, 0xFE, 0x18, 0x38, 0x38, 0x7F, 0xFF, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3D, 0xFF, 0xBF, 0x73,
  0xEE, 0xF0, 0xF7, 0x0E, 0x71, 0xE7, 0x1C, 0x79, 0xC3, 0x9C, 0x3B, 0xC3,
  0xB8, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xE3, 0xB8,
  0xF1, 0xDC, 0xF8, 0xEE, 0x7C, 0xF7, 0x37, 0x73, 0xDB, 0xB8, 0xEC, 0xDC,
  0x7E, 0x6E, 0x3F, 0x3E, 0x1F, 0x1F, 0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE1,
  0xC0, 0xF1, 0xEF, 0x38, 0xEF, 0x1D, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x3F, 0x87, 0x71, 0xEF, 0x38, 0xEF, 0x1E, 0xF0, 0xF7, 0x0E, 0x71, 0xE7,
  0x1C, 0x39, 0xC3, 0x9C, 0x3B, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0x0E, 0x1E, 0x1C, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0F, 0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF0,
  0xFC, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x1F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE1, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x7C, 0x39, 0xF3, 0x87, 0x0E, 0x1C, 0x38, 0x73, 0xE7,
  0x8E, 0x00, 0xFC, 0x7F, 0xF8, 0xFE, 0x04,
};

const GFXglyph NotoSans_Condensed_Bold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 9, 6, 11, 1, -17 },
  { 17, 12, 17, 13, 1, -17 },
  { 43, 10, 19, 12, 1, -18 },
  { 67, 18, 17, 19, 1, -17 },
  { 106, 14, 17, 15, 1, -17 },
  { 136, 4, 6, 6, 1, -17 },
  { 139, 6, 21, 8, 1, -17 },
  { 155, 7, 21, 8, 0, -17 },
  { 174, 10, 10, 11, 1, -18 },
  { 187, 10, 11, 12, 1, -14 },
  { 201, 4, 6, 6, 1, -3 },
  { 204, 6, 3, 7, 1, -8 },
  { 207, 4, 4, 6, 1, -4 },
  { 209, 10, 17, 10, 0, -17 },
  { 231, 10, 17, 12, 1, -17 },
  { 253, 8, 17, 12, 1, -17 },
  { 270, 10, 17, 12, 1, -17 },
  { 292, 10, 17, 12, 1, -17 },
  { 314, 12, 17, 12, 0, -17 },
  { 340, 10, 17, 12, 1, -17 },
  { 362, 10, 17, 12, 1, -17 },
  { 384, 10, 17, 12, 1, -17 },
  { 406, 10, 17, 12, 1, -17 },
  { 428, 10, 17, 12, 1, -17 },
  { 450, 4, 13, 6, 1, -13 },
  { 457, 4, 16, 6, 1, -13 },
  { 465, 10, 12, 12, 1, -15 },
  { 480, 10, 7, 12, 1, -12 },
  { 489, 10, 12, 12, 1, -15 },
  { 504, 9, 17, 10, 0, -17 },
  { 524, 17, 19, 19, 1, -17 },
  { 565, 14, 17, 14, 0, -17 },
  { 595, 11, 17, 14, 2, -17 },
  { 619, 11, 17, 13, 1, -17 },
  { 643, 12, 17, 15, 2, -17 },
  { 669, 8, 17, 11, 2, -17 },
  { 686, 8, 17, 11, 2, -17 },
  { 703, 12, 17, 15, 1, -17 },
  { 729, 12, 17, 15, 2, -17 },
  { 755, 6, 17, 8, 1, -17 },
  { 768, 6, 22, 7, -1, -17 },
  { 785, 12, 17, 13, 2, -17 },
  { 811, 8, 17, 11, 2, -17 },
  { 828, 16, 17, 20, 2, -17 },
  { 862, 13, 17, 16, 2, -17 },
  { 890, 14, 17, 16, 1, -17 },
  { 920, 10, 17, 13, 2, -17 },
  { 942, 14, 21, 16, 1, -17 },
  { 979, 11, 17, 13, 2, -17 },
  { 1003, 9, 17, 11, 1, -17 },
  { 1023, 11, 17, 11, 0, -17 },
  { 1047, 11, 17, 15, 2, -17 },
  { 1071, 13, 17, 13, 0, -17 },
  { 1099, 20, 17, 19, 0, -17 },
  { 1142, 13, 17, 13, 0, -17 },
  { 1170, 12, 17, 12, 0, -17 },
  { 1196, 11, 17, 11, 0, -17 },
  { 1220, 6, 21, 8, 1, -17 },
  { 1236, 10, 17, 10, 0, -17 },
  { 1258, 5, 21, 8, 1, -17 },
  { 1272, 11, 11, 13, 1, -17 },
  { 1288, 10, 2, 10, 0, 2 },
  { 1291, 6, 3, 8, 1, -18 },
  { 1294, 10, 13, 12, 1, -13 },
  { 1311, 11, 18, 13, 1, -18 },
  { 1336, 9, 13, 10, 1, -13 },
  { 1351, 11, 18, 13, 1, -18 },
  { 1376, 10, 13, 12, 1, -13 },
  { 1393, 9, 18, 8, 0, -18 },
  { 1414, 11, 19, 13, 1, -13 },
  { 1441, 11, 18, 13, 1, -18 },
  { 1466, 4, 18, 6, 1, -18 },
  { 1475, 6, 24, 6, -1, -18 },
  { 1493, 11, 18, 13, 2, -18 },
  { 1518, 4, 18, 6, 1, -18 },
  { 1527, 17, 13, 20, 1, -13 },
  { 1555, 11, 13, 13, 1, -13 },
  { 1573, 11, 13, 13, 1, -13 },
  { 1591, 11, 19, 13, 1, -13 },
  { 1618, 11, 19, 13, 1, -13 },
  { 1645, 8, 13, 9, 1, -13 },
  { 1658, 8, 13, 10, 1, -13 },
  { 1671, 8, 16, 9, 0, -16 },
  { 1687, 11, 13, 13, 1, -13 },
  { 1705, 12, 13, 12, 0, -13 },
  { 1725, 17, 13, 18, 0, -13 },
  { 1753, 11, 13, 11, 0, -13 },
  { 1771, 12, 19, 12, 0, -13 },
  { 1800, 8, 13, 10, 1, -13 },
  { 1813, 8, 21, 9, 0, -17 },
  { 1834, 3, 24, 11, 4, -18 },
  { 1843, 7, 21, 9, 1, -17 },
  { 1862, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_Bold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_BOLD24PT7B_H_
