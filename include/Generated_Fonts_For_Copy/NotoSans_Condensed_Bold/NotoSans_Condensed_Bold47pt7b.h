#ifndef _NOTOSANS_CONDENSED_BOLD47PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08,
  0xFE, 0x3F, 0xFF, 0x1F, 0xDF, 0x8F, 0xEF, 0xC7, 0xF7, 0xE1, 0xFB, 0xF0,
  0xFD, 0xF8, 0x7E, 0xFC, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0,
  0xF8, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1,
  0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xE1, 0xF0, 0x01, 0xE1, 0xE0, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xE3,
  0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xC7,
  0xC0, 0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x8F, 0x80, 0x0F, 0x8F,
  0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x1F, 0xFF,
  0x8F, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xEC, 0x7B, 0xF9, 0x82,
  0x7E, 0x30, 0x0F, 0xC6, 0x01, 0xFC, 0xC0, 0x1F, 0xD8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0x7F, 0x00, 0x67, 0xE0, 0x0C, 0xFE,
  0x01, 0x9F, 0xF0, 0x33, 0xFF, 0xC6, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x01,
  0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x3C,
  0x00, 0x7E, 0xFC, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x7C, 0x00, 0x7C, 0x7C,
  0x0F, 0x80, 0x07, 0xC7, 0xC0, 0xF8, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xE3, 0xE0,
  0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xC7, 0xC1, 0xC0, 0x7C, 0x7C,
  0x7C, 0x7F, 0x07, 0xC7, 0xCF, 0x8F, 0xF8, 0x7E, 0xFC, 0xF9, 0xFF, 0xC3,
  0xFF, 0x9F, 0x1F, 0xFE, 0x3F, 0xF9, 0xF3, 0xE3, 0xE1, 0xFF, 0x1E, 0x3E,
  0x3E, 0x07, 0xC3, 0xE3, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x07,
  0xC3, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE1, 0xF0,
  0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x3E,
  0x3E, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0x3F, 0x3E, 0x00, 0x3E,
  0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0x80,
  0x0F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x0F, 0xE1, 0xFF, 0xC0, 0xFE, 0x3F, 0xFE, 0x0F, 0xC3, 0xFF,
  0xF1, 0xFC, 0x7F, 0x3F, 0x9F, 0xC7, 0xF1, 0xFD, 0xF8, 0xFE, 0x1F, 0xFF,
  0x8F, 0xE0, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0x0F, 0xE0, 0x3F, 0xF0, 0xFE,
  0x03, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x87, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x9F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xF9,
  0xF3, 0xE7, 0xC0, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F,
  0x03, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x04, 0x0F, 0x02, 0x78, 0xF1,
  0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x3F,
  0x8F, 0xC1, 0xF0, 0xF8, 0x0F, 0x07, 0x00, 0x20, 0x40, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3,
  0xF1, 0xF9, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x08, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF,
  0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFE, 0x07,
  0xEF, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC, 0x7F, 0x1F, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFF, 0xFE, 0xFD, 0xF9, 0xF9, 0xE3, 0xF1, 0x87, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3E, 0x0F, 0xE1, 0x80, 0x7F, 0x10,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8C, 0x07, 0xF9, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xCF,
  0xC0, 0x1F, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0,
  0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0,
  0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x83, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFE, 0x70,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0xC1, 0xFB, 0xFF, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xC1, 0xFD, 0xFE, 0x07,
  0xEF, 0xE0, 0x3F, 0xFF, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E,
  0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0xC0, 0xFC, 0x7E, 0x0F, 0xE3, 0xF8, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xC7, 0xF9,
  0xFC, 0x1F, 0xCF, 0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC1,
  0xFC, 0x7F, 0x0F, 0xC3, 0xFC, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xF8, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xF0, 0x7F,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFC, 0x3F, 0x8F, 0xC0, 0xFE, 0x7E,
  0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xE0, 0xFF, 0x7F, 0x0F, 0xFB, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFB, 0xE1, 0xFF, 0xBF, 0x03, 0xF9, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x7E, 0x7F, 0xFF,
  0x7F, 0x7F, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x08, 0x3E,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3,
  0x81, 0xFC, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x01, 0xFE, 0x1F, 0x0F, 0x83,
  0xFF, 0xC7, 0xCF, 0x83, 0xFF, 0xE3, 0xE7, 0xC3, 0xFF, 0xF1, 0xF3, 0xE1,
  0xF0, 0xF8, 0x79, 0xE1, 0xF0, 0x7C, 0x3D, 0xF0, 0xF8, 0x3E, 0x1E, 0xF8,
  0x78, 0x1F, 0x0F, 0xFC, 0x7C, 0x0F, 0x87, 0xBE, 0x3E, 0x07, 0x83, 0xDF,
  0x1F, 0x07, 0xC1, 0xEF, 0x8F, 0x83, 0xE0, 0xF7, 0xC7, 0xC1, 0xF0, 0xFB,
  0xE3, 0xE0, 0xF8, 0x7D, 0xF0, 0xF8, 0x7C, 0x3C, 0xF8, 0x7E, 0xFF, 0x3E,
  0x7C, 0x3F, 0xFF, 0xFE, 0x1F, 0x0F, 0xF9, 0xFF, 0x0F, 0x83, 0xF8, 0x7F,
  0x07, 0xE0, 0x78, 0x0C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0x80, 0x03, 0xFE, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F,
  0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE,
  0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x07,
  0xF3, 0xF8, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0x83, 0xFE, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x1F, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFE, 0x03, 0x0F, 0xF0, 0x04, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x06, 0x1F, 0xF8, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x1F, 0xF0, 0x0C, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0x7E, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x7F, 0x1F, 0xF0, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8,
  0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xE7, 0xFF, 0x3F,
  0xE0, 0xFC, 0x00, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x0F, 0xE7,
  0xE0, 0x3F, 0xCF, 0xC0, 0x7F, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF8, 0x7E,
  0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xF8, 0xFF, 0x03, 0xF1, 0xFC, 0x07, 0xE7,
  0xF8, 0x0F, 0xCF, 0xE0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x87, 0xE0, 0x7F, 0x0F,
  0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xFE, 0x7E, 0x01, 0xFC, 0xFC,
  0x03, 0xFD, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF7, 0xC0, 0x3F, 0xFF, 0xEF, 0x80, 0x7D,
  0xFF, 0xDF, 0x80, 0xFB, 0xFF, 0xBF, 0x01, 0xF7, 0xFF, 0x3E, 0x07, 0xEF,
  0xFF, 0x7C, 0x0F, 0x9F, 0xFE, 0xFC, 0x1F, 0x3F, 0xFC, 0xF8, 0x7E, 0x7F,
  0xF9, 0xF0, 0xF8, 0xFF, 0xF3, 0xE1, 0xF1, 0xFF, 0xE7, 0xE3, 0xE3, 0xFF,
  0xC7, 0xCF, 0xC7, 0xFF, 0x8F, 0x9F, 0x0F, 0xFF, 0x1F, 0xBE, 0x1F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0xF0,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0x83,
  0xFC, 0x0F, 0xFF, 0x07, 0xF8, 0x1F, 0xFE, 0x07, 0xE0, 0x3F, 0xFC, 0x0F,
  0xC0, 0x7F, 0xF8, 0x1F, 0x80, 0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFE, 0xFC, 0x07, 0xFF, 0x7F, 0x03, 0xFF, 0x9F, 0x81, 0xFF, 0xCF,
  0xE0, 0xFF, 0xE3, 0xF0, 0x7F, 0xF1, 0xFC, 0x3F, 0xFC, 0x7E, 0x1F, 0xFE,
  0x3F, 0x8F, 0xFF, 0x1F, 0xC7, 0xFF, 0x87, 0xF3, 0xFF, 0xC3, 0xF9, 0xFF,
  0xE0, 0xFE, 0xFF, 0xF0, 0x7F, 0x7F, 0xF8, 0x1F, 0xBF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0x9F, 0xC0,
  0x0F, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xDF, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFF, 0x01, 0xFE,
  0x1F, 0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x7F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x7F,
  0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x03,
  0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F,
  0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x1F, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFE, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF,
  0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xF0, 0x7B, 0xF8, 0x04, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7,
  0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xE3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x01,
  0xF7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x03, 0xF7, 0xF0,
  0x07, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0xC0,
  0x3F, 0x9F, 0x80, 0x7F, 0x80, 0x7E, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x7F,
  0x03, 0xFF, 0x03, 0xF8, 0x7E, 0x07, 0xFE, 0x07, 0xF0, 0xFC, 0x0F, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0xF8, 0x3F, 0x07,
  0xF0, 0xFD, 0xF0, 0xFE, 0x07, 0xE1, 0xF3, 0xE1, 0xFC, 0x0F, 0xC3, 0xE7,
  0xC3, 0xF0, 0x1F, 0x87, 0xCF, 0x87, 0xE0, 0x3F, 0x1F, 0x9F, 0x8F, 0xC0,
  0x7F, 0x3F, 0x1F, 0x3F, 0x80, 0x7E, 0x7C, 0x3E, 0x7F, 0x00, 0xFC, 0xF8,
  0x7C, 0xFC, 0x01, 0xF9, 0xF0, 0xF9, 0xF8, 0x03, 0xF7, 0xE1, 0xFB, 0xF0,
  0x03, 0xEF, 0xC1, 0xF7, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xFB,
  0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0,
  0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x1F,
  0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xF7, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x80, 0x1F, 0x9F, 0x00, 0x3E,
  0x3F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0x80,
  0xFC, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x03,
  0xEF, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x03,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xE0, 0xFF, 0x08, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xC3,
  0xF7, 0xF0, 0x3F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0,
  0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x3F,
  0xF1, 0xF0, 0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0x81, 0xF9, 0xFF, 0x0F,
  0xDF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xF3, 0xFC, 0xFF, 0x07,
  0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0xFD, 0xFC, 0x07, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xFC,
  0x3F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3E, 0x7F, 0xE1,
  0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xF3, 0xFC, 0x39, 0xFC, 0x04, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x17, 0xF8, 0x3B,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0xE7, 0xF1, 0xFF, 0xBF, 0x9F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xF3, 0xFF, 0x7F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xBF, 0x83, 0xFD, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xEF, 0xC7, 0xFE, 0x7E, 0x1F, 0xE3, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0,
  0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x7F, 0xCF, 0xC7, 0xFE, 0x7E, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xC7, 0xFD, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0xFC, 0x0F, 0xF7, 0xF0, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFB, 0xF8, 0x7F, 0x9F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF9, 0x00, 0x1F,
  0xCF, 0x03, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x0F, 0xCF, 0xF8, 0xFD,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFD, 0xFE, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x39,
  0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x03, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0, 0x01, 0xC0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE8, 0xFE, 0xFF, 0xEF,
  0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F,
  0xBF, 0x00, 0xFE, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F,
  0x00, 0xFD, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xF3, 0xF0, 0x3F, 0x8F, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8, 0xFC, 0x07,
  0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0x03, 0xF8, 0x7C, 0x7F, 0xC3, 0xFE, 0x3E, 0x7F, 0xF3, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0xFF, 0xF7,
  0xFB, 0xFC, 0x3F, 0xE1, 0xFD, 0xFC, 0x0F, 0xE0, 0x7E, 0xFE, 0x07, 0xF0,
  0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0x80, 0xFC,
  0x07, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF0, 0x1F,
  0x80, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xFC, 0x07, 0xE0, 0x3F, 0xFE, 0x03,
  0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xC0,
  0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xF8,
  0x0F, 0xC0, 0x7F, 0xFC, 0x07, 0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0xF8, 0x7F, 0x0F, 0x8F, 0xF8, 0xF9, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFD, 0xFE, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF9, 0xFC, 0x1F, 0xDF,
  0xC0, 0x7E, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xF8, 0x7E, 0x07, 0xC7, 0xFC, 0x3F, 0x7F, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7F, 0xC7, 0xF3, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xF0,
  0x1F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xF0, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xBF, 0xF8, 0xFC, 0xFF, 0x87, 0xE3, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x7F, 0xCF, 0xC7, 0xFE, 0x7E,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xCF, 0xFD, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0xFF, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFB, 0xF8, 0x7F, 0x9F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x0C, 0xFC, 0x04, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x84, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xBF, 0x3F, 0xF3, 0xF1, 0xFE, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xDF, 0x81, 0xFE, 0x03, 0xF7,
  0xE0, 0x7F, 0x81, 0xFD, 0xF8, 0x1F, 0xE0, 0x7E, 0x7F, 0x07, 0xFC, 0x1F,
  0x8F, 0xC1, 0xFF, 0x07, 0xE3, 0xF0, 0xFF, 0xC3, 0xF8, 0xFC, 0x3E, 0xF0,
  0xFC, 0x3F, 0x0F, 0xBC, 0x3F, 0x0F, 0xE3, 0xCF, 0x8F, 0xC1, 0xF8, 0xF3,
  0xE3, 0xF0, 0x7E, 0x7C, 0xF9, 0xF8, 0x1F, 0x9F, 0x1E, 0x7E, 0x07, 0xE7,
  0xC7, 0x9F, 0x80, 0xFD, 0xE1, 0xE7, 0xE0, 0x3F, 0x78, 0x7D, 0xF0, 0x0F,
  0xDE, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xE3,
  0xF0, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7F, 0x3F, 0x80, 0xFC,
  0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xF3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC0, 0xFE,
  0x7F, 0x03, 0xFB, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF9,
  0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF9, 0xFC, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x23,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0C, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x0F, 0xFC, 0x3F, 0xE0,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0xC1, 0xFF,
  0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFA, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_Condensed_Bold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 35, 12, 2, -34 },
  { 36, 17, 13, 21, 2, -34 },
  { 64, 24, 34, 26, 1, -34 },
  { 166, 19, 39, 23, 2, -36 },
  { 259, 36, 34, 38, 1, -34 },
  { 412, 28, 34, 29, 1, -34 },
  { 531, 7, 13, 11, 2, -34 },
  { 543, 12, 41, 15, 2, -34 },
  { 605, 12, 41, 15, 1, -34 },
  { 667, 20, 20, 22, 1, -36 },
  { 717, 20, 23, 23, 2, -28 },
  { 775, 9, 11, 12, 1, -5 },
  { 788, 12, 6, 15, 1, -16 },
  { 797, 8, 8, 12, 2, -7 },
  { 805, 19, 34, 19, 0, -34 },
  { 886, 20, 34, 23, 2, -34 },
  { 971, 15, 34, 23, 2, -34 },
  { 1035, 20, 34, 23, 1, -34 },
  { 1120, 19, 34, 23, 2, -34 },
  { 1201, 22, 34, 23, 1, -34 },
  { 1295, 19, 34, 23, 2, -34 },
  { 1376, 21, 34, 23, 1, -34 },
  { 1466, 21, 34, 23, 1, -34 },
  { 1556, 21, 34, 23, 1, -34 },
  { 1646, 21, 34, 23, 1, -34 },
  { 1736, 8, 27, 13, 2, -26 },
  { 1763, 8, 32, 13, 2, -26 },
  { 1795, 21, 23, 23, 1, -28 },
  { 1856, 21, 15, 23, 1, -24 },
  { 1896, 20, 23, 23, 2, -28 },
  { 1954, 18, 35, 19, 0, -34 },
  { 2033, 33, 38, 36, 2, -34 },
  { 2190, 27, 34, 27, 0, -34 },
  { 2305, 22, 34, 27, 3, -34 },
  { 2399, 22, 34, 25, 2, -34 },
  { 2493, 24, 34, 29, 3, -34 },
  { 2595, 16, 34, 22, 4, -34 },
  { 2663, 16, 34, 22, 4, -34 },
  { 2731, 24, 34, 29, 2, -34 },
  { 2833, 23, 34, 30, 4, -34 },
  { 2931, 14, 34, 16, 1, -34 },
  { 2991, 13, 44, 14, -3, -34 },
  { 3063, 23, 34, 26, 4, -34 },
  { 3161, 17, 34, 21, 3, -34 },
  { 3234, 31, 34, 39, 4, -34 },
  { 3366, 25, 34, 32, 4, -34 },
  { 3473, 26, 34, 31, 2, -34 },
  { 3584, 20, 34, 25, 3, -34 },
  { 3669, 26, 42, 31, 2, -34 },
  { 3806, 23, 34, 26, 3, -34 },
  { 3904, 18, 34, 22, 2, -34 },
  { 3981, 21, 34, 22, 1, -34 },
  { 4071, 23, 34, 29, 3, -34 },
  { 4169, 26, 34, 26, 0, -34 },
  { 4280, 39, 34, 38, 0, -34 },
  { 4446, 25, 34, 25, 0, -34 },
  { 4553, 24, 34, 24, 0, -34 },
  { 4655, 20, 34, 22, 1, -34 },
  { 4740, 11, 41, 15, 3, -34 },
  { 4797, 19, 34, 19, 0, -34 },
  { 4878, 11, 41, 15, 1, -34 },
  { 4935, 23, 21, 26, 1, -34 },
  { 4996, 19, 3, 19, 0, 4 },
  { 5004, 11, 8, 15, 2, -36 },
  { 5015, 20, 26, 24, 1, -26 },
  { 5080, 21, 36, 25, 3, -36 },
  { 5175, 17, 26, 20, 2, -26 },
  { 5231, 21, 36, 25, 2, -36 },
  { 5326, 20, 26, 23, 2, -26 },
  { 5391, 16, 36, 15, 1, -36 },
  { 5463, 21, 37, 25, 2, -26 },
  { 5561, 20, 36, 26, 3, -36 },
  { 5651, 7, 36, 12, 3, -36 },
  { 5683, 12, 47, 12, -2, -36 },
  { 5754, 22, 36, 25, 3, -36 },
  { 5853, 6, 36, 12, 3, -36 },
  { 5880, 33, 26, 38, 3, -26 },
  { 5988, 20, 26, 26, 3, -26 },
  { 6053, 21, 26, 25, 2, -26 },
  { 6122, 21, 37, 25, 3, -26 },
  { 6220, 21, 37, 25, 2, -26 },
  { 6318, 14, 26, 18, 3, -26 },
  { 6364, 16, 26, 19, 2, -26 },
  { 6416, 15, 31, 17, 1, -31 },
  { 6475, 20, 26, 26, 3, -26 },
  { 6540, 23, 26, 23, 0, -26 },
  { 6615, 34, 26, 34, 0, -26 },
  { 6726, 22, 26, 22, 0, -26 },
  { 6798, 23, 37, 23, 0, -26 },
  { 6905, 17, 26, 19, 1, -26 },
  { 6961, 14, 41, 17, 1, -34 },
  { 7033, 6, 47, 22, 8, -36 },
  { 7069, 14, 41, 17, 2, -34 },
  { 7141, 21, 7, 23, 1, -20 },
};

const GFXfont NotoSans_Condensed_Bold47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_BOLD47PT7B_H_
