#ifndef _NOTOSANS_CONDENSED_BOLD18PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xC3, 0x7E, 0xCF, 0x3C, 0xF3, 0xCC, 0x19, 0x06,
  0xC1, 0xB0, 0x6C, 0x7F, 0xC4, 0xC1, 0x20, 0xD8, 0xFF, 0x8D, 0x83, 0x60,
  0xD8, 0x24, 0x00, 0x10, 0x21, 0xFF, 0xFD, 0x1A, 0x3C, 0x1E, 0x1E, 0x2E,
  0x5F, 0xFF, 0xC2, 0x04, 0x00, 0x70, 0xC7, 0x84, 0x36, 0x61, 0x33, 0x09,
  0xB0, 0x6D, 0xBB, 0xFB, 0xEE, 0xDB, 0x0C, 0xD8, 0x66, 0xC2, 0x36, 0x31,
  0xF1, 0x87, 0x00, 0x1E, 0x07, 0xE1, 0xDC, 0x3B, 0x83, 0x60, 0x7C, 0x0F,
  0x3B, 0xF6, 0x67, 0xDC, 0xF9, 0x8E, 0x3F, 0xE3, 0xEE, 0xFF, 0xC0, 0x33,
  0x66, 0xCC, 0xCC, 0xCC, 0xCC, 0x66, 0x33, 0xE3, 0x0C, 0x63, 0x8C, 0x63,
  0x18, 0xC6, 0x73, 0x19, 0x9C, 0x18, 0x18, 0x59, 0x7F, 0xBC, 0x3C, 0x76,
  0x24, 0x30, 0x60, 0xC1, 0x8F, 0xFF, 0xCC, 0x18, 0x30, 0xFB, 0x60, 0xFF,
  0xC0, 0xDF, 0x80, 0x06, 0x1C, 0x30, 0x61, 0xC3, 0x06, 0x18, 0x30, 0xE1,
  0x83, 0x0E, 0x00, 0x78, 0xFB, 0xBE, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0xBB, 0xE7, 0xC0, 0x1C, 0xF7, 0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x79, 0xFB, 0x38, 0x70, 0xE1, 0xC7, 0x0C, 0x30, 0xE3, 0x87, 0xFF,
  0xE0, 0x79, 0xFE, 0x38, 0x70, 0xEF, 0x9E, 0x0F, 0x0E, 0x0E, 0x3F, 0xFF,
  0xC0, 0x06, 0x07, 0x03, 0x83, 0xC1, 0x61, 0xB1, 0x98, 0xCC, 0xFF, 0xFF,
  0xC1, 0x80, 0xC0, 0x60, 0xFD, 0xFB, 0x87, 0x0C, 0x1F, 0xBF, 0x87, 0x06,
  0x0E, 0x3F, 0xEF, 0x80, 0x1E, 0xFD, 0x86, 0x0C, 0x1F, 0xBF, 0xE3, 0xC7,
  0x8F, 0x9B, 0xF7, 0xC0, 0xFF, 0xFF, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C,
  0x1C, 0x1C, 0x18, 0x38, 0x30, 0x7D, 0xFF, 0x3E, 0x3E, 0xEF, 0x9E, 0x7F,
  0xC7, 0x8F, 0x1F, 0xF7, 0xC0, 0x3C, 0x7E, 0x67, 0x63, 0xE3, 0x63, 0x7F,
  0x7F, 0x13, 0x03, 0x06, 0x7E, 0x7C, 0xFF, 0x80, 0x06, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0x60, 0x02, 0x0C, 0x7B, 0xCC, 0x1E, 0x0F, 0x87, 0x02, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x81, 0x83, 0xC1, 0xE0, 0x63, 0xFE, 0x70, 0x80,
  0x7D, 0xFD, 0x38, 0x30, 0xE3, 0x8E, 0x18, 0x30, 0x00, 0xC1, 0xC3, 0x00,
  0x0F, 0x83, 0xFC, 0x70, 0x66, 0x73, 0xCF, 0xBD, 0x9B, 0xD9, 0xBD, 0x9B,
  0xD9, 0xBD, 0xFF, 0xCE, 0xE6, 0x00, 0x70, 0xC3, 0xFC, 0x1E, 0x07, 0x81,
  0xE0, 0x7C, 0x3B, 0x0C, 0xC3, 0x38, 0xCE, 0x7F, 0x9F, 0xE6, 0x1F, 0x87,
  0xE0, 0xC0, 0xFC, 0xFF, 0xE7, 0xE3, 0xE7, 0xFE, 0xFE, 0xE7, 0xE3, 0xE3,
  0xE7, 0xFF, 0xFE, 0x1F, 0x7F, 0x71, 0xE0, 0xE0, 0xE0, 0xC0, 0xE0, 0xE0,
  0xE0, 0x71, 0x7F, 0x3F, 0xFC, 0x7F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F, 0x87,
  0xC7, 0xE3, 0xF1, 0xF9, 0xDF, 0xEF, 0xC0, 0xFF, 0xFF, 0x87, 0x0E, 0x1F,
  0xBF, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C,
  0x3F, 0x7E, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x1F, 0x1F, 0xDC, 0x5C, 0x0E,
  0x07, 0x03, 0xBF, 0xDF, 0xE3, 0xF1, 0xDC, 0xEF, 0xF3, 0xF8, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x18, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1E, 0xFC, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFE, 0xE0, 0xE3, 0xF1,
  0xB9, 0xDD, 0xCE, 0xC7, 0xE3, 0xF1, 0xF8, 0xEE, 0x73, 0x39, 0xDC, 0x6E,
  0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF,
  0xE0, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x9B, 0xFD, 0xBE,
  0xDB, 0xED, 0xBE, 0xF3, 0xE7, 0x3E, 0x73, 0xE6, 0x30, 0xF0, 0xFC, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFF, 0x3E, 0xCF, 0xBB, 0xE6, 0xF9, 0xFE, 0x3F, 0x8F,
  0xE1, 0xC0, 0x3E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x87,
  0xE1, 0xF8, 0x77, 0x39, 0xFE, 0x3F, 0x00, 0xFC, 0xFE, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3E, 0x1F, 0xE7, 0x3B,
  0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x39, 0xFE, 0x3F,
  0x01, 0xC0, 0x38, 0x0F, 0xFC, 0x7F, 0x39, 0xDC, 0xEE, 0x77, 0x3B, 0xF9,
  0xF8, 0xEE, 0x77, 0x39, 0xDC, 0xEE, 0x38, 0x7D, 0xFF, 0x96, 0x0E, 0x1E,
  0x1E, 0x1E, 0x0E, 0x1E, 0x3F, 0xEF, 0x80, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xEF, 0xE3, 0xE0, 0xE1,
  0xF8, 0x66, 0x19, 0x86, 0x73, 0x9C, 0xC3, 0x30, 0xCC, 0x3F, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x00, 0xC3, 0x0F, 0xC7, 0x1B, 0x8E, 0x33, 0x3C, 0x66,
  0x79, 0xCC, 0xDB, 0x9D, 0xB6, 0x3B, 0x6C, 0x3C, 0xD8, 0x79, 0xB0, 0xF1,
  0xE1, 0xE3, 0x81, 0xC7, 0x00, 0xE3, 0x9C, 0xE7, 0x30, 0xDC, 0x3E, 0x07,
  0x81, 0xC0, 0x78, 0x3E, 0x0D, 0xC7, 0x31, 0x8E, 0xE1, 0xC0, 0xE1, 0xB1,
  0xDC, 0xCE, 0xE3, 0x61, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xFF, 0xFF, 0x07, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60,
  0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xE0, 0xC1,
  0x83, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x70, 0x60, 0xFF, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF, 0x0C, 0x06, 0x07, 0x83,
  0xC3, 0x71, 0x99, 0x8F, 0xC3, 0xFE, 0xE6, 0x30, 0xFC, 0xFD, 0x38, 0x37,
  0xFC, 0xF1, 0xE7, 0xFF, 0xEC, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xDE, 0x3D, 0xFE, 0x70, 0xC3, 0x0C,
  0x39, 0xFD, 0xF0, 0x07, 0x07, 0x07, 0x07, 0x77, 0xFF, 0xE7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xE7, 0xFF, 0x7B, 0x3C, 0xFF, 0x9E, 0x3F, 0xFF, 0xF0, 0x70,
  0x7E, 0xFC, 0x1E, 0x79, 0xD3, 0x87, 0xDF, 0x9C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x00, 0x77, 0xFF, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF,
  0x7F, 0x07, 0x06, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x5F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x11, 0xCC, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xF7,
  0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x77, 0x33, 0xB9, 0xF8, 0xF8, 0x7E,
  0x3B, 0x1D, 0xCE, 0x77, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xDE,
  0xF7, 0xFF, 0xB9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7,
  0xE7, 0x3F, 0x39, 0xC0, 0xDE, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x3C, 0x7E, 0xE6, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6, 0x7E, 0x3C,
  0xDC, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xFE, 0xE0, 0xE0,
  0xE0, 0xE0, 0x77, 0xFF, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7F,
  0x07, 0x07, 0x07, 0x07, 0xDF, 0x6F, 0xB8, 0xE3, 0x8E, 0x38, 0xE3, 0x80,
  0x7B, 0xFC, 0x78, 0xF1, 0xE1, 0xE7, 0xFF, 0xE0, 0x30, 0xC7, 0xFF, 0x71,
  0xC7, 0x1C, 0x71, 0xC3, 0xCF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFF, 0x7B, 0xE3, 0xF1, 0x99, 0xCC, 0xE7, 0x61, 0xB0, 0xF8, 0x78,
  0x1C, 0x0E, 0x00, 0xE7, 0x1F, 0x39, 0xD9, 0xCC, 0xCB, 0x67, 0xDB, 0x3E,
  0xD8, 0xF7, 0xC7, 0x9C, 0x38, 0xE1, 0xC7, 0x00, 0xE7, 0x67, 0x76, 0x3E,
  0x3C, 0x3C, 0x3E, 0x76, 0x67, 0xE7, 0xE3, 0xF1, 0x99, 0xCE, 0xE7, 0x61,
  0xB0, 0xF8, 0x78, 0x1C, 0x0E, 0x06, 0x03, 0x07, 0x83, 0x80, 0x7E, 0xFC,
  0x30, 0xE1, 0x87, 0x0C, 0x38, 0xFF, 0xFC, 0x1C, 0xF3, 0x8C, 0x30, 0xC3,
  0x3C, 0xF0, 0xC3, 0x0C, 0x30, 0xE3, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC7, 0x18, 0xC6, 0x31, 0xC7, 0x3B, 0x98, 0xC6, 0x33, 0x98, 0xE3, 0xFE,
  0x78,
};

const GFXglyph NotoSans_Condensed_Bold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 6, 5, 8, 1, -13 },
  { 10, 10, 13, 10, 0, -13 },
  { 27, 7, 15, 9, 1, -14 },
  { 41, 13, 13, 15, 1, -13 },
  { 63, 11, 13, 11, 0, -13 },
  { 81, 2, 5, 4, 1, -13 },
  { 83, 4, 16, 6, 1, -13 },
  { 91, 5, 16, 6, 0, -13 },
  { 101, 8, 8, 9, 0, -14 },
  { 109, 7, 9, 9, 1, -11 },
  { 117, 3, 4, 5, 1, -2 },
  { 119, 5, 2, 6, 0, -6 },
  { 121, 3, 3, 5, 1, -3 },
  { 123, 7, 13, 7, 0, -13 },
  { 135, 7, 13, 9, 1, -13 },
  { 147, 6, 13, 9, 1, -13 },
  { 157, 7, 13, 9, 1, -13 },
  { 169, 7, 13, 9, 1, -13 },
  { 181, 9, 13, 9, 0, -13 },
  { 196, 7, 13, 9, 1, -13 },
  { 208, 7, 13, 9, 1, -13 },
  { 220, 8, 13, 9, 0, -13 },
  { 233, 7, 13, 9, 1, -13 },
  { 245, 8, 13, 9, 0, -13 },
  { 258, 3, 10, 5, 1, -10 },
  { 262, 3, 12, 5, 1, -10 },
  { 267, 7, 9, 9, 1, -11 },
  { 275, 7, 5, 9, 1, -9 },
  { 280, 7, 9, 9, 1, -11 },
  { 288, 7, 13, 7, 0, -13 },
  { 300, 12, 14, 14, 1, -13 },
  { 321, 10, 13, 10, 0, -13 },
  { 338, 8, 13, 10, 1, -13 },
  { 351, 8, 13, 10, 1, -13 },
  { 364, 9, 13, 11, 1, -13 },
  { 379, 7, 13, 9, 1, -13 },
  { 391, 7, 13, 8, 1, -13 },
  { 403, 9, 13, 11, 1, -13 },
  { 418, 9, 13, 12, 1, -13 },
  { 433, 6, 13, 6, 0, -13 },
  { 443, 5, 17, 5, -1, -13 },
  { 454, 9, 13, 10, 1, -13 },
  { 469, 7, 13, 8, 1, -13 },
  { 481, 12, 13, 15, 1, -13 },
  { 501, 10, 13, 12, 1, -13 },
  { 518, 10, 13, 12, 1, -13 },
  { 535, 8, 13, 10, 1, -13 },
  { 548, 10, 16, 12, 1, -13 },
  { 568, 9, 13, 10, 1, -13 },
  { 583, 7, 13, 8, 1, -13 },
  { 595, 8, 13, 9, 0, -13 },
  { 608, 9, 13, 11, 1, -13 },
  { 623, 10, 13, 10, 0, -13 },
  { 640, 15, 13, 15, 0, -13 },
  { 665, 10, 13, 10, 0, -13 },
  { 682, 9, 13, 9, 0, -13 },
  { 697, 8, 13, 8, 0, -13 },
  { 710, 4, 16, 6, 1, -13 },
  { 718, 7, 13, 7, 0, -13 },
  { 730, 5, 16, 6, 0, -13 },
  { 740, 9, 8, 10, 0, -13 },
  { 749, 7, 1, 7, 0, 2 },
  { 750, 4, 3, 6, 1, -14 },
  { 752, 7, 10, 9, 1, -10 },
  { 761, 8, 14, 10, 1, -14 },
  { 775, 6, 10, 8, 1, -10 },
  { 783, 8, 14, 10, 1, -14 },
  { 797, 7, 10, 9, 1, -10 },
  { 806, 7, 14, 6, 0, -14 },
  { 819, 8, 14, 10, 1, -10 },
  { 833, 8, 14, 10, 1, -14 },
  { 847, 3, 14, 5, 1, -14 },
  { 853, 5, 18, 5, -1, -14 },
  { 865, 9, 14, 9, 1, -14 },
  { 881, 3, 14, 5, 1, -14 },
  { 887, 13, 10, 15, 1, -10 },
  { 904, 8, 10, 10, 1, -10 },
  { 914, 8, 10, 10, 1, -10 },
  { 924, 8, 14, 10, 1, -10 },
  { 938, 8, 14, 10, 1, -10 },
  { 952, 6, 10, 7, 1, -10 },
  { 960, 6, 10, 7, 1, -10 },
  { 968, 6, 12, 7, 0, -12 },
  { 977, 8, 10, 10, 1, -10 },
  { 987, 9, 10, 9, 0, -10 },
  { 999, 13, 10, 13, 0, -10 },
  { 1016, 8, 10, 8, 0, -10 },
  { 1026, 9, 14, 9, 0, -10 },
  { 1042, 7, 10, 7, 0, -10 },
  { 1051, 6, 16, 7, 0, -13 },
  { 1063, 2, 18, 9, 3, -14 },
  { 1068, 5, 16, 7, 1, -13 },
  { 1078, 7, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Bold18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_BOLD18PT7B_H_
