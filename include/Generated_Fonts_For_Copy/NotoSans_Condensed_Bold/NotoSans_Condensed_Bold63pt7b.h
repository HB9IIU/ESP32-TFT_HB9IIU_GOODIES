#ifndef _NOTOSANS_CONDENSED_BOLD63PT7B_H_
#define _NOTOSANS_CONDENSED_BOLD63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Bold.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Bold63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x3F, 0x9F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF, 0x3F, 0x83, 0x80, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x7F, 0x83,
  0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFD,
  0xFE, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F, 0x03, 0xF9, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xDE,
  0x3E, 0x3F, 0xE7, 0x81, 0x8F, 0xF1, 0xE0, 0x03, 0xFC, 0x78, 0x00, 0xFF,
  0x1E, 0x00, 0x3F, 0xC7, 0x80, 0x0F, 0xF9, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7B, 0xFE, 0x00, 0x1E, 0x7F, 0xC0, 0x07, 0x8F, 0xF0, 0x01, 0xE3,
  0xFE, 0x00, 0x79, 0xFF, 0xE0, 0x1E, 0x7F, 0xBF, 0x07, 0xBF, 0xEF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xF0,
  0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x80,
  0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0x00,
  0x7F, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x01,
  0xFC, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x8F, 0xE0, 0x38, 0x07,
  0xF0, 0x7E, 0x1F, 0x83, 0xFE, 0x07, 0xE1, 0xFC, 0x7F, 0x0F, 0xFE, 0x0F,
  0xE3, 0xF8, 0xFE, 0x3F, 0xFE, 0x1F, 0xCF, 0xF1, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC7, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xC7, 0xF9, 0xFC, 0x3F,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x3F, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F,
  0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0x0C, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x3F, 0x80, 0x00,
  0x3F, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x01,
  0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xFF, 0xFE,
  0x1F, 0xF0, 0xFF, 0xDF, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF,
  0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xFF, 0xC7,
  0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xC0, 0xFC, 0x0E, 0x7E,
  0x3F, 0x1F, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xCF, 0xE0, 0x0F, 0xF3, 0xFC, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xF0,
  0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x60, 0x18, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F,
  0xF3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87,
  0xF1, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x0F, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xE0, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF,
  0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x00, 0x7F,
  0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01,
  0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFF, 0x01, 0xFF, 0x3F,
  0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFE, 0xFF, 0xFF, 0xCF,
  0xF7, 0xF8, 0xFF, 0x3F, 0x0F, 0xF1, 0xE0, 0xFF, 0x0C, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xC1, 0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x70, 0x01, 0xFF, 0x04, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x3F, 0x01, 0xFF, 0x83, 0x80, 0x1F, 0xF8, 0x20, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFD, 0x80, 0x01, 0xFF, 0xBE, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0x7F, 0xC0, 0x03, 0xFB, 0xFE, 0x00, 0x1F, 0x9F, 0xF0, 0x01, 0xFC,
  0xFF, 0x80, 0x0F, 0xC7, 0xFC, 0x00, 0xFE, 0x3F, 0xE0, 0x0F, 0xE1, 0xFF,
  0x00, 0x7F, 0x0F, 0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x83, 0xFE, 0x03,
  0xF8, 0x1F, 0xF0, 0x1F, 0x80, 0xFF, 0x81, 0xFC, 0x07, 0xFC, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x9E, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x10, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFA, 0x00, 0x07, 0xFE, 0xC0, 0x01, 0xFF, 0xBE, 0x01, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x7A,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x0F,
  0xE3, 0xFF, 0x83, 0xFC, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0x8F, 0xF7, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0x87, 0xFE, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0xFF,
  0xBF, 0xE0, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8,
  0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC,
  0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xC0,
  0xFF, 0x9F, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0x81, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0xE3, 0xFF, 0xFB, 0xFC, 0x7F,
  0xFE, 0x7F, 0x87, 0xFF, 0x8F, 0xE0, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0xCF, 0xE0, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x03, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xDF, 0xF3, 0xF8, 0x38, 0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xCF, 0xF9, 0xFF,
  0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x3F, 0x03, 0xFF, 0x18, 0x01, 0xFF, 0x10, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xFF, 0xE1, 0xFC, 0x7F, 0x01,
  0xFF, 0xFE, 0x1F, 0x8F, 0xC0, 0x7F, 0xFF, 0xC3, 0xF3, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xEF, 0xC1, 0xFE, 0x0F, 0xC0,
  0xFF, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xFF, 0x07, 0xE0, 0x3F, 0x03, 0xFF,
  0xC1, 0xFC, 0x07, 0xE0, 0x7F, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xFF, 0x07,
  0xF0, 0x1F, 0x81, 0xFF, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0x80,
  0x7E, 0x07, 0xFF, 0x83, 0xF0, 0x1F, 0xC0, 0xFF, 0xF0, 0x7E, 0x03, 0xF8,
  0x1F, 0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xFF, 0xC1, 0xF8, 0x0F, 0xE0, 0xFF,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xBF, 0x07, 0xF0, 0x7F, 0x83, 0xF7, 0xE0,
  0xFF, 0x0F, 0xF0, 0xFC, 0xFE, 0x0F, 0xF7, 0xFF, 0xBF, 0x9F, 0xC1, 0xFF,
  0xFB, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x3F, 0x01, 0xFF, 0xC7,
  0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFE, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0x3F, 0xFE, 0xFF, 0x80, 0x3F,
  0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF,
  0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0,
  0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC,
  0x07, 0xFF, 0x3F, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0xFF, 0xE0, 0x07,
  0x0F, 0xFE, 0x00, 0x08, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x30, 0x7F, 0xFC, 0x0F, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x80, 0x7F, 0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF8, 0xFF,
  0x80, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0xF8, 0x3F, 0xFC, 0x00, 0x30, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0x7F, 0xC0,
  0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x80,
  0x0F, 0xF3, 0xFF, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x3F, 0xC7, 0xFF, 0x80,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF,
  0x8F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF1, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF,
  0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1,
  0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0xFF, 0xBF,
  0xC0, 0x0F, 0xEF, 0xFF, 0xF7, 0xF0, 0x03, 0xFB, 0xFF, 0xFD, 0xFC, 0x00,
  0xFE, 0xFF, 0xFF, 0x7F, 0x00, 0x7F, 0x3F, 0xFF, 0xDF, 0xE0, 0x1F, 0xCF,
  0xFF, 0xF3, 0xF8, 0x07, 0xF3, 0xFF, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0xFF,
  0x3F, 0x80, 0xFE, 0x3F, 0xFF, 0xCF, 0xF0, 0x3F, 0x8F, 0xFF, 0xF1, 0xFC,
  0x0F, 0xE3, 0xFF, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0x1F, 0xC1, 0xFC,
  0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x83, 0xFF,
  0xFC, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF3, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFD, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x7F, 0x03, 0xFF, 0xFC, 0x1F, 0xDF,
  0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFB, 0xFE, 0x01,
  0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0x9F, 0xF0,
  0x3F, 0xFF, 0xCF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF,
  0x07, 0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0xFE, 0x0F,
  0xF8, 0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0xFF, 0x81, 0xFF, 0x3F, 0xFF, 0xC0,
  0xFF, 0x9F, 0xFF, 0xE0, 0x3F, 0xCF, 0xFF, 0xF0, 0x1F, 0xF3, 0xFF, 0xF8,
  0x07, 0xF9, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x07,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xBF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xE1,
  0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F,
  0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE,
  0x01, 0xFF, 0x87, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8,
  0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xF0, 0xFE,
  0x3F, 0xF0, 0x0F, 0x1F, 0xF0, 0x01, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFE, 0x1F, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07,
  0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0xFF,
  0xC7, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x07,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xEF, 0xC0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x7F, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x80, 0x7F, 0xC0,
  0xFE, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF3, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x1F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0xFE, 0x3F, 0x87,
  0xFC, 0x00, 0xFF, 0x87, 0xF1, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x87,
  0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F,
  0xC1, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x0F, 0xE3, 0xFC, 0x00, 0x1F,
  0xE7, 0xF0, 0x7F, 0x3F, 0xE0, 0x00, 0xFF, 0x7F, 0x81, 0xFD, 0xFE, 0x00,
  0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x7F, 0x7F,
  0x80, 0x01, 0xFE, 0xFE, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x0F,
  0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1E, 0x03,
  0xFE, 0x06, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFD, 0xFF, 0xE1, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF,
  0xC7, 0xF0, 0xFF, 0xC0, 0xFC, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF3, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF1, 0xFF, 0xCF, 0xFC, 0x07,
  0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF,
  0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80,
  0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F,
  0xEF, 0xFC, 0x07, 0xFC, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF,
  0xE0, 0xFE, 0x3F, 0xFC, 0x0F, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xF8, 0x7C, 0x7F,
  0xE0, 0x18, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x13, 0xFF, 0x00, 0xE7, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x03, 0xFF, 0x8F,
  0xF0, 0x7F, 0xFC, 0xFF, 0x0F, 0xFF, 0xEF, 0xF1, 0xFF, 0xFE, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0xFF, 0xF3, 0xFE, 0x03,
  0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xFC,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F,
  0xF7, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0xF0, 0xFF, 0xFC,
  0xFF, 0x07, 0xFF, 0x87, 0xF0, 0x1F, 0xF0, 0x7F, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF,
  0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xE0, 0x1F, 0xEF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x09, 0xFF, 0x80, 0x0C, 0x3F, 0xF8, 0x1F, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0x0C, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x7F, 0x07, 0xFF, 0xCF, 0xF0, 0xFF, 0xFE, 0xFF, 0x0F,
  0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0x8F,
  0xFF, 0x3F, 0xE0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F,
  0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE,
  0xFF, 0x0F, 0xFF, 0xCF, 0xF0, 0x7F, 0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x03, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x20, 0x00, 0x3F, 0xE3, 0x80, 0x07, 0xFE,
  0x3F, 0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC7, 0xFF, 0x07, 0xF9, 0xFF, 0xF0, 0xFF, 0x7F,
  0xFF, 0x1F, 0xEF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0x9F, 0xFD, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x3E, 0x7F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFE, 0x00, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x47,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xF8,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x07,
  0xFC, 0xFF, 0x80, 0x7F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF,
  0x80, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF9, 0xFE, 0x01, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0,
  0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0,
  0x03, 0xFC, 0x0F, 0xE1, 0xFF, 0xC0, 0xFF, 0xF0, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xE7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFE, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xEF, 0xFC,
  0x07, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x07,
  0xF0, 0x1F, 0xC3, 0xFF, 0x83, 0xF8, 0xFF, 0xFC, 0x7F, 0x3F, 0xFF, 0x8F,
  0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xCF,
  0xFE, 0xFF, 0xE0, 0x7F, 0xDF, 0xF8, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFD,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0xFF, 0xBF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE,
  0x7F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xC1, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0xE1, 0xFF, 0xC0, 0xFE, 0x3F, 0xFE, 0x0F, 0xF7, 0xFF, 0xF0, 0xFF, 0x7F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC,
  0xFF, 0xC0, 0x7F, 0xCF, 0xFC, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x1F,
  0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01,
  0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF,
  0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xCF, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0xF0,
  0xFF, 0x3F, 0xFE, 0x0F, 0xF1, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1C, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0x07, 0xFF,
  0xCF, 0xF0, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0x8F, 0xFF, 0x3F, 0xE0, 0x3F, 0xF7, 0xFE,
  0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F,
  0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xE0,
  0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xCF, 0xF0, 0x7F,
  0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xE0, 0x3C, 0xFF, 0x00, 0x23, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x10, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0C,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFC, 0xFF, 0xFE, 0x7F, 0x1F, 0xFF, 0x1F,
  0xC1, 0xFF, 0x83, 0xF0, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFD, 0xFF,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07,
  0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC,
  0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xE7, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xC3, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x1F, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xF3, 0xF0, 0x7F,
  0x81, 0xFE, 0x0F, 0xCF, 0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0x3F, 0x07, 0xF8,
  0x1F, 0xF0, 0xFC, 0xFC, 0x3F, 0xE0, 0x3F, 0xC7, 0xF1, 0xF8, 0xFF, 0x00,
  0xFF, 0x1F, 0x87, 0xE3, 0xFC, 0x03, 0xFC, 0x7E, 0x1F, 0x8F, 0xF0, 0x0F,
  0xF9, 0xF8, 0x7E, 0x3F, 0xC0, 0x1F, 0xE7, 0xE1, 0xF9, 0xFE, 0x00, 0x7F,
  0x9F, 0x83, 0xE7, 0xF8, 0x01, 0xFE, 0xFC, 0x0F, 0xDF, 0xE0, 0x07, 0xFB,
  0xF0, 0x3F, 0x7F, 0x80, 0x0F, 0xEF, 0xC0, 0xFD, 0xFC, 0x00, 0x3F, 0xBF,
  0x03, 0xF7, 0xF0, 0x00, 0xFE, 0xFC, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF9, 0xFF,
  0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0,
  0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xFC,
  0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x81, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xC7,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0x9F, 0xF0,
  0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x87, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x2F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0x90, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_Bold63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 46, 17, 3, -45 },
  { 59, 22, 16, 29, 3, -45 },
  { 103, 32, 45, 34, 1, -45 },
  { 283, 26, 52, 31, 3, -48 },
  { 452, 47, 47, 51, 2, -46 },
  { 729, 37, 47, 39, 2, -46 },
  { 947, 9, 16, 15, 3, -45 },
  { 965, 16, 55, 20, 3, -45 },
  { 1075, 16, 55, 20, 1, -45 },
  { 1185, 26, 27, 30, 2, -48 },
  { 1273, 27, 30, 31, 2, -37 },
  { 1375, 11, 15, 16, 2, -7 },
  { 1396, 16, 8, 19, 2, -21 },
  { 1412, 10, 11, 17, 3, -10 },
  { 1426, 24, 45, 26, 1, -45 },
  { 1561, 27, 47, 31, 2, -46 },
  { 1720, 20, 45, 31, 3, -45 },
  { 1833, 27, 46, 31, 2, -46 },
  { 1989, 27, 47, 31, 2, -46 },
  { 2148, 29, 45, 31, 1, -45 },
  { 2312, 26, 46, 31, 3, -45 },
  { 2462, 27, 46, 31, 2, -45 },
  { 2618, 28, 45, 31, 1, -45 },
  { 2776, 27, 47, 31, 2, -46 },
  { 2935, 27, 46, 31, 2, -45 },
  { 3091, 10, 36, 17, 3, -35 },
  { 3136, 11, 43, 17, 2, -35 },
  { 3196, 27, 31, 31, 2, -38 },
  { 3301, 27, 19, 31, 2, -32 },
  { 3366, 27, 31, 31, 2, -38 },
  { 3471, 24, 47, 25, 0, -46 },
  { 3612, 43, 50, 49, 3, -45 },
  { 3881, 36, 45, 36, 0, -45 },
  { 4084, 29, 45, 36, 4, -45 },
  { 4248, 29, 47, 33, 3, -46 },
  { 4419, 32, 45, 39, 4, -45 },
  { 4599, 22, 45, 30, 5, -45 },
  { 4723, 21, 45, 29, 5, -45 },
  { 4842, 31, 47, 39, 3, -46 },
  { 5025, 31, 45, 40, 5, -45 },
  { 5200, 18, 45, 21, 2, -45 },
  { 5302, 18, 58, 18, -4, -45 },
  { 5433, 31, 45, 35, 5, -45 },
  { 5608, 23, 45, 28, 4, -45 },
  { 5738, 42, 45, 52, 5, -45 },
  { 5975, 33, 45, 43, 5, -45 },
  { 6161, 35, 47, 41, 3, -46 },
  { 6367, 27, 45, 33, 4, -45 },
  { 6519, 35, 57, 41, 3, -46 },
  { 6769, 31, 45, 35, 4, -45 },
  { 6944, 25, 47, 29, 2, -46 },
  { 7091, 28, 45, 30, 1, -45 },
  { 7249, 31, 46, 40, 4, -45 },
  { 7428, 35, 45, 35, 0, -45 },
  { 7625, 53, 45, 51, -1, -45 },
  { 7924, 33, 45, 34, 0, -45 },
  { 8110, 33, 45, 33, 0, -45 },
  { 8296, 27, 45, 29, 1, -45 },
  { 8448, 14, 55, 20, 4, -45 },
  { 8545, 25, 45, 26, 0, -45 },
  { 8686, 14, 55, 20, 2, -45 },
  { 8783, 32, 28, 34, 1, -45 },
  { 8895, 26, 4, 26, 0, 6 },
  { 8908, 15, 10, 21, 3, -48 },
  { 8927, 26, 36, 32, 2, -35 },
  { 9044, 28, 49, 34, 4, -48 },
  { 9216, 23, 36, 27, 3, -35 },
  { 9320, 28, 49, 34, 2, -48 },
  { 9492, 26, 36, 31, 3, -35 },
  { 9609, 22, 48, 20, 1, -48 },
  { 9741, 28, 50, 34, 2, -35 },
  { 9916, 27, 48, 34, 4, -48 },
  { 10078, 9, 48, 16, 4, -48 },
  { 10132, 15, 63, 16, -2, -48 },
  { 10251, 29, 48, 33, 4, -48 },
  { 10425, 8, 48, 16, 4, -48 },
  { 10473, 44, 35, 51, 4, -35 },
  { 10666, 27, 35, 34, 4, -35 },
  { 10785, 29, 36, 33, 2, -35 },
  { 10916, 28, 50, 34, 4, -35 },
  { 11091, 28, 50, 34, 2, -35 },
  { 11266, 19, 35, 24, 4, -35 },
  { 11350, 22, 36, 26, 2, -35 },
  { 11449, 20, 43, 23, 1, -42 },
  { 11557, 26, 35, 34, 4, -34 },
  { 11671, 30, 34, 30, 0, -34 },
  { 11799, 46, 34, 46, 0, -34 },
  { 11995, 29, 34, 30, 0, -34 },
  { 12119, 30, 49, 30, 0, -34 },
  { 12303, 23, 34, 25, 1, -34 },
  { 12401, 19, 55, 23, 1, -45 },
  { 12532, 7, 63, 30, 11, -48 },
  { 12588, 20, 55, 23, 2, -45 },
  { 12726, 27, 10, 31, 2, -27 },
};

const GFXfont NotoSans_Condensed_Bold63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Bold63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Bold63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_BOLD63PT7B_H_
