#ifndef _NOTOSANS_CONDENSED_REGULAR32PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06, 0xFF,
  0xE0, 0xE7, 0xF1, 0xB8, 0xDC, 0x6E, 0x37, 0x1B, 0x8D, 0x86, 0x06, 0x18,
  0x0C, 0x30, 0x18, 0xC0, 0x31, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x3F,
  0xFF, 0x7F, 0xFE, 0x18, 0xC0, 0x31, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C,
  0x3F, 0xFF, 0x7F, 0xFE, 0x18, 0xC0, 0x31, 0x80, 0xC3, 0x01, 0x86, 0x03,
  0x0C, 0x06, 0x18, 0x0C, 0x70, 0x00, 0x02, 0x00, 0x10, 0x01, 0xC0, 0x3F,
  0xE7, 0xFF, 0x39, 0x09, 0x88, 0x1C, 0x40, 0x62, 0x03, 0x90, 0x1E, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x09, 0xC0, 0x47, 0x02, 0x38, 0x11, 0xC0,
  0x8D, 0x84, 0xEF, 0xFE, 0x3F, 0xE0, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x3C, 0x03, 0x03, 0xF0, 0x38, 0x19, 0xC1, 0x80, 0xC6, 0x0C, 0x06,
  0x30, 0xC0, 0x71, 0x86, 0x03, 0x8C, 0x70, 0x1C, 0x63, 0x00, 0xE3, 0x18,
  0x03, 0x19, 0x8E, 0x18, 0xCC, 0xF8, 0xCE, 0xEC, 0xE3, 0xE6, 0x63, 0x1E,
  0x73, 0x18, 0x03, 0x38, 0xC0, 0x19, 0xC6, 0x01, 0xCE, 0x38, 0x0C, 0x71,
  0x80, 0xE1, 0x8C, 0x06, 0x0C, 0x60, 0x30, 0x63, 0x03, 0x01, 0xF0, 0x18,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xE0, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E,
  0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xB8, 0x73, 0x9C, 0x31, 0x87, 0x39, 0xC1, 0xDC,
  0xE0, 0x7C, 0x70, 0x3E, 0x38, 0x0E, 0x1C, 0x0F, 0x87, 0x0F, 0xE3, 0xFF,
  0x78, 0x7E, 0x1E, 0xFF, 0xFF, 0xFE, 0x06, 0x1C, 0x70, 0xC3, 0x87, 0x0C,
  0x38, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0xC3, 0x87,
  0x06, 0x0E, 0x1C, 0x18, 0x38, 0x30, 0x30, 0xE0, 0xC1, 0xC1, 0xC3, 0x83,
  0x07, 0x0E, 0x0C, 0x18, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x61, 0xC3, 0x86, 0x1C, 0x38, 0xE1, 0x87, 0x00, 0x06, 0x00, 0x60, 0x06,
  0x04, 0x63, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xF8, 0x19, 0x83, 0x9C, 0x30,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x1F, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x39, 0xDC, 0xE7, 0x31, 0x9C, 0xFF, 0xFF, 0xF8, 0x6F, 0xFE,
  0x00, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x00, 0x0F, 0x80, 0xFE, 0x0E, 0x38, 0x60, 0xC7,
  0x07, 0x38, 0x39, 0x80, 0xCC, 0x06, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xEC, 0x06, 0x60, 0x33, 0x83, 0x9C, 0x1C,
  0xE0, 0xE3, 0x8E, 0x1F, 0xE0, 0x3E, 0x00, 0x07, 0x0F, 0x1F, 0x3F, 0x77,
  0xE7, 0x47, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1F, 0x83, 0xFE, 0x3E, 0x78, 0x80,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0x87, 0xFE, 0xF0,
  0xE4, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0xC0, 0xEF, 0xFE, 0x7F, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x1B, 0x80, 0x6E, 0x03, 0x38, 0x1C, 0xE0, 0x63,
  0x83, 0x8E, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0x8E, 0x0E, 0x30, 0x38, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x7F, 0xC7, 0xFC, 0x7F, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0xF0, 0xFF, 0xC4, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0xC3, 0xCF, 0xF8, 0xFF, 0x00, 0x07,
  0xE0, 0x7F, 0x07, 0x84, 0x78, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x3E, 0x1B, 0xF8, 0xF0, 0xEF, 0x07, 0x70, 0x1D, 0x80, 0xEC,
  0x07, 0x60, 0x3B, 0x81, 0xDC, 0x0C, 0x60, 0xE3, 0x8F, 0x0F, 0xF0, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x00, 0x0F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xE7, 0x03, 0x30,
  0x19, 0xC1, 0xCE, 0x0E, 0x38, 0xE1, 0xEF, 0x07, 0xE0, 0x1F, 0x03, 0xDE,
  0x3C, 0x79, 0xC1, 0xDC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x77,
  0x07, 0x1F, 0xF0, 0x7F, 0x00, 0x0F, 0x81, 0xFE, 0x1E, 0x78, 0xE0, 0xC6,
  0x07, 0x70, 0x3B, 0x80, 0xDC, 0x06, 0xE0, 0x37, 0x01, 0xDC, 0x1E, 0xE1,
  0xE3, 0xFB, 0x0F, 0xD8, 0x18, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x3C, 0x1F, 0xC0, 0xFC, 0x00, 0xEF, 0xF6, 0x00, 0x00, 0x00,
  0x00, 0x06, 0xFF, 0xE0, 0x73, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1D, 0xCE, 0x73, 0x99, 0xCC, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x80, 0x07,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x3F,
  0x1F, 0xF1, 0xCF, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x0E, 0x07, 0x01, 0xC0, 0x18, 0x38, 0x01, 0xC7, 0x00, 0x0C, 0x60, 0x78,
  0x66, 0x1F, 0xC6, 0xE3, 0x8C, 0x6C, 0x30, 0xC6, 0xC7, 0x1C, 0x7C, 0x61,
  0xC7, 0xC6, 0x1C, 0x7C, 0x61, 0xC7, 0xC6, 0x1C, 0x6C, 0x61, 0xC6, 0xC7,
  0x1C, 0x6C, 0x3F, 0xFC, 0xC3, 0xE7, 0xCE, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x06, 0x60,
  0x06, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x30, 0x0C, 0x38, 0x1C, 0x38,
  0x1C, 0x38, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x30, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x07,
  0xFE, 0x31, 0xF9, 0x81, 0xEC, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0,
  0x66, 0x0F, 0x3F, 0xF1, 0xFF, 0x8C, 0x1E, 0x60, 0x3B, 0x01, 0xD8, 0x0E,
  0xC0, 0x3E, 0x01, 0xB0, 0x1D, 0x80, 0xEC, 0x1E, 0x7F, 0xF3, 0xFE, 0x00,
  0x07, 0xF0, 0xFF, 0xCF, 0x8E, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xE1, 0x8F, 0xFC,
  0x1F, 0xC0, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x30, 0x3C, 0xC0, 0x7B, 0x00,
  0xEC, 0x03, 0xB0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x06, 0xC0, 0x3B, 0x00, 0xEC, 0x07, 0x30,
  0x3C, 0xC7, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFB, 0xFE, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0xFE, 0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7C, 0x71, 0xC0,
  0x27, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x06, 0xE0, 0x0D, 0xC0, 0x19, 0xC0, 0x33, 0xE0, 0xE3, 0xFF, 0xC1, 0xFF,
  0x00, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xC0, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x9F, 0xFF, 0x80, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1E, 0x7F, 0xEF, 0x80, 0xC0, 0x7E, 0x03, 0xB0, 0x39, 0x81, 0xCC,
  0x1C, 0x61, 0xC3, 0x0E, 0x18, 0xE0, 0xCE, 0x06, 0x70, 0x37, 0x01, 0xFC,
  0x0F, 0xE0, 0x73, 0x83, 0x1C, 0x18, 0x70, 0xC3, 0x86, 0x0E, 0x30, 0x79,
  0x81, 0xCC, 0x07, 0x60, 0x3B, 0x00, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x37,
  0xB0, 0x06, 0xF6, 0x01, 0xDE, 0xE0, 0x33, 0xCC, 0x06, 0x79, 0x81, 0xCF,
  0x38, 0x31, 0xE3, 0x06, 0x3C, 0x61, 0xC7, 0x8E, 0x38, 0xF1, 0xC6, 0x1E,
  0x19, 0xC3, 0xC3, 0xB8, 0x78, 0x76, 0x0F, 0x06, 0xC1, 0xE0, 0xF8, 0x3C,
  0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x18, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFB, 0x81, 0xF7, 0x03, 0xE6, 0x07, 0xCE, 0x0F,
  0x8C, 0x1F, 0x1C, 0x3E, 0x18, 0x7C, 0x38, 0xF8, 0x31, 0xF0, 0x73, 0xE0,
  0x67, 0xC0, 0xEF, 0x80, 0xDF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x3E, 0x7C, 0x78, 0x1C, 0x70,
  0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x78, 0x1C, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F,
  0xF0, 0xFE, 0x0F, 0xF8, 0xFF, 0xCC, 0x1E, 0xC0, 0xEC, 0x06, 0xC0, 0x7C,
  0x07, 0xC0, 0x6C, 0x0E, 0xC0, 0xEC, 0x7C, 0xFF, 0x8F, 0xF0, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3E, 0x7C, 0x78, 0x1C, 0x70, 0x0E, 0xE0, 0x0E,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x0E,
  0x70, 0x0E, 0x78, 0x1C, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0xFE, 0x07, 0xFC, 0x3F,
  0xF1, 0x81, 0xCC, 0x0E, 0x60, 0x33, 0x01, 0xD8, 0x0E, 0xC0, 0x66, 0x07,
  0x30, 0x79, 0xFF, 0x8F, 0xF0, 0x63, 0x83, 0x0E, 0x18, 0x70, 0xC1, 0xC6,
  0x0E, 0x30, 0x39, 0x81, 0xCC, 0x07, 0x60, 0x3B, 0x00, 0xE0, 0x0F, 0xE3,
  0xFF, 0x7C, 0xE7, 0x00, 0x70, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0xE1, 0xEF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x77, 0x01, 0xDC,
  0x07, 0x78, 0x78, 0xFF, 0xC0, 0xFE, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x60,
  0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x18, 0x18, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0C, 0x70, 0x0E,
  0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xDC,
  0x07, 0x00, 0xCE, 0x07, 0xC0, 0xE7, 0x03, 0x60, 0x73, 0x81, 0xB0, 0x38,
  0xC0, 0xD8, 0x18, 0x70, 0xEE, 0x1C, 0x38, 0x77, 0x0E, 0x1C, 0x31, 0x87,
  0x06, 0x18, 0xC3, 0x83, 0x0C, 0x61, 0x81, 0xCE, 0x39, 0xC0, 0xE7, 0x1C,
  0xE0, 0x73, 0x06, 0x70, 0x19, 0x83, 0x30, 0x0D, 0xC1, 0xD8, 0x07, 0xE0,
  0xFC, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x01, 0xC0, 0x70, 0x1D, 0xC0, 0x63, 0x83, 0x8E, 0x0E,
  0x1C, 0x70, 0x71, 0xC0, 0xCE, 0x03, 0xB8, 0x06, 0xC0, 0x1F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xEC, 0x03, 0x38, 0x1C, 0x60, 0x71,
  0xC3, 0x87, 0x0E, 0x0E, 0x70, 0x39, 0xC0, 0x7E, 0x01, 0xC0, 0xE0, 0x1D,
  0x80, 0x77, 0x03, 0x9C, 0x0E, 0x38, 0x30, 0xE1, 0xC1, 0x87, 0x07, 0x38,
  0x1C, 0xE0, 0x3B, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0xFF, 0xF0, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0xFF, 0xFC, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0x03, 0x00, 0x1C,
  0x00, 0x78, 0x03, 0xE0, 0x0D, 0xC0, 0x73, 0x01, 0x8E, 0x0E, 0x18, 0x30,
  0x71, 0xC0, 0xC6, 0x03, 0x38, 0x0E, 0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE1, 0xC3, 0x8E, 0x1C, 0x30, 0x3F, 0xC3, 0xFE, 0x20, 0xE0, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x71, 0xFF, 0x3F, 0xF7, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0x71, 0xF7, 0xF7, 0x3E, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1D, 0xF8, 0xFF, 0xE7, 0xC7, 0xBC,
  0x1D, 0xC0, 0x6E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x6F, 0x07, 0x7C, 0x7B, 0xFF, 0x99, 0xF8, 0x02, 0x01,
  0xFC, 0xFF, 0x1C, 0x27, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC2, 0x3F, 0xC1, 0xF8, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x08, 0xE3, 0xF7,
  0x3F, 0xF9, 0xC3, 0xDC, 0x0E, 0xE0, 0x76, 0x03, 0xB0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3B, 0x01, 0xD8, 0x0E, 0xE0, 0x77, 0x07, 0x9C, 0x3C, 0xFF,
  0x63, 0xF3, 0x1F, 0xC3, 0xFE, 0x38, 0x67, 0x07, 0x70, 0x36, 0x03, 0x60,
  0x3F, 0xFF, 0xFF, 0xF6, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x31, 0xFF, 0x0F, 0xE0, 0x0F, 0xC7, 0xE1, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x81, 0xFE, 0xFF, 0x86, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x02, 0x00,
  0xFC, 0xCF, 0xF6, 0x70, 0xF7, 0x07, 0xB8, 0x1D, 0x80, 0xEC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x76, 0x03, 0xB8, 0x1D, 0xC1, 0xE7, 0x0F,
  0x3F, 0xF8, 0xFD, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1D, 0x01, 0xCF,
  0xFE, 0x7F, 0xE0, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0xFC, 0xFF, 0xEF, 0x8F, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x5F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x08, 0x71, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F,
  0xEF, 0x98, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x70, 0xE6, 0x0E, 0xE0, 0xFE,
  0x0F, 0xF0, 0xF7, 0x0E, 0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE, 0x0E, 0xE0,
  0xEE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x02,
  0x01, 0x0E, 0xFC, 0xFE, 0xFF, 0xEF, 0xEF, 0x0F, 0x87, 0xF0, 0x70, 0x7E,
  0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07,
  0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60,
  0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0x01, 0x0E, 0xFC, 0xFF,
  0xEF, 0x8F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x02,
  0x00, 0xFE, 0x0F, 0xF8, 0x70, 0xE7, 0x03, 0xB8, 0x1D, 0x80, 0xEC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xC0, 0x76, 0x03, 0xB8, 0x1D, 0xC0, 0xC7,
  0x0E, 0x1F, 0xE0, 0x7E, 0x00, 0x01, 0x07, 0x7E, 0x3F, 0xF9, 0xE0, 0xEF,
  0x07, 0x70, 0x1B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1B, 0xC1, 0xDF, 0x1E, 0xFF, 0xE7, 0x7E, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x02, 0x00, 0xFC, 0xCF, 0xF6, 0x70, 0xF7, 0x03, 0xB8, 0x1D, 0x80, 0xEC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x76, 0x03, 0xB8, 0x1D, 0xC1,
  0xE7, 0x1F, 0x3F, 0xF8, 0xFD, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x02, 0xCF, 0xEF, 0xF8, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x04, 0x0F, 0xF7, 0xFF, 0x82, 0xE0, 0x38, 0x0E, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x70, 0x1F, 0x0F, 0xFF, 0x9F, 0xC0,
  0x30, 0x30, 0x30, 0x30, 0xFF, 0xFF, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38, 0x3F, 0x1F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0x71, 0xF7, 0xFF, 0x3F, 0x30, 0xE0,
  0x3B, 0x01, 0xDC, 0x0C, 0xE0, 0xE7, 0x07, 0x18, 0x30, 0xE1, 0x87, 0x1C,
  0x18, 0xE0, 0xC6, 0x07, 0x70, 0x3B, 0x80, 0xD8, 0x06, 0xC0, 0x3E, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x70, 0x3B, 0x03, 0x81, 0x9C, 0x3E, 0x0C, 0xE1,
  0xB0, 0xE7, 0x0D, 0x87, 0x18, 0x6C, 0x30, 0xC7, 0x71, 0x87, 0x39, 0x9C,
  0x39, 0x8C, 0xE0, 0xCC, 0x67, 0x06, 0x63, 0xB0, 0x37, 0x1D, 0x81, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0E, 0x03, 0x80,
  0x70, 0x39, 0x83, 0x8E, 0x18, 0x31, 0xC1, 0xCC, 0x06, 0xE0, 0x3E, 0x00,
  0xF0, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x3B, 0x81, 0xCE, 0x1C, 0x70, 0xE1,
  0xCE, 0x0E, 0xF0, 0x38, 0xE0, 0x3B, 0x01, 0xDC, 0x0C, 0xE0, 0xE3, 0x07,
  0x18, 0x30, 0xE1, 0x87, 0x1C, 0x18, 0xE0, 0xE6, 0x07, 0x70, 0x1B, 0x80,
  0xD8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x07, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xC0,
  0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x07, 0x07, 0x03,
  0x83, 0x81, 0xFF, 0xFF, 0x80, 0x01, 0xC1, 0xF0, 0xF0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x3E, 0x0F, 0x00,
  0xF0, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E,
  0x03, 0x80, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0E, 0x01, 0xF0, 0x3C, 0x3C, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x0F, 0x0F, 0x83, 0xC0, 0x7E,
  0x0F, 0xFF, 0xF0, 0xFF, 0x01, 0xC0,
};

const GFXglyph NotoSans_Condensed_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 9, 8, 12, 2, -23 },
  { 22, 15, 23, 17, 1, -23 },
  { 66, 13, 26, 15, 1, -24 },
  { 109, 21, 23, 23, 1, -23 },
  { 170, 17, 23, 18, 1, -23 },
  { 219, 3, 8, 7, 2, -23 },
  { 222, 7, 28, 9, 1, -23 },
  { 247, 7, 28, 9, 1, -23 },
  { 272, 12, 11, 14, 1, -24 },
  { 289, 13, 15, 15, 1, -19 },
  { 314, 5, 8, 8, 1, -4 },
  { 319, 7, 3, 9, 1, -10 },
  { 322, 4, 4, 8, 2, -4 },
  { 324, 10, 23, 12, 1, -23 },
  { 353, 13, 23, 15, 1, -23 },
  { 391, 8, 23, 15, 2, -23 },
  { 414, 13, 23, 15, 1, -23 },
  { 452, 12, 23, 15, 1, -23 },
  { 487, 14, 23, 15, 1, -23 },
  { 528, 12, 23, 15, 2, -23 },
  { 563, 13, 23, 15, 1, -23 },
  { 601, 13, 23, 15, 1, -23 },
  { 639, 13, 23, 15, 1, -23 },
  { 677, 13, 23, 15, 1, -23 },
  { 715, 4, 17, 8, 2, -17 },
  { 724, 5, 21, 8, 1, -17 },
  { 738, 13, 15, 15, 1, -19 },
  { 763, 13, 9, 15, 1, -16 },
  { 778, 13, 15, 15, 1, -19 },
  { 803, 11, 23, 11, 0, -23 },
  { 835, 20, 26, 23, 2, -23 },
  { 900, 16, 23, 16, 0, -23 },
  { 946, 13, 23, 17, 3, -23 },
  { 984, 13, 23, 16, 2, -23 },
  { 1022, 14, 23, 19, 3, -23 },
  { 1063, 10, 23, 14, 3, -23 },
  { 1092, 10, 23, 14, 3, -23 },
  { 1121, 15, 23, 19, 2, -23 },
  { 1165, 14, 23, 19, 3, -23 },
  { 1206, 7, 23, 10, 1, -23 },
  { 1227, 7, 29, 8, -2, -23 },
  { 1253, 13, 23, 16, 3, -23 },
  { 1291, 10, 23, 13, 3, -23 },
  { 1320, 19, 23, 25, 3, -23 },
  { 1375, 15, 23, 20, 3, -23 },
  { 1419, 16, 23, 20, 2, -23 },
  { 1465, 12, 23, 16, 3, -23 },
  { 1500, 16, 28, 20, 2, -23 },
  { 1556, 13, 23, 16, 3, -23 },
  { 1594, 12, 23, 15, 1, -23 },
  { 1629, 14, 23, 14, 0, -23 },
  { 1670, 14, 23, 19, 2, -23 },
  { 1711, 16, 23, 16, 0, -23 },
  { 1757, 25, 23, 25, 0, -23 },
  { 1829, 14, 23, 15, 0, -23 },
  { 1870, 14, 23, 14, 0, -23 },
  { 1911, 12, 23, 14, 1, -23 },
  { 1946, 7, 28, 10, 2, -23 },
  { 1971, 10, 23, 12, 1, -23 },
  { 2000, 7, 28, 10, 1, -23 },
  { 2025, 14, 13, 15, 1, -23 },
  { 2048, 14, 2, 14, 0, 3 },
  { 2052, 6, 6, 9, 1, -25 },
  { 2057, 12, 17, 15, 1, -17 },
  { 2083, 13, 24, 16, 2, -24 },
  { 2122, 11, 18, 12, 1, -18 },
  { 2147, 13, 24, 16, 1, -24 },
  { 2186, 12, 17, 15, 1, -17 },
  { 2212, 10, 24, 9, 0, -24 },
  { 2242, 13, 26, 16, 1, -18 },
  { 2285, 12, 24, 16, 2, -24 },
  { 2321, 3, 24, 7, 2, -24 },
  { 2330, 6, 32, 7, -1, -24 },
  { 2354, 12, 24, 14, 2, -24 },
  { 2390, 3, 24, 7, 2, -24 },
  { 2399, 20, 18, 24, 2, -18 },
  { 2444, 12, 18, 16, 2, -18 },
  { 2471, 13, 18, 16, 1, -18 },
  { 2501, 13, 26, 16, 2, -18 },
  { 2544, 13, 26, 16, 1, -18 },
  { 2587, 8, 18, 11, 2, -18 },
  { 2605, 10, 18, 12, 1, -18 },
  { 2628, 8, 21, 9, 1, -21 },
  { 2649, 12, 17, 16, 2, -17 },
  { 2675, 13, 17, 13, 0, -17 },
  { 2703, 21, 17, 21, 0, -17 },
  { 2748, 13, 17, 13, 0, -17 },
  { 2776, 13, 25, 13, 0, -17 },
  { 2817, 9, 17, 11, 1, -17 },
  { 2837, 10, 28, 12, 1, -23 },
  { 2872, 2, 32, 14, 6, -24 },
  { 2880, 10, 28, 12, 1, -23 },
  { 2915, 13, 4, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_Regular32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_REGULAR32PT7B_H_
