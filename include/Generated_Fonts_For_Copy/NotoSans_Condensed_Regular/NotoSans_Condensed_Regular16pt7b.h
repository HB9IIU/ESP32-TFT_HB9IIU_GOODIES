#ifndef _NOTOSANS_CONDENSED_REGULAR16PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFA, 0x3C, 0x99, 0x99, 0x12, 0x12, 0x14, 0x7F, 0x24, 0x24,
  0x24, 0xFF, 0x24, 0x28, 0x48, 0x21, 0xFE, 0xA8, 0xA3, 0x83, 0x8B, 0x26,
  0xBF, 0x88, 0x20, 0x41, 0x28, 0x8B, 0x22, 0x50, 0x94, 0x2F, 0xEA, 0xA9,
  0x29, 0x12, 0x44, 0x93, 0x2C, 0x8E, 0x20, 0x78, 0xC8, 0x48, 0x58, 0x70,
  0x72, 0x92, 0x8E, 0x8C, 0x8E, 0xFB, 0xF0, 0x6B, 0x49, 0x24, 0x93, 0x26,
  0x40, 0xC2, 0x23, 0x31, 0x11, 0x33, 0x22, 0x4C, 0x21, 0x3E, 0xED, 0xA8,
  0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xFA, 0xF0, 0xF0, 0x0C, 0x21, 0x84,
  0x10, 0xC2, 0x08, 0x41, 0x0C, 0x00, 0x21, 0xEC, 0xA3, 0x8E, 0x38, 0xE3,
  0x8E, 0x3C, 0x9C, 0x35, 0x91, 0x11, 0x11, 0x11, 0x10, 0x23, 0xE8, 0x82,
  0x08, 0x21, 0x0C, 0x61, 0x08, 0x3F, 0x23, 0xE0, 0x83, 0x08, 0xC7, 0x82,
  0x0C, 0x38, 0xBE, 0x04, 0x18, 0x70, 0xA3, 0x44, 0x91, 0x22, 0xFE, 0x08,
  0x10, 0x20, 0xFA, 0x08, 0x20, 0xF8, 0x20, 0xC3, 0x0E, 0x2F, 0x00, 0x19,
  0xE4, 0x30, 0x82, 0xEC, 0xE3, 0x86, 0x3C, 0x9E, 0xFC, 0x30, 0x82, 0x10,
  0x43, 0x08, 0x21, 0x84, 0x00, 0x33, 0xE8, 0xE3, 0xC9, 0xC7, 0x32, 0x86,
  0x18, 0xDE, 0x23, 0xE8, 0xA3, 0x8E, 0x3D, 0xDB, 0x08, 0x21, 0xBC, 0xF0,
  0x03, 0xC0, 0xB0, 0x03, 0xE8, 0x0C, 0xEE, 0x20, 0x60, 0x70, 0x40, 0xFC,
  0x00, 0x3F, 0xFC, 0x81, 0x81, 0x83, 0x33, 0x08, 0x00, 0x27, 0xC2, 0x10,
  0x88, 0xC4, 0x20, 0x08, 0xC0, 0x00, 0x0F, 0xC6, 0x09, 0x02, 0x9E, 0x64,
  0x99, 0x26, 0xC9, 0x96, 0xE7, 0xEC, 0x01, 0x00, 0x3E, 0x00, 0x18, 0x18,
  0x3C, 0x24, 0x24, 0x26, 0x7E, 0x42, 0x42, 0xC3, 0xC1, 0xFD, 0x8B, 0x16,
  0x2F, 0xDF, 0xB1, 0xE3, 0xC7, 0x8B, 0xE0, 0x18, 0xFD, 0x06, 0x08, 0x10,
  0x20, 0x40, 0xC1, 0x81, 0x89, 0xE0, 0xFD, 0x8F, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC7, 0x9B, 0xE0, 0xFE, 0x31, 0x8F, 0xFF, 0x18, 0xC6, 0x3E, 0xFE,
  0x31, 0x8C, 0x7F, 0x18, 0xC6, 0x30, 0x0C, 0x3F, 0x40, 0xC0, 0x80, 0x80,
  0x8F, 0x83, 0xC3, 0xC3, 0x63, 0x3F, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0,
  0xE1, 0xC3, 0x87, 0x08, 0xE9, 0x24, 0x92, 0x4B, 0x80, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x2E, 0xC7, 0x9B, 0x66, 0x8F, 0x1E, 0x36, 0x64, 0xCD,
  0x8B, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3E, 0xE0, 0xE8, 0x3E,
  0x17, 0x85, 0xD1, 0x74, 0x9D, 0x27, 0x69, 0xCE, 0x73, 0x1C, 0xC4, 0xC3,
  0xE3, 0xE3, 0xF3, 0xD3, 0xDB, 0xCB, 0xCF, 0xC5, 0xC7, 0xC3, 0x18, 0x7E,
  0x42, 0xC3, 0x83, 0x81, 0x81, 0x81, 0x83, 0xC3, 0x66, 0x3C, 0xFB, 0x3C,
  0x71, 0xC7, 0xEE, 0x30, 0xC3, 0x0C, 0x00, 0x18, 0x7E, 0x42, 0xC3, 0x83,
  0x81, 0x81, 0x81, 0x83, 0xC3, 0x66, 0x3C, 0x0C, 0x06, 0x03, 0xFD, 0x8B,
  0x16, 0x2C, 0xDF, 0x36, 0x64, 0xCD, 0x8B, 0x18, 0x33, 0xE8, 0x20, 0x83,
  0x83, 0x82, 0x0C, 0x38, 0xBC, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x8D,
  0xF0, 0xC3, 0x42, 0x42, 0x46, 0x64, 0x24, 0x24, 0x2C, 0x38, 0x18, 0x18,
  0xC6, 0x14, 0x61, 0x47, 0x34, 0x53, 0x6D, 0x26, 0x92, 0x29, 0xA2, 0x8E,
  0x28, 0xC3, 0x8C, 0x10, 0xC0, 0xC6, 0xC8, 0xB1, 0xC1, 0x83, 0x0E, 0x16,
  0x64, 0x8F, 0x08, 0xC6, 0x89, 0x91, 0x42, 0x87, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x7C, 0x30, 0x86, 0x10, 0x43, 0x08, 0x61, 0x0F, 0xC0, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0xFF, 0xC1, 0x06, 0x08, 0x20, 0xC1, 0x04, 0x08,
  0x20, 0xC0, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFF, 0x18, 0x70, 0xB1,
  0x24, 0x78, 0x40, 0xFE, 0xCC, 0x76, 0xC2, 0x17, 0xC6, 0x33, 0xE8, 0x82,
  0x08, 0x26, 0xAF, 0x1C, 0x61, 0x87, 0x1C, 0xEE, 0x33, 0x61, 0x08, 0x42,
  0x18, 0x78, 0x04, 0x10, 0x5D, 0xDE, 0x38, 0x61, 0x86, 0x1C, 0xDD, 0x31,
  0x68, 0xA3, 0xFE, 0x08, 0x31, 0x78, 0x3B, 0x18, 0xEF, 0x31, 0x8C, 0x63,
  0x18, 0xC0, 0x77, 0x78, 0xE1, 0x86, 0x18, 0x73, 0x74, 0x10, 0x62, 0x70,
  0x82, 0x08, 0x26, 0xAF, 0x1C, 0x61, 0x86, 0x18, 0x61, 0xB2, 0xAA, 0xAA,
  0x4C, 0x24, 0x92, 0x49, 0x24, 0x96, 0x82, 0x08, 0x23, 0x8A, 0x4B, 0x2C,
  0xD2, 0x68, 0xA3, 0xFF, 0xF0, 0xB9, 0xBA, 0xBC, 0xC7, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x40, 0xBB, 0xBC, 0x71, 0x86, 0x18, 0x61, 0x84,
  0x33, 0x28, 0xE1, 0x86, 0x18, 0x73, 0x78, 0xBA, 0xBC, 0x71, 0x86, 0x1C,
  0x73, 0xBA, 0x08, 0x20, 0x80, 0x77, 0x78, 0xE1, 0x86, 0x18, 0x73, 0x74,
  0x10, 0x41, 0x04, 0x9B, 0xCC, 0x88, 0x88, 0x80, 0x76, 0xA1, 0x06, 0x18,
  0x72, 0xF0, 0x26, 0x7F, 0x66, 0x66, 0x66, 0x30, 0x86, 0x18, 0x61, 0x86,
  0x18, 0xF3, 0x74, 0x87, 0x89, 0x12, 0x66, 0x85, 0x0A, 0x18, 0x30, 0xC4,
  0x73, 0x14, 0xE5, 0x2B, 0x4A, 0x9C, 0xA3, 0x28, 0xCE, 0x31, 0x00, 0xC5,
  0x36, 0x8E, 0x10, 0xE2, 0x93, 0xC4, 0x87, 0x89, 0x12, 0x66, 0x85, 0x0A,
  0x18, 0x10, 0x20, 0xC1, 0x0C, 0x00, 0x7B, 0xC6, 0x23, 0x11, 0x88, 0xF8,
  0x36, 0x66, 0x64, 0x84, 0x66, 0x66, 0x31, 0xFF, 0xFF, 0xC6, 0x66, 0x66,
  0x16, 0x66, 0x66, 0xC8, 0xC6, 0xF0,
};

const GFXglyph NotoSans_Condensed_Regular16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 8, 11, 8, 0, -11 },
  { 17, 6, 13, 8, 1, -12 },
  { 27, 10, 12, 11, 1, -12 },
  { 42, 8, 12, 9, 1, -12 },
  { 54, 1, 4, 3, 1, -11 },
  { 55, 3, 14, 5, 1, -11 },
  { 61, 4, 14, 5, 0, -11 },
  { 68, 5, 6, 7, 1, -12 },
  { 72, 6, 7, 8, 1, -9 },
  { 78, 2, 4, 4, 1, -2 },
  { 79, 4, 1, 5, 0, -5 },
  { 80, 2, 2, 4, 1, -2 },
  { 81, 6, 11, 6, 0, -11 },
  { 90, 6, 12, 8, 1, -12 },
  { 99, 4, 11, 8, 1, -11 },
  { 105, 6, 12, 8, 1, -12 },
  { 114, 6, 12, 8, 1, -12 },
  { 123, 7, 12, 8, 0, -12 },
  { 134, 6, 11, 8, 1, -11 },
  { 143, 6, 12, 8, 1, -12 },
  { 152, 6, 11, 8, 1, -11 },
  { 161, 6, 12, 8, 1, -12 },
  { 170, 6, 12, 8, 1, -12 },
  { 179, 2, 9, 4, 1, -9 },
  { 182, 2, 11, 4, 1, -9 },
  { 185, 6, 7, 8, 1, -9 },
  { 191, 6, 5, 8, 1, -8 },
  { 195, 6, 7, 8, 1, -9 },
  { 201, 5, 12, 6, 0, -12 },
  { 209, 10, 13, 12, 1, -12 },
  { 226, 8, 11, 8, 0, -11 },
  { 237, 7, 11, 8, 1, -11 },
  { 247, 7, 12, 8, 1, -12 },
  { 258, 7, 11, 9, 1, -11 },
  { 268, 5, 11, 7, 1, -11 },
  { 275, 5, 11, 7, 1, -11 },
  { 282, 8, 12, 10, 1, -12 },
  { 294, 7, 11, 10, 1, -11 },
  { 304, 3, 11, 5, 1, -11 },
  { 309, 4, 14, 4, -1, -11 },
  { 316, 7, 11, 8, 1, -11 },
  { 326, 5, 11, 7, 1, -11 },
  { 333, 10, 11, 12, 1, -11 },
  { 347, 8, 11, 10, 1, -11 },
  { 358, 8, 12, 10, 1, -12 },
  { 370, 6, 11, 8, 1, -11 },
  { 379, 8, 15, 10, 1, -12 },
  { 394, 7, 11, 8, 1, -11 },
  { 404, 6, 12, 7, 1, -12 },
  { 413, 7, 11, 7, 0, -11 },
  { 423, 7, 11, 9, 1, -11 },
  { 433, 8, 11, 8, 0, -11 },
  { 444, 12, 11, 13, 0, -11 },
  { 461, 7, 11, 7, 0, -11 },
  { 471, 7, 11, 7, 0, -11 },
  { 481, 6, 11, 7, 0, -11 },
  { 490, 4, 14, 5, 1, -11 },
  { 497, 6, 11, 6, 0, -11 },
  { 506, 4, 14, 5, 0, -11 },
  { 513, 7, 6, 8, 0, -11 },
  { 519, 7, 1, 7, 0, 1 },
  { 520, 3, 2, 4, 1, -12 },
  { 521, 5, 9, 7, 1, -9 },
  { 527, 6, 12, 8, 1, -12 },
  { 536, 5, 9, 6, 1, -9 },
  { 542, 6, 12, 8, 1, -12 },
  { 551, 6, 9, 7, 1, -9 },
  { 558, 5, 12, 4, 0, -12 },
  { 566, 6, 13, 8, 1, -9 },
  { 576, 6, 12, 8, 1, -12 },
  { 585, 2, 12, 4, 1, -12 },
  { 588, 3, 16, 4, 0, -12 },
  { 594, 6, 12, 7, 1, -12 },
  { 603, 1, 12, 4, 1, -12 },
  { 605, 10, 9, 12, 1, -9 },
  { 617, 6, 9, 8, 1, -9 },
  { 624, 6, 9, 8, 1, -9 },
  { 631, 6, 13, 8, 1, -9 },
  { 641, 6, 13, 8, 1, -9 },
  { 651, 4, 9, 5, 1, -9 },
  { 656, 5, 9, 6, 1, -9 },
  { 662, 4, 11, 5, 0, -11 },
  { 668, 6, 9, 8, 1, -9 },
  { 675, 7, 9, 7, 0, -9 },
  { 683, 10, 9, 11, 0, -9 },
  { 695, 6, 9, 7, 0, -9 },
  { 702, 7, 13, 7, 0, -9 },
  { 714, 5, 9, 6, 0, -9 },
  { 720, 4, 14, 6, 1, -11 },
  { 727, 1, 16, 7, 3, -12 },
  { 729, 4, 14, 6, 1, -11 },
  { 736, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Regular16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_REGULAR16PT7B_H_
