#ifndef _NOTOSANS_CONDENSED_REGULAR12PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xB6, 0xD0, 0x28, 0xA2, 0x9F, 0x29, 0x2F, 0x54, 0x50,
  0x4F, 0xCC, 0xE5, 0x5B, 0x44, 0xC5, 0x92, 0xA5, 0x8D, 0xFD, 0x4A, 0x95,
  0x4E, 0x30, 0xA1, 0x42, 0x82, 0x0A, 0xA3, 0x24, 0x76, 0xF0, 0x5A, 0xAA,
  0xA4, 0x89, 0x12, 0x49, 0x2B, 0x00, 0x27, 0xC8, 0xA0, 0x21, 0x3E, 0x42,
  0x10, 0x58, 0xE0, 0x80, 0x11, 0x12, 0x24, 0x44, 0x80, 0x6B, 0x99, 0x99,
  0x99, 0xE0, 0x2E, 0x92, 0x49, 0x20, 0x32, 0xC2, 0x11, 0x08, 0x88, 0xF8,
  0x36, 0xC2, 0x17, 0x0C, 0x21, 0xF0, 0x10, 0x8C, 0x65, 0x2B, 0xE2, 0x10,
  0xF8, 0x88, 0xF1, 0x11, 0xE0, 0x3C, 0x88, 0xF9, 0x99, 0xE0, 0xF8, 0x42,
  0x21, 0x08, 0x84, 0x60, 0x32, 0x52, 0x93, 0x2E, 0x29, 0x78, 0x32, 0xD3,
  0x94, 0xBC, 0x22, 0x70, 0xC2, 0x50, 0x05, 0x80, 0x09, 0xB0, 0xC1, 0x80,
  0xF8, 0x3E, 0xC1, 0x06, 0x6C, 0x00, 0x69, 0x11, 0x24, 0x40, 0x40, 0x38,
  0x8A, 0x0D, 0xDA, 0xB5, 0x6A, 0xDA, 0x80, 0xF0, 0x30, 0xC3, 0x0C, 0x49,
  0xE4, 0xB1, 0x84, 0xE4, 0xA3, 0x2E, 0x4E, 0x31, 0xF0, 0x32, 0x61, 0x08,
  0x42, 0x10, 0x70, 0xE4, 0xA3, 0x18, 0xC6, 0x33, 0xF0, 0xF8, 0x88, 0xF8,
  0x88, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0x80, 0x3A, 0x61, 0x09, 0xC6, 0x31,
  0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xE9, 0x24, 0x92, 0xE0, 0x24,
  0x92, 0x49, 0x27, 0x80, 0x8C, 0xAD, 0x4E, 0x52, 0xD2, 0x88, 0x88, 0x88,
  0x88, 0x88, 0xF0, 0x83, 0x87, 0x1E, 0x3A, 0x75, 0x6A, 0xCD, 0x92, 0x87,
  0x1C, 0x69, 0xA6, 0x59, 0x63, 0x8C, 0x33, 0x28, 0xA1, 0x86, 0x18, 0x62,
  0x78, 0xE9, 0x99, 0x9E, 0x88, 0x80, 0x33, 0x28, 0xE1, 0x86, 0x18, 0x62,
  0x78, 0x40, 0x80, 0xE4, 0xA5, 0x2F, 0x52, 0x52, 0x88, 0x32, 0x50, 0x87,
  0x0C, 0x21, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x20, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x70, 0x86, 0x14, 0x92, 0x49, 0x43, 0x0C, 0x30, 0x88, 0xC4,
  0x53, 0x2A, 0x95, 0x52, 0xA9, 0x4C, 0x46, 0x23, 0x00, 0x8A, 0x54, 0x62,
  0x19, 0x49, 0x88, 0x8E, 0x54, 0xA3, 0x10, 0x84, 0x20, 0xF8, 0xC4, 0x22,
  0x11, 0x08, 0xF8, 0xEA, 0xAA, 0xAC, 0x84, 0x44, 0x22, 0x21, 0x10, 0xE4,
  0x92, 0x49, 0x27, 0x80, 0x20, 0xC3, 0x12, 0xCC, 0xF8, 0xC4, 0x22, 0xC2,
  0xF4, 0xC5, 0xE0, 0x84, 0x29, 0xA9, 0x46, 0x72, 0xF0, 0x76, 0x49, 0x38,
  0x11, 0x5B, 0x99, 0x99, 0xF0, 0x4B, 0x9F, 0x88, 0xF0, 0x74, 0x6C, 0x44,
  0x44, 0x40, 0x4B, 0x99, 0x99, 0xF1, 0x1E, 0x88, 0xAD, 0x99, 0x99, 0x90,
  0xDF, 0x80, 0x51, 0x55, 0x56, 0x88, 0x9A, 0xAC, 0xAA, 0x90, 0xFF, 0x80,
  0x25, 0xB6, 0x4C, 0x99, 0x32, 0x64, 0x80, 0x2D, 0x99, 0x99, 0x90, 0x69,
  0x99, 0x99, 0xF0, 0x26, 0xA5, 0x19, 0xCB, 0xD0, 0x84, 0x00, 0x4B, 0x99,
  0x99, 0xF1, 0x11, 0x3E, 0x49, 0x20, 0x25, 0xC6, 0x11, 0xF0, 0x4F, 0x24,
  0x93, 0x99, 0x99, 0x9F, 0x8A, 0x94, 0xA5, 0x10, 0x99, 0x5A, 0x5A, 0x6A,
  0x66, 0x64, 0xDA, 0x88, 0x65, 0x64, 0x8A, 0x94, 0xA5, 0x10, 0x8C, 0xC0,
  0xF2, 0x24, 0x4F, 0x12, 0x22, 0x2C, 0x22, 0x22, 0x30, 0xFF, 0xF0, 0x86,
  0x22, 0x23, 0x22, 0x22, 0xC0, 0x6C, 0x80,
};

const GFXglyph NotoSans_Condensed_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 4, 5, 1, -9 },
  { 5, 6, 9, 6, 0, -9 },
  { 12, 4, 10, 6, 1, -9 },
  { 17, 7, 9, 9, 1, -9 },
  { 25, 7, 9, 7, 0, -9 },
  { 33, 1, 4, 3, 1, -9 },
  { 34, 2, 11, 4, 1, -9 },
  { 37, 3, 11, 4, 0, -9 },
  { 42, 5, 4, 5, 0, -9 },
  { 45, 5, 6, 6, 0, -7 },
  { 49, 2, 3, 3, 0, -1 },
  { 50, 3, 1, 3, 0, -4 },
  { 51, 1, 1, 3, 1, -1 },
  { 52, 4, 9, 4, 0, -9 },
  { 57, 4, 9, 6, 1, -9 },
  { 62, 3, 9, 6, 1, -9 },
  { 66, 5, 9, 6, 0, -9 },
  { 72, 5, 9, 6, 0, -9 },
  { 78, 5, 9, 6, 0, -9 },
  { 84, 4, 9, 6, 1, -9 },
  { 89, 4, 9, 6, 1, -9 },
  { 94, 5, 9, 6, 0, -9 },
  { 100, 5, 9, 6, 0, -9 },
  { 106, 5, 9, 6, 0, -9 },
  { 112, 1, 7, 3, 1, -7 },
  { 113, 2, 9, 3, 0, -7 },
  { 116, 5, 5, 6, 0, -7 },
  { 120, 5, 3, 6, 0, -6 },
  { 122, 5, 5, 6, 0, -7 },
  { 126, 4, 9, 4, 0, -9 },
  { 131, 7, 10, 9, 1, -9 },
  { 140, 6, 9, 6, 0, -9 },
  { 147, 5, 9, 6, 1, -9 },
  { 153, 5, 9, 6, 1, -9 },
  { 159, 5, 9, 7, 1, -9 },
  { 165, 4, 9, 5, 1, -9 },
  { 170, 4, 9, 5, 1, -9 },
  { 175, 5, 9, 7, 1, -9 },
  { 181, 5, 9, 7, 1, -9 },
  { 187, 3, 9, 4, 0, -9 },
  { 191, 3, 11, 3, -1, -9 },
  { 196, 5, 9, 6, 1, -9 },
  { 202, 4, 9, 5, 1, -9 },
  { 207, 7, 9, 9, 1, -9 },
  { 215, 6, 9, 8, 1, -9 },
  { 222, 6, 9, 7, 1, -9 },
  { 229, 4, 9, 6, 1, -9 },
  { 234, 6, 11, 7, 1, -9 },
  { 243, 5, 9, 6, 1, -9 },
  { 249, 5, 9, 5, 0, -9 },
  { 255, 5, 9, 5, 0, -9 },
  { 261, 5, 9, 7, 1, -9 },
  { 267, 6, 9, 6, 0, -9 },
  { 274, 9, 9, 9, 0, -9 },
  { 285, 5, 9, 5, 0, -9 },
  { 291, 5, 9, 5, 0, -9 },
  { 297, 5, 9, 5, 0, -9 },
  { 303, 2, 11, 4, 1, -9 },
  { 306, 4, 9, 4, 0, -9 },
  { 311, 3, 11, 4, 0, -9 },
  { 316, 6, 5, 6, 0, -9 },
  { 320, 5, 1, 5, 0, 1 },
  { 321, 3, 2, 3, 0, -9 },
  { 322, 5, 7, 6, 0, -7 },
  { 327, 5, 9, 6, 1, -9 },
  { 333, 3, 7, 5, 1, -7 },
  { 336, 4, 9, 6, 1, -9 },
  { 341, 4, 7, 6, 1, -7 },
  { 345, 4, 9, 3, 0, -9 },
  { 350, 4, 10, 6, 1, -7 },
  { 355, 4, 9, 6, 1, -9 },
  { 360, 1, 9, 3, 1, -9 },
  { 362, 2, 12, 3, 0, -9 },
  { 365, 4, 9, 5, 1, -9 },
  { 370, 1, 9, 3, 1, -9 },
  { 372, 7, 7, 9, 1, -7 },
  { 379, 4, 7, 6, 1, -7 },
  { 383, 4, 7, 6, 1, -7 },
  { 387, 5, 10, 6, 1, -7 },
  { 394, 4, 10, 6, 1, -7 },
  { 399, 3, 7, 4, 1, -7 },
  { 402, 4, 7, 5, 0, -7 },
  { 406, 3, 8, 3, 0, -8 },
  { 409, 4, 6, 6, 1, -6 },
  { 412, 5, 6, 5, 0, -6 },
  { 416, 8, 6, 8, 0, -6 },
  { 422, 5, 6, 5, 0, -6 },
  { 426, 5, 9, 5, 0, -6 },
  { 432, 4, 6, 4, 0, -6 },
  { 435, 4, 11, 4, 0, -9 },
  { 441, 1, 12, 5, 2, -9 },
  { 443, 4, 11, 4, 0, -9 },
  { 449, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_Regular12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_REGULAR12PT7B_H_
