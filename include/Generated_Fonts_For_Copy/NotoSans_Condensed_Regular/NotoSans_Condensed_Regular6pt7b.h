#ifndef _NOTOSANS_CONDENSED_REGULAR6PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xE0, 0x5B, 0x3C, 0xED, 0x77, 0xCB, 0xF0, 0x80,
  0xEA, 0x40, 0xF8, 0x7C, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A, 0xF6, 0xE0,
  0xD5, 0xE5, 0x70, 0xE8, 0xF0, 0x5B, 0xA0, 0xD8, 0xE0, 0xDA, 0xF0, 0xE9,
  0x20, 0xEA, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80, 0xFC, 0x8F, 0x00,
  0xDA, 0x7F, 0xF8, 0x60, 0x57, 0xD0, 0xFE, 0xF0, 0xF2, 0x30, 0xF6, 0xF0,
  0xFB, 0xFA, 0xF2, 0xB0, 0xBE, 0xD0, 0xEB, 0xF8, 0xBB, 0x50, 0xAB, 0x9D,
  0xFB, 0xBE, 0xD0, 0xF6, 0xB0, 0xF7, 0x40, 0xF6, 0xB2, 0xF7, 0x50, 0xE7,
  0xE9, 0x20, 0xB6, 0xF0, 0xB5, 0x20, 0xAF, 0x9C, 0xA0, 0xA9, 0x50, 0xA9,
  0x20, 0xDB, 0xEA, 0xC0, 0xA5, 0xF8, 0x54, 0xE0, 0x80, 0xFC, 0x9A, 0xDE,
  0xEC, 0x2E, 0xDE, 0xFB, 0x80, 0x7A, 0x80, 0xF6, 0xF0, 0x9A, 0xDA, 0xF0,
  0xF8, 0x97, 0x6A, 0xF8, 0xFB, 0xB0, 0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0,
  0xF7, 0x90, 0xE8, 0xDC, 0xEB, 0xB7, 0x80, 0xD4, 0xDE, 0x60, 0xDC, 0xD7,
  0xEC, 0x59, 0x40, 0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 1, 5, 2, 0, -4 },
  { 15, 2, 3, 3, 0, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 2, 4, 3, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 1, 3, 1, 0, -3 },
  { 42, 1, 4, 1, 0, -3 },
  { 43, 3, 3, 3, 0, -4 },
  { 45, 3, 2, 3, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 2, 4, 2, 0, -4 },
  { 49, 4, 5, 4, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 2, 4, 3, 0, -4 },
  { 61, 2, 4, 3, 0, -4 },
  { 62, 3, 4, 4, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 2, 4, 2, 0, -4 },
  { 67, 1, 5, 1, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 2, 4, 3, 0, -4 },
  { 71, 4, 4, 5, 0, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 3, 5, 4, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 2, 4, 3, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 5, 4, 5, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 2, 4, 3, 0, -4 },
  { 98, 2, 5, 2, 0, -4 },
  { 100, 2, 4, 2, 0, -4 },
  { 101, 1, 5, 2, 0, -4 },
  { 102, 3, 2, 3, 0, -4 },
  { 103, 3, 1, 3, 0, 0 },
  { 104, 1, 1, 2, 0, -5 },
  { 105, 2, 3, 3, 0, -3 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 2, 3, 2, 0, -3 },
  { 109, 3, 5, 3, 0, -5 },
  { 111, 3, 3, 3, 0, -3 },
  { 113, 2, 5, 2, 0, -5 },
  { 115, 3, 4, 3, 0, -3 },
  { 117, 3, 5, 3, 0, -5 },
  { 119, 1, 4, 1, 0, -4 },
  { 120, 1, 5, 1, 0, -4 },
  { 121, 3, 5, 3, 0, -5 },
  { 123, 1, 5, 1, 0, -5 },
  { 124, 4, 3, 5, 0, -3 },
  { 126, 3, 3, 3, 0, -3 },
  { 128, 3, 3, 3, 0, -3 },
  { 130, 3, 4, 3, 0, -3 },
  { 132, 3, 4, 3, 0, -3 },
  { 134, 2, 3, 2, 0, -3 },
  { 135, 2, 3, 2, 0, -3 },
  { 136, 2, 4, 2, 0, -4 },
  { 137, 3, 3, 3, 0, -3 },
  { 139, 2, 3, 2, 0, -3 },
  { 140, 4, 3, 4, 0, -3 },
  { 142, 2, 3, 3, 0, -3 },
  { 143, 2, 4, 2, 0, -3 },
  { 144, 2, 3, 2, 0, -3 },
  { 145, 2, 5, 2, 0, -4 },
  { 147, 1, 6, 3, 1, -5 },
  { 148, 2, 5, 2, 0, -4 },
  { 150, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_Regular6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_REGULAR6PT7B_H_
