#ifndef _NOTOSANS_CONDENSED_REGULAR62PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xE3, 0x00, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x0E, 0x78,
  0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x7E, 0x38, 0x38, 0x7C, 0x38, 0x04, 0xF8, 0x38,
  0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38,
  0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0x7C, 0x38, 0x00, 0x7F, 0x38,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x39,
  0xFC, 0x00, 0x38, 0x7E, 0x00, 0x38, 0x3E, 0x00, 0x38, 0x3E, 0x00, 0x38,
  0x1E, 0x00, 0x38, 0x1F, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x3E, 0x00, 0x38,
  0x3E, 0x80, 0x38, 0x7E, 0xF0, 0x38, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x00,
  0x3E, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0x07, 0x80, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x78, 0x3F, 0x07, 0x80, 0xF1, 0xF1, 0xFF, 0x0F, 0x03, 0xE3, 0xC7,
  0xFF, 0x0F, 0x07, 0x87, 0x8F, 0xFF, 0x1E, 0x0F, 0x1E, 0x3E, 0x1E, 0x3E,
  0x3E, 0x3C, 0x78, 0x3E, 0x3F, 0xF8, 0xF8, 0xF0, 0x3C, 0x7F, 0xE1, 0xE1,
  0xE0, 0x78, 0x7F, 0xC7, 0xC7, 0xC0, 0xF0, 0x3E, 0x0F, 0x0F, 0x01, 0xE0,
  0x00, 0x1E, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x3C, 0x07, 0xC0, 0x00, 0xF0,
  0x78, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0x3E,
  0x00, 0x0F, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x07, 0x80, 0xF8, 0x00, 0x78,
  0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x3C,
  0x00, 0xF8, 0x78, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x7C, 0x1F, 0x8F, 0xC0, 0x7C,
  0x3F, 0x0F, 0xC0, 0x7C, 0x3E, 0x07, 0xE0, 0xFC, 0x7E, 0x03, 0xF0, 0xF8,
  0x7C, 0x03, 0xF0, 0xF8, 0x7C, 0x01, 0xF9, 0xF8, 0xFC, 0x00, 0xFD, 0xF0,
  0xFC, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x3F, 0xE0,
  0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x1F, 0xE0,
  0x7E, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0xF0, 0x3F, 0x83, 0xFD, 0xF8,
  0x3F, 0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E,
  0x03, 0xFF, 0x80, 0x3F, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x78, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0xBC, 0x1E, 0x0E, 0x7F, 0x3D, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0,
  0x3F, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0x60, 0x38, 0x00,
  0x40, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E,
  0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x83, 0xF0,
  0x3F, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC,
  0x3E, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7,
  0xFF, 0x9F, 0xDF, 0x7F, 0x3F, 0xFC, 0x7D, 0xF0, 0xF9, 0xC1, 0xF1, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7E, 0x01, 0xFC, 0x3C, 0x00, 0xFC, 0x10, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7E, 0x01, 0xFC, 0x38, 0x00, 0xFC, 0x10,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x7E, 0xE0,
  0x00, 0xFE, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x01, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xD0, 0x00, 0x3F, 0xB0, 0x00, 0xFE, 0x7C, 0x07, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0xFF, 0xC0, 0xF9,
  0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFB, 0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0xFE,
  0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F,
  0x80, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF8,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xE1, 0xFC, 0x07,
  0xE0, 0x7F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x03, 0xF3, 0xE0, 0x01, 0xF9,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00,
  0xF9, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x3E, 0x00,
  0x7C, 0xFC, 0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xEF, 0x80, 0x1F, 0xDF, 0x80, 0x7F, 0xBF, 0x81, 0xFF, 0x3F,
  0xFF, 0xBE, 0x3F, 0xFF, 0x7C, 0x3F, 0xFC, 0xF8, 0x3F, 0xE1, 0xF0, 0x07,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x20, 0x3F, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x60, 0x0C, 0x0F,
  0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F,
  0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC,
  0xF0, 0x1F, 0xD8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x1F, 0xFC, 0x0F, 0x8F, 0x80,
  0x7F, 0xFC, 0x0F, 0x1E, 0x01, 0xFF, 0xF8, 0x1E, 0x3C, 0x07, 0xE1, 0xF0,
  0x3C, 0xF8, 0x1F, 0x03, 0xE0, 0x79, 0xE0, 0x3E, 0x07, 0xC0, 0xFB, 0xC0,
  0x78, 0x0F, 0x80, 0xF7, 0x81, 0xF0, 0x1F, 0x01, 0xEF, 0x03, 0xC0, 0x3E,
  0x03, 0xFE, 0x07, 0x80, 0x7C, 0x07, 0xFC, 0x0F, 0x00, 0xF8, 0x0F, 0xF0,
  0x1E, 0x01, 0xE0, 0x1F, 0xE0, 0x7C, 0x03, 0xC0, 0x3F, 0xC0, 0xF8, 0x07,
  0x80, 0x7F, 0x81, 0xF0, 0x0F, 0x01, 0xFF, 0x03, 0xE0, 0x1E, 0x03, 0xDE,
  0x03, 0xC0, 0x7C, 0x07, 0xBE, 0x07, 0x80, 0xF8, 0x0F, 0x7C, 0x0F, 0x01,
  0xF0, 0x1E, 0xF8, 0x1F, 0x07, 0x70, 0x78, 0xF0, 0x1F, 0x0E, 0xE1, 0xF1,
  0xE0, 0x3F, 0xFD, 0xFF, 0xC3, 0xC0, 0x3F, 0xF1, 0xFF, 0x87, 0xC0, 0x3F,
  0xC3, 0xFE, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x7F,
  0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0x7F,
  0xE7, 0xC0, 0x07, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0x80,
  0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x3E, 0x03, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xF0, 0x07, 0xF8,
  0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x03, 0xFB, 0xE0, 0x03, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0x01,
  0xFC, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x04, 0x07, 0xFE, 0x0F, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xFE, 0x0F, 0x80, 0x1F, 0xE0,
  0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x03, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E,
  0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3F,
  0x0F, 0x80, 0x0F, 0xF0, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF8, 0x07, 0xE0, 0x7F, 0x80, 0x03, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C,
  0x3F, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x07, 0xC1, 0xFE, 0x00, 0x1F, 0x03,
  0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x3F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xC0,
  0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE1,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03,
  0xE7, 0xE0, 0x00, 0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x3E, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E,
  0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFB, 0xC0, 0x00, 0x0F, 0x7F, 0xEF, 0x80, 0x00, 0x7D, 0xFF, 0xBE,
  0x00, 0x01, 0xF7, 0xFE, 0xF8, 0x00, 0x07, 0x9F, 0xF9, 0xF0, 0x00, 0x3E,
  0x7F, 0xE7, 0xC0, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x03, 0xC7, 0xFE, 0x3E,
  0x00, 0x0F, 0x1F, 0xF8, 0xF8, 0x00, 0x7C, 0x7F, 0xE3, 0xE0, 0x01, 0xF1,
  0xFF, 0x87, 0x80, 0x07, 0x87, 0xFE, 0x1F, 0x00, 0x3E, 0x1F, 0xF8, 0x7C,
  0x00, 0xF8, 0x7F, 0xE0, 0xF0, 0x03, 0xC1, 0xFF, 0x83, 0xE0, 0x1F, 0x07,
  0xFE, 0x0F, 0x80, 0x7C, 0x1F, 0xF8, 0x1E, 0x01, 0xE0, 0x7F, 0xE0, 0x7C,
  0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xF0, 0x1F,
  0xF8, 0x0F, 0x87, 0xC0, 0x7F, 0xE0, 0x3E, 0x1F, 0x01, 0xFF, 0x80, 0xF8,
  0x78, 0x07, 0xFE, 0x01, 0xF1, 0xE0, 0x1F, 0xF8, 0x07, 0xCF, 0x80, 0x7F,
  0xE0, 0x1F, 0x3E, 0x01, 0xFF, 0x80, 0x3C, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFE,
  0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xDF, 0x00, 0x07, 0xFE, 0xFC, 0x00, 0x3F, 0xF3, 0xE0, 0x01, 0xFF,
  0x9F, 0x80, 0x0F, 0xFC, 0x7C, 0x00, 0x7F, 0xE3, 0xF0, 0x03, 0xFF, 0x0F,
  0x80, 0x1F, 0xF8, 0x7E, 0x00, 0xFF, 0xC1, 0xF0, 0x07, 0xFE, 0x0F, 0xC0,
  0x3F, 0xF0, 0x3E, 0x01, 0xFF, 0x81, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F,
  0xE0, 0x3F, 0x03, 0xFF, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC0,
  0x3F, 0x07, 0xFE, 0x00, 0xFC, 0x3F, 0xF0, 0x07, 0xE1, 0xFF, 0x80, 0x1F,
  0x8F, 0xFC, 0x00, 0xFC, 0x7F, 0xE0, 0x03, 0xF3, 0xFF, 0x00, 0x1F, 0x9F,
  0xF8, 0x00, 0x7E, 0xFF, 0xC0, 0x03, 0xF7, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0x81, 0xFF, 0x9F, 0x00, 0x7F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x1F,
  0xDF, 0x00, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0xFF, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x07, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0xF8,
  0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x00,
  0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xF0, 0x1F, 0x1F, 0x80, 0x06, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xA0, 0x00, 0x7F, 0x60, 0x01, 0xFC, 0xFE, 0x0F, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE1, 0xFF, 0x07, 0xF8,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3E, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xF0,
  0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x78,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x78, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x7C,
  0x00, 0xFC, 0x1F, 0x80, 0x1E, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x7C,
  0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x3C,
  0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3C, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x1E,
  0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x78, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x0F,
  0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x03, 0xE0, 0xF0, 0x0F,
  0x87, 0xC0, 0x03, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x0F,
  0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x07, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x07,
  0xCF, 0x80, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x07,
  0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x03, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x03,
  0xCF, 0x80, 0x00, 0xFB, 0xC0, 0x03, 0xDF, 0x00, 0x00, 0xFB, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01,
  0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x03,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x01,
  0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x81, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3C,
  0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xC7, 0xF8, 0x38,
  0x07, 0xE0, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFC,
  0x07, 0xCF, 0xC0, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF,
  0x00, 0x3F, 0x7C, 0x01, 0xFD, 0xF8, 0x0E, 0xF3, 0xFF, 0xFB, 0xCF, 0xFF,
  0xCF, 0x1F, 0xFE, 0x3C, 0x3F, 0xE0, 0xF0, 0x0E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x03, 0xF1, 0xFF, 0x81, 0xF1, 0xFF, 0xE0,
  0xF9, 0xFF, 0xF8, 0x7D, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0x1F, 0xE0, 0x0F,
  0xCF, 0xE0, 0x03, 0xE7, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xDF,
  0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF8, 0x00, 0xFD,
  0xFC, 0x00, 0x7C, 0xFE, 0x00, 0x7E, 0x7F, 0x80, 0x3F, 0x3F, 0xF0, 0x3F,
  0x1F, 0x7F, 0xFF, 0x8F, 0x9F, 0xFF, 0x87, 0xC7, 0xFF, 0x83, 0xE1, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x87,
  0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0x00, 0x8F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x02, 0x7F, 0x81, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x1F, 0x03, 0xFF,
  0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x3F, 0x81,
  0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F, 0x81,
  0xFF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x8F, 0x03, 0xFE,
  0x0F, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x43, 0xF8, 0x07, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x81, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x03, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0x0F, 0x0F, 0xFF, 0x8F, 0x0F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x3F, 0x81,
  0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F, 0x81,
  0xFF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0xDF, 0x07, 0xFF, 0x9F, 0x03, 0xFE,
  0x1F, 0x00, 0x30, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x20, 0x00, 0x7E, 0x38, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x3F, 0x1F, 0xF8, 0x7C, 0xFF, 0xF8, 0xF9, 0xFF, 0xF9, 0xF7,
  0xFF, 0xFB, 0xFE, 0x03, 0xF7, 0xF8, 0x03, 0xEF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0x80, 0x31, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x7E, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0x7E, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x07,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x7C, 0x01, 0xF9, 0xF8, 0x03,
  0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0xBF, 0x80, 0x1F, 0x7F, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xBF, 0x00, 0xFF, 0x3E, 0x01, 0xFC, 0x7E, 0x03, 0xF0,
  0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xE7,
  0xFF, 0xC3, 0xFF, 0xC7, 0xDF, 0xFF, 0x8F, 0xFF, 0xCF, 0xBF, 0xFF, 0xBF,
  0xFF, 0x9F, 0xF0, 0x3F, 0xF0, 0x3F, 0xBF, 0xC0, 0x3F, 0xC0, 0x3F, 0x7F,
  0x00, 0x7F, 0x80, 0x3E, 0xFE, 0x00, 0x7E, 0x00, 0x7D, 0xF8, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x3F,
  0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x07,
  0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00,
  0x7C, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x00,
  0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x81, 0xF0, 0xFF, 0xC3, 0xE3, 0xFF, 0xC7, 0xCF, 0xFF, 0xCF, 0xBF,
  0xFF, 0xDF, 0xF0, 0x1F, 0xBF, 0xC0, 0x1F, 0x7F, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0xFC,
  0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF,
  0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x7D, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x3F, 0xF0, 0x3E, 0x3F, 0xFC,
  0x1F, 0x3F, 0xFF, 0x0F, 0xBF, 0xFF, 0xC7, 0xFC, 0x07, 0xE3, 0xFC, 0x01,
  0xF9, 0xFC, 0x00, 0x7C, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7F, 0x00, 0x1F,
  0xBF, 0x80, 0x0F, 0x9F, 0xE0, 0x0F, 0xCF, 0xF0, 0x07, 0xE7, 0xFE, 0x0F,
  0xE3, 0xEF, 0xFF, 0xF1, 0xF3, 0xFF, 0xF0, 0xF8, 0xFF, 0xF0, 0x7E, 0x3F,
  0xE0, 0x3F, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0x0F, 0xFF, 0x8F, 0x1F, 0xFF,
  0xDF, 0x1F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x7F, 0x3F, 0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF,
  0xDF, 0x07, 0xFF, 0x9F, 0x03, 0xFE, 0x1F, 0x00, 0x70, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF,
  0xFB, 0xFF, 0xFB, 0xE1, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFC, 0xFC,
  0xFC, 0x03, 0x9F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x30,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0xF8, 0x01, 0xFD, 0xF0, 0x03, 0xFB, 0xF0, 0x0F, 0xF7, 0xF0, 0x3F, 0xE7,
  0xFF, 0xF7, 0xCF, 0xFF, 0xCF, 0x8F, 0xFF, 0x9F, 0x07, 0xFC, 0x1E, 0x00,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xE7, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0xE0, 0x07, 0xCF, 0x80,
  0x3D, 0xE0, 0x0F, 0x9F, 0x00, 0x7B, 0xC0, 0x1F, 0x3F, 0x00, 0xF7, 0x80,
  0x7C, 0x3E, 0x01, 0xEF, 0x00, 0xF8, 0x7C, 0x07, 0xDF, 0x01, 0xF0, 0xF8,
  0x0F, 0x3E, 0x03, 0xE1, 0xF0, 0x1E, 0x3C, 0x07, 0xC1, 0xF0, 0x3C, 0x78,
  0x1F, 0x03, 0xE0, 0xF8, 0xF8, 0x3E, 0x07, 0xC1, 0xF1, 0xF0, 0x7C, 0x0F,
  0x83, 0xC1, 0xE0, 0xF8, 0x1F, 0x87, 0x83, 0xC3, 0xE0, 0x1F, 0x1F, 0x07,
  0x87, 0xC0, 0x3E, 0x3E, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x1F, 0x1F, 0x00,
  0xF8, 0xF0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x3C, 0xF8, 0x01, 0xF7, 0xC0,
  0x7D, 0xF0, 0x03, 0xEF, 0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0,
  0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xE0,
  0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF8,
  0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x3F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0x80, 0x00, 0xF7, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xF9,
  0x00, 0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_Regular62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 45, 15, 4, -44 },
  { 41, 16, 16, 24, 4, -44 },
  { 73, 30, 44, 32, 1, -44 },
  { 238, 24, 51, 29, 3, -47 },
  { 391, 39, 46, 44, 3, -45 },
  { 616, 32, 46, 34, 2, -45 },
  { 800, 6, 16, 13, 4, -44 },
  { 812, 13, 55, 18, 3, -45 },
  { 902, 13, 55, 18, 2, -45 },
  { 992, 23, 23, 27, 2, -47 },
  { 1059, 25, 30, 29, 2, -37 },
  { 1153, 9, 15, 15, 2, -7 },
  { 1170, 14, 5, 18, 2, -19 },
  { 1179, 7, 8, 15, 4, -7 },
  { 1186, 21, 44, 23, 1, -44 },
  { 1302, 24, 46, 29, 3, -45 },
  { 1440, 15, 44, 29, 4, -44 },
  { 1523, 24, 45, 29, 2, -45 },
  { 1658, 24, 46, 29, 2, -45 },
  { 1796, 27, 45, 29, 1, -45 },
  { 1948, 23, 45, 29, 3, -44 },
  { 2078, 24, 46, 29, 3, -45 },
  { 2216, 25, 44, 29, 2, -44 },
  { 2354, 25, 46, 29, 2, -45 },
  { 2498, 23, 46, 29, 3, -45 },
  { 2631, 7, 35, 15, 4, -34 },
  { 2662, 9, 42, 15, 2, -34 },
  { 2710, 25, 28, 29, 2, -36 },
  { 2798, 25, 17, 29, 2, -30 },
  { 2852, 25, 28, 29, 2, -36 },
  { 2940, 19, 46, 22, 1, -45 },
  { 3050, 39, 50, 45, 3, -45 },
  { 3294, 31, 44, 31, 0, -44 },
  { 3465, 25, 44, 33, 5, -44 },
  { 3603, 27, 46, 31, 3, -45 },
  { 3759, 28, 44, 36, 5, -44 },
  { 3913, 20, 44, 28, 5, -44 },
  { 4023, 20, 44, 26, 5, -44 },
  { 4133, 30, 46, 37, 3, -45 },
  { 4306, 27, 44, 37, 5, -44 },
  { 4455, 14, 44, 19, 2, -44 },
  { 4532, 14, 56, 15, -4, -44 },
  { 4630, 26, 44, 31, 5, -44 },
  { 4773, 20, 44, 26, 5, -44 },
  { 4883, 38, 44, 48, 5, -44 },
  { 5092, 29, 44, 39, 5, -44 },
  { 5252, 32, 46, 38, 3, -45 },
  { 5436, 23, 44, 31, 5, -44 },
  { 5563, 32, 56, 38, 3, -45 },
  { 5787, 26, 44, 32, 5, -44 },
  { 5930, 23, 46, 28, 3, -45 },
  { 6063, 25, 44, 27, 1, -44 },
  { 6201, 27, 45, 36, 5, -44 },
  { 6353, 30, 44, 30, 0, -44 },
  { 6518, 48, 44, 48, 0, -44 },
  { 6782, 28, 44, 28, 0, -44 },
  { 6936, 28, 44, 28, 0, -44 },
  { 7090, 23, 44, 26, 2, -44 },
  { 7217, 13, 55, 20, 5, -45 },
  { 7307, 21, 44, 23, 1, -44 },
  { 7423, 13, 55, 20, 2, -45 },
  { 7513, 28, 25, 30, 1, -44 },
  { 7601, 27, 4, 27, 0, 5 },
  { 7615, 12, 9, 17, 2, -47 },
  { 7629, 22, 35, 28, 2, -34 },
  { 7726, 25, 48, 32, 4, -47 },
  { 7876, 19, 35, 24, 3, -34 },
  { 7960, 24, 48, 32, 3, -47 },
  { 8104, 23, 35, 29, 3, -34 },
  { 8205, 18, 47, 17, 1, -47 },
  { 8311, 24, 49, 32, 3, -34 },
  { 8458, 23, 47, 31, 4, -47 },
  { 8594, 6, 46, 14, 4, -46 },
  { 8629, 12, 61, 14, -2, -46 },
  { 8721, 23, 47, 27, 4, -47 },
  { 8857, 6, 47, 14, 4, -47 },
  { 8893, 39, 34, 47, 4, -34 },
  { 9059, 23, 34, 31, 4, -34 },
  { 9157, 25, 35, 31, 3, -34 },
  { 9267, 25, 49, 32, 4, -34 },
  { 9421, 24, 49, 32, 3, -34 },
  { 9568, 16, 34, 21, 4, -34 },
  { 9636, 19, 35, 24, 2, -34 },
  { 9720, 16, 42, 18, 1, -41 },
  { 9804, 23, 34, 31, 4, -33 },
  { 9902, 25, 33, 25, 0, -33 },
  { 10006, 39, 33, 41, 1, -33 },
  { 10167, 24, 33, 26, 1, -33 },
  { 10266, 25, 48, 26, 0, -33 },
  { 10416, 18, 33, 22, 2, -33 },
  { 10491, 18, 54, 23, 2, -44 },
  { 10613, 4, 62, 28, 12, -47 },
  { 10644, 18, 54, 23, 2, -44 },
  { 10766, 25, 8, 29, 2, -26 },
};

const GFXfont NotoSans_Condensed_Regular62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_REGULAR62PT7B_H_
