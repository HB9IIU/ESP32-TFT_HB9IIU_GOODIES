#ifndef _NOTOSANS_CONDENSED_REGULAR48PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0x00, 0x00, 0x00, 0x31, 0xEF,
  0xFF, 0xF9, 0xE0, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0x78,
  0x3B, 0xC1, 0xDE, 0x0E, 0xF0, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE0, 0x00,
  0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x81, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xE0, 0x70, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x1F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7F,
  0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xE7, 0x1C, 0x78, 0xE0, 0x9E, 0x1C,
  0x03, 0xC3, 0x80, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x1E, 0x38,
  0x03, 0xF7, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xDF, 0x00, 0x38, 0xF0, 0x07, 0x1E, 0x00, 0xE1,
  0xC0, 0x1C, 0x3C, 0x03, 0x87, 0x00, 0x71, 0xE8, 0x0E, 0x3D, 0xE1, 0xDF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0xE0, 0x1E, 0x78, 0x07,
  0x80, 0x70, 0xE0, 0x1C, 0x01, 0xC3, 0xC0, 0x70, 0x0F, 0x0F, 0x03, 0x80,
  0x3C, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x78, 0x03, 0x81, 0xC1, 0xC0, 0x0E,
  0x07, 0x0F, 0x00, 0x38, 0x1C, 0x38, 0x00, 0xE0, 0x70, 0xE0, 0x03, 0x81,
  0xC7, 0x80, 0x0E, 0x07, 0x1C, 0x3E, 0x3C, 0x3C, 0xF3, 0xFC, 0x70, 0xF3,
  0x8F, 0xF9, 0xC3, 0x8E, 0x79, 0xE7, 0x9E, 0x79, 0xC3, 0x8F, 0xF1, 0xC7,
  0x0F, 0x1F, 0x8F, 0x3C, 0x1C, 0x3C, 0x38, 0xF0, 0x70, 0x00, 0xE3, 0xC1,
  0xC0, 0x07, 0x0E, 0x07, 0x00, 0x1C, 0x38, 0x1C, 0x00, 0xF0, 0xE0, 0x70,
  0x03, 0x83, 0xC1, 0xC0, 0x1E, 0x0F, 0x07, 0x00, 0x70, 0x3C, 0x1C, 0x01,
  0xC0, 0x70, 0xF0, 0x0F, 0x01, 0xC3, 0xC0, 0x38, 0x07, 0x8E, 0x01, 0xE0,
  0x0F, 0xF8, 0x07, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x7E, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1C,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0x87, 0xDF, 0x03,
  0xC7, 0xC7, 0xC1, 0xE3, 0xC1, 0xE1, 0xE3, 0xE0, 0xF8, 0xF1, 0xE0, 0x3E,
  0x78, 0xF0, 0x0F, 0xFC, 0x78, 0x03, 0xFC, 0x3C, 0x01, 0xFE, 0x1E, 0x00,
  0x7E, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0xE0, 0xFC,
  0x3F, 0xF8, 0x7F, 0xFF, 0x3E, 0x1F, 0xFF, 0x1F, 0x03, 0xFE, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x03, 0xE0, 0x70, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0xF8, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x03, 0x87, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0xFE, 0x00, 0x77, 0x80, 0x79, 0xC0, 0x78, 0xF0, 0x7C, 0x3C,
  0x1C, 0x1E, 0x06, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x7C,
  0xF1, 0xE7, 0xCF, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0xBC, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF,
  0x83, 0xE1, 0xF0, 0x78, 0x1F, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E,
  0xF8, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x78,
  0x78, 0x0F, 0x0F, 0x83, 0xE1, 0xF8, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x1F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xEF,
  0x7C, 0xFF, 0x8F, 0x30, 0xF2, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x07, 0xFF, 0x03, 0xFF,
  0xE3, 0xFF, 0xFC, 0x78, 0x1F, 0x18, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x78, 0x1F,
  0x98, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x07,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFB, 0xC0,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F,
  0x03, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xF1,
  0xFF, 0xFC, 0x79, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF4, 0x00, 0xFB, 0x81, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x60, 0x1C, 0x7F, 0x87, 0x9F, 0xF8, 0xF7, 0xFF, 0x9F, 0xC1, 0xF3,
  0xF0, 0x1F, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x3C, 0x78, 0x07, 0x8F, 0x81, 0xE0, 0xF8, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xE0, 0xF8, 0xF8, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x7C, 0x1E, 0x07,
  0xCF, 0xC0, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0x9F, 0x83, 0xE1, 0xF8, 0xF8, 0x1F, 0x1E, 0x01, 0xF7, 0x80, 0x1E, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0x9E, 0x01, 0xF3, 0xE0, 0x7C, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3E,
  0x1F, 0x1F, 0x03, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0x78, 0x07, 0xDF, 0x03, 0xF7, 0xE1, 0xFC, 0xFF, 0xEF, 0x1F,
  0xFB, 0xC3, 0xF8, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x83, 0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xBC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF,
  0xFB, 0xC0, 0x38, 0xF9, 0xF3, 0xE7, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC7, 0xCF, 0x3E, 0x7C,
  0xF1, 0xE3, 0xC7, 0x1E, 0x38, 0x70, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xE6, 0x07, 0xC8,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xCF, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE3, 0xC0, 0x7F,
  0x83, 0x8E, 0x03, 0xFF, 0x0F, 0x38, 0x1F, 0xFC, 0x1D, 0xE0, 0xF0, 0xF0,
  0x77, 0x03, 0x83, 0xC1, 0xDC, 0x1E, 0x0F, 0x07, 0x70, 0x70, 0x3C, 0x1D,
  0xC1, 0xC0, 0xF0, 0x77, 0x07, 0x03, 0xC1, 0xFC, 0x3C, 0x0F, 0x07, 0xF0,
  0xF0, 0x3C, 0x1F, 0xC3, 0xC0, 0xE0, 0x7F, 0x0F, 0x03, 0x81, 0xDC, 0x1C,
  0x0E, 0x07, 0x70, 0x70, 0x7C, 0x3D, 0xC1, 0xE1, 0xF0, 0xE7, 0x07, 0xDE,
  0xE7, 0x9C, 0x0F, 0xF3, 0xFC, 0x78, 0x1F, 0x87, 0xE0, 0xE0, 0x1C, 0x0E,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x01, 0xF8, 0x03, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xE7, 0x80, 0x01,
  0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07,
  0x81, 0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x78, 0x1F, 0xCF, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7D,
  0xE0, 0x1F, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3,
  0xC0, 0x3F, 0x78, 0x03, 0xEF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xC0, 0xE1, 0xF0, 0x02, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x21, 0xFE, 0x1E, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xE0, 0xFF, 0x0F, 0x00, 0xFC, 0x78, 0x01, 0xF3, 0xC0, 0x0F,
  0x9E, 0x00, 0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7,
  0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x78, 0x07,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFC, 0x03, 0xC3, 0xF0,
  0x01, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x7B, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xC7, 0xE0,
  0x07, 0x87, 0xF8, 0x3F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFD, 0xFE, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x87, 0xFE, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF7,
  0xFE, 0xFF, 0x9F, 0xE3, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x3C, 0xF0,
  0x07, 0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x1F, 0x00,
  0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFD, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF8, 0x0F, 0x07,
  0x80, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0xF0,
  0x1F, 0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xCF,
  0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0x80, 0x01, 0xDF, 0xFC, 0x00, 0x1E,
  0xFF, 0xE0, 0x00, 0xFF, 0xF7, 0x80, 0x07, 0x7F, 0xBC, 0x00, 0x7B, 0xFD,
  0xE0, 0x03, 0xDF, 0xE7, 0x00, 0x1C, 0xFF, 0x3C, 0x01, 0xE7, 0xF9, 0xE0,
  0x0F, 0x3F, 0xC7, 0x00, 0x71, 0xFE, 0x3C, 0x07, 0x8F, 0xF1, 0xE0, 0x3C,
  0x7F, 0x87, 0x01, 0xC3, 0xFC, 0x3C, 0x0E, 0x1F, 0xE1, 0xE0, 0xF0, 0xFF,
  0x0F, 0x07, 0x87, 0xF8, 0x3C, 0x38, 0x3F, 0xC1, 0xE3, 0xC1, 0xFE, 0x0F,
  0x1E, 0x0F, 0xF0, 0x3C, 0xE0, 0x7F, 0x81, 0xEF, 0x03, 0xFC, 0x0F, 0x78,
  0x1F, 0xE0, 0x3B, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x3E, 0x01, 0xFE, 0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x80, 0x7F, 0x80,
  0x38, 0x03, 0xC0, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0xF0, 0x03, 0xFB, 0xE0,
  0x0F, 0xF7, 0x80, 0x3F, 0xDF, 0x00, 0xFF, 0x3C, 0x03, 0xFC, 0xF8, 0x0F,
  0xF1, 0xE0, 0x3F, 0xC7, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x3E, 0x0F, 0xF0,
  0x78, 0x3F, 0xC1, 0xF0, 0xFF, 0x03, 0xC3, 0xFC, 0x0F, 0x8F, 0xF0, 0x1E,
  0x3F, 0xC0, 0x7C, 0xFF, 0x00, 0xF3, 0xFC, 0x03, 0xEF, 0xF0, 0x07, 0xBF,
  0xC0, 0x1F, 0x7F, 0x00, 0x3D, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0xC3,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC3, 0xFC, 0xF0, 0x1F, 0xBC, 0x03, 0xEF,
  0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x3F,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0x80, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xF8,
  0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0x1F,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x00,
  0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0,
  0x0F, 0x8F, 0x01, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0,
  0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x07,
  0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00,
  0x1F, 0x01, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7E, 0x07,
  0x1F, 0x00, 0x47, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xEC, 0x00, 0xFB, 0xE0,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0xC0, 0x3E,
  0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x0F,
  0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xC0, 0x03, 0xDE, 0x00, 0x3E,
  0x00, 0x3E, 0xF0, 0x01, 0xF8, 0x01, 0xE7, 0xC0, 0x0F, 0xC0, 0x0F, 0x1E,
  0x00, 0xFE, 0x00, 0x78, 0xF0, 0x07, 0xF0, 0x03, 0xC7, 0x80, 0x3B, 0xC0,
  0x3E, 0x3C, 0x01, 0xDE, 0x01, 0xE1, 0xF0, 0x0E, 0xF0, 0x0F, 0x07, 0x80,
  0xF3, 0x80, 0x78, 0x3C, 0x07, 0x9C, 0x03, 0xC1, 0xE0, 0x38, 0xF0, 0x3C,
  0x0F, 0x01, 0xC7, 0x81, 0xE0, 0x3C, 0x1E, 0x3C, 0x0F, 0x01, 0xE0, 0xF0,
  0xE0, 0x78, 0x0F, 0x07, 0x87, 0x87, 0xC0, 0x78, 0x38, 0x3C, 0x3C, 0x01,
  0xE3, 0xC1, 0xE1, 0xE0, 0x0F, 0x1E, 0x07, 0x0F, 0x00, 0x78, 0xF0, 0x3C,
  0x78, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0x1E, 0x38, 0x0F, 0x3C, 0x00, 0x7B,
  0xC0, 0x39, 0xE0, 0x03, 0xDE, 0x01, 0xCF, 0x00, 0x1E, 0xF0, 0x0F, 0x78,
  0x00, 0xF7, 0x00, 0x7F, 0x80, 0x03, 0xB8, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x07, 0x80,
  0x78, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE1, 0xF0,
  0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3C,
  0x1F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0xF8, 0x1E, 0x01, 0xE0, 0xF8, 0x07,
  0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xFB, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0,
  0x1E, 0x1F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x3C, 0x03, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE7,
  0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xEE, 0x00, 0x0E, 0x78, 0x00, 0xF1, 0xC0, 0x07, 0x8F, 0x00, 0x38, 0x38,
  0x03, 0xC1, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x3C, 0x0E, 0x00, 0xE0, 0xF0,
  0x07, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xF3, 0x80, 0x03, 0xBC, 0x00, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7C, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x07, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x83,
  0x83, 0xE1, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0xFF, 0xF1, 0xFF, 0xF9, 0xFE, 0x3D, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFE, 0xFF, 0xEF, 0x3F, 0xE7, 0x8F, 0xE1,
  0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC3, 0xF0, 0x79, 0xFF, 0x8F, 0x7F, 0xF1, 0xFE, 0x3F, 0x3F, 0x01,
  0xF7, 0xE0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07,
  0xBF, 0x00, 0xF7, 0xE0, 0x3E, 0xFE, 0x0F, 0x9E, 0xFF, 0xF3, 0xCF, 0xFC,
  0x78, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0xFC, 0xE3, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0xC1, 0x8F, 0xFF,
  0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x1F, 0xC7, 0x87, 0xFC, 0xF1, 0xFF, 0xDE, 0x7E,
  0x3F, 0xCF, 0x01, 0xFB, 0xE0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x07, 0xDF, 0x00, 0xF9, 0xE0, 0x3F, 0x3E, 0x0F, 0xE3, 0xFF,
  0xBC, 0x3F, 0xF3, 0x83, 0xF8, 0x70, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0x7C, 0x7C, 0x3C, 0x0F, 0x9F, 0x01, 0xE7, 0x80, 0x39, 0xE0, 0x0F,
  0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x21, 0xF0, 0x38, 0x7F, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xF0, 0x0F, 0xF0, 0x7F, 0x83, 0xFE,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x07, 0xF0,
  0xE1, 0xFF, 0x1C, 0x7F, 0xF7, 0x9F, 0x8F, 0xF3, 0xC0, 0x7E, 0xF8, 0x07,
  0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3E,
  0x78, 0x0F, 0xCF, 0x83, 0xF8, 0xFF, 0xEF, 0x0F, 0xFD, 0xE0, 0xFE, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x40, 0x07, 0xC7, 0x01, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81,
  0xFF, 0xC0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x0F, 0xC3, 0xCF, 0xFC, 0xF7, 0xFF, 0x3F, 0xC7,
  0xEF, 0xE0, 0x7B, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x07, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC,
  0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87,
  0xDF, 0xEF, 0xE7, 0xE0, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07,
  0x8F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x1E, 0x03,
  0xCF, 0x80, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFC,
  0xF0, 0x3E, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x01, 0xE3, 0xC0, 0x7C, 0xF0, 0x0F, 0x3C, 0x03, 0xEF, 0x00, 0x7B,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x0F, 0xE3,
  0xCF, 0xF8, 0xFF, 0xCF, 0x7F, 0xF3, 0xFF, 0xBF, 0xC7, 0xDE, 0x7E, 0xFC,
  0x0F, 0xE0, 0x7F, 0xF0, 0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x01,
  0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x3F, 0xE0, 0x1E, 0x00, 0xFF, 0x00, 0x78,
  0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00,
  0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0,
  0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01,
  0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0xF0, 0xFC,
  0x3C, 0xFF, 0xCF, 0x7F, 0xFB, 0xFC, 0x7E, 0xFC, 0x07, 0xBF, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x87, 0xC3, 0xE0, 0x7C, 0xF8, 0x07, 0x9E,
  0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0xC0, 0x3C, 0x78,
  0x0F, 0x8F, 0xC3, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xF1,
  0xFC, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7B, 0x87, 0xCF, 0xC0, 0x7D, 0xF8,
  0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xEF, 0xC0,
  0x3D, 0xF8, 0x0F, 0xBF, 0xC3, 0xE7, 0xBF, 0xFC, 0xF3, 0xFF, 0x1E, 0x3F,
  0xC3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0xE1, 0xFF, 0x1C, 0x7F,
  0xF7, 0x9F, 0x8F, 0xF3, 0xC0, 0x7E, 0xF8, 0x07, 0xDE, 0x00, 0xFB, 0xC0,
  0x1F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0xC0, 0x3E, 0x78, 0x0F, 0xCF, 0x83,
  0xF8, 0xFF, 0xEF, 0x0F, 0xFD, 0xE0, 0xFE, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0xFF, 0x9F, 0xBC, 0xFD, 0xEF, 0xEF, 0xF0, 0x7F, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0xF9,
  0xFF, 0xF7, 0xE1, 0xCF, 0x00, 0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xD0,
  0x07, 0xB8, 0x1F, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x03, 0xF7, 0xC1,
  0xFC, 0xFF, 0xEF, 0x3F, 0xF3, 0xC3, 0xF8, 0xF0, 0xF0, 0x01, 0xF7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x7C, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0x71, 0xE0,
  0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9C, 0x00, 0x3B, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0xF0, 0x0F, 0x80, 0x3D, 0xE0, 0x1F, 0x80,
  0x7B, 0xC0, 0x3F, 0x01, 0xE7, 0x80, 0x7E, 0x03, 0xC7, 0x81, 0xFC, 0x07,
  0x8F, 0x03, 0xBC, 0x0F, 0x1E, 0x07, 0x78, 0x1C, 0x3C, 0x0E, 0x70, 0x78,
  0x3C, 0x3C, 0xE0, 0xF0, 0x78, 0x79, 0xC1, 0xE0, 0xF0, 0xE3, 0xC3, 0xC1,
  0xE1, 0xC7, 0x87, 0x01, 0xC7, 0x87, 0x1E, 0x03, 0xCF, 0x0E, 0x3C, 0x07,
  0x9C, 0x1E, 0x78, 0x0F, 0x38, 0x3C, 0xE0, 0x1E, 0x70, 0x3B, 0xC0, 0x1D,
  0xE0, 0x77, 0x80, 0x3F, 0xC0, 0xEF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xDE, 0x01, 0xE7, 0xC0,
  0x78, 0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0x87, 0x81, 0xF1, 0xE0, 0x3C, 0xF0,
  0x07, 0xBC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x78, 0x78, 0x1E, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF9, 0xE0, 0x1E,
  0x78, 0x07, 0xFC, 0x00, 0xF0, 0xF0, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x0E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x03, 0x9C, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x3F, 0x80, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x0F, 0xF0, 0x3F, 0x80, 0xF8, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x2F,
  0xF8, 0x0F, 0xFF, 0xE3, 0xFB, 0xFF, 0xFC, 0x0F, 0xFD, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 34, 12, 3, -34 },
  { 27, 13, 12, 19, 3, -34 },
  { 47, 23, 34, 25, 1, -34 },
  { 145, 19, 39, 23, 2, -36 },
  { 238, 30, 35, 34, 2, -35 },
  { 370, 25, 35, 27, 2, -35 },
  { 480, 4, 12, 10, 3, -34 },
  { 486, 11, 42, 14, 2, -34 },
  { 544, 11, 42, 14, 1, -34 },
  { 602, 17, 18, 21, 2, -37 },
  { 641, 19, 22, 23, 2, -28 },
  { 694, 7, 12, 11, 2, -6 },
  { 705, 11, 4, 14, 1, -15 },
  { 711, 5, 6, 11, 3, -6 },
  { 715, 16, 34, 18, 1, -34 },
  { 783, 19, 35, 23, 2, -35 },
  { 867, 12, 34, 23, 3, -34 },
  { 918, 18, 35, 23, 2, -35 },
  { 997, 18, 35, 23, 2, -35 },
  { 1076, 21, 35, 23, 1, -35 },
  { 1168, 17, 34, 23, 3, -34 },
  { 1241, 19, 35, 23, 2, -35 },
  { 1325, 19, 34, 23, 2, -34 },
  { 1406, 19, 35, 23, 2, -35 },
  { 1490, 18, 35, 23, 2, -35 },
  { 1569, 5, 26, 12, 3, -26 },
  { 1586, 7, 32, 12, 2, -26 },
  { 1614, 19, 22, 23, 2, -28 },
  { 1667, 19, 14, 23, 2, -24 },
  { 1701, 19, 22, 23, 2, -28 },
  { 1754, 15, 35, 17, 1, -35 },
  { 1820, 30, 39, 35, 2, -35 },
  { 1967, 24, 34, 24, 0, -34 },
  { 2069, 19, 34, 25, 4, -34 },
  { 2150, 20, 35, 24, 3, -35 },
  { 2238, 21, 34, 28, 4, -34 },
  { 2328, 15, 34, 22, 4, -34 },
  { 2392, 15, 34, 20, 4, -34 },
  { 2456, 23, 35, 29, 3, -35 },
  { 2557, 21, 34, 29, 4, -34 },
  { 2647, 11, 34, 14, 2, -34 },
  { 2694, 11, 43, 11, -3, -34 },
  { 2754, 20, 34, 24, 4, -34 },
  { 2839, 15, 34, 20, 4, -34 },
  { 2903, 29, 34, 37, 4, -34 },
  { 3027, 22, 34, 30, 4, -34 },
  { 3121, 24, 35, 30, 3, -35 },
  { 3226, 18, 34, 24, 4, -34 },
  { 3303, 24, 43, 30, 3, -35 },
  { 3432, 20, 34, 24, 4, -34 },
  { 3517, 18, 35, 22, 2, -35 },
  { 3596, 20, 34, 21, 0, -34 },
  { 3681, 20, 34, 28, 4, -34 },
  { 3766, 23, 34, 23, 0, -34 },
  { 3864, 37, 34, 38, 0, -34 },
  { 4022, 22, 34, 22, 0, -34 },
  { 4116, 21, 34, 21, 0, -34 },
  { 4206, 18, 34, 20, 1, -34 },
  { 4283, 10, 42, 15, 4, -34 },
  { 4336, 16, 34, 18, 1, -34 },
  { 4404, 11, 42, 15, 1, -34 },
  { 4462, 21, 19, 23, 1, -34 },
  { 4512, 21, 3, 21, 0, 4 },
  { 4520, 9, 8, 13, 2, -37 },
  { 4529, 17, 26, 22, 2, -26 },
  { 4585, 19, 36, 24, 3, -36 },
  { 4671, 15, 26, 19, 2, -26 },
  { 4720, 19, 36, 24, 2, -36 },
  { 4806, 18, 26, 22, 2, -26 },
  { 4865, 14, 37, 13, 1, -37 },
  { 4930, 19, 38, 24, 2, -26 },
  { 5021, 18, 36, 24, 3, -36 },
  { 5102, 5, 35, 11, 3, -35 },
  { 5124, 9, 47, 11, -1, -35 },
  { 5177, 18, 36, 21, 3, -36 },
  { 5258, 4, 36, 11, 3, -36 },
  { 5276, 30, 26, 36, 3, -26 },
  { 5374, 18, 26, 24, 3, -26 },
  { 5433, 19, 26, 24, 2, -26 },
  { 5495, 19, 38, 24, 3, -26 },
  { 5586, 19, 38, 24, 2, -26 },
  { 5677, 13, 26, 16, 3, -26 },
  { 5720, 15, 26, 18, 2, -26 },
  { 5769, 12, 32, 14, 1, -32 },
  { 5817, 18, 26, 24, 3, -26 },
  { 5876, 20, 26, 20, 0, -26 },
  { 5941, 31, 26, 32, 0, -26 },
  { 6042, 18, 26, 20, 1, -26 },
  { 6101, 20, 38, 20, 0, -26 },
  { 6196, 15, 26, 17, 1, -26 },
  { 6245, 14, 42, 18, 2, -34 },
  { 6319, 4, 48, 22, 9, -37 },
  { 6343, 14, 42, 18, 2, -34 },
  { 6417, 19, 6, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_Regular48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_REGULAR48PT7B_H_
