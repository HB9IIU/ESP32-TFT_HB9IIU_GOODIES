#ifndef _NOTOSANS_CONDENSED_REGULAR17PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0x4F, 0xDE, 0xA5, 0x20, 0x12, 0x12, 0x12, 0x7F, 0x12,
  0x24, 0x24, 0xFF, 0x24, 0x24, 0x24, 0x6C, 0x20, 0x8F, 0xE8, 0xA3, 0x87,
  0x07, 0x24, 0x9A, 0xFE, 0x20, 0x80, 0xE1, 0x24, 0x89, 0x22, 0x58, 0x94,
  0x25, 0x7E, 0xA4, 0x29, 0x1A, 0x44, 0x91, 0x34, 0x87, 0x78, 0x48, 0x48,
  0x48, 0x78, 0x30, 0xD3, 0x9B, 0x8E, 0x86, 0xCE, 0x7B, 0xFA, 0x29, 0x69,
  0x24, 0x93, 0x64, 0xC8, 0xC6, 0x23, 0x31, 0x11, 0x11, 0x33, 0x26, 0x40,
  0x30, 0x8E, 0xCC, 0x53, 0x60, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0xFA,
  0xE0, 0xF0, 0x04, 0x20, 0x86, 0x10, 0x43, 0x08, 0x21, 0x84, 0x30, 0x7B,
  0x3C, 0xE1, 0x86, 0x18, 0x61, 0x87, 0x3C, 0xDE, 0x37, 0xD1, 0x11, 0x11,
  0x11, 0x11, 0xFA, 0x30, 0xC3, 0x0C, 0x21, 0x8C, 0x61, 0x08, 0x3F, 0xFA,
  0x30, 0xC3, 0x09, 0xC1, 0x83, 0x04, 0x18, 0xFE, 0x0C, 0x0C, 0x1C, 0x14,
  0x34, 0x24, 0x44, 0x44, 0xFF, 0x04, 0x04, 0x04, 0xFF, 0x0C, 0x20, 0x83,
  0xE0, 0xC1, 0x04, 0x38, 0xFE, 0x3D, 0x8C, 0x20, 0x93, 0xFC, 0x61, 0x87,
  0x14, 0xDE, 0xFC, 0x10, 0xC2, 0x08, 0x61, 0x0C, 0x30, 0x86, 0x18, 0x7B,
  0x38, 0x73, 0x48, 0xC7, 0xA3, 0x86, 0x1C, 0xDE, 0x7B, 0x38, 0x61, 0x86,
  0x3F, 0x49, 0x0C, 0x31, 0xBC, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE8, 0x04,
  0x33, 0x30, 0xC0, 0xC0, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0x03, 0x03, 0x0C,
  0xCC, 0x20, 0xFA, 0x20, 0xC3, 0x08, 0x43, 0x08, 0x20, 0x02, 0x08, 0x1F,
  0x08, 0x24, 0x07, 0x39, 0x9A, 0x64, 0x99, 0x26, 0x49, 0x92, 0x67, 0x6C,
  0x01, 0x80, 0x3F, 0x00, 0x18, 0x0E, 0x05, 0x06, 0x83, 0x41, 0x30, 0x88,
  0xFC, 0x63, 0x21, 0xB0, 0x58, 0x30, 0xFD, 0x8F, 0x1E, 0x3C, 0x7F, 0x31,
  0xE1, 0xC3, 0x87, 0x1F, 0xE0, 0x3E, 0xC5, 0x06, 0x0C, 0x10, 0x20, 0x60,
  0xC0, 0x81, 0x89, 0xF0, 0xFC, 0xC6, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC2, 0xCE, 0xF8, 0xFF, 0x0C, 0x30, 0xC3, 0xFC, 0x30, 0xC3, 0x0C,
  0x3F, 0xFF, 0x0C, 0x30, 0xC3, 0x0F, 0xF0, 0xC3, 0x0C, 0x30, 0x3F, 0x61,
  0x40, 0xC0, 0xC0, 0x80, 0x87, 0xC1, 0xC1, 0x41, 0x61, 0x3F, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE9, 0x24,
  0x92, 0x49, 0x70, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xE0, 0xC6,
  0xC4, 0xCC, 0xD8, 0xD0, 0xF0, 0xF8, 0xD8, 0xCC, 0xC4, 0xC6, 0xC3, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xE0, 0x7C, 0x1F, 0x83,
  0xF8, 0x7D, 0x1F, 0xA2, 0xF6, 0x5E, 0x5B, 0xCA, 0x79, 0x4F, 0x39, 0xE2,
  0x30, 0xC1, 0xE1, 0xE1, 0xF1, 0xD1, 0xD9, 0xC9, 0xCD, 0xC5, 0xC7, 0xC3,
  0xC3, 0x3E, 0x31, 0xB0, 0x58, 0x2C, 0x1C, 0x0E, 0x07, 0x83, 0xC1, 0x61,
  0x98, 0xC7, 0xC0, 0xF9, 0x9B, 0x1E, 0x3C, 0x79, 0xBF, 0x60, 0xC1, 0x83,
  0x06, 0x00, 0x3E, 0x31, 0xB0, 0x58, 0x2C, 0x1C, 0x0E, 0x07, 0x83, 0xC1,
  0x61, 0x98, 0xC7, 0xC0, 0x40, 0x30, 0x0C, 0xFD, 0x9B, 0x1E, 0x3C, 0x79,
  0xBE, 0x64, 0xCD, 0x8B, 0x1E, 0x10, 0x7F, 0x18, 0x20, 0xC1, 0xC1, 0x83,
  0x04, 0x38, 0xFE, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x80, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x66, 0x3C, 0xC1, 0xC3, 0x43, 0x42, 0x62, 0x26, 0x24, 0x34, 0x34, 0x1C,
  0x18, 0x18, 0xC2, 0x0E, 0x18, 0xD1, 0xC6, 0x8A, 0x26, 0x51, 0x32, 0xD8,
  0xB2, 0xC5, 0x14, 0x28, 0xA1, 0xC5, 0x06, 0x38, 0x30, 0xC0, 0xC2, 0x66,
  0x24, 0x3C, 0x18, 0x18, 0x18, 0x3C, 0x24, 0x66, 0x46, 0xC3, 0xC3, 0x46,
  0x64, 0x64, 0x2C, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFC, 0x21,
  0x84, 0x30, 0xC2, 0x18, 0x43, 0x08, 0x3F, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xF0, 0xC1, 0x06, 0x08, 0x20, 0xC1, 0x04, 0x18, 0x20, 0xC1,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18, 0x18, 0x3C, 0x24,
  0x66, 0x42, 0xC3, 0xFF, 0xFF, 0xC8, 0x80, 0xF8, 0x20, 0xC3, 0xFE, 0x38,
  0xE3, 0xFC, 0xC1, 0x83, 0x06, 0x0F, 0xD8, 0xB1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x2B, 0xC0, 0x7E, 0x21, 0x08, 0x43, 0x19, 0x78, 0x04, 0x10, 0x41, 0x7F,
  0x38, 0x61, 0x86, 0x18, 0x73, 0x7C, 0x7B, 0x38, 0x61, 0xFE, 0x08, 0x31,
  0x7C, 0x39, 0x18, 0xCF, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x00, 0x7F, 0x38,
  0x61, 0x86, 0x18, 0x73, 0x74, 0x10, 0x63, 0xF8, 0xC3, 0x0C, 0x30, 0xFF,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC4, 0xB0, 0xFF, 0xFF, 0xC0, 0x4C, 0x06,
  0xDB, 0x6D, 0xB6, 0xDB, 0xC0, 0xC3, 0x0C, 0x30, 0xCF, 0x6D, 0x3C, 0xF3,
  0x6C, 0xB3, 0xC4, 0xFF, 0xFF, 0xFF, 0xC0, 0xBF, 0xD9, 0xCF, 0x11, 0xE2,
  0x3C, 0x47, 0x88, 0xF1, 0x1E, 0x23, 0xC4, 0x60, 0xBF, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC4, 0x79, 0x9A, 0x14, 0x38, 0x70, 0xE1, 0x66, 0x78, 0xBD,
  0x8B, 0x1E, 0x3C, 0x78, 0xF1, 0xE2, 0xFD, 0x83, 0x06, 0x0C, 0x00, 0x7F,
  0x38, 0x61, 0x86, 0x18, 0x73, 0x74, 0x10, 0x41, 0x04, 0xBF, 0x31, 0x8C,
  0x63, 0x18, 0xC0, 0xFC, 0x21, 0x87, 0x0C, 0x73, 0xF0, 0x23, 0x3E, 0xC6,
  0x31, 0x8C, 0x63, 0x0E, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x74, 0xC6,
  0x89, 0x12, 0x26, 0xC5, 0x0A, 0x1C, 0x10, 0xC6, 0x29, 0xCD, 0x29, 0x25,
  0x26, 0xA4, 0xD7, 0x8C, 0x61, 0x8C, 0x31, 0x80, 0xC6, 0xD8, 0xA1, 0xC1,
  0x07, 0x0B, 0x32, 0xC6, 0xC6, 0x89, 0x13, 0x66, 0xC5, 0x0A, 0x1C, 0x10,
  0x20, 0xC1, 0x0E, 0x00, 0x78, 0x21, 0x84, 0x30, 0x86, 0x10, 0xFC, 0x39,
  0x18, 0xC6, 0x31, 0x18, 0x63, 0x18, 0xC6, 0x18, 0x60, 0xFF, 0xFF, 0x80,
  0xC3, 0x18, 0xC6, 0x30, 0x87, 0x23, 0x18, 0xC6, 0x62, 0x00, 0xE6, 0x70,
};

const GFXglyph NotoSans_Condensed_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 5, 4, 7, 1, -12 },
  { 7, 8, 12, 9, 0, -12 },
  { 19, 6, 14, 8, 1, -13 },
  { 30, 10, 12, 12, 1, -12 },
  { 45, 8, 12, 9, 1, -12 },
  { 57, 2, 4, 4, 1, -12 },
  { 58, 3, 15, 5, 1, -12 },
  { 64, 4, 15, 5, 0, -12 },
  { 72, 6, 6, 8, 1, -13 },
  { 77, 6, 8, 8, 1, -10 },
  { 83, 2, 4, 4, 1, -2 },
  { 84, 3, 1, 5, 1, -5 },
  { 85, 2, 2, 4, 1, -2 },
  { 86, 6, 12, 6, 0, -12 },
  { 95, 6, 12, 8, 1, -12 },
  { 104, 4, 12, 8, 1, -12 },
  { 110, 6, 12, 8, 1, -12 },
  { 119, 6, 12, 8, 1, -12 },
  { 128, 8, 12, 8, 0, -12 },
  { 140, 6, 12, 8, 1, -12 },
  { 149, 6, 12, 8, 1, -12 },
  { 158, 6, 12, 8, 1, -12 },
  { 167, 6, 12, 8, 1, -12 },
  { 176, 6, 12, 8, 1, -12 },
  { 185, 2, 9, 4, 1, -9 },
  { 188, 2, 11, 4, 1, -9 },
  { 191, 6, 8, 8, 1, -10 },
  { 197, 6, 4, 8, 1, -8 },
  { 200, 6, 8, 8, 1, -10 },
  { 206, 6, 12, 6, 0, -12 },
  { 215, 10, 13, 12, 1, -12 },
  { 232, 9, 12, 9, 0, -12 },
  { 246, 7, 12, 9, 1, -12 },
  { 257, 7, 12, 9, 1, -12 },
  { 268, 8, 12, 10, 1, -12 },
  { 280, 6, 12, 8, 1, -12 },
  { 289, 6, 12, 7, 1, -12 },
  { 298, 8, 12, 10, 1, -12 },
  { 310, 8, 12, 10, 1, -12 },
  { 322, 3, 12, 5, 1, -12 },
  { 327, 4, 15, 4, -1, -12 },
  { 335, 8, 12, 8, 1, -12 },
  { 347, 6, 12, 7, 1, -12 },
  { 356, 11, 12, 13, 1, -12 },
  { 373, 8, 12, 11, 1, -12 },
  { 385, 9, 12, 11, 1, -12 },
  { 399, 7, 12, 8, 1, -12 },
  { 410, 9, 15, 11, 1, -12 },
  { 427, 7, 12, 9, 1, -12 },
  { 438, 6, 12, 8, 1, -12 },
  { 447, 7, 12, 7, 0, -12 },
  { 458, 8, 12, 10, 1, -12 },
  { 470, 8, 12, 8, 0, -12 },
  { 482, 13, 12, 13, 0, -12 },
  { 502, 8, 12, 8, 0, -12 },
  { 514, 8, 12, 8, 0, -12 },
  { 526, 6, 12, 7, 1, -12 },
  { 535, 4, 15, 5, 1, -12 },
  { 543, 6, 12, 6, 0, -12 },
  { 552, 4, 15, 5, 0, -12 },
  { 560, 8, 7, 8, 0, -12 },
  { 567, 8, 2, 7, 0, 1 },
  { 569, 3, 3, 5, 1, -13 },
  { 571, 6, 9, 8, 1, -9 },
  { 578, 7, 13, 9, 1, -13 },
  { 590, 5, 9, 7, 1, -9 },
  { 596, 6, 13, 9, 1, -13 },
  { 606, 6, 9, 8, 1, -9 },
  { 613, 5, 13, 5, 0, -13 },
  { 622, 6, 13, 9, 1, -9 },
  { 632, 6, 13, 9, 1, -13 },
  { 642, 2, 13, 4, 1, -13 },
  { 646, 3, 17, 4, 0, -13 },
  { 653, 6, 13, 7, 1, -13 },
  { 663, 2, 13, 4, 1, -13 },
  { 667, 11, 9, 13, 1, -9 },
  { 680, 6, 9, 9, 1, -9 },
  { 687, 7, 9, 8, 1, -9 },
  { 695, 7, 13, 9, 1, -9 },
  { 707, 6, 13, 9, 1, -9 },
  { 717, 5, 9, 6, 1, -9 },
  { 723, 5, 9, 6, 1, -9 },
  { 729, 5, 11, 5, 0, -11 },
  { 736, 6, 9, 9, 1, -9 },
  { 743, 7, 9, 7, 0, -9 },
  { 751, 11, 9, 11, 0, -9 },
  { 764, 7, 9, 7, 0, -9 },
  { 772, 7, 13, 7, 0, -9 },
  { 784, 6, 9, 6, 0, -9 },
  { 791, 5, 15, 6, 1, -12 },
  { 801, 1, 17, 8, 3, -13 },
  { 804, 5, 15, 6, 1, -12 },
  { 814, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Regular17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_REGULAR17PT7B_H_
