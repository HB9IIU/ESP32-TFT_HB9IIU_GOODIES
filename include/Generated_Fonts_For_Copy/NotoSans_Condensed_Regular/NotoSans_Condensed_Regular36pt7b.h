#ifndef _NOTOSANS_CONDENSED_REGULAR36PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x60, 0x00,
  0x7F, 0xF7, 0xF3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xD8, 0x66, 0x19, 0x86,
  0x61, 0x98, 0x60, 0x03, 0x0C, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xE1, 0x80,
  0x70, 0xC0, 0x30, 0xE0, 0x18, 0x70, 0x0C, 0x30, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC3, 0x86, 0x01, 0xC3, 0x00, 0xC3, 0x80, 0x61, 0xC0, 0x30, 0xC0, 0x18,
  0x60, 0xFF, 0xFF, 0x7F, 0xFF, 0x86, 0x0C, 0x03, 0x0E, 0x01, 0x87, 0x00,
  0xC3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x38, 0x60, 0x1C, 0x70, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x3F, 0xE7, 0xFF, 0xFD, 0x3B, 0x88, 0x1C, 0x40,
  0xC2, 0x07, 0x10, 0x38, 0x81, 0xE4, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x02, 0x78, 0x11, 0xC0, 0x86, 0x04, 0x30, 0x23, 0xC1, 0x1F, 0xEF,
  0xDF, 0xFC, 0x7F, 0xC0, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x3C,
  0x01, 0x81, 0xF8, 0x0E, 0x0E, 0x70, 0x30, 0x38, 0xC0, 0xC0, 0xC3, 0x07,
  0x03, 0x0C, 0x18, 0x0C, 0x38, 0xE0, 0x30, 0xE3, 0x00, 0xC3, 0x9C, 0x03,
  0x0E, 0x70, 0x0C, 0x31, 0x8E, 0x30, 0xCE, 0x7C, 0xE3, 0x33, 0xBB, 0x9D,
  0xCC, 0x77, 0xE7, 0x71, 0xCF, 0x19, 0xC7, 0x00, 0xE7, 0x0C, 0x03, 0x1C,
  0x30, 0x1C, 0x70, 0xC0, 0x61, 0xC3, 0x01, 0x87, 0x0C, 0x0E, 0x1C, 0x70,
  0x30, 0x31, 0xC1, 0xC0, 0xC6, 0x06, 0x03, 0xF8, 0x38, 0x07, 0xC0, 0x07,
  0xC0, 0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x70,
  0x60, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x70, 0x73, 0xCF,
  0x1C, 0x70, 0xF3, 0x9E, 0x0E, 0x73, 0x80, 0xFE, 0x70, 0x1F, 0x8E, 0x01,
  0xF1, 0xE0, 0x3C, 0x1C, 0x0F, 0xC3, 0xE7, 0xFC, 0x3F, 0xF3, 0xC3, 0xF8,
  0x3C, 0xFE, 0xEE, 0xE6, 0x66, 0x66, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38,
  0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C,
  0x0E, 0x06, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x07, 0x80,
  0x0C, 0x00, 0x30, 0x20, 0xC2, 0x73, 0x39, 0xFF, 0xEF, 0xFF, 0xC1, 0xE0,
  0x0F, 0xC0, 0x73, 0x81, 0xCE, 0x0E, 0x1C, 0x08, 0x40, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x39, 0xCE, 0xF7, 0x39, 0xCC, 0xE0, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF7, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x81, 0xFE, 0x0F, 0xF8,
  0xF1, 0xE7, 0x07, 0x70, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x39, 0xC1, 0xCF, 0xBC, 0x3F, 0xE0,
  0xFE, 0x00, 0x07, 0x0F, 0x1F, 0x3F, 0x7F, 0xF7, 0xE7, 0x47, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1C, 0x1E, 0x20,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0xFF, 0xCF, 0xFF, 0x98, 0x1E, 0x40, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x07, 0xF8, 0x1F,
  0x80, 0x7F, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xBC, 0x3E, 0xFF, 0xF1, 0xFF, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x76, 0x00,
  0xDC, 0x03, 0xB8, 0x06, 0x70, 0x1C, 0xE0, 0x31, 0xC0, 0xE3, 0x83, 0x87,
  0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3E, 0x03, 0xDE, 0x3E, 0xFF, 0xE7, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x87,
  0xFC, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x39, 0xF1, 0xDF, 0xCF, 0xDF, 0x78, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x1D, 0xC1, 0xE7, 0xBE, 0x3F,
  0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFB, 0xE3, 0xC1, 0xE7,
  0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0x7B,
  0xC0, 0x7F, 0x00, 0x7C, 0x01, 0xFC, 0x0F, 0x3C, 0x1C, 0x3C, 0x70, 0x3C,
  0xE0, 0x3B, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xEE, 0x03, 0x9C, 0x07, 0x3E,
  0x3C, 0x3F, 0xF8, 0x1F, 0xC0, 0x07, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E,
  0x70, 0x39, 0xC0, 0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01,
  0xDC, 0x07, 0x70, 0x3C, 0xE1, 0xF3, 0xFF, 0xC7, 0xF7, 0x02, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x08, 0xF8, 0x3F,
  0xC0, 0xFE, 0x00, 0x27, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF7, 0x13, 0xDE, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39,
  0xCE, 0xE7, 0x39, 0x8C, 0xE0, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x60, 0x00,
  0x1F, 0x8F, 0xFC, 0x7F, 0xE4, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x3C, 0x03,
  0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x0F,
  0x86, 0x70, 0xFF, 0x1D, 0x87, 0x9C, 0x3E, 0x18, 0x70, 0xF8, 0xE1, 0xC3,
  0xC3, 0x87, 0x0F, 0x0E, 0x1C, 0x3C, 0x30, 0x70, 0xF0, 0xC1, 0xC3, 0xC3,
  0x07, 0x0F, 0x0E, 0x1C, 0x7C, 0x38, 0xF1, 0xF8, 0x77, 0xEE, 0xE1, 0xF9,
  0xF1, 0x83, 0xC7, 0x87, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x02, 0x01, 0xF0, 0x38, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x33, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xC6, 0x00, 0xE1, 0xC0,
  0x38, 0x70, 0x0E, 0x1C, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x9E, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x70, 0xFF, 0x83,
  0xFF, 0x8F, 0xFF, 0xB8, 0x1E, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xEE, 0x07, 0xBF, 0xFC, 0xFF, 0xC3, 0xFF, 0xCE, 0x07,
  0xB8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xFC,
  0x7F, 0xF9, 0xF0, 0x23, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0xCE, 0x0F, 0xFC, 0x0F, 0xF8, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0xE0, 0xF8, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xC0, 0x23, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x80, 0x39, 0xC0, 0x1C,
  0xF8, 0x0E, 0x3F, 0x9F, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFF, 0x3E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0xFE, 0xFC, 0xF8,
  0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x1C, 0x38,
  0x78, 0x70, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x70, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x79, 0xC0, 0xE3, 0xC1, 0xC3, 0x83, 0x87, 0x87,
  0x07, 0x0E, 0x07, 0x1C, 0x0F, 0x38, 0x0E, 0x70, 0x1E, 0xE0, 0x1D, 0xC0,
  0x3C, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0D, 0xFB, 0x80, 0x77, 0xEE,
  0x01, 0xDF, 0xB8, 0x06, 0x7E, 0x70, 0x39, 0xF9, 0xC0, 0xE7, 0xE7, 0x03,
  0x1F, 0x8C, 0x1C, 0x7E, 0x38, 0x71, 0xF8, 0xE1, 0xC7, 0xE1, 0x8E, 0x1F,
  0x87, 0x38, 0x7E, 0x1C, 0xE1, 0xF8, 0x73, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xC0,
  0x70, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xDC, 0x07, 0xEF, 0x03, 0xF3, 0x81, 0xF9, 0xE0,
  0xFC, 0x70, 0x7E, 0x3C, 0x3F, 0x0E, 0x1F, 0x87, 0x8F, 0xC1, 0xC7, 0xE0,
  0xF3, 0xF0, 0x39, 0xF8, 0x1E, 0xFC, 0x07, 0x7E, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xE7, 0x00,
  0x3B, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x0F, 0x70, 0x03, 0x9E, 0x01, 0xE3, 0xC0,
  0xF0, 0x7E, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xFE, 0x3F,
  0xFD, 0xC1, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0x7F, 0xFB, 0xFF, 0x9F, 0xF0, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C,
  0x78, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x0F,
  0x70, 0x03, 0x9E, 0x01, 0xE3, 0xC0, 0xF0, 0x7E, 0xFC, 0x0F, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0x07, 0x8E, 0x07,
  0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7,
  0x03, 0xCE, 0x1F, 0x1F, 0xFC, 0x3F, 0xE0, 0x71, 0xE0, 0xE1, 0xC1, 0xC3,
  0xC3, 0x83, 0x87, 0x07, 0x8E, 0x07, 0x1C, 0x0F, 0x38, 0x0E, 0x70, 0x1E,
  0xE0, 0x1D, 0xC0, 0x3C, 0x0F, 0xE1, 0xFF, 0xDF, 0xFD, 0xE0, 0x6E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3E, 0x03, 0xDF, 0xFE, 0xFF, 0xE7, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x03, 0xDC, 0x07, 0x3F, 0x7E, 0x3F, 0xF8, 0x3F,
  0xE0, 0xE0, 0x03, 0xFC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07,
  0x1E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x3C, 0x38, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x78, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x03, 0x70,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0xE0, 0x07, 0x00, 0x7F, 0x00, 0xF0, 0x07, 0x70, 0x0F, 0x00, 0xE7, 0x00,
  0xF0, 0x0E, 0x70, 0x0F, 0x80, 0xE7, 0x81, 0xF8, 0x0E, 0x38, 0x1F, 0x81,
  0xE3, 0x81, 0xD8, 0x1C, 0x38, 0x19, 0x81, 0xC3, 0x83, 0x9C, 0x1C, 0x1C,
  0x39, 0xC1, 0xC1, 0xC3, 0x9C, 0x38, 0x1C, 0x38, 0xC3, 0x81, 0xC3, 0x0E,
  0x38, 0x1C, 0x70, 0xE3, 0x80, 0xE7, 0x0E, 0x78, 0x0E, 0x70, 0x67, 0x00,
  0xE6, 0x06, 0x70, 0x0E, 0xE0, 0x77, 0x00, 0x6E, 0x07, 0x70, 0x07, 0xE0,
  0x76, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xC0, 0x70, 0x0F, 0x78, 0x0E, 0x38,
  0x0E, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x07,
  0x70, 0x07, 0x70, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C,
  0x3C, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E,
  0xE0, 0x0C, 0x60, 0x1C, 0x70, 0x18, 0x30, 0x38, 0x38, 0x38, 0x18, 0x70,
  0x1C, 0x70, 0x0C, 0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0xE0, 0xE0, 0xC0, 0xC0, 0x03, 0x00, 0xFF, 0x0F, 0xFC, 0x20, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x01, 0xF8, 0xFF, 0xCF, 0xEE, 0xF0,
  0x77, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0x70, 0x7B, 0xC7, 0xDF, 0xE6,
  0x7E, 0x30, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0xE0, 0xEF, 0xE3, 0x7F, 0xCF, 0x87, 0x3C, 0x1E, 0xE0,
  0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xBC, 0x1E, 0xF8, 0xF3, 0x7F, 0x8C,
  0xFC, 0x00, 0x03, 0x83, 0xFC, 0xFF, 0xBC, 0x27, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x0F, 0x8C, 0xFF, 0x8F, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0x87, 0x1F, 0x9C, 0xFF, 0x77,
  0x87, 0xDC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x03, 0xDC, 0x0F,
  0x78, 0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0x07, 0x00, 0xFE, 0x0F, 0xF8, 0xF1,
  0xE7, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x0B, 0xE1, 0x8F,
  0xFC, 0x1F, 0xE0, 0x00, 0x80, 0xFC, 0x3F, 0x87, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x0F, 0xFB, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x06, 0x00, 0x7E, 0x73, 0xFD, 0xDE,
  0x1F, 0x70, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0x70, 0x7D,
  0xF3, 0xF3, 0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x39, 0x81, 0xE7, 0xFF, 0x1F, 0xF8, 0x06, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x70, 0xEF, 0xE6,
  0xFF, 0xBE, 0x3D, 0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0x2F, 0xF7, 0x20, 0x00, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x04, 0x3C, 0x78, 0x70, 0x40,
  0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x1D,
  0xFB, 0xE3, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0xF7, 0x07, 0x38, 0x71, 0xC7, 0x0E, 0x38,
  0x73, 0x83, 0xB8, 0x1B, 0xC0, 0xDE, 0x07, 0xF8, 0x3D, 0xC1, 0xC7, 0x0E,
  0x38, 0x70, 0xE3, 0x87, 0x1C, 0x1C, 0xE0, 0xE7, 0x03, 0xB8, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x81,
  0xC3, 0x3F, 0x1F, 0xCD, 0xFE, 0xFF, 0xBC, 0x3F, 0x0E, 0xF0, 0x78, 0x3F,
  0x81, 0xE0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F, 0x81,
  0xC0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F, 0x81, 0xC0,
  0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F, 0x81, 0xC0, 0x7E,
  0x07, 0x01, 0xF8, 0x1C, 0x07, 0x03, 0x06, 0x7F, 0x37, 0xFD, 0xF1, 0xEF,
  0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x70, 0x07, 0x00, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0x80,
  0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x0E, 0x70, 0x39, 0xE3, 0xC3, 0xFF, 0x07,
  0xF0, 0x03, 0x83, 0x3F, 0x8D, 0xFF, 0x3E, 0x1C, 0xF0, 0x7B, 0x80, 0xEE,
  0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xF0, 0x7B, 0x63, 0xCD, 0xFE, 0x3B, 0xF0,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x7E, 0x73, 0xFD, 0xDE, 0x1F, 0x70,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0x70, 0x7D, 0xF3, 0xF3,
  0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x03, 0xE7, 0xF7, 0xDB, 0x9F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x07, 0x07, 0xFD, 0xFF, 0xB8, 0x2E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0xFE, 0x3F, 0xFF, 0x3F, 0xC0, 0x18, 0x1C,
  0x0E, 0x07, 0x03, 0x87, 0xFF, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE4, 0xFE,
  0x3F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0xC0, 0xF7, 0x03, 0xDC, 0x1F, 0x78, 0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0xE0,
  0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE3, 0x03, 0x87, 0x07, 0x0E, 0x0E,
  0x1C, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0x67, 0x00, 0xEE, 0x01,
  0xDC, 0x03, 0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0xF0,
  0x3C, 0x0E, 0xE0, 0x78, 0x1D, 0xC0, 0xF0, 0x3B, 0x83, 0xE0, 0x77, 0x07,
  0xE1, 0xC7, 0x0D, 0xC3, 0x8E, 0x19, 0x87, 0x1C, 0x73, 0x0E, 0x38, 0xE7,
  0x38, 0x39, 0x8E, 0x70, 0x73, 0x1C, 0xE0, 0xEE, 0x19, 0xC1, 0xDC, 0x33,
  0x01, 0xB8, 0x7E, 0x03, 0x60, 0xFC, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xE0,
  0x1F, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0xF0, 0x39, 0xC1, 0xC7, 0x87, 0x0E,
  0x38, 0x38, 0xE0, 0x77, 0x01, 0xDC, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xF0, 0x1D, 0xC0, 0xF3, 0x83, 0x8E, 0x1E, 0x1C, 0x70, 0x73,
  0xC0, 0xEE, 0x03, 0xC0, 0xE0, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE3,
  0x83, 0x87, 0x07, 0x0E, 0x0E, 0x0C, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71,
  0xC0, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x60, 0x7C, 0x1F, 0x83, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x0F, 0x07, 0xC0, 0xF8, 0x07,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x0F, 0xC0, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0xE0, 0x1F, 0x03, 0xE0, 0xF0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE1, 0xF8, 0x3E, 0x07,
  0x00, 0x3E, 0x02, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xE8, 0x02, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 26, 9, 2, -26 },
  { 14, 10, 10, 14, 2, -26 },
  { 27, 17, 26, 19, 1, -26 },
  { 83, 13, 29, 17, 2, -27 },
  { 131, 22, 26, 26, 2, -26 },
  { 203, 19, 26, 20, 1, -26 },
  { 265, 4, 10, 8, 2, -26 },
  { 270, 8, 32, 11, 2, -26 },
  { 302, 8, 32, 11, 1, -26 },
  { 334, 14, 13, 16, 1, -27 },
  { 357, 15, 17, 17, 1, -21 },
  { 389, 5, 9, 9, 1, -4 },
  { 395, 8, 3, 10, 1, -11 },
  { 398, 4, 4, 9, 2, -4 },
  { 400, 12, 26, 13, 1, -26 },
  { 439, 13, 26, 17, 2, -26 },
  { 482, 8, 26, 17, 3, -26 },
  { 508, 14, 26, 17, 1, -26 },
  { 554, 14, 26, 17, 1, -26 },
  { 600, 15, 26, 17, 1, -26 },
  { 649, 13, 26, 17, 2, -26 },
  { 692, 13, 26, 17, 2, -26 },
  { 735, 15, 26, 17, 1, -26 },
  { 784, 15, 26, 17, 1, -26 },
  { 833, 14, 26, 17, 1, -26 },
  { 879, 4, 20, 9, 2, -20 },
  { 889, 5, 25, 9, 1, -20 },
  { 905, 15, 16, 17, 1, -21 },
  { 935, 15, 10, 17, 1, -18 },
  { 954, 15, 16, 17, 1, -21 },
  { 984, 12, 26, 13, 0, -26 },
  { 1023, 22, 29, 26, 2, -26 },
  { 1103, 18, 26, 18, 0, -26 },
  { 1162, 14, 26, 19, 3, -26 },
  { 1208, 15, 26, 18, 2, -26 },
  { 1257, 16, 26, 21, 3, -26 },
  { 1309, 11, 26, 16, 3, -26 },
  { 1345, 11, 26, 15, 3, -26 },
  { 1381, 17, 26, 22, 2, -26 },
  { 1437, 16, 26, 21, 3, -26 },
  { 1489, 8, 26, 11, 1, -26 },
  { 1515, 8, 33, 9, -2, -26 },
  { 1548, 15, 26, 18, 3, -26 },
  { 1597, 11, 26, 15, 3, -26 },
  { 1633, 22, 26, 28, 3, -26 },
  { 1705, 17, 26, 23, 3, -26 },
  { 1761, 18, 26, 22, 2, -26 },
  { 1820, 13, 26, 18, 3, -26 },
  { 1863, 18, 32, 22, 2, -26 },
  { 1935, 15, 26, 18, 3, -26 },
  { 1984, 13, 26, 16, 2, -26 },
  { 2027, 15, 26, 16, 0, -26 },
  { 2076, 15, 26, 21, 3, -26 },
  { 2125, 18, 26, 18, 0, -26 },
  { 2184, 28, 26, 28, 0, -26 },
  { 2275, 16, 26, 16, 0, -26 },
  { 2327, 16, 26, 16, 0, -26 },
  { 2379, 13, 26, 15, 1, -26 },
  { 2422, 7, 32, 11, 3, -26 },
  { 2450, 12, 26, 13, 1, -26 },
  { 2489, 8, 32, 11, 1, -26 },
  { 2521, 16, 15, 17, 1, -26 },
  { 2551, 16, 2, 16, 0, 3 },
  { 2555, 7, 6, 10, 1, -28 },
  { 2561, 13, 20, 17, 1, -20 },
  { 2594, 14, 27, 18, 3, -27 },
  { 2642, 11, 20, 14, 2, -20 },
  { 2670, 14, 27, 18, 2, -27 },
  { 2718, 13, 20, 17, 2, -20 },
  { 2751, 11, 28, 10, 0, -28 },
  { 2790, 14, 29, 18, 2, -20 },
  { 2841, 13, 27, 18, 3, -27 },
  { 2885, 4, 27, 8, 2, -27 },
  { 2899, 7, 36, 8, -1, -27 },
  { 2931, 13, 27, 16, 3, -27 },
  { 2975, 3, 27, 8, 3, -27 },
  { 2986, 22, 20, 27, 3, -20 },
  { 3041, 13, 20, 18, 3, -20 },
  { 3074, 14, 20, 18, 2, -20 },
  { 3109, 14, 29, 18, 3, -20 },
  { 3160, 14, 29, 18, 2, -20 },
  { 3211, 9, 20, 12, 3, -20 },
  { 3234, 11, 20, 14, 1, -20 },
  { 3262, 9, 24, 10, 1, -24 },
  { 3289, 14, 19, 18, 2, -19 },
  { 3323, 15, 19, 15, 0, -19 },
  { 3359, 23, 19, 24, 0, -19 },
  { 3414, 14, 19, 15, 1, -19 },
  { 3448, 15, 28, 15, 0, -19 },
  { 3501, 11, 19, 13, 1, -19 },
  { 3528, 11, 32, 13, 1, -26 },
  { 3572, 2, 36, 16, 7, -27 },
  { 3581, 11, 32, 13, 1, -26 },
  { 3625, 15, 5, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_Regular36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_REGULAR36PT7B_H_
