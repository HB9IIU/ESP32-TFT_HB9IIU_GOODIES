#ifndef _NOTOSANS_CONDENSED_REGULAR40PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0x66, 0x66, 0x60,
  0x00, 0x6F, 0xFF, 0xF0, 0xF1, 0xFE, 0x3D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1,
  0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1D, 0xC3, 0x00, 0x03, 0x83, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x07, 0x0E, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x87,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x70, 0xE0, 0x0E, 0x1C,
  0x01, 0xC3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xC1, 0x80, 0x18, 0x30,
  0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x03, 0x87, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x7F,
  0x83, 0xFF, 0xCF, 0xFF, 0x9E, 0xC3, 0x71, 0x80, 0xE3, 0x01, 0xC6, 0x03,
  0x8C, 0x07, 0x18, 0x0F, 0x30, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x07, 0xF8, 0x0C, 0x78, 0x18, 0x70, 0x30, 0xE0, 0x61, 0xC0, 0xC3,
  0xC1, 0x8F, 0xC3, 0x3D, 0xFF, 0xF3, 0xFF, 0xC1, 0xFE, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x1E, 0x00, 0x70, 0x1F, 0x80, 0x70, 0x1F,
  0xE0, 0x38, 0x1C, 0x70, 0x38, 0x0E, 0x18, 0x1C, 0x07, 0x0E, 0x0C, 0x03,
  0x87, 0x0E, 0x01, 0x83, 0x87, 0x00, 0xC1, 0xC7, 0x00, 0x60, 0xE3, 0x80,
  0x30, 0x71, 0x80, 0x1C, 0x39, 0xC3, 0x0E, 0x1C, 0xE7, 0xE7, 0x0C, 0xE7,
  0xF1, 0x8E, 0x73, 0x9C, 0xFF, 0x33, 0x86, 0x3F, 0x39, 0xC3, 0x8F, 0x1C,
  0xE1, 0xC0, 0x1C, 0x70, 0xE0, 0x0E, 0x38, 0x70, 0x0E, 0x1C, 0x38, 0x07,
  0x0E, 0x1C, 0x03, 0x07, 0x0E, 0x03, 0x83, 0x87, 0x01, 0xC1, 0xC3, 0x01,
  0xC0, 0xE3, 0x80, 0xE0, 0x39, 0xC0, 0x60, 0x1F, 0xC0, 0x70, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3C, 0x78, 0x01, 0xC3,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x3C, 0x00,
  0xF1, 0xC0, 0x03, 0x9E, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0x87, 0x1E,
  0x1E, 0x38, 0xE0, 0x7B, 0xCF, 0x01, 0xFE, 0x78, 0x0F, 0xE3, 0xC0, 0x3F,
  0x0E, 0x00, 0xF0, 0x78, 0x0F, 0xC3, 0xC0, 0xFE, 0x0F, 0xFF, 0x78, 0x7F,
  0xF1, 0xE0, 0xFF, 0x07, 0x80, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x70, 0x07,
  0x83, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1E,
  0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E,
  0x07, 0x01, 0xE0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C,
  0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0,
  0xF0, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x0C, 0x06, 0x18, 0xEF, 0xFF, 0xDF, 0xFF, 0xC3, 0xF0, 0x07, 0xC0,
  0x1D, 0xC0, 0x39, 0xC0, 0xF3, 0xC3, 0xC3, 0x81, 0x86, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x3C, 0xF3, 0xCE, 0x38, 0xE7, 0x9C, 0x73, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x6F, 0xFF, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xC1, 0xE3, 0xC7, 0x83,
  0xCE, 0x07, 0x9C, 0x07, 0x78, 0x0E, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0x38, 0x0E,
  0x78, 0x3C, 0xF0, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0x83,
  0xC3, 0xE3, 0xF3, 0xFB, 0xDF, 0xCE, 0xC7, 0x43, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x07, 0xE0, 0x1F, 0xF8, 0x7F,
  0xFC, 0x78, 0x3C, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83,
  0xC4, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x1F, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3D, 0x00, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0E,
  0xE0, 0x07, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x01,
  0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C,
  0x38, 0x0E, 0x3C, 0x07, 0x1C, 0x03, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x98,
  0x07, 0xFE, 0x1F, 0xFF, 0x1C, 0x7E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3D, 0x80, 0xFB, 0xFF, 0xE7, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0xF8, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x1F, 0x0E, 0x7F, 0x9D, 0xFF, 0x3F,
  0x0F, 0x78, 0x0E, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xB8, 0x0F, 0x78, 0x1C, 0x78, 0x78, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1C, 0xE0, 0x39, 0xE0, 0xF1, 0xE3,
  0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x3C, 0xF8, 0xF0, 0x7B,
  0xC0, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xE0, 0x3D, 0xFB, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xC0, 0x3F,
  0xC0, 0xFF, 0xC3, 0xC3, 0xC7, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xDC,
  0x0F, 0xBF, 0xF7, 0x3F, 0xFE, 0x3F, 0xBC, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE1, 0xFF, 0x83,
  0xFE, 0x07, 0xF8, 0x00, 0x6F, 0xFF, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0xFF, 0xFF, 0x18, 0xF3, 0xCF, 0x3C, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x38, 0xE7, 0x9C, 0x71, 0xCE, 0x00,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x1F, 0x87, 0xFF,
  0x1F, 0xFC, 0xE1, 0xF4, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x01,
  0xC0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x38, 0x1F,
  0x87, 0x38, 0x3F, 0xE1, 0x9C, 0x3C, 0x70, 0xEE, 0x1C, 0x38, 0x7E, 0x1C,
  0x1C, 0x3F, 0x0E, 0x0E, 0x1F, 0x87, 0x07, 0x0F, 0xC3, 0x83, 0x87, 0xE1,
  0xC1, 0xC3, 0xF0, 0xE0, 0xE1, 0xF8, 0x70, 0xF0, 0xFC, 0x38, 0x78, 0x6E,
  0x1C, 0x3C, 0x77, 0x0F, 0x36, 0x3B, 0x83, 0xFB, 0xF8, 0xE0, 0xF8, 0xF8,
  0x70, 0x10, 0x10, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x02, 0x00, 0x7C, 0x07, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xDC, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00,
  0x39, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xF0,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3C, 0x03, 0xC3, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0xFE, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0xFC, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0,
  0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0x61, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xC7, 0xF8, 0xF0,
  0x1F, 0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xBC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x1F,
  0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x1E, 0x1E, 0x00, 0x43, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x3E, 0x00, 0xF1, 0xF0,
  0x0F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xF7, 0xF8, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE3, 0xFF, 0xFF, 0xC0, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0xBF, 0xFE, 0xFC, 0x70, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0x9E,
  0x03, 0xCF, 0x03, 0xC7, 0x81, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xE0,
  0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0xFB, 0xC0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0xC3, 0xC0, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x78, 0x0F,
  0x3C, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x70,
  0x01, 0xDF, 0xB8, 0x00, 0xEF, 0xDC, 0x00, 0x77, 0xE7, 0x00, 0x77, 0xF3,
  0x80, 0x3B, 0xF9, 0xC0, 0x1D, 0xFC, 0xF0, 0x1C, 0xFE, 0x38, 0x0E, 0x7F,
  0x1C, 0x07, 0x3F, 0x8F, 0x07, 0x1F, 0xC3, 0x83, 0x8F, 0xE1, 0xC1, 0xC7,
  0xF0, 0xE0, 0xE3, 0xF8, 0x38, 0xE1, 0xFC, 0x1C, 0x70, 0xFE, 0x0E, 0x38,
  0x7F, 0x03, 0xB8, 0x3F, 0x81, 0xDC, 0x1F, 0xC0, 0xEE, 0x0F, 0xE0, 0x3E,
  0x07, 0xF0, 0x1F, 0x03, 0xF8, 0x0F, 0x81, 0xFC, 0x07, 0x80, 0xFE, 0x01,
  0xC0, 0x78, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFB, 0x80, 0x3F, 0x78, 0x07, 0xE7, 0x00, 0xFC,
  0xF0, 0x1F, 0x8E, 0x03, 0xF1, 0xE0, 0x7E, 0x1C, 0x0F, 0xC3, 0xC1, 0xF8,
  0x38, 0x3F, 0x07, 0x87, 0xE0, 0x70, 0xFC, 0x0F, 0x1F, 0x80, 0xE3, 0xF0,
  0x1E, 0x7E, 0x01, 0xCF, 0xC0, 0x3D, 0xF8, 0x03, 0xBF, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1E, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3C,
  0x1E, 0x00, 0xF1, 0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x70, 0x00, 0xF3, 0x80,
  0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1D, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xC7,
  0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x3E, 0x03, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0x9F, 0xEF,
  0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xBC, 0x3F, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3C,
  0x1E, 0x00, 0xF1, 0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x70, 0x00, 0xF3, 0x80,
  0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xC7,
  0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x3E, 0x07, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0xFE, 0x00,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x03, 0xC7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x1C, 0xF0, 0x0E, 0x78, 0x07, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xC7, 0x83, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x78, 0x70,
  0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC0, 0xF1, 0xE0,
  0x78, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x78,
  0x07, 0xE0, 0x3F, 0xF8, 0xFF, 0xF3, 0xE1, 0xCF, 0x00, 0x9E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3D, 0x80,
  0xFB, 0xFF, 0xE7, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0x78, 0x07, 0xBE, 0x07, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0xF0,
  0x00, 0xFF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1E, 0x78, 0x01, 0xC7,
  0x80, 0x1C, 0x38, 0x03, 0xC3, 0x80, 0x3C, 0x3C, 0x03, 0x83, 0xC0, 0x38,
  0x1C, 0x07, 0x81, 0xC0, 0x78, 0x1E, 0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x0F,
  0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1E, 0x00, 0x79,
  0xC0, 0x03, 0x9C, 0x00, 0x3B, 0xC0, 0x03, 0xB8, 0x00, 0x3B, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x03, 0x80, 0x0F, 0xE0, 0x07, 0x80, 0x3D, 0xC0, 0x1F, 0x00, 0x7B,
  0x80, 0x3E, 0x00, 0xE7, 0x80, 0x7C, 0x01, 0xCF, 0x00, 0xF8, 0x07, 0x8E,
  0x01, 0xB8, 0x0F, 0x1C, 0x07, 0x70, 0x1C, 0x38, 0x0E, 0xE0, 0x38, 0x78,
  0x1D, 0xC0, 0x70, 0x70, 0x39, 0xC1, 0xE0, 0xE0, 0xE3, 0x83, 0xC1, 0xC1,
  0xC7, 0x07, 0x03, 0xC3, 0x8E, 0x0E, 0x07, 0x87, 0x1E, 0x3C, 0x07, 0x1E,
  0x1C, 0x78, 0x0E, 0x38, 0x38, 0xE0, 0x1C, 0x70, 0x71, 0xC0, 0x3C, 0xE0,
  0xE3, 0x80, 0x39, 0xC0, 0xEF, 0x00, 0x77, 0x01, 0xDE, 0x00, 0xEE, 0x03,
  0xB8, 0x01, 0xDC, 0x07, 0x70, 0x03, 0xF8, 0x06, 0xE0, 0x03, 0xF0, 0x0D,
  0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x03, 0xDE, 0x00, 0xE3, 0x80, 0x78,
  0xF0, 0x1C, 0x1C, 0x0F, 0x07, 0x83, 0x80, 0xE1, 0xE0, 0x3C, 0x70, 0x07,
  0x3C, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7B, 0x80,
  0x1C, 0xF0, 0x0F, 0x1C, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x38, 0x3C,
  0x0F, 0x0E, 0x01, 0xC7, 0x80, 0x79, 0xC0, 0x0E, 0xF0, 0x03, 0xC0, 0xF0,
  0x03, 0xFC, 0x00, 0xE7, 0x00, 0x79, 0xE0, 0x1E, 0x38, 0x07, 0x0F, 0x03,
  0xC3, 0xC0, 0xE0, 0x70, 0x78, 0x1E, 0x1C, 0x03, 0x87, 0x00, 0xF3, 0xC0,
  0x1C, 0xE0, 0x07, 0x78, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x7F, 0xFF, 0xE0, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C,
  0x70, 0x0E, 0x38, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x01, 0xC3, 0x80, 0xE3,
  0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF1, 0xE1, 0xE1, 0xC1, 0xC1, 0xC1, 0x80, 0x07, 0xC1, 0xFF, 0xC3,
  0xFF, 0x8C, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x1F, 0xF3, 0xFF, 0xDF, 0xEF, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xFE, 0x77, 0x7F, 0x9C, 0xFC, 0x70, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE3, 0xE0, 0xE7, 0xF0, 0xEF, 0xF8, 0xFC, 0x3C, 0xF8,
  0x1C, 0xF0, 0x1E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF8, 0x3C, 0xFE, 0xFC, 0xEF, 0xF8, 0xE7, 0xF0, 0x07,
  0xE1, 0xFF, 0x3F, 0xF3, 0xC3, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x13, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x07, 0x8F, 0x1F, 0xEF, 0x3F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0x70, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1F,
  0x78, 0x3F, 0x3E, 0xFF, 0x3F, 0xE7, 0x0F, 0xC7, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE1, 0xC3, 0xC7, 0x83, 0xCE, 0x03, 0xBC, 0x07, 0x70, 0x0F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x11, 0xFB, 0xE1, 0xFF, 0xC1,
  0xFF, 0x00, 0x00, 0xC0, 0x7F, 0x07, 0xF0, 0xF1, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0xEF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0x1F, 0xE7, 0x3F, 0xFF, 0x7C, 0x7F, 0x78, 0x1F, 0x70,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70,
  0x1F, 0x78, 0x3F, 0x3E, 0xFF, 0x3F, 0xEF, 0x0F, 0xCF, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x40, 0x1E, 0x78, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE1, 0xE3, 0x9F, 0xCE, 0xFF,
  0xBF, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0x5F, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x1C,
  0x38, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xF9, 0xFF, 0xBF, 0x30, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0xEE, 0x07, 0x38, 0x3C, 0xE1, 0xE3, 0x87, 0x0E, 0x3C, 0x39,
  0xE0, 0xE7, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFB, 0x83, 0xCF, 0x0E,
  0x1C, 0x38, 0x78, 0xE0, 0xF3, 0x83, 0xCE, 0x07, 0xB8, 0x1E, 0xE0, 0x3F,
  0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xE0, 0x78, 0x77, 0xF8, 0xFF, 0x3B, 0xFE, 0xFF, 0xDF,
  0x0F, 0x61, 0xEF, 0x03, 0xE0, 0x77, 0x81, 0xF0, 0x3B, 0xC0, 0xF0, 0x1F,
  0xC0, 0x38, 0x0F, 0xE0, 0x1C, 0x07, 0xF0, 0x0E, 0x03, 0xF8, 0x07, 0x01,
  0xFC, 0x03, 0x80, 0xFE, 0x01, 0xC0, 0x7F, 0x00, 0xE0, 0x3F, 0x80, 0x70,
  0x1F, 0xC0, 0x38, 0x0F, 0xE0, 0x1C, 0x07, 0xF0, 0x0E, 0x03, 0xF8, 0x07,
  0x01, 0xFC, 0x03, 0x80, 0xFE, 0x01, 0xC0, 0x7F, 0x00, 0xE0, 0x3C, 0x03,
  0xE3, 0x9F, 0xEE, 0xFF, 0xBF, 0x1F, 0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x70, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x3C, 0x78, 0x1E,
  0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E,
  0x70, 0x1E, 0x78, 0x1C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xE0,
  0xE7, 0xF0, 0xEF, 0xF8, 0xFC, 0x3C, 0xF0, 0x1C, 0xF0, 0x1E, 0xF0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3C,
  0xFF, 0xFC, 0xEF, 0xF8, 0xE7, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x1F, 0xE7, 0x3F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F,
  0x70, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x70, 0x1F, 0x78, 0x3F, 0x3E, 0xFF, 0x3F, 0xEF, 0x0F, 0xCF, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x03, 0xF9, 0xFE, 0xFF, 0xF9, 0xF8,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x0F, 0x83,
  0xFF, 0x7F, 0xEF, 0x06, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x0F, 0x80, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x3F, 0xFF, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0,
  0xFF, 0x1F, 0xC3, 0xF0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xF7,
  0xFF, 0xDF, 0xF7, 0x3F, 0x8C, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x78,
  0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x3C, 0x1C, 0x1C, 0x3C, 0x1C,
  0x38, 0x1C, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xDC, 0x07, 0xC0, 0xF7, 0x01, 0xF0, 0x39, 0xE0, 0xFC, 0x0E,
  0x38, 0x3F, 0x03, 0x8E, 0x0E, 0xC1, 0xE3, 0x83, 0xB8, 0x70, 0xF1, 0xCE,
  0x1C, 0x3C, 0x73, 0x87, 0x07, 0x1C, 0xE3, 0xC1, 0xC7, 0x1C, 0xE0, 0x73,
  0x87, 0x38, 0x1E, 0xE1, 0xCE, 0x03, 0xB8, 0x73, 0x80, 0xEE, 0x0D, 0xC0,
  0x3B, 0x03, 0xF0, 0x0E, 0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1E, 0xF0, 0x78,
  0xE0, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0x3C,
  0x0E, 0x38, 0x38, 0x78, 0xF0, 0x71, 0xC0, 0xF7, 0x80, 0xEE, 0x01, 0xE0,
  0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x0E, 0x38, 0x0E, 0x38, 0x1E,
  0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x1C, 0x38, 0x1E, 0x38, 0x0E, 0x38,
  0x0E, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x9F, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x30, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30,
  0x1F, 0x03, 0xF0, 0x7C, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x7E, 0x0F,
  0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xE0,
  0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x03, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0xE0, 0x7C, 0x0F, 0x83, 0xC0, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0xFC, 0x1F, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xBF, 0xC0, 0xFF,
  0xFD, 0xFC, 0x7F, 0xE8, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 29, 10, 3, -29 },
  { 16, 11, 11, 16, 2, -29 },
  { 32, 19, 29, 21, 1, -29 },
  { 101, 15, 32, 19, 2, -30 },
  { 161, 25, 29, 29, 2, -29 },
  { 252, 21, 29, 22, 1, -29 },
  { 329, 4, 11, 9, 2, -29 },
  { 335, 9, 35, 12, 2, -29 },
  { 375, 9, 35, 12, 1, -29 },
  { 415, 15, 14, 18, 1, -30 },
  { 442, 16, 19, 19, 1, -24 },
  { 480, 6, 10, 10, 1, -5 },
  { 488, 9, 3, 12, 1, -12 },
  { 492, 4, 5, 10, 3, -5 },
  { 495, 13, 29, 15, 1, -29 },
  { 543, 15, 29, 19, 2, -29 },
  { 598, 9, 29, 19, 3, -29 },
  { 631, 16, 29, 19, 1, -29 },
  { 689, 15, 29, 19, 2, -29 },
  { 744, 17, 29, 19, 1, -29 },
  { 806, 15, 29, 19, 2, -29 },
  { 861, 15, 29, 19, 2, -29 },
  { 916, 16, 29, 19, 1, -29 },
  { 974, 15, 29, 19, 2, -29 },
  { 1029, 15, 29, 19, 2, -29 },
  { 1084, 4, 22, 10, 3, -22 },
  { 1095, 6, 27, 10, 1, -22 },
  { 1116, 16, 18, 19, 1, -23 },
  { 1152, 15, 11, 19, 2, -20 },
  { 1173, 16, 18, 19, 1, -23 },
  { 1209, 13, 29, 14, 0, -29 },
  { 1257, 25, 32, 29, 2, -29 },
  { 1357, 20, 29, 20, 0, -29 },
  { 1430, 16, 29, 21, 3, -29 },
  { 1488, 17, 29, 20, 2, -29 },
  { 1550, 18, 29, 23, 3, -29 },
  { 1616, 13, 29, 18, 3, -29 },
  { 1664, 13, 29, 17, 3, -29 },
  { 1712, 20, 29, 24, 2, -29 },
  { 1785, 18, 29, 24, 3, -29 },
  { 1851, 10, 29, 12, 1, -29 },
  { 1888, 8, 37, 10, -2, -29 },
  { 1925, 17, 29, 20, 3, -29 },
  { 1987, 13, 29, 17, 3, -29 },
  { 2035, 25, 29, 31, 3, -29 },
  { 2126, 19, 29, 25, 3, -29 },
  { 2195, 21, 29, 25, 2, -29 },
  { 2272, 15, 29, 20, 3, -29 },
  { 2327, 21, 36, 25, 2, -29 },
  { 2422, 17, 29, 20, 3, -29 },
  { 2484, 15, 29, 18, 2, -29 },
  { 2539, 17, 29, 17, 0, -29 },
  { 2601, 17, 29, 23, 3, -29 },
  { 2663, 20, 29, 20, 0, -29 },
  { 2736, 31, 29, 31, 0, -29 },
  { 2849, 18, 29, 18, 0, -29 },
  { 2915, 18, 29, 18, 0, -29 },
  { 2981, 15, 29, 17, 1, -29 },
  { 3036, 9, 35, 13, 3, -29 },
  { 3076, 13, 29, 15, 1, -29 },
  { 3124, 9, 35, 13, 1, -29 },
  { 3164, 17, 16, 19, 1, -29 },
  { 3198, 18, 3, 18, 0, 3 },
  { 3205, 7, 7, 11, 2, -31 },
  { 3212, 14, 22, 18, 2, -22 },
  { 3251, 16, 30, 20, 3, -30 },
  { 3311, 12, 22, 15, 2, -22 },
  { 3344, 16, 30, 20, 2, -30 },
  { 3404, 15, 22, 18, 2, -22 },
  { 3446, 12, 31, 11, 0, -31 },
  { 3493, 16, 32, 20, 2, -22 },
  { 3557, 14, 30, 20, 3, -30 },
  { 3610, 3, 30, 9, 3, -30 },
  { 3622, 7, 40, 9, -1, -30 },
  { 3657, 14, 30, 18, 3, -30 },
  { 3710, 3, 30, 9, 3, -30 },
  { 3722, 25, 22, 30, 3, -22 },
  { 3791, 14, 22, 20, 3, -22 },
  { 3830, 16, 22, 20, 2, -22 },
  { 3874, 16, 32, 20, 3, -22 },
  { 3938, 16, 32, 20, 2, -22 },
  { 4002, 10, 22, 13, 3, -22 },
  { 4030, 12, 22, 15, 2, -22 },
  { 4063, 10, 26, 12, 1, -26 },
  { 4096, 14, 21, 20, 3, -21 },
  { 4133, 16, 21, 16, 0, -21 },
  { 4175, 26, 21, 26, 0, -21 },
  { 4244, 15, 21, 17, 1, -21 },
  { 4284, 16, 31, 16, 0, -21 },
  { 4346, 12, 21, 14, 1, -21 },
  { 4378, 12, 35, 15, 1, -29 },
  { 4431, 3, 40, 18, 7, -30 },
  { 4446, 11, 35, 15, 2, -29 },
  { 4495, 17, 5, 19, 1, -17 },
};

const GFXfont NotoSans_Condensed_Regular40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_REGULAR40PT7B_H_
